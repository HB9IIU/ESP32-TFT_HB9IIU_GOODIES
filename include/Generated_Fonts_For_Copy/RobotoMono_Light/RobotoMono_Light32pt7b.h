#ifndef _ROBOTOMONO_LIGHT32PT7B_H_
#define _ROBOTOMONO_LIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x00, 0x01, 0xF8, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0x00, 0x01, 0x86, 0x00, 0x83, 0x00, 0x41, 0x80,
  0x60, 0x80, 0x30, 0x40, 0x18, 0x60, 0x08, 0x30, 0xFF, 0xFF, 0x06, 0x08,
  0x03, 0x04, 0x01, 0x82, 0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x30,
  0x41, 0xFF, 0xFE, 0xFF, 0xFF, 0x04, 0x18, 0x02, 0x0C, 0x03, 0x04, 0x01,
  0x82, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0xF0, 0x3F, 0xF0, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0x40, 0x0D, 0x80, 0x36,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xD8, 0x06,
  0x3C, 0xF0, 0x7F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x37,
  0x00, 0x30, 0x80, 0x10, 0x61, 0x88, 0x30, 0x84, 0x18, 0xC2, 0x0C, 0x41,
  0x84, 0x60, 0xC6, 0x20, 0x3E, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x70, 0x0C, 0xEE, 0x04, 0x63, 0x06, 0x20, 0x82, 0x10, 0x43,
  0x08, 0x23, 0x04, 0x10, 0x82, 0x08, 0x01, 0x8C, 0x00, 0x7C, 0x07, 0x80,
  0x0F, 0xF0, 0x06, 0x18, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC1,
  0x80, 0x31, 0x80, 0x19, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xB0, 0x03, 0x8C, 0x19, 0x83, 0x0D, 0x81, 0xC4, 0xC0, 0x66, 0x60, 0x1B,
  0x30, 0x07, 0x1C, 0x03, 0x86, 0x03, 0xE1, 0xC7, 0xB0, 0x7F, 0x0E, 0xFF,
  0xFC, 0x02, 0x04, 0x18, 0x61, 0x82, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0,
  0xC1, 0x81, 0x03, 0x03, 0x03, 0x02, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x60, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x83, 0x07,
  0x8C, 0x77, 0xFF, 0x83, 0xF0, 0x07, 0x80, 0x1A, 0x00, 0xCC, 0x06, 0x18,
  0x30, 0x30, 0x40, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x6D, 0xB6, 0xF2, 0xFF, 0xFF, 0xFC, 0x6F, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0xA0,
  0x0F, 0xC0, 0x37, 0x80, 0xCF, 0x03, 0x1E, 0x0C, 0x3C, 0x30, 0x78, 0xC0,
  0xF7, 0x01, 0xBC, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x31, 0x80, 0x63,
  0x01, 0x83, 0x8E, 0x03, 0xF8, 0x00, 0x00, 0x83, 0xC7, 0xFF, 0x3C, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x0F, 0xC0, 0xFF, 0x86,
  0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x68, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0xFF, 0x87, 0x03, 0x38, 0x06, 0xC0, 0x1B, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x06,
  0x60, 0x38, 0xF3, 0xC1, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xD8, 0x01, 0x98, 0x01, 0x98, 0x03, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x18, 0x60, 0x18,
  0x60, 0x18, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x3F, 0xFC, 0xFF, 0xF3, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x61, 0x01, 0xFF, 0x87, 0x8F, 0x08,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x34,
  0x01, 0xD8, 0x06, 0x70, 0x38, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xE0, 0x0F,
  0x80, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x67,
  0xC1, 0x3F, 0xCD, 0x83, 0xB8, 0x07, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x05, 0x80, 0x36, 0x00, 0xDC, 0x03, 0x30, 0x18, 0x71, 0xC0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0x03, 0x98, 0x06, 0x40, 0x1B, 0x00, 0x3C, 0x00, 0xD0, 0x02,
  0x60, 0x18, 0xC0, 0xC1, 0xFE, 0x03, 0xF0, 0x38, 0x71, 0x80, 0x6C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x18, 0xF3,
  0xC1, 0xFE, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x00,
  0xCC, 0x01, 0x90, 0x03, 0x60, 0x02, 0xC0, 0x06, 0x80, 0x0D, 0x80, 0x3B,
  0x00, 0x73, 0x01, 0xC7, 0x0E, 0x83, 0xFB, 0x01, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x6F,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0x60, 0x37, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x33, 0x66, 0xC4, 0x00, 0x08, 0x01, 0xC0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x03, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3C, 0x00, 0xC0, 0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0x0C, 0xC0,
  0x34, 0x01, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xF0, 0x03, 0xFE,
  0x03, 0x01, 0x83, 0x00, 0x63, 0x00, 0x11, 0x0F, 0x8D, 0x8E, 0x66, 0x84,
  0x21, 0xC6, 0x10, 0xE2, 0x08, 0x61, 0x04, 0x31, 0x82, 0x18, 0xC1, 0x0C,
  0x60, 0x86, 0x30, 0xC7, 0x88, 0x62, 0xC6, 0x53, 0x23, 0xCF, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE1, 0xC0, 0x1F, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x04,
  0x60, 0x0C, 0x20, 0x0C, 0x30, 0x08, 0x30, 0x18, 0x30, 0x18, 0x18, 0x10,
  0x18, 0x30, 0x18, 0x3F, 0xFC, 0x3F, 0xFC, 0x60, 0x0C, 0x60, 0x06, 0x60,
  0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x8C, 0x07,
  0x30, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00,
  0xCF, 0xFE, 0x3F, 0xF8, 0xC0, 0x73, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3B, 0xFF, 0xCF, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0xEC, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x1B,
  0x80, 0x63, 0x01, 0xC3, 0xCF, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x83,
  0x03, 0x86, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x30, 0x03, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x66, 0x01, 0x8C, 0x07, 0x1F,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFC, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0x6C,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0, 0x0D,
  0x80, 0x19, 0x80, 0x33, 0x80, 0xE3, 0xC7, 0x81, 0xFC, 0x00, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x06, 0x60, 0x38, 0xE3, 0xC1, 0xFC,
  0x00, 0xC0, 0x0F, 0x80, 0x3B, 0x00, 0x66, 0x01, 0x8C, 0x06, 0x18, 0x18,
  0x30, 0x70, 0x61, 0xC0, 0xC7, 0x01, 0x8C, 0x03, 0x30, 0x06, 0xF0, 0x0F,
  0x70, 0x1C, 0x70, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xE1, 0x80, 0xC3, 0x00,
  0xC6, 0x00, 0xCC, 0x01, 0xD8, 0x01, 0xB0, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xB0, 0x3E, 0xC1,
  0xBB, 0x06, 0xE6, 0x13, 0x98, 0xCE, 0x23, 0x38, 0xC8, 0xE3, 0x63, 0x85,
  0x8E, 0x1C, 0x38, 0x70, 0xE0, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xB0, 0x0E, 0xC0, 0x39, 0x80, 0xE6, 0x03, 0x8C, 0x0E, 0x30,
  0x38, 0x60, 0xE0, 0xC3, 0x83, 0x0E, 0x06, 0x38, 0x18, 0xE0, 0x33, 0x80,
  0xCE, 0x01, 0xB8, 0x06, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xC0,
  0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE1, 0x80, 0xE6, 0x00, 0xCC, 0x00, 0xB0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x33,
  0x80, 0x63, 0x01, 0x83, 0xDE, 0x03, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xE3,
  0x00, 0xE6, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1B, 0x00, 0x76, 0x01, 0xCF, 0xFF, 0x1F, 0xE0, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF0, 0x38, 0x18, 0x70, 0x0C,
  0x60, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x30, 0x18, 0x1E, 0xF0,
  0x0F, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x02, 0xFF, 0x01,
  0xFF, 0xC3, 0x01, 0xC6, 0x00, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x03, 0x8F, 0xFE, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x80, 0x63, 0x00, 0xC6, 0x00, 0xCC,
  0x01, 0x98, 0x01, 0xB0, 0x03, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73,
  0x80, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x1B, 0x00, 0x33, 0x00, 0xC3, 0xCF, 0x83,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0,
  0x0D, 0x80, 0x33, 0x00, 0x63, 0x01, 0x83, 0x8E, 0x03, 0xF8, 0x00, 0xC0,
  0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x02, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x02, 0x20, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x2C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0xC0, 0xC0, 0xE0, 0x60, 0xD0, 0x30, 0x6C, 0x38, 0x36, 0x1E, 0x1B, 0x0F,
  0x0D, 0x85, 0x86, 0xC2, 0xC2, 0x61, 0x21, 0x11, 0x91, 0x8C, 0xCC, 0xC6,
  0x66, 0x63, 0x23, 0x31, 0x90, 0x98, 0xD8, 0x48, 0x6C, 0x34, 0x16, 0x1E,
  0x0A, 0x0F, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x60, 0x70,
  0x30, 0xC0, 0x07, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x38, 0x18, 0x18,
  0x38, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18,
  0x18, 0x38, 0x18, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x03, 0xC0,
  0x03, 0xB0, 0x01, 0x98, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x98, 0x00, 0x6C,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7F, 0xE0, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x04,
  0x01, 0xC0, 0x38, 0x05, 0x81, 0xB0, 0x32, 0x0C, 0x61, 0x8C, 0x20, 0xCC,
  0x19, 0x01, 0xE0, 0x3C, 0x02, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0x8C, 0x30,
  0x1F, 0xC0, 0xF3, 0xC6, 0x03, 0x30, 0x06, 0xC0, 0x18, 0x00, 0x60, 0x01,
  0x83, 0xFE, 0x3F, 0xF9, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00,
  0xEC, 0x07, 0x9E, 0x76, 0x3F, 0x9C, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x33, 0xF0, 0xDD, 0xE3, 0xC0, 0xCE,
  0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xB0, 0x06, 0xE0, 0x1B, 0x80, 0xCD, 0xCE, 0x33, 0xF0,
  0x0F, 0xC0, 0xF7, 0xC7, 0x03, 0x18, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x09, 0x80,
  0x66, 0x03, 0x8E, 0x3C, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC3, 0xF3, 0x1E, 0xEC, 0xE0, 0x77,
  0x00, 0xD8, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D,
  0x00, 0x36, 0x00, 0xD8, 0x03, 0x70, 0x0C, 0xC0, 0x71, 0xC7, 0xC3, 0xF3,
  0x07, 0xE0, 0x3D, 0xF0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x00, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x8E, 0x03, 0x8F, 0x1C, 0x07, 0xF0, 0x00, 0x10, 0x03, 0xFC,
  0x0E, 0x08, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF,
  0xF9, 0xFF, 0xF0, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0F, 0xCC, 0x7B, 0xF3, 0x81,
  0xDC, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0xD0, 0x03, 0xC0, 0x0F, 0x00,
  0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0xC0, 0x33, 0x01, 0xC7, 0x1F, 0x0F,
  0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x60, 0x18, 0xE0, 0xE1, 0xFE, 0x00,
  0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0xFC, 0xDE, 0xF7, 0x81, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x70,
  0x08, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0xFE, 0x3E, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x07, 0xC0, 0x33, 0x01, 0x8C, 0x1C, 0x30, 0xE0, 0xC7, 0x03, 0x38, 0x0D,
  0xC0, 0x3F, 0x80, 0xF3, 0x03, 0x0E, 0x0C, 0x1C, 0x30, 0x38, 0xC0, 0x63,
  0x00, 0xCC, 0x01, 0xB0, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF,
  0x1E, 0x7D, 0xFB, 0xB8, 0x70, 0x78, 0x18, 0x3C, 0x08, 0x1E, 0x04, 0x0F,
  0x02, 0x07, 0x81, 0x03, 0xC0, 0x81, 0xE0, 0x40, 0xF0, 0x20, 0x78, 0x10,
  0x3C, 0x08, 0x1E, 0x04, 0x0F, 0x02, 0x07, 0x81, 0x03, 0xC0, 0x81, 0x80,
  0xC7, 0xE6, 0xF7, 0xBC, 0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x18, 0x0F, 0xE0, 0x3C, 0xE0, 0xC0, 0x63, 0x00, 0x66,
  0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x36, 0x00, 0xCC, 0x01, 0x8C, 0x06, 0x0E, 0x38, 0x0F, 0xE0,
  0xCF, 0xC3, 0x77, 0x8F, 0x03, 0x38, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00,
  0x6E, 0x03, 0x3E, 0x38, 0xCF, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0xCC, 0x7B, 0xF3, 0x81, 0xDC,
  0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0xD0, 0x03, 0xC0, 0x0F, 0x00, 0x36,
  0x00, 0xD8, 0x03, 0x60, 0x0D, 0xC0, 0x33, 0x01, 0xC7, 0x1F, 0x0F, 0xCC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x87, 0xF3, 0xFF, 0xC0, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00,
  0x1F, 0xE0, 0xF3, 0xC6, 0x03, 0x98, 0x06, 0x40, 0x0D, 0x80, 0x07, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0x00,
  0x36, 0x01, 0x8E, 0x1C, 0x1F, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x0F, 0xFF, 0xFF, 0xFC, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0F, 0x10, 0x3F, 0x80, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xA0, 0x0D, 0x80, 0xE7, 0x3F, 0x1F, 0x98, 0xC0, 0x07, 0x80,
  0x0D, 0x80, 0x13, 0x00, 0x62, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x18, 0x60, 0x31, 0x80, 0x63, 0x00, 0x6C, 0x00, 0xD8, 0x00,
  0xA0, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x80, 0xE0, 0x60, 0xD0, 0x70, 0x68,
  0x38, 0x36, 0x14, 0x13, 0x0B, 0x09, 0x8D, 0x8C, 0x46, 0x46, 0x22, 0x23,
  0x19, 0x19, 0x0D, 0x8C, 0x86, 0xC2, 0xC1, 0x41, 0x60, 0xA0, 0xE0, 0x70,
  0x30, 0x38, 0x18, 0x08, 0x0C, 0x00, 0xE0, 0x06, 0x70, 0x0C, 0x30, 0x18,
  0x18, 0x38, 0x0C, 0x30, 0x0E, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x0C, 0x30, 0x18, 0x18, 0x30, 0x1C,
  0x60, 0x0C, 0xE0, 0x07, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xC6, 0x00,
  0xC3, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x03,
  0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x3C, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x0E, 0x07,
  0x00, 0xF0, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0F,
  0x03, 0xE0, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x38, 0x00, 0x3E, 0x00, 0xBB,
  0xC0, 0x70, 0x70, 0x78, 0x1E, 0x68, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 3, 23, 19, 8, -23 },
  { 10, 7, 7, 19, 6, -24 },
  { 17, 17, 23, 19, 1, -23 },
  { 66, 14, 29, 19, 3, -26 },
  { 117, 17, 23, 19, 1, -23 },
  { 166, 17, 23, 19, 2, -23 },
  { 215, 2, 7, 19, 8, -24 },
  { 217, 7, 33, 19, 6, -26 },
  { 246, 8, 33, 19, 5, -26 },
  { 279, 14, 14, 19, 3, -23 },
  { 304, 15, 17, 19, 2, -19 },
  { 336, 3, 8, 19, 6, -3 },
  { 339, 11, 2, 19, 4, -11 },
  { 342, 4, 3, 19, 8, -3 },
  { 344, 12, 25, 19, 4, -23 },
  { 382, 15, 23, 19, 2, -23 },
  { 426, 9, 23, 19, 3, -23 },
  { 452, 14, 23, 19, 2, -23 },
  { 493, 14, 23, 19, 2, -23 },
  { 534, 16, 23, 19, 1, -23 },
  { 580, 14, 23, 19, 3, -23 },
  { 621, 14, 23, 19, 2, -23 },
  { 662, 15, 23, 19, 2, -23 },
  { 706, 14, 23, 19, 3, -23 },
  { 747, 15, 23, 19, 2, -23 },
  { 791, 4, 17, 19, 9, -17 },
  { 800, 4, 22, 19, 8, -17 },
  { 811, 13, 13, 19, 3, -17 },
  { 833, 14, 8, 19, 3, -14 },
  { 847, 14, 13, 19, 3, -17 },
  { 870, 13, 23, 19, 3, -23 },
  { 908, 17, 23, 19, 1, -23 },
  { 957, 16, 23, 19, 2, -23 },
  { 1003, 14, 23, 19, 3, -23 },
  { 1044, 15, 23, 19, 2, -23 },
  { 1088, 15, 23, 19, 3, -23 },
  { 1132, 14, 23, 19, 3, -23 },
  { 1173, 14, 23, 19, 3, -23 },
  { 1214, 15, 23, 19, 2, -23 },
  { 1258, 15, 23, 19, 2, -23 },
  { 1302, 13, 23, 19, 3, -23 },
  { 1340, 14, 23, 19, 2, -23 },
  { 1381, 15, 23, 19, 3, -23 },
  { 1425, 14, 23, 19, 3, -23 },
  { 1466, 14, 23, 19, 3, -23 },
  { 1507, 14, 23, 19, 3, -23 },
  { 1548, 15, 23, 19, 2, -23 },
  { 1592, 15, 23, 19, 3, -23 },
  { 1636, 16, 27, 19, 2, -23 },
  { 1690, 15, 23, 19, 3, -23 },
  { 1734, 15, 23, 19, 2, -23 },
  { 1778, 17, 23, 19, 1, -23 },
  { 1827, 15, 23, 19, 2, -23 },
  { 1871, 17, 23, 19, 1, -23 },
  { 1920, 17, 23, 19, 1, -23 },
  { 1969, 16, 23, 19, 2, -23 },
  { 2015, 17, 23, 19, 1, -23 },
  { 2064, 15, 23, 19, 2, -23 },
  { 2108, 5, 31, 19, 7, -26 },
  { 2128, 11, 25, 19, 4, -23 },
  { 2163, 5, 31, 19, 7, -26 },
  { 2183, 11, 13, 19, 4, -23 },
  { 2201, 13, 2, 19, 3, 0 },
  { 2205, 5, 4, 19, 7, -23 },
  { 2208, 14, 17, 19, 3, -17 },
  { 2238, 14, 24, 19, 3, -24 },
  { 2280, 14, 17, 19, 3, -17 },
  { 2310, 14, 24, 19, 2, -24 },
  { 2352, 15, 17, 19, 2, -17 },
  { 2384, 15, 25, 19, 3, -25 },
  { 2431, 14, 24, 19, 2, -17 },
  { 2473, 13, 24, 19, 3, -24 },
  { 2512, 14, 23, 19, 3, -23 },
  { 2553, 10, 30, 19, 3, -23 },
  { 2591, 14, 24, 19, 3, -24 },
  { 2633, 14, 24, 19, 3, -24 },
  { 2675, 17, 17, 19, 1, -17 },
  { 2712, 13, 17, 19, 3, -17 },
  { 2740, 15, 17, 19, 2, -17 },
  { 2772, 14, 24, 19, 3, -17 },
  { 2814, 14, 24, 19, 2, -17 },
  { 2856, 11, 17, 19, 6, -17 },
  { 2880, 14, 17, 19, 3, -17 },
  { 2910, 13, 21, 19, 3, -21 },
  { 2945, 13, 17, 19, 3, -17 },
  { 2973, 15, 17, 19, 2, -17 },
  { 3005, 17, 17, 19, 1, -17 },
  { 3042, 16, 17, 19, 2, -17 },
  { 3076, 17, 24, 19, 1, -17 },
  { 3127, 15, 17, 19, 2, -17 },
  { 3159, 11, 31, 19, 5, -25 },
  { 3202, 1, 28, 19, 9, -23 },
  { 3206, 11, 31, 19, 5, -25 },
  { 3249, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_Light32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light32pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_LIGHT32PT7B_H_
