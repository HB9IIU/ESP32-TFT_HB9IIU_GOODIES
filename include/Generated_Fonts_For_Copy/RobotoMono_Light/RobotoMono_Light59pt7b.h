#ifndef _ROBOTOMONO_LIGHT59PT7B_H_
#define _ROBOTOMONO_LIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x13, 0xDF, 0xFF, 0x80, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x3F,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x38, 0x02, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x60, 0x03,
  0x00, 0x70, 0x70, 0x01, 0xC0, 0x70, 0x70, 0x00, 0xF0, 0x38, 0x38, 0x00,
  0x3C, 0x78, 0x38, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x03, 0xF8, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x81, 0xFC, 0x00, 0x01, 0xC1, 0xFF, 0x80, 0x01, 0xC1,
  0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x38, 0x00, 0x70,
  0x70, 0x0E, 0x00, 0x70, 0x30, 0x07, 0x00, 0x38, 0x38, 0x03, 0x80, 0x38,
  0x1C, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x1C,
  0x03, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x8F, 0x80, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x1F, 0x1E, 0x00, 0x38, 0xF8, 0x3C, 0x00, 0xE3, 0xC0, 0x78,
  0x07, 0x9E, 0x00, 0xF0, 0x1E, 0x70, 0x01, 0xE0, 0x73, 0xC0, 0x07, 0x81,
  0xCF, 0x00, 0x0F, 0x07, 0x38, 0x00, 0x1E, 0x3C, 0xE0, 0x00, 0x3C, 0xE3,
  0x80, 0x00, 0xFF, 0x8F, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x03, 0xF0, 0x70,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3F, 0x03, 0xC0, 0x01, 0xFE, 0x0F, 0x80,
  0x1F, 0x78, 0x1F, 0xC7, 0xF8, 0xF0, 0x3F, 0xFF, 0x81, 0xE0, 0x3F, 0xF8,
  0x03, 0xC0, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x08,
  0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x02, 0x00, 0x08, 0x40, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x0E, 0x01, 0xCF, 0x81, 0xC0, 0xFB, 0xFE, 0x38, 0xFF, 0x9F, 0xFF, 0x7F,
  0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0xF0, 0x06, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x38,
  0xE7, 0xBC, 0x60, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFB, 0xEF, 0xFE, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7B,
  0xF8, 0x00, 0x3C, 0xFE, 0x00, 0x1E, 0x3F, 0x80, 0x0F, 0x0F, 0xE0, 0x07,
  0x81, 0xF8, 0x03, 0xC0, 0x7E, 0x03, 0xC0, 0x1F, 0x81, 0xE0, 0x07, 0xE0,
  0xF0, 0x01, 0xF8, 0x78, 0x00, 0x7E, 0x3C, 0x00, 0x1F, 0x9E, 0x00, 0x07,
  0xEF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xE0,
  0x3C, 0x01, 0xF0, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0,
  0xFF, 0xE7, 0xF9, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xEF, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x0F,
  0xF1, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x7E, 0x00, 0x39, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x07, 0xC0, 0x3F, 0xC3, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xDC, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x20, 0x01, 0xC1, 0xFF, 0x80, 0x71, 0xFF, 0xF8,
  0x1C, 0xFE, 0xFF, 0x07, 0x78, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x0F, 0x3E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x1F, 0xE7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFE,
  0x00, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3E, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x7E, 0x1F, 0x00, 0x1D, 0xC1, 0xF0, 0x0F, 0x38, 0x1F, 0xFF, 0xC7, 0x01,
  0xFF, 0xF0, 0xE0, 0x0F, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0xF8,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x03, 0xF8, 0x0C, 0x38, 0x07,
  0xFC, 0x0E, 0x38, 0x0F, 0x1E, 0x0E, 0x30, 0x1C, 0x0E, 0x06, 0x70, 0x38,
  0x0E, 0x06, 0x70, 0x30, 0x0E, 0x06, 0x60, 0x70, 0x0C, 0x06, 0xE0, 0x70,
  0x0C, 0x07, 0xE0, 0x60, 0x0C, 0x07, 0xE0, 0xE0, 0x0C, 0x07, 0xC0, 0xE0,
  0x0C, 0x07, 0xC0, 0xE0, 0x0C, 0x07, 0xC0, 0xE0, 0x0C, 0x06, 0xC0, 0xC0,
  0x1C, 0x06, 0xC0, 0xC0, 0x1C, 0x06, 0xC0, 0xC0, 0x1C, 0x06, 0xC0, 0xC0,
  0x1C, 0x06, 0xC0, 0xE0, 0x38, 0x0E, 0xE0, 0xE0, 0x3C, 0x0C, 0xE0, 0xE0,
  0x7C, 0x1C, 0xE0, 0x70, 0xFC, 0x18, 0xE0, 0x7B, 0xCE, 0x38, 0x60, 0x3F,
  0x8F, 0xF0, 0x70, 0x1F, 0x07, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x06, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0xE0, 0xE0, 0x00, 0x7C,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x3E, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x3F, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0E, 0x00, 0x07, 0xC3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x8E,
  0x00, 0x0F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0x9F, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xF1, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x78, 0x01, 0xF8,
  0x0F, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x8F, 0x00, 0x03, 0xE1, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x01, 0xFE,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0x80,
  0x7F, 0x9F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x3E,
  0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xE0, 0x3E, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0xE0, 0xF8,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x3F, 0x00, 0x00,
  0xE7, 0xF0, 0x00, 0x0E, 0xF7, 0x80, 0x00, 0xFE, 0x3C, 0x00, 0x0F, 0xE3,
  0xE0, 0x00, 0xFC, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x0E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0xE0,
  0x01, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xDF, 0xB8, 0x00, 0x77, 0xEE, 0x00, 0x3D, 0xFB, 0xC0,
  0x0E, 0x7E, 0x70, 0x03, 0x9F, 0x9C, 0x01, 0xE7, 0xE7, 0x80, 0x71, 0xF8,
  0xE0, 0x1C, 0x7E, 0x38, 0x0E, 0x1F, 0x87, 0x03, 0x87, 0xE1, 0xC1, 0xE1,
  0xF8, 0x70, 0x70, 0x7E, 0x0E, 0x1C, 0x1F, 0x83, 0x8F, 0x07, 0xE0, 0xF3,
  0x81, 0xF8, 0x1C, 0xE0, 0x7E, 0x07, 0x70, 0x1F, 0x81, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x70, 0x07,
  0xE0, 0x1C, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xB8, 0x00, 0x0F,
  0xEF, 0x00, 0x03, 0xF9, 0xC0, 0x00, 0xFE, 0x78, 0x00, 0x3F, 0x8E, 0x00,
  0x0F, 0xE3, 0xC0, 0x03, 0xF8, 0x70, 0x00, 0xFE, 0x1E, 0x00, 0x3F, 0x83,
  0xC0, 0x0F, 0xE0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x03, 0x80, 0x3F,
  0x80, 0xF0, 0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x00, 0xE0,
  0x3F, 0x80, 0x3C, 0x0F, 0xE0, 0x07, 0x03, 0xF8, 0x01, 0xE0, 0xFE, 0x00,
  0x3C, 0x3F, 0x80, 0x0F, 0x0F, 0xE0, 0x01, 0xE3, 0xF8, 0x00, 0x38, 0xFE,
  0x00, 0x0F, 0x3F, 0x80, 0x01, 0xCF, 0xE0, 0x00, 0x7B, 0xF8, 0x00, 0x0E,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x01, 0xF0,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x78,
  0x00, 0x3F, 0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF1,
  0xE0, 0x01, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x78, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0xE0, 0xE0, 0x00, 0x7C, 0x38,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF8,
  0xE0, 0x00, 0x7C, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x07, 0xFD, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78,
  0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x70, 0x03, 0xC0, 0x07, 0x70, 0x03, 0xC0, 0x0F, 0x70, 0x03,
  0xC0, 0x0E, 0x70, 0x03, 0xE0, 0x0E, 0x70, 0x03, 0xE0, 0x0E, 0x78, 0x07,
  0xE0, 0x0E, 0x78, 0x07, 0xE0, 0x0E, 0x38, 0x07, 0xE0, 0x0E, 0x38, 0x07,
  0x70, 0x1E, 0x38, 0x07, 0x70, 0x1C, 0x38, 0x06, 0x70, 0x1C, 0x38, 0x0E,
  0x70, 0x1C, 0x3C, 0x0E, 0x70, 0x1C, 0x3C, 0x0E, 0x30, 0x1C, 0x1C, 0x0E,
  0x38, 0x1C, 0x1C, 0x0E, 0x38, 0x3C, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x1C,
  0x38, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x38, 0x1E, 0x1C,
  0x1C, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x0E, 0x38,
  0x1C, 0x78, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x30,
  0x0E, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x07, 0x70,
  0x0E, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x78, 0x00, 0x79, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0F, 0x00, 0xF0, 0x38, 0x07,
  0x01, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE1, 0xE0, 0x07,
  0x0E, 0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x3F, 0xC0,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x07, 0xF0, 0x1E, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x8F, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x1E, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF9,
  0xE0, 0x00, 0xFE, 0x7C, 0x00, 0xF7, 0x8F, 0xFF, 0xF9, 0xE1, 0xFF, 0xFC,
  0x38, 0x1F, 0xFC, 0x0F, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0xE0,
  0x07, 0x0F, 0xFE, 0x03, 0x8F, 0xFF, 0xC1, 0xCF, 0xCF, 0xF0, 0xEE, 0x00,
  0xFC, 0x7E, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xF8, 0x00,
  0x78, 0xEF, 0x00, 0xF8, 0x77, 0xFF, 0xF8, 0x38, 0xFF, 0xF8, 0x1C, 0x3F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0xCF, 0x00, 0x03, 0xC3, 0xC0, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0x3F, 0x8F, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x0F, 0xFC, 0x3C, 0x1F, 0xFF, 0x9E,
  0x1F, 0xC7, 0xEF, 0x1F, 0x00, 0x7F, 0x9F, 0x00, 0x0F, 0xCF, 0x00, 0x03,
  0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7C,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x87, 0xFB, 0xFB,
  0xC1, 0xFF, 0xF9, 0xE0, 0x3F, 0xF0, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x78, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x10, 0x78, 0x00, 0x07, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0xF8,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xC0, 0x10, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xC3, 0xC1, 0xFF, 0xF9, 0xE1, 0xFC, 0x7E, 0xF1, 0xF0,
  0x07, 0xF9, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0xC0,
  0x03, 0xF1, 0xF0, 0x07, 0xF8, 0x7F, 0xBF, 0xBC, 0x1F, 0xFF, 0x9E, 0x03,
  0xFF, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x78, 0x1F, 0x00, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0xE0, 0xFF, 0xE0, 0xE1, 0xFF,
  0xF8, 0xE3, 0xE1, 0xFC, 0xE7, 0x00, 0x3C, 0xEE, 0x00, 0x1E, 0xFC, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE3, 0x8F,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC3,
  0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x7E, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x0F, 0xC3, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x07, 0x83, 0x9F, 0xF0, 0xFF, 0x8E, 0xFF, 0xE7, 0xFF,
  0x3F, 0x8F, 0xBE, 0x3E, 0xF8, 0x0F, 0xC0, 0x7B, 0xC0, 0x3E, 0x00, 0xFE,
  0x00, 0x78, 0x03, 0xF8, 0x01, 0xC0, 0x0F, 0xE0, 0x07, 0x00, 0x1F, 0x80,
  0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07,
  0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0,
  0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01,
  0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E,
  0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80,
  0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07,
  0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0,
  0x07, 0x00, 0x1F, 0x00, 0xE0, 0xFF, 0xE0, 0xE1, 0xFF, 0xF8, 0xE7, 0xE1,
  0xFC, 0xE7, 0x00, 0x3C, 0xEE, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7E, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x70, 0xFF, 0xE0, 0x39, 0xFF, 0xF8, 0x1D, 0xF8, 0x7F, 0x0F, 0xE0, 0x0F,
  0x87, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x0F,
  0x8F, 0xE0, 0x0F, 0x87, 0x7F, 0x3F, 0x83, 0x8F, 0xFF, 0x81, 0xC3, 0xFF,
  0x80, 0xE0, 0x08, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC3, 0xC1, 0xFF, 0xF9,
  0xE1, 0xF8, 0x7E, 0xF1, 0xF0, 0x07, 0xF9, 0xF0, 0x00, 0xFC, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x03, 0xF1, 0xF0, 0x07, 0xF8, 0x7F, 0xBF,
  0xBC, 0x1F, 0xFF, 0x9E, 0x03, 0xFF, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE7,
  0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3E, 0x00, 0x7B, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x87, 0xF8, 0x1F, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0x78, 0x00, 0x77, 0x3E,
  0x00, 0xF7, 0x1F, 0xDF, 0xE7, 0x0F, 0xFF, 0x87, 0x07, 0xFF, 0x07, 0x00,
  0x60, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x03, 0xC0,
  0x01, 0xE0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0xE0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x70,
  0x03, 0xC0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x1E, 0x38,
  0x06, 0xE0, 0x1C, 0x38, 0x06, 0x60, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38,
  0x0E, 0x70, 0x1C, 0x38, 0x0C, 0x70, 0x38, 0x1C, 0x1C, 0x70, 0x38, 0x1C,
  0x1C, 0x38, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x38, 0x38, 0x1C,
  0x38, 0x18, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E,
  0x30, 0x1C, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x06, 0x70, 0x0E, 0xE0, 0x07,
  0x70, 0x0E, 0xE0, 0x07, 0x60, 0x0E, 0xE0, 0x07, 0x60, 0x06, 0xE0, 0x07,
  0xE0, 0x06, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0xF8,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x80,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x3F, 0xFC, 0x00, 0x07,
  0x3E, 0x7F, 0x00, 0x06, 0x78, 0x0F, 0x80, 0x0E, 0xF0, 0x07, 0xC0, 0x0E,
  0xE0, 0x03, 0xF0, 0x1C, 0xE0, 0x00, 0xFC, 0x7C, 0xE0, 0x00, 0x7F, 0xF8,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoMono_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 5, 42, 35, 15, -42 },
  { 28, 11, 13, 35, 12, -44 },
  { 46, 32, 42, 35, 2, -42 },
  { 214, 26, 54, 35, 5, -48 },
  { 390, 33, 44, 35, 1, -43 },
  { 572, 30, 44, 35, 4, -43 },
  { 737, 3, 13, 35, 15, -44 },
  { 742, 14, 61, 35, 11, -47 },
  { 849, 14, 61, 35, 10, -47 },
  { 956, 27, 26, 35, 5, -42 },
  { 1044, 29, 31, 35, 3, -35 },
  { 1157, 6, 14, 35, 11, -5 },
  { 1168, 21, 3, 35, 7, -20 },
  { 1176, 6, 5, 35, 16, -5 },
  { 1180, 21, 46, 35, 8, -42 },
  { 1301, 26, 44, 35, 5, -43 },
  { 1444, 15, 42, 35, 6, -42 },
  { 1523, 27, 43, 35, 3, -43 },
  { 1669, 26, 44, 35, 3, -43 },
  { 1812, 30, 42, 35, 2, -42 },
  { 1970, 25, 43, 35, 6, -42 },
  { 2105, 26, 43, 35, 4, -42 },
  { 2245, 27, 42, 35, 4, -42 },
  { 2387, 27, 44, 35, 5, -43 },
  { 2536, 27, 43, 35, 4, -43 },
  { 2682, 6, 30, 35, 17, -30 },
  { 2705, 8, 39, 35, 15, -30 },
  { 2744, 24, 24, 35, 5, -31 },
  { 2816, 26, 14, 35, 5, -26 },
  { 2862, 25, 24, 35, 5, -31 },
  { 2937, 24, 43, 35, 6, -43 },
  { 3066, 32, 42, 35, 2, -42 },
  { 3234, 30, 42, 35, 3, -42 },
  { 3392, 26, 42, 35, 6, -42 },
  { 3529, 28, 44, 35, 4, -43 },
  { 3683, 27, 42, 35, 5, -42 },
  { 3825, 25, 42, 35, 6, -42 },
  { 3957, 25, 42, 35, 6, -42 },
  { 4089, 29, 44, 35, 3, -43 },
  { 4249, 26, 42, 35, 5, -42 },
  { 4386, 24, 42, 35, 6, -42 },
  { 4512, 27, 43, 35, 3, -42 },
  { 4658, 28, 42, 35, 6, -42 },
  { 4805, 25, 42, 35, 6, -42 },
  { 4937, 26, 42, 35, 5, -42 },
  { 5074, 26, 42, 35, 5, -42 },
  { 5211, 28, 44, 35, 4, -43 },
  { 5365, 27, 42, 35, 6, -42 },
  { 5507, 30, 50, 35, 3, -43 },
  { 5695, 26, 42, 35, 6, -42 },
  { 5832, 28, 44, 35, 4, -43 },
  { 5986, 30, 42, 35, 3, -42 },
  { 6144, 26, 43, 35, 5, -42 },
  { 6284, 30, 42, 35, 3, -42 },
  { 6442, 32, 42, 35, 2, -42 },
  { 6610, 30, 42, 35, 3, -42 },
  { 6768, 30, 42, 35, 2, -42 },
  { 6926, 27, 42, 35, 4, -42 },
  { 7068, 10, 57, 35, 13, -48 },
  { 7140, 21, 46, 35, 7, -42 },
  { 7261, 10, 57, 35, 12, -48 },
  { 7333, 21, 23, 35, 7, -42 },
  { 7394, 25, 3, 35, 5, 0 },
  { 7404, 9, 7, 35, 13, -43 },
  { 7412, 26, 33, 35, 5, -32 },
  { 7520, 25, 45, 35, 6, -44 },
  { 7661, 25, 33, 35, 5, -32 },
  { 7765, 25, 45, 35, 5, -44 },
  { 7906, 27, 33, 35, 4, -32 },
  { 8018, 27, 45, 35, 5, -45 },
  { 8170, 25, 44, 35, 5, -32 },
  { 8308, 24, 44, 35, 6, -44 },
  { 8440, 25, 42, 35, 6, -42 },
  { 8572, 18, 55, 35, 6, -42 },
  { 8696, 26, 44, 35, 6, -44 },
  { 8839, 25, 44, 35, 6, -44 },
  { 8977, 30, 32, 35, 3, -32 },
  { 9097, 24, 32, 35, 6, -32 },
  { 9193, 28, 33, 35, 4, -32 },
  { 9309, 25, 44, 35, 6, -32 },
  { 9447, 25, 44, 35, 5, -32 },
  { 9585, 21, 32, 35, 10, -32 },
  { 9669, 26, 33, 35, 5, -32 },
  { 9777, 25, 40, 35, 5, -39 },
  { 9902, 24, 32, 35, 6, -31 },
  { 9998, 29, 31, 35, 3, -31 },
  { 10111, 32, 31, 35, 2, -31 },
  { 10235, 28, 31, 35, 4, -31 },
  { 10344, 31, 44, 35, 2, -31 },
  { 10515, 28, 31, 35, 4, -31 },
  { 10624, 19, 58, 35, 10, -46 },
  { 10762, 3, 52, 35, 16, -42 },
  { 10782, 19, 58, 35, 10, -46 },
  { 10920, 32, 11, 35, 2, -23 },
};

const GFXfont RobotoMono_Light59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light59pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_LIGHT59PT7B_H_
