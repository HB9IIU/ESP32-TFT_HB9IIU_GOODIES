#ifndef _ROBOTOMONO_LIGHT28PT7B_H_
#define _ROBOTOMONO_LIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x45, 0x14, 0x51, 0x47, 0x10, 0x02,
  0x08, 0x04, 0x30, 0x08, 0x60, 0x30, 0x80, 0x61, 0x00, 0x82, 0x1F, 0xFF,
  0x82, 0x18, 0x0C, 0x20, 0x18, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86, 0x1F,
  0xFF, 0x86, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x80, 0x43, 0x01, 0x84,
  0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0x83, 0x8E, 0x18, 0x19, 0x80,
  0xCC, 0x03, 0x60, 0x1B, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x36, 0x03, 0x1C,
  0x38, 0x7F, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x78, 0x01, 0x98, 0x02,
  0x10, 0x44, 0x31, 0x88, 0x62, 0x10, 0x8C, 0x21, 0x10, 0x76, 0x60, 0x30,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0xC0, 0x67, 0xC0, 0x88, 0xC3, 0x30,
  0x84, 0x61, 0x18, 0xC2, 0x21, 0x84, 0x01, 0x18, 0x01, 0xE0, 0x1F, 0x00,
  0xE6, 0x03, 0x0C, 0x08, 0x30, 0x20, 0xC0, 0x82, 0x03, 0x18, 0x04, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0x60, 0x18, 0x83, 0x43, 0x0B, 0x06, 0x2C, 0x0D,
  0xB0, 0x1E, 0xC0, 0x73, 0x01, 0xC7, 0x0D, 0x8F, 0xE3, 0xFE, 0xA0, 0x06,
  0x18, 0x20, 0x83, 0x04, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x81, 0x06, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41,
  0x0C, 0x30, 0xC3, 0x08, 0x61, 0x84, 0x30, 0x84, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xC4, 0x7F, 0xDE, 0x0F, 0x00, 0xE0, 0x1B, 0x01, 0x18,
  0x30, 0xC6, 0x04, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x6D, 0xB6, 0xB0, 0xFF, 0xFF, 0xF0, 0x5D, 0x80, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x00, 0x0F, 0x81, 0xC7, 0x18, 0x08, 0xC0, 0x64, 0x01, 0x60, 0x0B,
  0x00, 0xF8, 0x1B, 0xC1, 0x9E, 0x18, 0xF1, 0x87, 0x98, 0x3D, 0x81, 0xF8,
  0x0F, 0x80, 0x48, 0x02, 0x60, 0x33, 0x01, 0x0E, 0x38, 0x3F, 0x80, 0x02,
  0x3D, 0xEE, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x1F, 0x81, 0xC7, 0x18, 0x0C, 0xC0, 0x6C,
  0x01, 0x60, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xFF, 0xF0, 0x0F, 0xC1, 0xC7, 0x18, 0x0C, 0xC0, 0x64, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x7E, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x01, 0x8E, 0x18, 0x3F, 0x80, 0x00,
  0x60, 0x03, 0x80, 0x0A, 0x00, 0x68, 0x03, 0x20, 0x08, 0x80, 0x62, 0x03,
  0x08, 0x08, 0x20, 0x60, 0x83, 0x02, 0x0C, 0x08, 0x60, 0x23, 0x00, 0x8F,
  0xFF, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x7F, 0xF7,
  0xFF, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0xE0, 0x7F, 0xC6,
  0x1E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x66,
  0x06, 0x7F, 0xC1, 0xF8, 0x03, 0xC0, 0xF8, 0x18, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0xF8, 0xD9, 0xEE, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x60, 0x36, 0x06, 0x38, 0xE1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x0F, 0xC1, 0xC7, 0x0C, 0x0C,
  0xC0, 0x26, 0x01, 0xB0, 0x0D, 0x80, 0x44, 0x06, 0x30, 0x60, 0x7E, 0x07,
  0xF8, 0x60, 0x66, 0x01, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x01,
  0x8E, 0x1C, 0x3F, 0x80, 0x1F, 0x83, 0x8C, 0x60, 0x66, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x33, 0x0D, 0x1F, 0x90,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x07, 0x81, 0xE0, 0x5F, 0x80,
  0x00, 0x00, 0x05, 0xF8, 0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66,
  0x64, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0xF0, 0x3C, 0x0E, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x1E, 0x0F, 0x03, 0xC0,
  0x70, 0x08, 0x00, 0x1F, 0x8E, 0x39, 0x81, 0x60, 0x3C, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0x07, 0xE0, 0x1C, 0x70, 0x60,
  0x21, 0x00, 0x26, 0x1C, 0x48, 0xEC, 0xD1, 0x08, 0xC6, 0x11, 0x88, 0x63,
  0x10, 0x86, 0x21, 0x0C, 0x42, 0x18, 0x84, 0x51, 0x18, 0xA3, 0x7B, 0x63,
  0x9C, 0x40, 0x00, 0xC0, 0x00, 0xE0, 0x80, 0x7F, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x14, 0x00, 0x6C, 0x00, 0xC8, 0x01, 0x10, 0x06, 0x30,
  0x0C, 0x60, 0x10, 0x40, 0x60, 0xC0, 0xC1, 0x81, 0x01, 0x07, 0xFF, 0x0C,
  0x06, 0x10, 0x04, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x16, 0x00, 0x30, 0xFF,
  0x0F, 0xFC, 0x80, 0xE8, 0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80,
  0xCF, 0xF0, 0x83, 0xC8, 0x06, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x06, 0x83, 0xCF, 0xF0, 0x0F, 0x81, 0xC7, 0x18, 0x0C, 0xC0, 0x2C,
  0x01, 0xE0, 0x0F, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x78, 0x03, 0x60, 0x13, 0x01, 0x8E, 0x38,
  0x3F, 0x80, 0xFF, 0x07, 0xFE, 0x30, 0x19, 0x80, 0x6C, 0x01, 0x60, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x02, 0xC0, 0x36, 0x03, 0x30, 0xF1, 0xFE, 0x00, 0xFF,
  0xEF, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFC, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFC, 0xFF, 0xCC, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F,
  0xC1, 0xC7, 0x18, 0x0C, 0xC0, 0x2C, 0x01, 0xE0, 0x0E, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0x60, 0x1B, 0x80, 0xCE, 0x1C, 0x1F, 0xC0, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x7F, 0xF0, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x2C, 0x06,
  0x71, 0xC1, 0xF8, 0x80, 0x3C, 0x03, 0x20, 0x39, 0x01, 0x88, 0x18, 0x41,
  0x82, 0x18, 0x11, 0x80, 0x98, 0x05, 0xE0, 0x2F, 0x01, 0xCC, 0x0C, 0x30,
  0x41, 0x82, 0x06, 0x10, 0x18, 0x80, 0x64, 0x03, 0x20, 0x0D, 0x00, 0x30,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xE0,
  0xFF, 0x07, 0xE8, 0x2F, 0x63, 0x79, 0x13, 0xC9, 0x9E, 0x6C, 0xF1, 0x47,
  0x8E, 0x3C, 0x71, 0xE1, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x30, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3D, 0x01, 0xEC,
  0x0F, 0x20, 0x79, 0x83, 0xC4, 0x1E, 0x30, 0xF0, 0xC7, 0x86, 0x3C, 0x19,
  0xE0, 0xCF, 0x03, 0x78, 0x0B, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x30,
  0x0F, 0x81, 0xCF, 0x18, 0x18, 0xC0, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x02, 0x60, 0x33, 0x03, 0x0E, 0x38, 0x3F, 0x00, 0xFF, 0x87, 0xFE,
  0x30, 0x19, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x58, 0x02, 0xC0, 0x36,
  0x03, 0x3F, 0xF1, 0xFE, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x73, 0xC3, 0x01, 0x88,
  0x06, 0x60, 0x0D, 0x80, 0x34, 0x00, 0x50, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x40, 0x05, 0x00, 0x16, 0x00, 0xD8, 0x03, 0x20, 0x18,
  0xC0, 0x61, 0xC7, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF,
  0x0F, 0xFC, 0x80, 0x68, 0x06, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x68, 0x0C, 0xFF, 0x8F, 0xF0, 0x81, 0x88, 0x18, 0x80, 0xC8, 0x0C, 0x80,
  0x68, 0x06, 0x80, 0x38, 0x03, 0x0F, 0xC1, 0xC7, 0x18, 0x0C, 0x80, 0x3C,
  0x01, 0xE0, 0x0D, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1B, 0x00, 0xCE, 0x1C,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02, 0x60, 0x33, 0x01, 0x8E, 0x38, 0x3F,
  0x00, 0xC0, 0x05, 0x00, 0x36, 0x00, 0xD8, 0x02, 0x20, 0x18, 0xC0, 0x63,
  0x01, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x80, 0x86, 0x03, 0x18, 0x0C, 0x60,
  0x31, 0x00, 0x4C, 0x01, 0xB0, 0x06, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0xC1, 0x03, 0x83, 0x0F, 0x0E, 0x1A, 0x1C, 0x34, 0x28, 0x48, 0x50, 0x98,
  0xB1, 0x31, 0x62, 0x66, 0x4C, 0xCC, 0x98, 0x91, 0x31, 0x23, 0x62, 0x46,
  0x87, 0x8D, 0x0F, 0x0A, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0xE0,
  0xC0, 0x80, 0x60, 0x0E, 0x40, 0x18, 0xC0, 0x60, 0xC0, 0x81, 0x83, 0x01,
  0x8C, 0x01, 0x18, 0x03, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x16,
  0x00, 0x6C, 0x01, 0x8C, 0x03, 0x08, 0x0C, 0x18, 0x10, 0x18, 0x60, 0x31,
  0x80, 0x37, 0x00, 0x30, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x8C, 0x06, 0x30,
  0x30, 0x60, 0xC1, 0x86, 0x03, 0x18, 0x0C, 0xC0, 0x1B, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0xFF, 0xF7, 0xFF, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xF0,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x3E, 0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFE, 0x04,
  0x03, 0x80, 0xA0, 0x68, 0x1B, 0x04, 0x43, 0x18, 0x86, 0x60, 0xD0, 0x3C,
  0x04, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x0F, 0x81, 0xC7, 0x18, 0x0C, 0x80,
  0x60, 0x03, 0x00, 0x18, 0x1F, 0xC7, 0xFE, 0x60, 0x32, 0x01, 0xB0, 0x0D,
  0x80, 0x64, 0x07, 0x38, 0xE8, 0xFC, 0x60, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x9F, 0x0B, 0xBC, 0xE0, 0xCC, 0x06, 0x80, 0x28,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x2C, 0x06, 0xC0, 0x6B,
  0x1C, 0x9F, 0x80, 0x0F, 0x83, 0x9E, 0x30, 0x36, 0x03, 0x40, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x16, 0x01, 0x60, 0x33, 0x86,
  0x1F, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F,
  0x33, 0x9F, 0x70, 0x76, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x40, 0x36, 0x03, 0x60, 0x33, 0x8F, 0x1F, 0x90, 0x0F, 0x80,
  0xEF, 0x0C, 0x0C, 0xC0, 0x64, 0x01, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x01, 0x1C, 0x38, 0x3F, 0x00, 0x01,
  0xF8, 0x18, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x03, 0xFF, 0xDF, 0xFE,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0x13,
  0x9D, 0x60, 0x76, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x36, 0x03, 0x60, 0x33, 0x8F, 0x1F, 0xB0, 0x03, 0x00, 0x34,
  0x03, 0x60, 0x63, 0xFC, 0x0F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x23, 0xE5, 0xCE, 0xA0, 0x78, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0x03, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x9E, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x30, 0xC6, 0x0C,
  0xC0, 0xD8, 0x0F, 0xC0, 0xE6, 0x0C, 0x60, 0xC3, 0x0C, 0x18, 0xC0, 0xCC,
  0x06, 0xC0, 0x30, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0xDE,
  0x79, 0xEF, 0x9B, 0x0E, 0x16, 0x08, 0x3C, 0x10, 0x78, 0x20, 0xF0, 0x41,
  0xE0, 0x83, 0xC1, 0x07, 0x82, 0x0F, 0x04, 0x1E, 0x08, 0x3C, 0x10, 0x78,
  0x20, 0xF0, 0x41, 0x80, 0x8F, 0x97, 0x3A, 0x81, 0xE0, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x0F, 0x81, 0xC7, 0x18, 0x1C, 0xC0, 0x6C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x06, 0x80, 0x66, 0x03, 0x1C, 0x70,
  0x7F, 0x00, 0x9F, 0x0B, 0xBC, 0xC0, 0xCC, 0x06, 0x80, 0x68, 0x02, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0xC0, 0xCB, 0x1C, 0x9F,
  0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x93,
  0x9F, 0x70, 0x76, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x36, 0x03, 0x60, 0x33, 0x8F, 0x1F, 0xB0, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xCF, 0xF7, 0xFF, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x1F, 0x87, 0x1C, 0xC0, 0x6C, 0x02, 0xC0, 0x1C, 0x00, 0x78, 0x01,
  0xF0, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x66, 0x0E, 0x3F, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x70, 0x03, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x3C, 0x06, 0xC3,
  0x4F, 0xC8, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0x8C, 0x06, 0x30, 0x10, 0x40,
  0xC1, 0x83, 0x02, 0x08, 0x0C, 0x60, 0x31, 0x00, 0x4C, 0x01, 0xB0, 0x02,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0x81, 0x03, 0x82, 0x0F, 0x0E, 0x1A, 0x14,
  0x24, 0x28, 0x48, 0x50, 0x99, 0xB3, 0x32, 0x26, 0x24, 0x48, 0x48, 0x90,
  0xF1, 0xA1, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x00, 0xC0, 0x1B,
  0x01, 0x8C, 0x18, 0x20, 0xC1, 0x8C, 0x06, 0xC0, 0x1C, 0x00, 0x60, 0x07,
  0x00, 0x6C, 0x06, 0x30, 0x60, 0xC3, 0x06, 0x30, 0x1B, 0x00, 0x60, 0xC0,
  0x06, 0x80, 0x19, 0x80, 0x31, 0x00, 0xC3, 0x01, 0x86, 0x02, 0x06, 0x0C,
  0x0C, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x28, 0x00,
  0x70, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x03, 0xE0,
  0x07, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0xFF, 0xE0, 0x01, 0x03, 0xC3, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x07, 0x03, 0x80, 0x60, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xE0, 0x10,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x70, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x1C, 0x1E, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x30, 0x30, 0x10, 0x00,
  0x38, 0x00, 0xFC, 0x07, 0x0C, 0x1C, 0x0E, 0x68, 0x07, 0x80,
};

const GFXglyph RobotoMono_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 2, 20, 17, 7, -20 },
  { 6, 6, 6, 17, 5, -21 },
  { 11, 15, 20, 17, 1, -20 },
  { 49, 13, 26, 17, 2, -23 },
  { 92, 15, 20, 17, 1, -20 },
  { 130, 14, 20, 17, 2, -20 },
  { 165, 2, 6, 17, 7, -21 },
  { 167, 7, 28, 17, 5, -22 },
  { 192, 6, 28, 17, 5, -22 },
  { 213, 12, 12, 17, 3, -20 },
  { 231, 13, 14, 17, 2, -16 },
  { 254, 3, 7, 17, 5, -3 },
  { 257, 10, 2, 17, 3, -10 },
  { 260, 3, 3, 17, 7, -3 },
  { 262, 10, 22, 17, 4, -20 },
  { 290, 13, 20, 17, 2, -20 },
  { 323, 7, 20, 17, 3, -20 },
  { 341, 13, 20, 17, 1, -20 },
  { 374, 13, 20, 17, 1, -20 },
  { 407, 14, 20, 17, 1, -20 },
  { 442, 12, 20, 17, 3, -20 },
  { 472, 12, 20, 17, 2, -20 },
  { 502, 13, 20, 17, 2, -20 },
  { 535, 13, 20, 17, 2, -20 },
  { 568, 12, 20, 17, 2, -20 },
  { 598, 3, 15, 17, 8, -15 },
  { 604, 4, 19, 17, 7, -15 },
  { 614, 12, 12, 17, 2, -15 },
  { 632, 13, 8, 17, 2, -13 },
  { 645, 12, 12, 17, 2, -15 },
  { 663, 11, 20, 17, 3, -20 },
  { 691, 15, 20, 17, 1, -20 },
  { 729, 15, 20, 17, 1, -20 },
  { 767, 12, 20, 17, 3, -20 },
  { 797, 13, 20, 17, 2, -20 },
  { 830, 13, 20, 17, 2, -20 },
  { 863, 12, 20, 17, 3, -20 },
  { 893, 12, 20, 17, 3, -20 },
  { 923, 13, 20, 17, 2, -20 },
  { 956, 13, 20, 17, 2, -20 },
  { 989, 11, 20, 17, 3, -20 },
  { 1017, 12, 20, 17, 2, -20 },
  { 1047, 13, 20, 17, 3, -20 },
  { 1080, 12, 20, 17, 3, -20 },
  { 1110, 13, 20, 17, 2, -20 },
  { 1143, 13, 20, 17, 2, -20 },
  { 1176, 13, 20, 17, 2, -20 },
  { 1209, 13, 20, 17, 3, -20 },
  { 1242, 14, 23, 17, 1, -20 },
  { 1283, 12, 20, 17, 3, -20 },
  { 1313, 13, 20, 17, 2, -20 },
  { 1346, 15, 20, 17, 1, -20 },
  { 1384, 13, 20, 17, 2, -20 },
  { 1417, 14, 20, 17, 1, -20 },
  { 1452, 15, 20, 17, 1, -20 },
  { 1490, 15, 20, 17, 1, -20 },
  { 1528, 14, 20, 17, 1, -20 },
  { 1563, 13, 20, 17, 2, -20 },
  { 1596, 5, 27, 17, 6, -23 },
  { 1613, 9, 22, 17, 4, -20 },
  { 1638, 5, 27, 17, 6, -23 },
  { 1655, 10, 11, 17, 3, -20 },
  { 1669, 12, 1, 17, 2, 0 },
  { 1671, 5, 4, 17, 6, -21 },
  { 1674, 13, 15, 17, 2, -15 },
  { 1699, 12, 21, 17, 3, -21 },
  { 1731, 12, 15, 17, 2, -15 },
  { 1754, 12, 21, 17, 2, -21 },
  { 1786, 13, 15, 17, 2, -15 },
  { 1811, 13, 21, 17, 2, -21 },
  { 1846, 12, 21, 17, 2, -15 },
  { 1878, 11, 21, 17, 3, -21 },
  { 1907, 12, 20, 17, 3, -20 },
  { 1937, 8, 26, 17, 3, -20 },
  { 1963, 12, 21, 17, 3, -21 },
  { 1995, 12, 21, 17, 3, -21 },
  { 2027, 15, 15, 17, 1, -15 },
  { 2056, 11, 15, 17, 3, -15 },
  { 2077, 13, 15, 17, 2, -15 },
  { 2102, 12, 21, 17, 3, -15 },
  { 2134, 12, 21, 17, 2, -15 },
  { 2166, 10, 15, 17, 5, -15 },
  { 2185, 12, 15, 17, 3, -15 },
  { 2208, 12, 19, 17, 2, -19 },
  { 2237, 11, 15, 17, 3, -15 },
  { 2258, 14, 15, 17, 1, -15 },
  { 2285, 15, 15, 17, 1, -15 },
  { 2314, 13, 15, 17, 2, -15 },
  { 2339, 15, 21, 17, 1, -15 },
  { 2379, 13, 15, 17, 2, -15 },
  { 2404, 9, 28, 17, 5, -22 },
  { 2436, 1, 25, 17, 8, -20 },
  { 2440, 9, 28, 17, 5, -22 },
  { 2472, 15, 5, 17, 1, -11 },
};

const GFXfont RobotoMono_Light28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light28pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_LIGHT28PT7B_H_
