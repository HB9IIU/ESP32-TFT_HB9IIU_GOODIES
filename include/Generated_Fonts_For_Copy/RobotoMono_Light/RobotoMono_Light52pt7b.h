#ifndef _ROBOTOMONO_LIGHT52PT7B_H_
#define _ROBOTOMONO_LIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x37, 0x06, 0xE0, 0xDC, 0x1B, 0x83, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x07, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x70, 0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x18, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x30,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xC3, 0xE0, 0x78,
  0x03, 0xC3, 0xC0, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0x8F, 0x00, 0x3E,
  0x1F, 0x87, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x02, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x03, 0x01, 0xC0, 0xE0, 0x18, 0x1C, 0x07, 0x00, 0xC0, 0xC0, 0x38, 0x06,
  0x0E, 0x01, 0xC0, 0x70, 0x60, 0x06, 0x03, 0x87, 0x00, 0x38, 0x38, 0x30,
  0x01, 0xE3, 0xC3, 0x80, 0x07, 0xFC, 0x18, 0x00, 0x0F, 0xC1, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x3E, 0x00, 0x03, 0x87,
  0xFC, 0x00, 0x18, 0x78, 0xF0, 0x01, 0xC3, 0x81, 0x80, 0x0C, 0x18, 0x0E,
  0x00, 0xE1, 0xC0, 0x70, 0x0E, 0x0E, 0x03, 0x80, 0x70, 0x70, 0x0C, 0x07,
  0x03, 0x80, 0x60, 0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x08, 0x07,
  0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1D,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0x78, 0x03, 0x87, 0x07,
  0x80, 0x71, 0xE0, 0x78, 0x0E, 0x78, 0x07, 0x01, 0xCE, 0x00, 0x70, 0x39,
  0xC0, 0x0F, 0x0E, 0x38, 0x00, 0xF1, 0xCE, 0x00, 0x0F, 0x39, 0xE0, 0x00,
  0xEE, 0x1C, 0x00, 0x0F, 0xC3, 0x80, 0x01, 0xF0, 0x70, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0xE0, 0xF0, 0x03, 0xDC, 0x0F, 0x81, 0xF3, 0xC0, 0xFF, 0xFC,
  0x3C, 0x07, 0xFE, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x20, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x1C, 0x06, 0xF8, 0x38, 0x7F, 0xFE, 0x73, 0xFC, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80,
  0x00, 0xE7, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x70, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x73, 0xB9, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x7C, 0x1F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x3C,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3B, 0xF0, 0x00,
  0xE7, 0xE0, 0x07, 0x8F, 0xC0, 0x1E, 0x1F, 0x80, 0x78, 0x3F, 0x01, 0xE0,
  0x7E, 0x07, 0x80, 0xFC, 0x1C, 0x01, 0xF8, 0x70, 0x03, 0xF1, 0xC0, 0x07,
  0xE7, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x7C, 0x1F, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0xFE, 0x1F, 0xF3, 0xF3, 0xFE, 0x1F, 0xC0, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7C, 0x1F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E,
  0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E,
  0x00, 0x7C, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x0F, 0x80, 0x0E, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0x8F, 0xF0, 0x78, 0x07, 0xE0, 0x40, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x1F, 0xE0, 0x38, 0xFF, 0xF0,
  0x73, 0xF3, 0xF0, 0xEE, 0x00, 0xF1, 0xF8, 0x00, 0xF3, 0xE0, 0x00, 0xE7,
  0x80, 0x01, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xEF, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x1F, 0x00, 0x78, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x07, 0xE3,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xC3, 0xF0, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3E, 0x0F,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xF9, 0xC0,
  0x03, 0xF3, 0xC0, 0x0E, 0xE3, 0xE0, 0x79, 0xC3, 0xFF, 0xE3, 0x03, 0xFF,
  0x8E, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xDE, 0x1C, 0x7C, 0xF9, 0xF1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x3C,
  0x71, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F,
  0x0F, 0xC7, 0x80, 0x3C, 0x70, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x60, 0x38, 0x00, 0x03, 0x81, 0x80, 0x10, 0x0C, 0x1C, 0x07, 0xF0, 0x70,
  0xC0, 0x7F, 0xC1, 0x8E, 0x07, 0x06, 0x0C, 0x60, 0x70, 0x30, 0x63, 0x07,
  0x01, 0x83, 0x38, 0x30, 0x0C, 0x19, 0x81, 0x80, 0xE0, 0xEC, 0x1C, 0x06,
  0x03, 0x60, 0xC0, 0x30, 0x1B, 0x06, 0x01, 0x80, 0xD8, 0x30, 0x0C, 0x0E,
  0xC1, 0x80, 0x60, 0x66, 0x0C, 0x03, 0x03, 0x30, 0x60, 0x18, 0x19, 0x83,
  0x01, 0xC0, 0xCC, 0x18, 0x0E, 0x06, 0x60, 0xC0, 0xF0, 0x63, 0x07, 0x07,
  0x83, 0x18, 0x18, 0xEE, 0x30, 0xE0, 0xFE, 0x3F, 0x83, 0x03, 0xE1, 0xF8,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x40, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0xF0, 0xE0, 0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xC0, 0x03, 0xE3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x3C, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x1C, 0x00,
  0x0E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x07, 0xC0, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0,
  0x07, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xE0, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0xC0, 0x07, 0x81, 0xF8, 0x1F,
  0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x7C, 0x01,
  0xE0, 0x7E, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00,
  0x0F, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x07, 0x80, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x38, 0x07, 0x80, 0x1C,
  0x07, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x01,
  0xC3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x73, 0xF0, 0x00, 0x3B, 0xFC, 0x00,
  0x1F, 0xDE, 0x00, 0x0F, 0xC7, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xC0, 0x70,
  0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x77, 0xEC, 0x00, 0x77, 0xEE, 0x00, 0x77, 0xEE,
  0x00, 0xE7, 0xE7, 0x00, 0xE7, 0xE7, 0x00, 0xC7, 0xE7, 0x01, 0xC7, 0xE3,
  0x81, 0xC7, 0xE3, 0x83, 0x87, 0xE1, 0x83, 0x87, 0xE1, 0xC3, 0x87, 0xE1,
  0xC7, 0x07, 0xE0, 0xC7, 0x07, 0xE0, 0xE6, 0x07, 0xE0, 0xEE, 0x07, 0xE0,
  0x6E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xF7, 0x00,
  0x07, 0xE7, 0x00, 0x0F, 0xCE, 0x00, 0x1F, 0x8E, 0x00, 0x3F, 0x1C, 0x00,
  0x7E, 0x1C, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x38, 0x03, 0xF0, 0x78, 0x07,
  0xE0, 0x70, 0x0F, 0xC0, 0xF0, 0x1F, 0x80, 0xE0, 0x3F, 0x00, 0xE0, 0x7E,
  0x01, 0xC0, 0xFC, 0x01, 0xC1, 0xF8, 0x03, 0x83, 0xF0, 0x03, 0x87, 0xE0,
  0x07, 0x8F, 0xC0, 0x07, 0x1F, 0x80, 0x0F, 0x3F, 0x00, 0x0E, 0x7E, 0x00,
  0x1E, 0xFC, 0x00, 0x1D, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xE0,
  0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01,
  0xF8, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00, 0x0F, 0x8E,
  0x00, 0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xF3, 0x80, 0x07, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x03, 0xC0,
  0x1E, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x30, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xE0, 0x07, 0x81, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00,
  0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x77, 0x00, 0xF0, 0x06, 0x70,
  0x0F, 0x00, 0xE7, 0x00, 0xF0, 0x0E, 0x70, 0x0F, 0x80, 0xE7, 0x01, 0xF8,
  0x0E, 0x70, 0x1F, 0x80, 0xE7, 0x01, 0x98, 0x0E, 0x30, 0x19, 0x80, 0xC3,
  0x81, 0x9C, 0x0C, 0x38, 0x39, 0xC1, 0xC3, 0x83, 0x9C, 0x1C, 0x38, 0x38,
  0xC1, 0xC3, 0x83, 0x0C, 0x1C, 0x38, 0x30, 0xC1, 0xC1, 0x87, 0x0E, 0x18,
  0x1C, 0x70, 0xE1, 0x81, 0xC7, 0x0E, 0x38, 0x1C, 0x60, 0x63, 0x81, 0xC6,
  0x06, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x0C, 0xE0, 0x73,
  0x00, 0xCE, 0x03, 0x30, 0x0E, 0xC0, 0x33, 0x00, 0xEC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x78,
  0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x0F,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x3C,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1B, 0x80, 0x07, 0x70, 0x00, 0xE6, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x03, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0,
  0x07, 0x70, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0xFC, 0x07, 0x1F, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xBC,
  0x00, 0x0F, 0x38, 0x00, 0x3E, 0x78, 0x01, 0xFC, 0x7E, 0x1F, 0xBC, 0x7F,
  0xFC, 0x78, 0x3F, 0xF0, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x3F, 0x80, 0xE3, 0xFF, 0x83, 0x9F, 0xFF, 0x0E, 0xE0,
  0x3E, 0x3F, 0x00, 0x3C, 0xF8, 0x00, 0x73, 0xC0, 0x01, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x80, 0x0F, 0x3F, 0x00, 0x78, 0xEF,
  0x87, 0xE3, 0x9F, 0xFE, 0x0E, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x07,
  0x87, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEF, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x1F, 0x03,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x3F, 0x07, 0x03, 0xFF, 0x1C, 0x3F, 0xFF,
  0x71, 0xF0, 0x1F, 0xC7, 0x00, 0x1F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xC7, 0x80,
  0x3F, 0x0F, 0x83, 0xDC, 0x1F, 0xFE, 0x70, 0x3F, 0xF1, 0xC0, 0x0C, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81,
  0xE0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x0E, 0x00, 0x07, 0x1F, 0x00, 0x3C,
  0x1F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC,
  0x70, 0xFF, 0xFD, 0xC7, 0xC0, 0x7F, 0x1E, 0x00, 0x7C, 0xF0, 0x00, 0xF7,
  0x80, 0x03, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xCF, 0x00,
  0x1F, 0x1E, 0x00, 0xFC, 0x3E, 0x0F, 0x70, 0x7F, 0xF9, 0xC0, 0xFF, 0xC7,
  0x00, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x10,
  0x00, 0x38, 0xC0, 0x01, 0xE3, 0x80, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x1F, 0xC0, 0xE1, 0xFF, 0xC3, 0x8F, 0xFF, 0x8E, 0x70, 0x1F,
  0x3B, 0x00, 0x1C, 0xF8, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x02, 0xE0, 0x00,
  0xF3, 0x80, 0x07, 0x8E, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x03,
  0x80, 0xF8, 0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0x8F,
  0x00, 0x0E, 0x78, 0x00, 0x3B, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF7, 0x80,
  0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x0E,
  0x01, 0xE0, 0x38, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x3C, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x03,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xF0, 0x3E, 0x1C, 0xFF, 0x1F, 0xF3, 0xBF, 0xF7, 0xFF, 0x7C,
  0x0F, 0xC0, 0xEF, 0x00, 0xF0, 0x1F, 0xE0, 0x1C, 0x01, 0xF8, 0x03, 0x80,
  0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80,
  0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01,
  0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01,
  0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F,
  0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E,
  0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x70,
  0x00, 0x7F, 0x03, 0x87, 0xFF, 0x0E, 0x3F, 0xFE, 0x3B, 0xC0, 0x7C, 0xEC,
  0x00, 0x73, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFE, 0x03, 0x8F, 0xFE, 0x0E, 0xFF, 0xFC, 0x3B, 0x80, 0xF8, 0xF8,
  0x00, 0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEF, 0x00, 0x07, 0x3E, 0x00, 0x3C, 0xFC, 0x01, 0xE3, 0xBC, 0x1F, 0x0E,
  0x7F, 0xF8, 0x38, 0x7F, 0xC0, 0xE0, 0x10, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x70, 0xFF, 0xFD, 0xC7, 0xC0, 0x7F, 0x1E,
  0x00, 0x7C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xE0, 0x00,
  0x73, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0xFC, 0x3E, 0x0F, 0x70,
  0x7F, 0xF9, 0xC0, 0xFF, 0xC7, 0x00, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0x01, 0xEF, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0x80, 0x7C, 0x38, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x7C, 0x00, 0x78,
  0xFC, 0x07, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7E, 0x04, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D,
  0xE0, 0x03, 0xE7, 0x00, 0x3F, 0x3E, 0x0F, 0xB8, 0xFF, 0xF9, 0xC1, 0xFF,
  0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07,
  0xE0, 0x0F, 0x00, 0x6E, 0x00, 0xF0, 0x0E, 0x60, 0x1F, 0x00, 0xE7, 0x01,
  0xB0, 0x0E, 0x70, 0x1B, 0x80, 0xC7, 0x01, 0xB8, 0x0C, 0x30, 0x39, 0x81,
  0xC3, 0x03, 0x98, 0x1C, 0x38, 0x31, 0xC1, 0xC3, 0x83, 0x1C, 0x18, 0x38,
  0x70, 0xC1, 0x81, 0x87, 0x0C, 0x38, 0x1C, 0x60, 0xE3, 0x81, 0xC6, 0x0E,
  0x30, 0x1C, 0xE0, 0x63, 0x00, 0xCE, 0x06, 0x30, 0x0C, 0xC0, 0x77, 0x00,
  0xEC, 0x07, 0x70, 0x0E, 0xC0, 0x36, 0x00, 0xFC, 0x03, 0x60, 0x07, 0x80,
  0x36, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x87, 0x80,
  0x07, 0x81, 0xC0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x0F,
  0x03, 0xC0, 0x03, 0x83, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x79, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xBC, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x00,
  0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x80, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0x7F, 0xF8, 0x00, 0x77, 0x03, 0xC0, 0x06, 0xE0, 0x1F, 0x00, 0xEE,
  0x00, 0xF8, 0x1E, 0xC0, 0x03, 0xF7, 0xCC, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0x00,
};

const GFXglyph RobotoMono_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 4, 37, 31, 13, -37 },
  { 20, 11, 11, 31, 10, -39 },
  { 36, 28, 37, 31, 2, -37 },
  { 166, 22, 48, 31, 5, -43 },
  { 298, 29, 39, 31, 1, -38 },
  { 440, 27, 39, 31, 3, -38 },
  { 572, 3, 11, 31, 13, -39 },
  { 577, 12, 53, 31, 10, -41 },
  { 657, 12, 53, 31, 9, -41 },
  { 737, 23, 23, 31, 5, -37 },
  { 804, 25, 27, 31, 3, -31 },
  { 889, 5, 12, 31, 10, -5 },
  { 897, 19, 3, 31, 6, -18 },
  { 905, 5, 5, 31, 14, -5 },
  { 909, 18, 40, 31, 7, -37 },
  { 999, 23, 39, 31, 4, -38 },
  { 1112, 13, 37, 31, 6, -37 },
  { 1173, 23, 37, 31, 3, -37 },
  { 1280, 24, 38, 31, 2, -37 },
  { 1394, 26, 37, 31, 2, -37 },
  { 1515, 23, 38, 31, 5, -37 },
  { 1625, 23, 38, 31, 4, -37 },
  { 1735, 24, 37, 31, 3, -37 },
  { 1846, 24, 38, 31, 4, -37 },
  { 1960, 23, 37, 31, 4, -37 },
  { 2067, 5, 27, 31, 15, -27 },
  { 2084, 7, 34, 31, 13, -27 },
  { 2114, 22, 22, 31, 4, -28 },
  { 2175, 23, 13, 31, 4, -23 },
  { 2213, 22, 22, 31, 5, -28 },
  { 2274, 20, 37, 31, 6, -37 },
  { 2367, 29, 37, 31, 1, -37 },
  { 2502, 26, 37, 31, 3, -37 },
  { 2623, 23, 37, 31, 5, -37 },
  { 2730, 25, 39, 31, 3, -38 },
  { 2852, 24, 37, 31, 5, -37 },
  { 2963, 22, 37, 31, 5, -37 },
  { 3065, 22, 37, 31, 5, -37 },
  { 3167, 25, 38, 31, 3, -37 },
  { 3286, 23, 37, 31, 4, -37 },
  { 3393, 21, 37, 31, 5, -37 },
  { 3491, 23, 38, 31, 3, -37 },
  { 3601, 25, 37, 31, 5, -37 },
  { 3717, 21, 37, 31, 6, -37 },
  { 3815, 24, 37, 31, 4, -37 },
  { 3926, 23, 37, 31, 4, -37 },
  { 4033, 25, 38, 31, 3, -37 },
  { 4152, 23, 37, 31, 6, -37 },
  { 4259, 26, 43, 31, 3, -37 },
  { 4399, 24, 37, 31, 5, -37 },
  { 4510, 25, 38, 31, 3, -37 },
  { 4629, 27, 37, 31, 2, -37 },
  { 4754, 23, 38, 31, 4, -37 },
  { 4864, 27, 37, 31, 2, -37 },
  { 4989, 28, 37, 31, 2, -37 },
  { 5119, 26, 37, 31, 3, -37 },
  { 5240, 27, 37, 31, 2, -37 },
  { 5365, 24, 37, 31, 3, -37 },
  { 5476, 9, 50, 31, 11, -42 },
  { 5533, 18, 40, 31, 7, -37 },
  { 5623, 9, 50, 31, 11, -42 },
  { 5680, 19, 20, 31, 6, -37 },
  { 5728, 23, 3, 31, 4, 0 },
  { 5737, 8, 7, 31, 12, -38 },
  { 5744, 23, 29, 31, 4, -28 },
  { 5828, 22, 40, 31, 5, -39 },
  { 5938, 23, 29, 31, 4, -28 },
  { 6022, 22, 40, 31, 4, -39 },
  { 6132, 23, 29, 31, 4, -28 },
  { 6216, 23, 40, 31, 5, -40 },
  { 6331, 22, 39, 31, 4, -28 },
  { 6439, 22, 39, 31, 5, -39 },
  { 6547, 22, 37, 31, 6, -37 },
  { 6649, 16, 48, 31, 5, -37 },
  { 6745, 22, 39, 31, 6, -39 },
  { 6853, 22, 39, 31, 6, -39 },
  { 6961, 27, 28, 31, 2, -28 },
  { 7056, 22, 28, 31, 5, -28 },
  { 7133, 25, 29, 31, 3, -28 },
  { 7224, 22, 39, 31, 5, -28 },
  { 7332, 22, 39, 31, 4, -28 },
  { 7440, 18, 28, 31, 9, -28 },
  { 7503, 22, 29, 31, 5, -28 },
  { 7583, 22, 36, 31, 4, -35 },
  { 7682, 21, 28, 31, 5, -27 },
  { 7756, 25, 27, 31, 3, -27 },
  { 7841, 28, 27, 31, 2, -27 },
  { 7936, 25, 27, 31, 3, -27 },
  { 8021, 27, 38, 31, 2, -27 },
  { 8150, 24, 27, 31, 4, -27 },
  { 8231, 17, 51, 31, 8, -41 },
  { 8340, 3, 45, 31, 14, -37 },
  { 8357, 17, 51, 31, 8, -41 },
  { 8466, 28, 9, 31, 2, -20 },
};

const GFXfont RobotoMono_Light52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light52pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_LIGHT52PT7B_H_
