#ifndef _ROBOTOMONO_LIGHT61PT7B_H_
#define _ROBOTOMONO_LIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xCF, 0xFF, 0xDE, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0x00, 0x07, 0x00, 0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x10, 0x06, 0x00, 0xE0,
  0x0E, 0x03, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x06, 0x01, 0xC0, 0x38, 0x01,
  0x80, 0x70, 0x0E, 0x00, 0x60, 0x38, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0,
  0x0E, 0x07, 0x00, 0x1C, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0xE0, 0x01,
  0xE0, 0x70, 0x38, 0x00, 0x3C, 0x3C, 0x1C, 0x00, 0x07, 0xFE, 0x0F, 0x00,
  0x00, 0xFF, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00,
  0x38, 0x3F, 0xE0, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x0F, 0x0F, 0x07, 0x80,
  0x03, 0x83, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x70, 0x70, 0x07,
  0x00, 0x38, 0x1C, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x07, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x07,
  0x00, 0x70, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x38, 0xF0, 0x1E, 0x00, 0xF1, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x1E, 0x03,
  0xCF, 0x00, 0x1E, 0x07, 0x3C, 0x00, 0x3E, 0x0E, 0x78, 0x00, 0x3C, 0x3C,
  0xF0, 0x00, 0x3C, 0x79, 0xE0, 0x00, 0x3D, 0xE3, 0xC0, 0x00, 0x3F, 0xC7,
  0x80, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xF8, 0x1E, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x7E, 0xF8, 0x1F,
  0xEF, 0xF8, 0xF0, 0x1F, 0xFF, 0xC0, 0xF0, 0x0F, 0xFE, 0x00, 0xF0, 0x01,
  0x80, 0x00, 0x00, 0x77, 0x77, 0x77, 0x7F, 0xEE, 0xEE, 0xEE, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x02,
  0x70, 0x07, 0x00, 0xE7, 0xE0, 0x70, 0x3E, 0xFF, 0xC7, 0x1F, 0xF3, 0xFF,
  0x7F, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x00, 0x0E, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xC7, 0x9E, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x11, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3D, 0xFC, 0x00,
  0x0F, 0x3F, 0x80, 0x03, 0xC7, 0xF0, 0x00, 0xF0, 0xFE, 0x00, 0x3C, 0x1F,
  0xC0, 0x1F, 0x03, 0xF8, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x0F, 0xE0, 0x78,
  0x01, 0xFC, 0x1E, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xF1, 0xE0, 0x00, 0xFF,
  0x78, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x7C, 0x03, 0xF8, 0x3F, 0xF1, 0xFE, 0xFF, 0xF1, 0xFF, 0x03, 0xF8, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0xFE, 0x00, 0x3D, 0xFF, 0xE0, 0x0E, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xFC, 0x07, 0xF8, 0x3C, 0x00, 0x3F, 0x02, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x3F, 0xF0, 0x0F, 0x1F, 0xFF, 0x81, 0xCF,
  0xFF, 0xF8, 0x3B, 0xE0, 0x1F, 0x87, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x1E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x1D, 0xC3, 0xE0, 0x0F, 0xB8, 0x3F, 0x8F, 0xE7, 0x03, 0xFF,
  0xF8, 0xE0, 0x1F, 0xFC, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x23, 0xEF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x3E, 0xFF, 0xFF, 0xDE, 0x0C, 0x3E, 0x3F, 0x3F,
  0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE0,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x3E, 0x00, 0x7C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x10, 0x07, 0x07, 0x00, 0xFF, 0x01, 0x87, 0x00, 0xFF, 0xC0, 0xE3, 0x80,
  0xF0, 0xF0, 0x71, 0x80, 0xF0, 0x38, 0x19, 0xC0, 0x70, 0x18, 0x0C, 0xE0,
  0x70, 0x0C, 0x06, 0x60, 0x38, 0x06, 0x03, 0xB0, 0x38, 0x03, 0x01, 0xF8,
  0x1C, 0x01, 0x80, 0xFC, 0x0E, 0x00, 0xC0, 0x7E, 0x06, 0x00, 0x60, 0x3F,
  0x07, 0x00, 0x70, 0x1F, 0x83, 0x80, 0x38, 0x0F, 0x81, 0xC0, 0x1C, 0x06,
  0xC0, 0xE0, 0x0E, 0x03, 0x60, 0x70, 0x06, 0x01, 0xB0, 0x38, 0x03, 0x00,
  0xDC, 0x1C, 0x03, 0x80, 0xEE, 0x0E, 0x01, 0xC0, 0x77, 0x03, 0x01, 0xE0,
  0x33, 0x81, 0xC0, 0xF8, 0x39, 0xC0, 0xE1, 0xDC, 0x38, 0x60, 0x3F, 0xC7,
  0xBC, 0x38, 0x1F, 0xE3, 0xFC, 0x1C, 0x07, 0xC0, 0x78, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x01, 0xFF,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x7F, 0x0E,
  0x00, 0x03, 0xE1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xC3, 0x80,
  0x03, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x38, 0x00, 0x3F, 0x87, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0xFB, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x7D, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x07, 0xC7, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xE0, 0x7E, 0x00, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x0F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x34, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C,
  0x7C, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x0F, 0x7F, 0x80, 0x00, 0x7B, 0xFE,
  0x00, 0x03, 0xFC, 0xF0, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFB, 0x80, 0x03, 0xBF, 0x70, 0x00, 0x77,
  0xEF, 0x00, 0x1E, 0xFC, 0xE0, 0x03, 0x9F, 0x9C, 0x00, 0xF3, 0xF3, 0xC0,
  0x1C, 0x7E, 0x38, 0x03, 0x8F, 0xC7, 0x80, 0xF1, 0xF8, 0x70, 0x1C, 0x3F,
  0x0E, 0x03, 0x87, 0xE1, 0xE0, 0xF0, 0xFC, 0x1C, 0x1C, 0x1F, 0x83, 0x87,
  0x83, 0xF0, 0x78, 0xE0, 0x7E, 0x07, 0x1C, 0x0F, 0xC0, 0xE7, 0x81, 0xF8,
  0x1E, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0,
  0x1C, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x78,
  0x00, 0x0F, 0xEF, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x3F, 0x8E, 0x00, 0x07,
  0xF1, 0xE0, 0x00, 0xFE, 0x1C, 0x00, 0x1F, 0xC3, 0xC0, 0x03, 0xF8, 0x3C,
  0x00, 0x7F, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x01, 0xFC, 0x0F, 0x00, 0x3F,
  0x80, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x1C,
  0x03, 0xF8, 0x03, 0xC0, 0x7F, 0x00, 0x38, 0x0F, 0xE0, 0x07, 0x81, 0xFC,
  0x00, 0x78, 0x3F, 0x80, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0xFE, 0x00, 0x1E,
  0x1F, 0xC0, 0x01, 0xE3, 0xF8, 0x00, 0x3C, 0x7F, 0x00, 0x03, 0xCF, 0xE0,
  0x00, 0x39, 0xFC, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x77, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x78,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x01, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x8F, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3E, 0x38, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1F,
  0x07, 0x80, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0F,
  0xF0, 0x07, 0xC0, 0x0E, 0xF0, 0x07, 0xE0, 0x0E, 0xF0, 0x07, 0xE0, 0x0E,
  0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0xE0, 0x1E,
  0x70, 0x0E, 0xE0, 0x1E, 0x78, 0x0E, 0x70, 0x1C, 0x78, 0x0E, 0x70, 0x1C,
  0x78, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x38, 0x1C, 0x70, 0x1C,
  0x38, 0x1C, 0x38, 0x3C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x1C, 0x38, 0x38,
  0x3C, 0x1C, 0x38, 0x38, 0x3C, 0x38, 0x38, 0x38, 0x1C, 0x38, 0x3C, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0x70,
  0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0,
  0x03, 0xC7, 0x00, 0x0E, 0x1E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xF0, 0x07,
  0x03, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x38, 0x1C, 0x00,
  0xF0, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1E, 0x78, 0x00, 0x39,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xF0, 0x7F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xE7,
  0xC0, 0x03, 0xFC, 0x7C, 0x01, 0xF7, 0x87, 0xFF, 0xFC, 0xF0, 0x7F, 0xFF,
  0x0E, 0x07, 0xFF, 0x81, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x0F, 0x0F, 0xFE, 0x03, 0xCF, 0xFF, 0xC0,
  0xF7, 0xE3, 0xFC, 0x3F, 0xC0, 0x1F, 0x0F, 0xC0, 0x01, 0xE3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x73, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x3F, 0x80, 0x0F,
  0x8E, 0xF0, 0x07, 0xC3, 0x9F, 0xFF, 0xE0, 0xE3, 0xFF, 0xF0, 0x38, 0x3F,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x78,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0x9F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x1F, 0xFC, 0x3C, 0x1F, 0xFF, 0xCF,
  0x0F, 0xF1, 0xFB, 0xC7, 0xE0, 0x0F, 0xF1, 0xE0, 0x01, 0xFC, 0xF0, 0x00,
  0x3F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xC7, 0x80, 0x07,
  0xF0, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xEF, 0x03, 0xFF, 0xF3, 0xC0, 0x7F,
  0xF0, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x00, 0x78, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x41, 0xF0, 0x00, 0x0E, 0x0F, 0x80, 0x01, 0xE0, 0x7E,
  0x00, 0x7C, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0xF0, 0x7F, 0xFF, 0x3C, 0x3F,
  0xCF, 0xEF, 0x1F, 0x80, 0x3F, 0xC7, 0x80, 0x07, 0xF3, 0xC0, 0x00, 0xFC,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0xC3,
  0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xBC, 0x0F, 0xFF, 0xCF, 0x01, 0xFF, 0xC3,
  0xC0, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE1, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x7C, 0x03, 0x81, 0xFF, 0xC1, 0xC3, 0xFF, 0xF8, 0xE3, 0xF0, 0xFE,
  0x73, 0xC0, 0x1F, 0x3B, 0x80, 0x07, 0xDD, 0x80, 0x01, 0xEF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xBC, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x83, 0xC0,
  0x03, 0xE0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x1F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0x00, 0x07, 0xF1, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x78,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0xC1, 0xCF, 0xFC, 0x3F, 0xE3,
  0xBF, 0xF8, 0xFF, 0xE7, 0xF1, 0xFB, 0xE7, 0xEF, 0x80, 0xFE, 0x03, 0xDE,
  0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0xE0,
  0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00,
  0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07,
  0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0,
  0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00,
  0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x0F, 0x80, 0x70, 0x3F, 0xF8, 0x38, 0x7F, 0xFF, 0x1C, 0x7E, 0x1F,
  0xCE, 0x78, 0x03, 0xE7, 0x70, 0x00, 0xFB, 0xB0, 0x00, 0x3D, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x7C, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0xF7, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x38, 0x7F, 0xF8, 0x0E, 0x3F, 0xFF, 0x03, 0x9F, 0x8F,
  0xE0, 0xEF, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x78, 0xFC, 0x00, 0x3E, 0x3B, 0xC0,
  0x1F, 0x0E, 0x7F, 0x7F, 0x83, 0x8F, 0xFF, 0xC0, 0xE0, 0xFF, 0xC0, 0x38,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0xF0, 0x7F, 0xFF,
  0x3C, 0x3F, 0x87, 0xEF, 0x1F, 0x80, 0x3F, 0xC7, 0x80, 0x07, 0xF3, 0xC0,
  0x00, 0xFC, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0x1E, 0x00,
  0x1F, 0xC3, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xBC, 0x0F, 0xFF, 0xCF, 0x01,
  0xFF, 0xC3, 0xC0, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF7, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7C, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x3E, 0x00,
  0x3F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC1, 0xFF,
  0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE,
  0x00, 0x07, 0xE7, 0x80, 0x07, 0xF3, 0xE0, 0x0F, 0x78, 0xFF, 0xFF, 0x3C,
  0x3F, 0xFF, 0x0E, 0x07, 0xFE, 0x07, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x70, 0x01, 0xEE, 0x00,
  0x7C, 0x00, 0xE7, 0x00, 0x3E, 0x00, 0x73, 0x80, 0x1B, 0x00, 0x39, 0xE0,
  0x0D, 0x80, 0x1C, 0x70, 0x0E, 0xE0, 0x1C, 0x38, 0x07, 0x70, 0x0E, 0x1C,
  0x03, 0xB8, 0x07, 0x0E, 0x01, 0x8C, 0x03, 0x87, 0x81, 0xC7, 0x03, 0xC1,
  0xC0, 0xE3, 0x81, 0xC0, 0xE0, 0x71, 0xC0, 0xE0, 0x70, 0x30, 0x60, 0x70,
  0x38, 0x38, 0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x38, 0x07, 0x0E, 0x0E, 0x1C,
  0x03, 0x86, 0x03, 0x0E, 0x01, 0xC7, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE3,
  0x80, 0x39, 0xC0, 0x73, 0x80, 0x1C, 0xC0, 0x19, 0xC0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x07, 0x70, 0x07, 0x70, 0x01, 0xB8, 0x03, 0xB0, 0x00, 0xF8, 0x00,
  0xD8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0xF8, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00,
  0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x02, 0x0F, 0xFE, 0x00, 0x01, 0xCF, 0xFF, 0xC0, 0x00, 0xEF, 0x03,
  0xF0, 0x00, 0xE7, 0x00, 0x7C, 0x00, 0x77, 0x80, 0x1F, 0x80, 0x7B, 0x80,
  0x03, 0xE0, 0x79, 0xC0, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00,
};

const GFXglyph RobotoMono_Light61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 5, 43, 37, 15, -43 },
  { 28, 12, 14, 37, 12, -46 },
  { 49, 33, 43, 37, 2, -43 },
  { 227, 27, 56, 37, 5, -50 },
  { 416, 34, 45, 37, 1, -44 },
  { 608, 31, 45, 37, 4, -44 },
  { 783, 4, 14, 37, 15, -46 },
  { 790, 15, 63, 37, 11, -49 },
  { 909, 15, 63, 37, 10, -49 },
  { 1028, 28, 26, 37, 5, -43 },
  { 1119, 29, 32, 37, 4, -36 },
  { 1235, 7, 15, 37, 11, -6 },
  { 1249, 22, 3, 37, 7, -21 },
  { 1258, 6, 6, 37, 16, -6 },
  { 1263, 22, 47, 37, 8, -43 },
  { 1393, 27, 45, 37, 5, -44 },
  { 1545, 15, 43, 37, 7, -43 },
  { 1626, 28, 44, 37, 3, -44 },
  { 1780, 27, 45, 37, 3, -44 },
  { 1932, 31, 43, 37, 2, -43 },
  { 2099, 26, 44, 37, 6, -43 },
  { 2242, 27, 45, 37, 4, -44 },
  { 2394, 28, 43, 37, 4, -43 },
  { 2545, 28, 45, 37, 5, -44 },
  { 2703, 27, 44, 37, 5, -44 },
  { 2852, 6, 32, 37, 18, -32 },
  { 2876, 8, 41, 37, 16, -32 },
  { 2917, 25, 25, 37, 5, -32 },
  { 2996, 27, 15, 37, 5, -27 },
  { 3047, 26, 25, 37, 5, -32 },
  { 3129, 24, 44, 37, 7, -44 },
  { 3261, 33, 44, 37, 2, -44 },
  { 3443, 31, 43, 37, 3, -43 },
  { 3610, 27, 43, 37, 6, -43 },
  { 3756, 29, 45, 37, 4, -44 },
  { 3920, 28, 43, 37, 5, -43 },
  { 4071, 26, 43, 37, 6, -43 },
  { 4211, 26, 43, 37, 6, -43 },
  { 4351, 29, 45, 37, 4, -44 },
  { 4515, 27, 43, 37, 5, -43 },
  { 4661, 25, 43, 37, 6, -43 },
  { 4796, 28, 44, 37, 3, -43 },
  { 4950, 29, 43, 37, 6, -43 },
  { 5106, 25, 43, 37, 7, -43 },
  { 5241, 27, 43, 37, 5, -43 },
  { 5387, 27, 43, 37, 5, -43 },
  { 5533, 29, 45, 37, 4, -44 },
  { 5697, 28, 43, 37, 6, -43 },
  { 5848, 31, 52, 37, 3, -44 },
  { 6050, 28, 43, 37, 6, -43 },
  { 6201, 29, 45, 37, 4, -44 },
  { 6365, 31, 43, 37, 3, -43 },
  { 6532, 27, 44, 37, 5, -43 },
  { 6681, 31, 43, 37, 3, -43 },
  { 6848, 32, 43, 37, 3, -43 },
  { 7020, 31, 43, 37, 3, -43 },
  { 7187, 32, 43, 37, 2, -43 },
  { 7359, 28, 43, 37, 4, -43 },
  { 7510, 11, 59, 37, 13, -50 },
  { 7592, 21, 47, 37, 8, -43 },
  { 7716, 10, 59, 37, 13, -50 },
  { 7790, 22, 23, 37, 7, -43 },
  { 7854, 26, 3, 37, 5, 0 },
  { 7864, 9, 8, 37, 14, -45 },
  { 7873, 27, 34, 37, 5, -33 },
  { 7988, 26, 47, 37, 6, -46 },
  { 8141, 26, 34, 37, 5, -33 },
  { 8252, 26, 47, 37, 5, -46 },
  { 8405, 28, 34, 37, 4, -33 },
  { 8524, 28, 47, 37, 5, -47 },
  { 8689, 26, 46, 37, 5, -33 },
  { 8839, 25, 46, 37, 6, -46 },
  { 8983, 26, 44, 37, 7, -44 },
  { 9126, 19, 57, 37, 6, -44 },
  { 9262, 27, 46, 37, 6, -46 },
  { 9418, 26, 46, 37, 7, -46 },
  { 9568, 31, 33, 37, 3, -33 },
  { 9696, 25, 33, 37, 6, -33 },
  { 9800, 29, 34, 37, 4, -33 },
  { 9924, 26, 45, 37, 6, -33 },
  { 10071, 26, 45, 37, 5, -33 },
  { 10218, 21, 33, 37, 11, -33 },
  { 10305, 26, 34, 37, 6, -33 },
  { 10416, 26, 41, 37, 5, -40 },
  { 10550, 25, 33, 37, 6, -32 },
  { 10654, 30, 32, 37, 3, -32 },
  { 10774, 33, 32, 37, 2, -32 },
  { 10906, 29, 32, 37, 4, -32 },
  { 11022, 32, 45, 37, 2, -32 },
  { 11202, 29, 32, 37, 4, -32 },
  { 11318, 20, 60, 37, 10, -48 },
  { 11468, 3, 53, 37, 17, -43 },
  { 11488, 20, 60, 37, 10, -48 },
  { 11638, 33, 10, 37, 2, -23 },
};

const GFXfont RobotoMono_Light61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light61pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_LIGHT61PT7B_H_
