#ifndef _ROBOTOMONO_LIGHT8PT7B_H_
#define _ROBOTOMONO_LIGHT8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x32, 0x9E, 0xAF, 0x30, 0x4E, 0xC7, 0x6A, 0xC6, 0xB8,
  0x66, 0x9C, 0xCA, 0xCD, 0xAF, 0xC0, 0x5A, 0xA5, 0xD5, 0x56, 0x5D, 0x50,
  0x22, 0xF2, 0xC0, 0xE0, 0x80, 0x25, 0x25, 0x00, 0xD6, 0xFB, 0xC0, 0x75,
  0x50, 0x69, 0x12, 0x4F, 0x69, 0x13, 0x97, 0x12, 0x55, 0xF1, 0xF3, 0x1B,
  0xC0, 0x53, 0x5B, 0xC0, 0xF1, 0x12, 0x24, 0xD6, 0xFB, 0xC0, 0xD6, 0xF3,
  0x80, 0x90, 0x98, 0x71, 0x80, 0xFC, 0xC7, 0x00, 0xD4, 0xA0, 0x80, 0x75,
  0x77, 0xBB, 0x38, 0x21, 0x14, 0xA7, 0x44, 0xD6, 0xFB, 0xC0, 0x69, 0x88,
  0x97, 0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x69, 0x8B,
  0x97, 0xB6, 0xFB, 0x40, 0xE9, 0x25, 0xC0, 0x11, 0x11, 0x97, 0x9A, 0xCC,
  0xAB, 0x92, 0x49, 0xC0, 0xB6, 0xFB, 0x40, 0xB6, 0xFB, 0x40, 0x69, 0x99,
  0x97, 0xF6, 0xE9, 0x00, 0x69, 0x99, 0x97, 0x10, 0xD6, 0xEB, 0x40, 0xF6,
  0x3B, 0xC0, 0xF2, 0x22, 0x22, 0xB6, 0xDB, 0xC0, 0x99, 0x55, 0x62, 0xAD,
  0x6B, 0xA5, 0x28, 0x8A, 0x88, 0x45, 0x4C, 0x95, 0x52, 0x22, 0x71, 0x22,
  0x4F, 0xFF, 0x91, 0x24, 0x40, 0xFF, 0x5A, 0x80, 0xE0, 0x80, 0xEE, 0xF0,
  0x9A, 0xDB, 0xC0, 0xF2, 0x70, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0x7D, 0x24,
  0x80, 0xF6, 0xF3, 0x80, 0x9A, 0xDB, 0x40, 0x51, 0x25, 0xC0, 0x65, 0x56,
  0x92, 0xED, 0x40, 0xC9, 0x25, 0xC0, 0xFB, 0xBB, 0xF6, 0xD0, 0xF6, 0xF0,
  0xF6, 0xF9, 0x00, 0xF6, 0xF2, 0x40, 0xF2, 0x40, 0xF8, 0xF0, 0xE9, 0x26,
  0xB6, 0xF0, 0x95, 0x62, 0xAD, 0x54, 0xA0, 0xAB, 0x50, 0x95, 0x52, 0x24,
  0xEA, 0x70, 0x69, 0x44, 0x91, 0xFE, 0xC9, 0x14, 0x94, 0xF8,
};

const GFXglyph RobotoMono_Light8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 1, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 5, 1, -6 },
  { 17, 1, 2, 5, 2, -6 },
  { 18, 2, 8, 5, 1, -6 },
  { 20, 2, 8, 5, 1, -6 },
  { 22, 3, 4, 5, 1, -6 },
  { 24, 4, 4, 5, 0, -5 },
  { 26, 1, 2, 5, 1, -1 },
  { 27, 3, 1, 5, 1, -3 },
  { 28, 1, 1, 5, 2, -1 },
  { 29, 3, 6, 5, 1, -6 },
  { 32, 3, 6, 5, 1, -6 },
  { 35, 2, 6, 5, 1, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 3, 6, 5, 1, -6 },
  { 49, 3, 6, 5, 1, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 3, 6, 5, 1, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 1, 4, 5, 2, -4 },
  { 62, 1, 5, 5, 2, -4 },
  { 63, 3, 3, 5, 1, -4 },
  { 65, 3, 2, 5, 1, -4 },
  { 66, 3, 3, 5, 1, -4 },
  { 68, 3, 6, 5, 1, -6 },
  { 71, 5, 6, 5, 0, -6 },
  { 75, 5, 6, 5, 0, -6 },
  { 79, 3, 6, 5, 1, -6 },
  { 82, 4, 6, 5, 0, -6 },
  { 85, 3, 6, 5, 1, -6 },
  { 88, 3, 6, 5, 1, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 4, 6, 5, 0, -6 },
  { 97, 3, 6, 5, 1, -6 },
  { 100, 3, 6, 5, 1, -6 },
  { 103, 4, 6, 5, 0, -6 },
  { 106, 4, 6, 5, 1, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 3, 6, 5, 1, -6 },
  { 118, 4, 6, 5, 0, -6 },
  { 121, 3, 6, 5, 1, -6 },
  { 124, 4, 7, 5, 0, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 4, 6, 5, 0, -6 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 4, 6, 5, 0, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 4, 6, 5, 0, -6 },
  { 157, 1, 8, 5, 2, -7 },
  { 158, 3, 6, 5, 1, -6 },
  { 161, 1, 8, 5, 2, -7 },
  { 162, 3, 3, 5, 1, -6 },
  { 164, 3, 1, 5, 1, 0 },
  { 165, 1, 1, 5, 2, -6 },
  { 166, 3, 4, 5, 1, -4 },
  { 168, 3, 6, 5, 1, -6 },
  { 171, 3, 4, 5, 1, -4 },
  { 173, 3, 6, 5, 1, -6 },
  { 176, 3, 4, 5, 1, -4 },
  { 178, 3, 6, 5, 1, -6 },
  { 181, 3, 6, 5, 1, -4 },
  { 184, 3, 6, 5, 1, -6 },
  { 187, 3, 6, 5, 1, -6 },
  { 190, 2, 8, 5, 1, -6 },
  { 192, 3, 6, 5, 1, -6 },
  { 195, 3, 6, 5, 1, -6 },
  { 198, 4, 4, 5, 0, -4 },
  { 200, 3, 4, 5, 1, -4 },
  { 202, 3, 4, 5, 1, -4 },
  { 204, 3, 6, 5, 1, -4 },
  { 207, 3, 6, 5, 1, -4 },
  { 210, 3, 4, 5, 1, -4 },
  { 212, 3, 4, 5, 1, -4 },
  { 214, 3, 5, 5, 1, -5 },
  { 216, 3, 4, 5, 1, -4 },
  { 218, 4, 4, 5, 0, -4 },
  { 220, 5, 4, 5, 0, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 4, 6, 5, 0, -4 },
  { 228, 3, 4, 5, 1, -4 },
  { 230, 3, 8, 5, 1, -6 },
  { 233, 1, 7, 5, 2, -6 },
  { 234, 3, 8, 5, 1, -6 },
  { 237, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_Light8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light8pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_LIGHT8PT7B_H_
