#ifndef _ROBOTOMONO_LIGHT30PT7B_H_
#define _ROBOTOMONO_LIGHT30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xC0, 0x03, 0x0C, 0x03, 0x0C, 0x02, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x06,
  0x18, 0x7F, 0xFF, 0x04, 0x18, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x0C,
  0x30, 0x0C, 0x30, 0x08, 0x20, 0xFF, 0xFE, 0x08, 0x20, 0x18, 0x60, 0x18,
  0x60, 0x10, 0x40, 0x10, 0x40, 0x30, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0E, 0x01, 0xFC, 0x18, 0x31, 0x80, 0xC8, 0x06, 0xC0, 0x1E, 0x00, 0xD0,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0x80, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0xCF, 0x1C, 0x1F, 0xC0,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x7C, 0x00, 0xC6, 0x00, 0x86,
  0x08, 0x82, 0x18, 0x82, 0x30, 0x82, 0x20, 0x86, 0x60, 0xCC, 0x40, 0x78,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x3E, 0x02, 0x63, 0x06,
  0x61, 0x0C, 0x41, 0x08, 0x41, 0x18, 0x41, 0x08, 0x61, 0x00, 0x63, 0x00,
  0x3E, 0x02, 0x00, 0x3F, 0x80, 0x63, 0x01, 0x83, 0x03, 0x06, 0x06, 0x0C,
  0x0C, 0x10, 0x18, 0x60, 0x1B, 0x80, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x03,
  0x30, 0x6C, 0x30, 0xF0, 0x61, 0xE0, 0x62, 0xC0, 0x6D, 0x80, 0x73, 0x00,
  0xE3, 0x01, 0xC7, 0x0E, 0xC3, 0xF0, 0xC0, 0xFE, 0x04, 0x1C, 0x20, 0xC3,
  0x04, 0x18, 0x30, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03,
  0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xC0, 0x81, 0xC1, 0x00,
  0x81, 0x81, 0x81, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x08, 0x30, 0x41,
  0x86, 0x18, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0E, 0x23,
  0xBD, 0x78, 0x3E, 0x00, 0xE0, 0x0D, 0x80, 0xC6, 0x0C, 0x30, 0x60, 0xC2,
  0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x6D, 0xB5, 0xA0, 0xFF, 0xE0, 0x5F,
  0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x7F,
  0x83, 0x87, 0x0C, 0x06, 0x60, 0x19, 0x80, 0x24, 0x01, 0xF0, 0x0F, 0xC0,
  0x6F, 0x03, 0x3C, 0x18, 0xF0, 0xC3, 0xC6, 0x0F, 0x30, 0x3D, 0x80, 0xFC,
  0x03, 0x40, 0x09, 0x80, 0x66, 0x01, 0x8C, 0x0C, 0x18, 0x70, 0x3F, 0x00,
  0x03, 0x1F, 0x7B, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x00, 0x7F,
  0x83, 0x87, 0x18, 0x06, 0x60, 0x19, 0x00, 0x6C, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFD, 0xFF, 0xF0,
  0x03, 0x80, 0x7F, 0x83, 0x83, 0x18, 0x06, 0x60, 0x19, 0x80, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0x9C, 0x06, 0x38,
  0x70, 0x3F, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B,
  0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x10, 0x60, 0x60, 0xC1,
  0x81, 0x82, 0x03, 0x0C, 0x06, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x3F, 0xF9, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0xE0, 0x7F, 0xC3, 0x87, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x78, 0x03, 0xC0, 0x1A, 0x01,
  0x98, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0x03, 0xE0, 0x78, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0xF8, 0xDF, 0xE7, 0x81, 0xB8, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x60, 0x1B, 0x00, 0xCC,
  0x0C, 0x39, 0xC0, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x02, 0x01, 0xFE, 0x1C, 0x18, 0xC0,
  0x6C, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x02, 0x60, 0x33, 0x83, 0x07, 0xF0,
  0x3F, 0x87, 0x06, 0x60, 0x1B, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0xC0, 0x67, 0x0E, 0x0F, 0xE0, 0x07, 0x00, 0x7F, 0x03, 0x87, 0x18,
  0x0C, 0x60, 0x19, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x36,
  0x01, 0xD8, 0x06, 0x30, 0x28, 0x7F, 0xA0, 0xF9, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x0F, 0xC0, 0x7C, 0x00, 0x5F, 0x80, 0x00,
  0x00, 0x00, 0xBF, 0x27, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66,
  0xCC, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x80, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80,
  0x0E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x0E, 0x07,
  0x81, 0xE0, 0xF8, 0x0C, 0x00, 0x80, 0x00, 0x07, 0x03, 0xFC, 0x70, 0xE6,
  0x03, 0xC0, 0x3C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x07, 0xF8, 0x0C, 0x0C, 0x18, 0x06, 0x30, 0x02,
  0x61, 0xE2, 0x43, 0x33, 0x46, 0x31, 0xC4, 0x21, 0x8C, 0x21, 0x8C, 0x21,
  0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x8C, 0x62, 0x8C, 0xE2, 0xC7, 0xBC,
  0x43, 0x18, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x30, 0x0F, 0xE0, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20,
  0x06, 0x30, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x18,
  0x1F, 0xF8, 0x1F, 0xFC, 0x30, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x06,
  0x60, 0x02, 0xC0, 0x03, 0xFF, 0x86, 0x07, 0x30, 0x0D, 0x80, 0x6C, 0x01,
  0x60, 0x0B, 0x00, 0xD8, 0x06, 0xC0, 0x67, 0xFE, 0x3F, 0xF9, 0x80, 0xEC,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0xFF,
  0xCF, 0xF8, 0x00, 0x03, 0x80, 0x7F, 0x83, 0x83, 0x0C, 0x06, 0x60, 0x19,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0D, 0x80, 0x36, 0x01,
  0x8C, 0x06, 0x1C, 0x70, 0x3F, 0x00, 0xFF, 0x04, 0x0E, 0x20, 0x19, 0x00,
  0x68, 0x03, 0x40, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x34, 0x03, 0xA0,
  0x39, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xF6, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0x3F, 0xF9, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0x3F, 0xF9, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x83, 0x83, 0x1C, 0x06, 0x60, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x81, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x36, 0x00,
  0xCC, 0x03, 0x1C, 0x38, 0x3F, 0x80, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xFF, 0xF0, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x01, 0x98, 0x0C, 0x73, 0xC1,
  0xFC, 0x00, 0xC0, 0x1F, 0x00, 0xCC, 0x06, 0x30, 0x30, 0xC1, 0xC3, 0x06,
  0x0C, 0x30, 0x31, 0x80, 0xCC, 0x03, 0x70, 0x0F, 0xE0, 0x39, 0x80, 0xE3,
  0x03, 0x06, 0x0C, 0x1C, 0x30, 0x30, 0xC0, 0x63, 0x00, 0xCC, 0x03, 0xB0,
  0x06, 0xC0, 0x0C, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xD0, 0x2F, 0x61,
  0xBC, 0x86, 0xF3, 0x13, 0xCC, 0xCF, 0x12, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0C, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xD8, 0x0F,
  0x60, 0x3C, 0xC0, 0xF1, 0x03, 0xC6, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0x63,
  0xC1, 0x8F, 0x03, 0x3C, 0x0C, 0xF0, 0x1B, 0xC0, 0x6F, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x0C, 0x03, 0x00, 0x7F, 0x83, 0x87, 0x0C, 0x0C, 0x60,
  0x19, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x66,
  0x01, 0x8C, 0x0C, 0x1C, 0xE0, 0x3F, 0x00, 0xFF, 0xC3, 0x01, 0xCC, 0x03,
  0xB0, 0x06, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00,
  0xEC, 0x0F, 0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xC0,
  0xE1, 0xC3, 0x00, 0xC6, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0x80,
  0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x01,
  0x60, 0x06, 0xC0, 0x0C, 0x80, 0x19, 0x80, 0x61, 0x81, 0x83, 0xCF, 0x01,
  0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xC3, 0x03,
  0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x33, 0x01, 0xCC, 0x1E, 0x3F, 0xE0, 0xC1, 0x83, 0x03, 0x0C, 0x0C, 0x30,
  0x18, 0xC0, 0x63, 0x00, 0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1C, 0x01, 0x00,
  0x7F, 0x83, 0x83, 0x98, 0x06, 0x60, 0x0D, 0x00, 0x36, 0x00, 0xD8, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0xDC, 0x07, 0x3C, 0x78, 0x3F,
  0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40,
  0x19, 0x80, 0x63, 0x03, 0x0F, 0x3C, 0x0F, 0xC0, 0xC0, 0x07, 0x60, 0x06,
  0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x04, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0xC1, 0x83, 0xC1, 0x83, 0x41, 0xC3, 0x41, 0xC3, 0x61, 0xC3,
  0x63, 0x42, 0x63, 0x42, 0x62, 0x62, 0x62, 0x66, 0x22, 0x66, 0x26, 0x26,
  0x36, 0x26, 0x36, 0x24, 0x34, 0x34, 0x34, 0x34, 0x3C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x18, 0xC0, 0x0E, 0xC0, 0x19,
  0xC0, 0x61, 0x81, 0x81, 0x83, 0x03, 0x0C, 0x03, 0x18, 0x02, 0x60, 0x07,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x18,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0x31, 0x80, 0x67, 0x00, 0x6C, 0x00, 0x60,
  0xE0, 0x07, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x10,
  0x08, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0xFF, 0x80, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x04, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43,
  0xFF, 0x80, 0x0C, 0x03, 0x01, 0xE0, 0x48, 0x33, 0x0C, 0xC2, 0x11, 0x86,
  0x40, 0xB0, 0x3C, 0x0C, 0xFF, 0xFF, 0xFF, 0xC6, 0x23, 0x0F, 0xC0, 0xF3,
  0xC3, 0x03, 0x18, 0x06, 0x60, 0x18, 0x00, 0x60, 0x01, 0x83, 0xFE, 0x38,
  0x19, 0x80, 0x64, 0x01, 0xB0, 0x06, 0x40, 0x19, 0x80, 0xE7, 0x8F, 0x87,
  0xE3, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x19, 0xF0, 0xF9, 0xE7, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x01, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xB0, 0x0D, 0x80, 0x6E, 0x06, 0x7C,
  0x73, 0x7E, 0x00, 0x0F, 0xC0, 0xE7, 0x8C, 0x0E, 0xC0, 0x36, 0x00, 0xA0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x16, 0x01,
  0x98, 0x0C, 0x71, 0xC1, 0xFC, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x61, 0xF3, 0x1C, 0xF9, 0x81, 0xD8, 0x06, 0xC0,
  0x34, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1A, 0x00, 0xD8, 0x06,
  0xC0, 0x33, 0x03, 0x9C, 0x7C, 0x3F, 0x60, 0x0F, 0xC0, 0x7B, 0xC3, 0x03,
  0x98, 0x06, 0x60, 0x0B, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x61, 0xC3, 0x83, 0xF8, 0x01,
  0xF8, 0x1F, 0xC1, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x1F, 0xFE,
  0xFF, 0xF0, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x0F, 0x98, 0xE7, 0xCC, 0x0E, 0xC0, 0x36, 0x01, 0xA0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x36, 0x01, 0x98, 0x1C,
  0xE3, 0xE1, 0xFB, 0x00, 0x18, 0x00, 0xC0, 0x06, 0xC0, 0x63, 0x8E, 0x07,
  0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0xFC, 0xDC, 0xEE, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10,
  0x02, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x81, 0x9F, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x07, 0xC0, 0x66, 0x06,
  0x30, 0x61, 0x86, 0x0C, 0xE0, 0x6E, 0x03, 0xF0, 0x1E, 0xC0, 0xC7, 0x06,
  0x1C, 0x30, 0x61, 0x81, 0x8C, 0x06, 0x60, 0x1B, 0x00, 0x60, 0xFF, 0x07,
  0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0,
  0xDF, 0x3C, 0xF3, 0x6E, 0xE1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0x8F, 0xCD, 0xCE, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x0F, 0xC0, 0x73, 0x83,
  0x03, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x19, 0xC0, 0xE3, 0x87, 0x03, 0xF0,
  0xCF, 0x87, 0xCE, 0x38, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0B, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x05, 0x80, 0x6C, 0x03, 0x70, 0x33, 0xC3,
  0x9B, 0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x0F, 0x99, 0xE7, 0xCC, 0x0E, 0xC0, 0x36, 0x01, 0xA0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x36, 0x01, 0x98, 0x1C, 0xE1,
  0xE1, 0xFB, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0xC7, 0xFB, 0xFF, 0x40, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x1F, 0xC1,
  0xCF, 0x18, 0x0D, 0x80, 0x6C, 0x01, 0xB0, 0x01, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x3C, 0x01, 0xE0, 0x19, 0xC3, 0xC3, 0xF8,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF, 0xFF, 0xFC, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xE2, 0x03, 0xF0, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x07, 0x71, 0xD3, 0xF9, 0xC0, 0x0F, 0x00,
  0x34, 0x00, 0x98, 0x06, 0x60, 0x18, 0xC0, 0xC3, 0x03, 0x04, 0x08, 0x18,
  0x60, 0x61, 0x00, 0xCC, 0x03, 0x30, 0x04, 0x80, 0x1E, 0x00, 0x30, 0x00,
  0xC0, 0xC1, 0x81, 0xC1, 0x83, 0xC1, 0x83, 0x41, 0xC3, 0x43, 0xC2, 0x63,
  0x42, 0x62, 0x46, 0x22, 0x66, 0x26, 0x64, 0x26, 0x24, 0x34, 0x24, 0x34,
  0x3C, 0x1C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE0, 0x0D, 0x80,
  0x63, 0x03, 0x06, 0x0C, 0x0C, 0x60, 0x33, 0x00, 0x78, 0x00, 0xC0, 0x03,
  0x80, 0x1E, 0x00, 0xCC, 0x06, 0x18, 0x18, 0x30, 0xC0, 0xE6, 0x01, 0xB0,
  0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x08, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x03, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xFF, 0xFB, 0xFF,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x3C, 0x0E, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0F,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0C, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xF0, 0x1C, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x00,
  0x7E, 0x01, 0x63, 0x83, 0xC1, 0xC3, 0x80, 0xFE, 0x00, 0x3C,
};

const GFXglyph RobotoMono_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 2, 21, 18, 8, -21 },
  { 7, 6, 7, 18, 6, -23 },
  { 13, 16, 21, 18, 1, -21 },
  { 55, 13, 28, 18, 3, -25 },
  { 101, 16, 22, 18, 1, -22 },
  { 145, 15, 22, 18, 2, -22 },
  { 187, 1, 7, 18, 8, -23 },
  { 188, 7, 31, 18, 6, -24 },
  { 216, 7, 31, 18, 5, -24 },
  { 244, 13, 13, 18, 3, -21 },
  { 266, 14, 16, 18, 2, -18 },
  { 294, 3, 7, 18, 6, -3 },
  { 297, 11, 1, 18, 3, -10 },
  { 299, 3, 3, 18, 8, -3 },
  { 301, 11, 23, 18, 4, -21 },
  { 333, 14, 22, 18, 2, -22 },
  { 372, 8, 21, 18, 3, -21 },
  { 393, 14, 22, 18, 1, -22 },
  { 432, 14, 22, 18, 1, -22 },
  { 471, 15, 21, 18, 1, -21 },
  { 511, 13, 21, 18, 3, -21 },
  { 546, 13, 21, 18, 2, -21 },
  { 581, 14, 21, 18, 2, -21 },
  { 618, 13, 22, 18, 3, -22 },
  { 654, 14, 22, 18, 2, -22 },
  { 693, 3, 16, 18, 9, -16 },
  { 699, 4, 20, 18, 8, -16 },
  { 709, 13, 13, 18, 2, -16 },
  { 731, 13, 7, 18, 3, -13 },
  { 743, 12, 13, 18, 3, -16 },
  { 763, 12, 22, 18, 3, -22 },
  { 796, 16, 21, 18, 1, -21 },
  { 838, 16, 21, 18, 1, -21 },
  { 880, 13, 21, 18, 3, -21 },
  { 915, 14, 22, 18, 2, -22 },
  { 954, 13, 21, 18, 3, -21 },
  { 989, 13, 21, 18, 3, -21 },
  { 1024, 13, 21, 18, 3, -21 },
  { 1059, 14, 22, 18, 2, -22 },
  { 1098, 14, 21, 18, 2, -21 },
  { 1135, 12, 21, 18, 3, -21 },
  { 1167, 13, 21, 18, 2, -21 },
  { 1202, 14, 21, 18, 3, -21 },
  { 1239, 13, 21, 18, 3, -21 },
  { 1274, 14, 21, 18, 2, -21 },
  { 1311, 14, 21, 18, 2, -21 },
  { 1348, 14, 22, 18, 2, -22 },
  { 1387, 14, 21, 18, 3, -21 },
  { 1424, 15, 26, 18, 2, -22 },
  { 1473, 14, 21, 18, 3, -21 },
  { 1510, 14, 22, 18, 2, -22 },
  { 1549, 16, 21, 18, 1, -21 },
  { 1591, 14, 21, 18, 2, -21 },
  { 1628, 16, 21, 18, 1, -21 },
  { 1670, 16, 21, 18, 1, -21 },
  { 1712, 15, 21, 18, 2, -21 },
  { 1752, 16, 21, 18, 1, -21 },
  { 1794, 14, 21, 18, 2, -21 },
  { 1831, 5, 29, 18, 7, -24 },
  { 1850, 10, 23, 18, 4, -21 },
  { 1879, 5, 29, 18, 6, -24 },
  { 1898, 10, 11, 18, 4, -21 },
  { 1912, 12, 2, 18, 3, 0 },
  { 1915, 4, 4, 18, 7, -22 },
  { 1917, 14, 16, 18, 2, -16 },
  { 1945, 13, 23, 18, 3, -23 },
  { 1983, 13, 16, 18, 2, -16 },
  { 2009, 13, 23, 18, 2, -23 },
  { 2047, 14, 16, 18, 2, -16 },
  { 2075, 13, 23, 18, 3, -23 },
  { 2113, 13, 22, 18, 2, -16 },
  { 2149, 12, 23, 18, 3, -23 },
  { 2184, 13, 22, 18, 3, -22 },
  { 2220, 9, 28, 18, 3, -22 },
  { 2252, 13, 23, 18, 3, -23 },
  { 2290, 13, 23, 18, 3, -23 },
  { 2328, 16, 16, 18, 1, -16 },
  { 2360, 12, 16, 18, 3, -16 },
  { 2384, 14, 16, 18, 2, -16 },
  { 2412, 13, 22, 18, 3, -16 },
  { 2448, 13, 22, 18, 2, -16 },
  { 2484, 11, 16, 18, 5, -16 },
  { 2506, 13, 16, 18, 3, -16 },
  { 2532, 13, 20, 18, 2, -20 },
  { 2565, 12, 16, 18, 3, -16 },
  { 2589, 14, 16, 18, 2, -16 },
  { 2617, 16, 16, 18, 1, -16 },
  { 2649, 14, 16, 18, 2, -16 },
  { 2677, 16, 22, 18, 1, -16 },
  { 2721, 14, 16, 18, 2, -16 },
  { 2749, 10, 29, 18, 5, -23 },
  { 2786, 2, 26, 18, 8, -21 },
  { 2793, 10, 29, 18, 5, -23 },
  { 2830, 16, 6, 18, 1, -12 },
};

const GFXfont RobotoMono_Light30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light30pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_LIGHT30PT7B_H_
