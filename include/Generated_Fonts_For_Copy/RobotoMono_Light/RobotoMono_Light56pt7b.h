#ifndef _ROBOTOMONO_LIGHT56PT7B_H_
#define _ROBOTOMONO_LIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x7F, 0xEE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x60, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x07,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3B,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x1F, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x38, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x06, 0x01, 0xC1, 0x80, 0x0E, 0x07,
  0x07, 0x00, 0x0E, 0x1E, 0x0C, 0x00, 0x1F, 0xF8, 0x38, 0x00, 0x1F, 0xE0,
  0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x03, 0xF8, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x18, 0x38,
  0x78, 0x00, 0x70, 0xE0, 0x30, 0x01, 0xC1, 0xC0, 0x70, 0x03, 0x83, 0x00,
  0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0x1C, 0x1C, 0x01, 0x80, 0x70, 0x38, 0x03,
  0x00, 0xC0, 0x70, 0x06, 0x03, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0xC0, 0x38,
  0x04, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0xE3, 0xC1, 0xE0, 0x0E, 0x78,
  0x0F, 0x00, 0xE7, 0x00, 0x78, 0x0E, 0xF0, 0x03, 0xC0, 0xEE, 0x00, 0x1E,
  0x1C, 0xE0, 0x01, 0xE1, 0xCE, 0x00, 0x0F, 0x1C, 0xE0, 0x00, 0x7B, 0x8E,
  0x00, 0x03, 0xF8, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0x70, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xF8, 0x3C, 0x00, 0xFB, 0xC1, 0xF8, 0x7F, 0x3C,
  0x0F, 0xFF, 0xC1, 0xE0, 0x3F, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x20, 0x40, 0x01,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00,
  0x60, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x80, 0x38, 0x02, 0x70, 0x1C, 0x07, 0x7F, 0x0E, 0x0F, 0xFF,
  0xE7, 0x3F, 0xE3, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x7B, 0xBD, 0xC4, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01,
  0xFC, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xEF, 0xE0, 0x01, 0xE7, 0xF0, 0x01, 0xE3, 0xF8, 0x01,
  0xE1, 0xFC, 0x01, 0xE0, 0xFE, 0x01, 0xE0, 0x7F, 0x01, 0xE0, 0x3F, 0x81,
  0xC0, 0x1F, 0xC1, 0xC0, 0x0F, 0xE3, 0xC0, 0x07, 0xF3, 0xC0, 0x03, 0xFB,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xEF, 0xC0, 0x00, 0x77, 0xC0, 0x00, 0x3B,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x07,
  0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC0, 0xFF, 0x1F, 0xFD, 0xFC,
  0x7F, 0xC1, 0xFC, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x78, 0x03,
  0xE0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x03, 0xE0, 0x0F, 0x83, 0xC0,
  0x03, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x87,
  0x80, 0x03, 0xC3, 0xE0, 0x03, 0xC0, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x10, 0x00, 0x39, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x78, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x3E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3F, 0x81, 0xF8, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC1, 0xFE, 0x00, 0xE3, 0xFF,
  0xC0, 0x73, 0xFF, 0xF8, 0x7B, 0xC0, 0x7E, 0x3B, 0x80, 0x0F, 0x1F, 0x80,
  0x03, 0xCF, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9E, 0x00, 0x03,
  0xC7, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x0F,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0xF9, 0xE0, 0x00, 0xFC, 0x78, 0x01, 0xEE, 0x1F, 0x03, 0xE7, 0x07,
  0xFF, 0xE7, 0x01, 0xFF, 0xE3, 0x80, 0x1F, 0x81, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0x78, 0x1E,
  0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0xF0, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0x80, 0x7C, 0x7C, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x1C,
  0x01, 0xE0, 0x38, 0xE0, 0x1F, 0xC0, 0xE3, 0x81, 0xFF, 0x81, 0x8C, 0x07,
  0x07, 0x06, 0x70, 0x38, 0x18, 0x19, 0x81, 0xC0, 0x60, 0x76, 0x06, 0x01,
  0x81, 0xF8, 0x18, 0x06, 0x03, 0xE0, 0xE0, 0x18, 0x0F, 0x03, 0x00, 0x60,
  0x3C, 0x0C, 0x01, 0x80, 0xF0, 0x30, 0x06, 0x03, 0xC1, 0xC0, 0x38, 0x0F,
  0x07, 0x00, 0xE0, 0x7C, 0x1C, 0x03, 0x81, 0xB0, 0x70, 0x0C, 0x06, 0xC1,
  0xC0, 0x30, 0x1B, 0x07, 0x01, 0xC0, 0x6C, 0x0C, 0x07, 0x03, 0xB8, 0x38,
  0x3E, 0x0C, 0xE0, 0xE1, 0xB8, 0x73, 0x81, 0xFE, 0x7F, 0x86, 0x07, 0xF0,
  0xFC, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x38, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x7F,
  0x0F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x1C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x87, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xCF, 0x00, 0x0F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xE7, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x1F,
  0x80, 0xE0, 0x01, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x38,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0xC3, 0x80, 0x03, 0xE0, 0xE0, 0x03, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x87, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x8E, 0x00,
  0x07, 0x87, 0x80, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07,
  0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0xC0,
  0x00, 0x7B, 0xF8, 0x00, 0x0F, 0x7F, 0x80, 0x01, 0xFE, 0x78, 0x00, 0x3F,
  0x87, 0x80, 0x07, 0xE0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xDF, 0xF0, 0x00, 0xEF, 0xF8, 0x00,
  0x77, 0xEE, 0x00, 0x73, 0xF7, 0x00, 0x39, 0xFB, 0x80, 0x3C, 0xFC, 0xE0,
  0x1C, 0x7E, 0x70, 0x0E, 0x3F, 0x3C, 0x0E, 0x1F, 0x8E, 0x07, 0x0F, 0xC7,
  0x03, 0x87, 0xE1, 0xC3, 0x83, 0xF0, 0xE1, 0xC3, 0xF8, 0x71, 0xC1, 0xFC,
  0x1C, 0xE0, 0xFE, 0x0E, 0x70, 0x7F, 0x07, 0x70, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x1E, 0x03, 0xF8, 0x0E, 0x01,
  0xFC, 0x03, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF7, 0x00, 0x03, 0xFB, 0xC0, 0x01,
  0xFC, 0xE0, 0x00, 0xFE, 0x78, 0x00, 0x7F, 0x1C, 0x00, 0x3F, 0x87, 0x00,
  0x1F, 0xC3, 0xC0, 0x0F, 0xE0, 0xE0, 0x07, 0xF0, 0x78, 0x03, 0xF8, 0x1C,
  0x01, 0xFC, 0x0F, 0x00, 0xFE, 0x03, 0x80, 0x7F, 0x01, 0xE0, 0x3F, 0x80,
  0x70, 0x1F, 0xC0, 0x3C, 0x0F, 0xE0, 0x0E, 0x07, 0xF0, 0x03, 0x83, 0xF8,
  0x01, 0xE1, 0xFC, 0x00, 0x70, 0xFE, 0x00, 0x3C, 0x7F, 0x00, 0x0E, 0x3F,
  0x80, 0x07, 0x9F, 0xC0, 0x01, 0xCF, 0xE0, 0x00, 0xF7, 0xF0, 0x00, 0x3B,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x07, 0xB8, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x8E, 0x00, 0x1F, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x3F, 0x9F, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x04, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x0F, 0x87, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x00,
  0xF8, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x38, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x83,
  0xC0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x3F, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xF0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x1D,
  0xC0, 0x0E, 0x00, 0x77, 0x00, 0x78, 0x01, 0xDC, 0x01, 0xE0, 0x07, 0x70,
  0x07, 0xC0, 0x1D, 0xC0, 0x1F, 0x00, 0xE7, 0x00, 0x7C, 0x03, 0x9C, 0x03,
  0xF0, 0x0E, 0x78, 0x0E, 0xC0, 0x38, 0xE0, 0x3B, 0x80, 0xE3, 0x80, 0xEE,
  0x03, 0x8E, 0x03, 0x38, 0x0E, 0x38, 0x0C, 0xE0, 0x70, 0xE0, 0x73, 0x81,
  0xC3, 0x81, 0xC6, 0x07, 0x0F, 0x07, 0x1C, 0x1C, 0x1C, 0x1C, 0x70, 0x70,
  0x70, 0x61, 0xC1, 0xC1, 0xC3, 0x87, 0x07, 0x07, 0x0E, 0x0C, 0x1C, 0x1C,
  0x38, 0x38, 0xE0, 0x70, 0xE0, 0xE3, 0x81, 0xC3, 0x03, 0x8E, 0x03, 0x9C,
  0x0E, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x77,
  0x00, 0x7E, 0x00, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x3C, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x78, 0x1C, 0x03, 0x83, 0x80, 0x38,
  0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xE7, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xF0, 0x0E, 0x3E, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x7E, 0x7C, 0x01, 0xEE, 0x3F, 0x9F, 0xCF, 0x1F, 0xFF, 0x8F, 0x0F,
  0xFE, 0x0F, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0xF1, 0xFF, 0xE0, 0xF7,
  0xFF, 0xF0, 0xFF, 0x00, 0xF8, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x3C, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xFC, 0x00, 0x3C, 0xFE,
  0x00, 0xF8, 0xF7, 0xE7, 0xF0, 0xF3, 0xFF, 0xE0, 0xF0, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xF0, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x03,
  0xC0, 0x0F, 0x80, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0x07, 0x03, 0xFF, 0xC7, 0x07, 0xFF, 0xE7,
  0x0F, 0x80, 0xF7, 0x1F, 0x00, 0x3F, 0x1C, 0x00, 0x1F, 0x3C, 0x00, 0x0F,
  0x38, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x78, 0x00, 0x07,
  0x38, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x7F,
  0x07, 0xE3, 0xF7, 0x03, 0xFF, 0xE7, 0x01, 0xFF, 0x87, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0x07, 0xC0, 0x01,
  0xE0, 0xF8, 0x01, 0xF0, 0x1F, 0xC3, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0x03, 0xFF, 0xC7, 0x07, 0xFF, 0xE7, 0x0F, 0x80,
  0xF7, 0x1F, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x38, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x78, 0x00, 0x07, 0x38, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x7F, 0x07, 0xE3,
  0xF7, 0x03, 0xFF, 0xE7, 0x01, 0xFF, 0x87, 0x00, 0x08, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x0F, 0x81, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0xF0, 0xFF,
  0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0x80, 0x7C, 0xF6, 0x00, 0x3C, 0xFC, 0x00,
  0x1E, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0xF8, 0xE0, 0x01, 0xF0, 0xE0, 0x03,
  0xE0, 0xE0, 0x07, 0xC0, 0xE0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x3C,
  0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0,
  0x00, 0xE7, 0xC0, 0x00, 0xEF, 0xE0, 0x00, 0xFE, 0xF0, 0x00, 0xFC, 0x78,
  0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8,
  0x1F, 0xC7, 0x3F, 0xF1, 0xFF, 0x3B, 0xFF, 0x9F, 0xFD, 0xD8, 0x1F, 0xC1,
  0xEF, 0x80, 0x7C, 0x07, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x1E, 0x00, 0xFE,
  0x00, 0xE0, 0x07, 0xF0, 0x07, 0x00, 0x3F, 0x80, 0x38, 0x01, 0xFC, 0x01,
  0xC0, 0x0F, 0xE0, 0x0E, 0x00, 0x7F, 0x00, 0x70, 0x03, 0xF8, 0x03, 0x80,
  0x1F, 0xC0, 0x1C, 0x00, 0xFE, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0x00, 0x3F,
  0x80, 0x38, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0xE0, 0x0E, 0x00, 0x7F, 0x00,
  0x70, 0x03, 0xF8, 0x03, 0x80, 0x1F, 0xC0, 0x1C, 0x00, 0xFE, 0x00, 0xE0,
  0x07, 0xF0, 0x07, 0x00, 0x3F, 0x80, 0x38, 0x01, 0xFC, 0x01, 0xC0, 0x0F,
  0xE0, 0x0E, 0x00, 0x7F, 0x00, 0x70, 0x03, 0xF8, 0x03, 0x80, 0x1C, 0xE0,
  0x3F, 0xC0, 0xE0, 0xFF, 0xF0, 0xE3, 0xFF, 0xF8, 0xE7, 0x80, 0x7C, 0xEE,
  0x00, 0x3C, 0xEC, 0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x3F, 0x87, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x7F,
  0x00, 0xE1, 0xFF, 0xC0, 0xF7, 0xFF, 0xF0, 0xFF, 0x01, 0xF8, 0xFE, 0x00,
  0x78, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x3C, 0xFC, 0x00, 0x3C, 0xFE, 0x00, 0xF8, 0xF7, 0xC3, 0xF0, 0xF3, 0xFF,
  0xE0, 0xF0, 0xFF, 0x80, 0xF0, 0x08, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0x03, 0xFF, 0xC7, 0x07, 0xFF, 0xE7, 0x0F, 0x80,
  0xF7, 0x1F, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x78, 0x00, 0x07, 0x3C, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x7F, 0x07, 0xE1,
  0xF7, 0x03, 0xFF, 0xE7, 0x01, 0xFF, 0x87, 0x00, 0x08, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xF0, 0x1E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x3E, 0x00,
  0x3E, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x38, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x0C, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0xFC, 0xF8, 0x03, 0xB8, 0xFC, 0x7F, 0x70,
  0xFF, 0xF8, 0xE0, 0x7F, 0xE1, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80,
  0x3C, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x1F, 0x80, 0x0C,
  0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x70, 0x07, 0x80,
  0x39, 0xC0, 0x1E, 0x00, 0xE7, 0x00, 0xFC, 0x03, 0x9C, 0x03, 0xF0, 0x0E,
  0x70, 0x0C, 0xC0, 0x30, 0xE0, 0x33, 0x01, 0xC3, 0x81, 0xCE, 0x07, 0x0E,
  0x07, 0x38, 0x1C, 0x38, 0x18, 0x60, 0x70, 0x60, 0x61, 0x81, 0x81, 0xC3,
  0x87, 0x0E, 0x07, 0x0E, 0x1C, 0x38, 0x1C, 0x30, 0x30, 0xE0, 0x70, 0xC0,
  0xC3, 0x00, 0xC7, 0x03, 0x8C, 0x03, 0x9C, 0x0E, 0x70, 0x0E, 0x60, 0x19,
  0xC0, 0x39, 0x80, 0x67, 0x00, 0x6E, 0x01, 0xD8, 0x01, 0xB8, 0x07, 0x60,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x63, 0xFF, 0x80, 0x01, 0xDF, 0xBF, 0x80, 0x07, 0x70, 0x1F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0xEE, 0x00, 0x3E, 0x07, 0xB0, 0x00, 0x7F,
  0xFC, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph RobotoMono_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 5, 40, 34, 14, -40 },
  { 26, 11, 12, 34, 11, -42 },
  { 43, 30, 40, 34, 2, -40 },
  { 193, 25, 52, 34, 5, -46 },
  { 356, 31, 41, 34, 1, -40 },
  { 515, 28, 41, 34, 4, -40 },
  { 659, 3, 12, 34, 14, -42 },
  { 664, 14, 58, 34, 10, -45 },
  { 766, 14, 58, 34, 9, -45 },
  { 868, 25, 24, 34, 5, -40 },
  { 943, 28, 29, 34, 3, -33 },
  { 1045, 5, 13, 34, 11, -5 },
  { 1054, 21, 3, 34, 6, -19 },
  { 1062, 5, 5, 34, 15, -5 },
  { 1066, 19, 43, 34, 8, -40 },
  { 1169, 25, 41, 34, 4, -40 },
  { 1298, 14, 40, 34, 6, -40 },
  { 1368, 26, 40, 34, 3, -40 },
  { 1498, 25, 41, 34, 3, -40 },
  { 1627, 29, 40, 34, 2, -40 },
  { 1772, 24, 41, 34, 6, -40 },
  { 1895, 25, 41, 34, 4, -40 },
  { 2024, 27, 40, 34, 3, -40 },
  { 2159, 25, 41, 34, 5, -40 },
  { 2288, 25, 40, 34, 4, -40 },
  { 2413, 6, 29, 34, 16, -29 },
  { 2435, 8, 37, 34, 14, -29 },
  { 2472, 23, 24, 34, 5, -30 },
  { 2541, 24, 14, 34, 5, -25 },
  { 2583, 24, 24, 34, 5, -30 },
  { 2655, 22, 40, 34, 6, -40 },
  { 2765, 30, 40, 34, 2, -40 },
  { 2915, 29, 40, 34, 3, -40 },
  { 3060, 25, 40, 34, 5, -40 },
  { 3185, 27, 41, 34, 3, -40 },
  { 3324, 26, 40, 34, 5, -40 },
  { 3454, 24, 40, 34, 5, -40 },
  { 3574, 23, 40, 34, 6, -40 },
  { 3689, 27, 41, 34, 3, -40 },
  { 3828, 25, 40, 34, 4, -40 },
  { 3953, 23, 40, 34, 5, -40 },
  { 4068, 25, 41, 34, 3, -40 },
  { 4197, 27, 40, 34, 5, -40 },
  { 4332, 24, 40, 34, 6, -40 },
  { 4452, 25, 40, 34, 5, -40 },
  { 4577, 25, 40, 34, 4, -40 },
  { 4702, 27, 41, 34, 3, -40 },
  { 4841, 25, 40, 34, 6, -40 },
  { 4966, 28, 47, 34, 3, -40 },
  { 5131, 25, 40, 34, 6, -40 },
  { 5256, 26, 41, 34, 4, -40 },
  { 5390, 28, 40, 34, 3, -40 },
  { 5530, 25, 41, 34, 4, -40 },
  { 5659, 29, 40, 34, 2, -40 },
  { 5804, 30, 40, 34, 2, -40 },
  { 5954, 29, 40, 34, 3, -40 },
  { 6099, 29, 40, 34, 2, -40 },
  { 6244, 25, 40, 34, 4, -40 },
  { 6369, 10, 55, 34, 12, -46 },
  { 6438, 20, 43, 34, 7, -40 },
  { 6546, 9, 55, 34, 12, -46 },
  { 6608, 20, 22, 34, 7, -40 },
  { 6663, 24, 3, 34, 5, 0 },
  { 6672, 9, 7, 34, 12, -41 },
  { 6680, 24, 31, 34, 5, -30 },
  { 6773, 24, 43, 34, 5, -42 },
  { 6902, 25, 31, 34, 4, -30 },
  { 6999, 24, 43, 34, 4, -42 },
  { 7128, 26, 31, 34, 4, -30 },
  { 7229, 26, 43, 34, 5, -43 },
  { 7369, 24, 42, 34, 4, -30 },
  { 7495, 24, 42, 34, 5, -42 },
  { 7621, 24, 40, 34, 6, -40 },
  { 7741, 18, 52, 34, 5, -40 },
  { 7858, 24, 42, 34, 6, -42 },
  { 7984, 24, 42, 34, 6, -42 },
  { 8110, 29, 30, 34, 2, -30 },
  { 8219, 24, 30, 34, 5, -30 },
  { 8309, 26, 31, 34, 4, -30 },
  { 8410, 24, 41, 34, 5, -30 },
  { 8533, 24, 41, 34, 4, -30 },
  { 8656, 19, 30, 34, 10, -30 },
  { 8728, 24, 31, 34, 5, -30 },
  { 8821, 23, 38, 34, 5, -37 },
  { 8931, 23, 31, 34, 5, -30 },
  { 9021, 28, 30, 34, 3, -30 },
  { 9126, 30, 30, 34, 2, -30 },
  { 9239, 27, 30, 34, 4, -30 },
  { 9341, 29, 42, 34, 2, -30 },
  { 9494, 26, 30, 34, 4, -30 },
  { 9592, 18, 55, 34, 9, -44 },
  { 9716, 3, 49, 34, 15, -40 },
  { 9735, 18, 55, 34, 9, -44 },
  { 9859, 30, 10, 34, 2, -22 },
};

const GFXfont RobotoMono_Light56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light56pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_LIGHT56PT7B_H_
