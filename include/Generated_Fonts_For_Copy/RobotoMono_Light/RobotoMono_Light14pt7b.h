#ifndef _ROBOTOMONO_LIGHT14PT7B_H_
#define _ROBOTOMONO_LIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x7F, 0x24, 0x24, 0xFF,
  0x24, 0x24, 0x28, 0x10, 0xE4, 0x61, 0x40, 0x81, 0x81, 0x86, 0x17, 0x84,
  0x60, 0x92, 0x94, 0xD4, 0x28, 0x12, 0x15, 0x29, 0x29, 0x07, 0x70, 0x91,
  0x22, 0x82, 0x0A, 0x24, 0xC6, 0x84, 0xF4, 0xF0, 0x2A, 0x49, 0x24, 0x92,
  0x44, 0x40, 0x84, 0x22, 0x21, 0x11, 0x12, 0x22, 0x48, 0x10, 0x23, 0xF8,
  0x82, 0x88, 0x80, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xE0, 0xF8,
  0x80, 0x08, 0x84, 0x22, 0x11, 0x08, 0x44, 0x20, 0x79, 0x18, 0x63, 0x96,
  0x9C, 0x61, 0x45, 0xE0, 0x1F, 0x11, 0x11, 0x11, 0x11, 0x7A, 0x28, 0x41,
  0x08, 0x42, 0x08, 0x43, 0xF0, 0x7A, 0x18, 0x41, 0x38, 0x20, 0x61, 0x85,
  0xE0, 0x08, 0x30, 0xA1, 0x44, 0x91, 0x22, 0x3F, 0x08, 0x10, 0x7D, 0x04,
  0x10, 0x7C, 0x10, 0x61, 0x44, 0xE0, 0x39, 0x04, 0x2C, 0xCE, 0x18, 0x61,
  0x85, 0xE0, 0xFC, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21, 0x00, 0x78, 0x8A,
  0x12, 0x27, 0x88, 0xA1, 0x41, 0x84, 0xF8, 0x7A, 0x18, 0x61, 0x85, 0x33,
  0x41, 0x09, 0xC0, 0x82, 0x83, 0x80, 0x0D, 0xC8, 0x1C, 0x0C, 0xFC, 0x0F,
  0xC0, 0xE0, 0x60, 0x46, 0xE0, 0x79, 0x18, 0x41, 0x08, 0x41, 0x00, 0x00,
  0x40, 0x1C, 0x22, 0x5D, 0x95, 0xA5, 0xA5, 0xA5, 0x9E, 0x40, 0x3C, 0x10,
  0x60, 0xA1, 0x44, 0x88, 0x9F, 0x42, 0x85, 0x04, 0xF9, 0x0A, 0x14, 0x2F,
  0x90, 0xA0, 0xC1, 0x85, 0xF0, 0x78, 0x8A, 0x14, 0x18, 0x10, 0x20, 0x41,
  0x84, 0xF0, 0xF9, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC2, 0x85, 0xF0, 0xFE,
  0x08, 0x20, 0xFE, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0xFE, 0x08,
  0x20, 0x82, 0x00, 0x79, 0x0A, 0x0C, 0x08, 0x13, 0xE0, 0xC1, 0x42, 0xF8,
  0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xFC, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x13, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x61, 0x85, 0xE0,
  0x87, 0x0A, 0x24, 0x8A, 0x1A, 0x22, 0x44, 0x85, 0x04, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x83, 0xF0, 0x87, 0x1C, 0xEB, 0xAE, 0xD9, 0x61, 0x86,
  0x10, 0x87, 0x1C, 0x69, 0xA6, 0x58, 0xE3, 0x86, 0x10, 0x78, 0x8A, 0x14,
  0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0xF9, 0x0A, 0x0C, 0x18, 0x5F, 0x20,
  0x40, 0x81, 0x00, 0x79, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0,
  0x10, 0x10, 0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x22, 0x44, 0x85, 0x04, 0x79,
  0x0A, 0x0C, 0x07, 0x01, 0x81, 0x41, 0x84, 0xF8, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85,
  0xE0, 0x83, 0x0A, 0x12, 0x24, 0x89, 0x0A, 0x18, 0x30, 0x20, 0x93, 0x26,
  0x4D, 0x9A, 0xB5, 0xAB, 0x66, 0x44, 0x88, 0x82, 0x89, 0x21, 0x41, 0x06,
  0x0A, 0x24, 0x45, 0x04, 0x87, 0x09, 0x22, 0x43, 0x06, 0x04, 0x08, 0x10,
  0x20, 0xFC, 0x10, 0x84, 0x10, 0x82, 0x10, 0x83, 0xF0, 0xEA, 0xAA, 0xAA,
  0xC0, 0x84, 0x10, 0x84, 0x10, 0x84, 0x10, 0x82, 0xD5, 0x55, 0x55, 0xC0,
  0x23, 0x15, 0x29, 0x80, 0xFC, 0xD0, 0x31, 0x38, 0x41, 0x7E, 0x18, 0x5F,
  0x82, 0x08, 0x2C, 0xCE, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x31, 0x38, 0x60,
  0x82, 0x04, 0x5E, 0x04, 0x10, 0x4D, 0x4E, 0x18, 0x61, 0x86, 0x17, 0xC0,
  0x31, 0x38, 0x61, 0xFA, 0x04, 0x5F, 0x0E, 0x20, 0x87, 0xE2, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x31, 0x38, 0x61, 0x86, 0x18, 0x5F, 0x06, 0x17,
  0x80, 0x82, 0x08, 0x26, 0xE6, 0x18, 0x61, 0x86, 0x18, 0x40, 0x20, 0x30,
  0x42, 0x10, 0x84, 0x27, 0xC0, 0x18, 0x1C, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x2E, 0x00, 0x81, 0x02, 0x04, 0x28, 0x92, 0x28, 0x68, 0x91, 0x12, 0x18,
  0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x6D, 0x26, 0x4C, 0x99, 0x32,
  0x64, 0xC9, 0x13, 0xB8, 0x61, 0x86, 0x18, 0x61, 0x30, 0x9A, 0x14, 0x18,
  0x30, 0xA1, 0x3C, 0x33, 0x38, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x00,
  0x31, 0x38, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10, 0x40, 0x1D, 0x31, 0x08,
  0x42, 0x10, 0x31, 0x38, 0x50, 0x38, 0x18, 0x5F, 0x23, 0xF2, 0x08, 0x20,
  0x82, 0x08, 0x1C, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x87, 0x09, 0x12,
  0x42, 0x86, 0x04, 0x00, 0x89, 0x59, 0x59, 0x56, 0x56, 0x26, 0x22, 0xC6,
  0x90, 0xC0, 0x82, 0x88, 0xA1, 0x80, 0x87, 0x09, 0x12, 0x42, 0x86, 0x04,
  0x10, 0x21, 0x80, 0xFC, 0x10, 0x41, 0x02, 0x08, 0x3F, 0x80, 0x19, 0x08,
  0x42, 0x13, 0x08, 0x21, 0x08, 0x41, 0x04, 0xFF, 0xF0, 0xC1, 0x08, 0x42,
  0x10, 0x62, 0x21, 0x08, 0x44, 0x40, 0x71, 0x8E,
};

const GFXglyph RobotoMono_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 10, 8, 4, -10 },
  { 3, 3, 4, 8, 3, -11 },
  { 5, 8, 10, 8, 0, -10 },
  { 15, 6, 12, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 7, 10, 8, 1, -10 },
  { 43, 1, 4, 8, 3, -11 },
  { 44, 3, 14, 8, 3, -11 },
  { 50, 4, 14, 8, 2, -11 },
  { 57, 7, 6, 8, 1, -10 },
  { 63, 7, 7, 8, 1, -8 },
  { 70, 1, 3, 8, 3, -1 },
  { 71, 5, 1, 8, 2, -5 },
  { 72, 1, 1, 8, 4, -1 },
  { 73, 5, 11, 8, 2, -10 },
  { 80, 6, 10, 8, 1, -10 },
  { 88, 4, 10, 8, 1, -10 },
  { 93, 6, 10, 8, 1, -10 },
  { 101, 6, 10, 8, 1, -10 },
  { 109, 7, 10, 8, 1, -10 },
  { 118, 6, 10, 8, 1, -10 },
  { 126, 6, 10, 8, 1, -10 },
  { 134, 6, 10, 8, 1, -10 },
  { 142, 7, 10, 8, 1, -10 },
  { 151, 6, 10, 8, 1, -10 },
  { 159, 1, 7, 8, 4, -7 },
  { 160, 1, 9, 8, 4, -7 },
  { 162, 6, 5, 8, 1, -7 },
  { 166, 6, 3, 8, 1, -6 },
  { 169, 6, 5, 8, 1, -7 },
  { 173, 6, 10, 8, 1, -10 },
  { 181, 8, 10, 8, 0, -10 },
  { 191, 7, 10, 8, 1, -10 },
  { 200, 7, 10, 8, 1, -10 },
  { 209, 7, 10, 8, 1, -10 },
  { 218, 7, 10, 8, 1, -10 },
  { 227, 6, 10, 8, 1, -10 },
  { 235, 6, 10, 8, 1, -10 },
  { 243, 7, 10, 8, 1, -10 },
  { 252, 6, 10, 8, 1, -10 },
  { 260, 6, 10, 8, 1, -10 },
  { 268, 6, 10, 8, 1, -10 },
  { 276, 7, 10, 8, 1, -10 },
  { 285, 6, 10, 8, 1, -10 },
  { 293, 6, 10, 8, 1, -10 },
  { 301, 6, 10, 8, 1, -10 },
  { 309, 7, 10, 8, 1, -10 },
  { 318, 7, 10, 8, 1, -10 },
  { 327, 7, 12, 8, 1, -10 },
  { 338, 7, 10, 8, 1, -10 },
  { 347, 7, 10, 8, 1, -10 },
  { 356, 7, 10, 8, 1, -10 },
  { 365, 6, 10, 8, 1, -10 },
  { 373, 7, 10, 8, 1, -10 },
  { 382, 7, 10, 8, 1, -10 },
  { 391, 7, 10, 8, 1, -10 },
  { 400, 7, 10, 8, 1, -10 },
  { 409, 6, 10, 8, 1, -10 },
  { 417, 2, 13, 8, 3, -11 },
  { 421, 5, 11, 8, 2, -10 },
  { 428, 2, 13, 8, 3, -11 },
  { 432, 5, 5, 8, 2, -10 },
  { 436, 6, 1, 8, 1, 0 },
  { 437, 2, 2, 8, 3, -10 },
  { 438, 6, 8, 8, 1, -8 },
  { 444, 6, 11, 8, 1, -11 },
  { 453, 6, 8, 8, 1, -8 },
  { 459, 6, 11, 8, 1, -11 },
  { 468, 6, 8, 8, 1, -8 },
  { 474, 7, 11, 8, 1, -11 },
  { 484, 6, 11, 8, 1, -8 },
  { 493, 6, 11, 8, 1, -11 },
  { 502, 5, 10, 8, 2, -10 },
  { 509, 5, 13, 8, 1, -10 },
  { 518, 7, 11, 8, 1, -11 },
  { 528, 5, 11, 8, 2, -11 },
  { 535, 7, 8, 8, 1, -8 },
  { 542, 6, 8, 8, 1, -8 },
  { 548, 7, 8, 8, 1, -8 },
  { 555, 6, 11, 8, 1, -8 },
  { 564, 6, 11, 8, 1, -8 },
  { 573, 5, 8, 8, 2, -8 },
  { 578, 6, 8, 8, 1, -8 },
  { 584, 6, 9, 8, 1, -9 },
  { 591, 6, 7, 8, 1, -7 },
  { 597, 7, 7, 8, 1, -7 },
  { 604, 8, 7, 8, 0, -7 },
  { 611, 7, 7, 8, 1, -7 },
  { 618, 7, 10, 8, 1, -7 },
  { 627, 7, 7, 8, 1, -7 },
  { 634, 5, 14, 8, 2, -11 },
  { 643, 1, 12, 8, 4, -10 },
  { 645, 5, 14, 8, 2, -11 },
  { 654, 8, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_Light14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light14pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_LIGHT14PT7B_H_
