#ifndef _ROBOTOMONO_LIGHT22PT7B_H_
#define _ROBOTOMONO_LIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE3, 0x8C, 0x63, 0x18, 0x80, 0x0C, 0x40, 0x84, 0x08, 0x40,
  0x88, 0x08, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x11, 0x0F,
  0xFE, 0x21, 0x02, 0x30, 0x22, 0x02, 0x20, 0x0C, 0x03, 0x01, 0xE1, 0xCC,
  0x41, 0x90, 0x2C, 0x0D, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xA0,
  0x38, 0x0F, 0x02, 0x61, 0x8F, 0xC0, 0xC0, 0x30, 0x38, 0x02, 0x40, 0x11,
  0x11, 0x88, 0x8C, 0x48, 0x22, 0x41, 0xE4, 0x00, 0x60, 0x02, 0x00, 0x23,
  0x01, 0x24, 0x12, 0x10, 0x90, 0x88, 0x84, 0x02, 0x40, 0x1E, 0x0E, 0x03,
  0x30, 0x21, 0x02, 0x10, 0x21, 0x03, 0x20, 0x14, 0x01, 0x80, 0x3C, 0x06,
  0x62, 0x42, 0x24, 0x12, 0xC1, 0xC4, 0x0C, 0x61, 0xE3, 0xF3, 0xF8, 0x08,
  0x44, 0x42, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x43, 0x18, 0x42, 0x18, 0x43,
  0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x42, 0x18, 0xC2, 0x10, 0x8C, 0x62,
  0x10, 0x8C, 0x44, 0x62, 0x00, 0x0C, 0x03, 0x00, 0xC2, 0x21, 0xFB, 0xC3,
  0x01, 0xC0, 0x48, 0x21, 0x18, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x55, 0xC0,
  0xFF, 0xFF, 0xF0, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x1E, 0x18, 0xC4, 0x1A,
  0x02, 0x80, 0xA0, 0x78, 0x2E, 0x13, 0x88, 0xE4, 0x3E, 0x0F, 0x02, 0x80,
  0xB0, 0x66, 0x10, 0xF8, 0x04, 0x77, 0x61, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x1E, 0x18, 0xC4, 0x0B, 0x02, 0x80, 0x80, 0x20,
  0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0xFF,
  0x1E, 0x1C, 0xC4, 0x0B, 0x02, 0x00, 0xC0, 0x20, 0x18, 0x7C, 0x1F, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x70, 0x36, 0x18, 0xFC, 0x01, 0x80, 0x70, 0x0E,
  0x02, 0xC0, 0xD8, 0x13, 0x04, 0x61, 0x8C, 0x21, 0x88, 0x33, 0x06, 0x7F,
  0xF0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0x9F, 0xE6, 0x01, 0x00, 0x40,
  0x10, 0x05, 0xE1, 0x8E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0xC0, 0xD0, 0x26,
  0x38, 0xFC, 0x06, 0x0E, 0x08, 0x08, 0x0C, 0x04, 0x02, 0xF9, 0x82, 0x81,
  0xC0, 0x60, 0x30, 0x18, 0x0E, 0x0D, 0x84, 0x7C, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x1E, 0x18, 0xC4, 0x0B, 0x02, 0xC0,
  0xB0, 0x24, 0x18, 0xFC, 0x3F, 0x10, 0x28, 0x0E, 0x01, 0x80, 0x70, 0x36,
  0x18, 0xFC, 0x1C, 0x31, 0xB0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC1,
  0xB1, 0x4F, 0x20, 0x10, 0x10, 0x18, 0x18, 0x70, 0x5C, 0x00, 0x00, 0x0B,
  0x80, 0x5C, 0x00, 0x00, 0x09, 0x2D, 0x00, 0x00, 0x81, 0xC3, 0x87, 0x0C,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x1C, 0x38, 0x70, 0xC0,
  0x40, 0x00, 0x1E, 0x31, 0x90, 0x78, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x06,
  0x06, 0x02, 0x01, 0x00, 0x00, 0x00, 0x20, 0x10, 0x07, 0x01, 0x8C, 0x20,
  0x44, 0x02, 0x4F, 0x28, 0x92, 0x91, 0x19, 0x11, 0x91, 0x19, 0x12, 0x93,
  0x29, 0x32, 0x8C, 0xC4, 0x00, 0x60, 0x81, 0xF0, 0x04, 0x00, 0xC0, 0x38,
  0x05, 0x00, 0xB0, 0x12, 0x04, 0x40, 0x8C, 0x10, 0x84, 0x10, 0xFF, 0x1F,
  0xE6, 0x04, 0x80, 0xD0, 0x0E, 0x01, 0xFC, 0x3F, 0xC8, 0x1A, 0x02, 0x80,
  0xA0, 0x28, 0x1B, 0xF8, 0x87, 0x20, 0x28, 0x0E, 0x01, 0x80, 0xE0, 0x28,
  0x1B, 0xF8, 0x0F, 0x06, 0x30, 0x83, 0x20, 0x24, 0x07, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x34, 0x06, 0xC0, 0x8C, 0x20, 0xF8,
  0xF8, 0x23, 0x88, 0x12, 0x02, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xA0, 0x68, 0x33, 0xF0, 0xFF, 0xFF, 0xE0, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xFE, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0x06,
  0x31, 0x83, 0x20, 0x24, 0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x7F,
  0x00, 0xA0, 0x14, 0x02, 0xC0, 0x4C, 0x10, 0xFC, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0xC0, 0xD0, 0x26, 0x18, 0xFC, 0x80, 0x50, 0x12, 0x04, 0x41, 0x88,
  0x61, 0x18, 0x26, 0x05, 0x80, 0xA8, 0x19, 0x82, 0x18, 0x41, 0x08, 0x11,
  0x03, 0x20, 0x34, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0xC0, 0xF0, 0x3C, 0x1F, 0x87, 0xA3, 0xE8, 0xBB, 0x2E, 0x53, 0x94, 0xE3,
  0x38, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x3C,
  0x1A, 0x0D, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0xB0, 0x58, 0x3C, 0x0E,
  0x07, 0x01, 0x0E, 0x06, 0x30, 0x83, 0x20, 0x24, 0x05, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xA0, 0x34, 0x04, 0xC1, 0x8C, 0x60, 0xF8,
  0xFC, 0x30, 0xEC, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x02, 0xFF, 0xBF,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0x06, 0x31, 0x83,
  0x20, 0x24, 0x07, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x14, 0x06, 0xC0, 0x8C, 0x20, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0xFC,
  0x21, 0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x38, 0x0A, 0x06, 0xFF, 0x21, 0x88,
  0x22, 0x0C, 0x81, 0x20, 0x68, 0x0A, 0x03, 0x0F, 0x06, 0x31, 0x81, 0x20,
  0x34, 0x02, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x80, 0x18, 0x01, 0xC0, 0x14,
  0x02, 0x80, 0xCC, 0x30, 0xFC, 0xFF, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x02, 0x80, 0xB0, 0x26, 0x10, 0xF8, 0x80,
  0x38, 0x0D, 0x01, 0x20, 0x26, 0x04, 0x41, 0x88, 0x21, 0x84, 0x11, 0x82,
  0x20, 0x44, 0x05, 0x80, 0xA0, 0x14, 0x03, 0x80, 0x20, 0x84, 0x38, 0x62,
  0x86, 0x2C, 0x62, 0xCE, 0x24, 0xA2, 0x4B, 0x24, 0x96, 0x49, 0x64, 0x94,
  0x51, 0x47, 0x14, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x0C, 0xC0, 0x28, 0x0C,
  0x83, 0x18, 0x41, 0x18, 0x32, 0x02, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x24,
  0x08, 0xC3, 0x08, 0x41, 0x98, 0x16, 0x01, 0x80, 0x38, 0x0D, 0x01, 0x30,
  0x42, 0x08, 0x62, 0x04, 0x40, 0xD0, 0x0A, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xC0, 0x10, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x03,
  0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x0C, 0x04, 0x04, 0x02, 0x03, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x9E, 0x10, 0x18, 0x28, 0x28, 0x64, 0x44, 0x46, 0x82, 0x83, 0xFF, 0x80,
  0xC8, 0x80, 0x1E, 0x31, 0xB0, 0x70, 0x10, 0x08, 0xFD, 0x83, 0x81, 0x80,
  0xC0, 0xF0, 0xEF, 0x90, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x27, 0x8B,
  0x33, 0x06, 0x80, 0xA0, 0x28, 0x0A, 0x03, 0x80, 0xA0, 0x2C, 0x1B, 0x84,
  0xBE, 0x00, 0x1E, 0x31, 0x90, 0x70, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xE0, 0x58, 0x67, 0xC0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xE5, 0x8A,
  0x83, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x02, 0xC3, 0x3E, 0x80,
  0x1E, 0x1C, 0xC4, 0x1A, 0x02, 0x80, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x30,
  0x06, 0x18, 0xFC, 0x03, 0xC3, 0x11, 0x80, 0x60, 0x10, 0x3F, 0xE1, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x00, 0x1C, 0xB1, 0x50, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x58, 0x67, 0xD0, 0x08, 0x0F, 0x04, 0xEE, 0x1C, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x72, 0xCD, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3,
  0xFF, 0x06, 0x0C, 0x00, 0x07, 0xEF, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0xEF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x2C, 0x13, 0x18, 0xCC, 0x36, 0x0F, 0x03, 0xA0, 0xCC,
  0x31, 0x8C, 0x33, 0x06, 0xC0, 0xC0, 0xFC, 0x3F, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0xFF, 0xC0, 0xB9, 0xD9, 0xCE, 0x10, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x10, 0x8E, 0x59, 0xB0,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x0F,
  0x06, 0x31, 0x83, 0x20, 0x24, 0x07, 0x80, 0xF0, 0x1A, 0x03, 0x40, 0x4C,
  0x08, 0xC2, 0x0F, 0x80, 0x9E, 0x51, 0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xE0, 0xF8, 0x57, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x1C, 0xB1,
  0x70, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x58, 0x67, 0xD0,
  0x08, 0x04, 0x02, 0x01, 0x8F, 0xB9, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x1E, 0x31, 0xD0, 0x38, 0x14, 0x01, 0xC0, 0x3C,
  0x03, 0x00, 0xE0, 0x50, 0x67, 0xE0, 0x10, 0x08, 0x04, 0x1F, 0xF1, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x3E, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0xD0, 0xE7,
  0xD0, 0xC0, 0x28, 0x0D, 0x01, 0x30, 0x62, 0x08, 0x61, 0x04, 0x40, 0x88,
  0x0B, 0x01, 0x40, 0x38, 0x02, 0x00, 0x84, 0x38, 0x42, 0x86, 0x2C, 0xA2,
  0x4A, 0x24, 0xA6, 0x49, 0x45, 0x14, 0x71, 0x43, 0x14, 0x30, 0x82, 0x08,
  0x40, 0x6C, 0x18, 0xC2, 0x08, 0x80, 0xB0, 0x0C, 0x01, 0x80, 0x58, 0x19,
  0x06, 0x10, 0x83, 0x60, 0x30, 0x80, 0x38, 0x0D, 0x01, 0x30, 0x22, 0x0C,
  0x61, 0x04, 0x60, 0x88, 0x0B, 0x01, 0x40, 0x38, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x05, 0x80, 0x60, 0x00, 0xFF, 0xBF, 0xE0, 0x10, 0x08, 0x06, 0x03,
  0x01, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x03, 0xFF, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x30, 0x43, 0x03, 0x03, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0xC0, 0xE0, 0xFF, 0xFF, 0xF0, 0xC0, 0xC0, 0x81, 0x83, 0x06, 0x0C,
  0x18, 0x10, 0x30, 0x18, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x0C,
  0x00, 0x78, 0x38, 0x62, 0x83, 0xE0,
};

const GFXglyph RobotoMono_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 1, 16, 13, 6, -16 },
  { 3, 5, 5, 13, 4, -17 },
  { 7, 12, 16, 13, 1, -16 },
  { 31, 10, 20, 13, 2, -18 },
  { 56, 13, 16, 13, 0, -16 },
  { 82, 12, 16, 13, 1, -16 },
  { 106, 1, 5, 13, 6, -17 },
  { 107, 5, 23, 13, 4, -18 },
  { 122, 5, 23, 13, 4, -18 },
  { 137, 10, 10, 13, 2, -16 },
  { 150, 11, 11, 13, 1, -13 },
  { 166, 2, 5, 13, 4, -2 },
  { 168, 8, 2, 13, 3, -8 },
  { 170, 2, 2, 13, 6, -2 },
  { 171, 8, 17, 13, 3, -16 },
  { 188, 10, 16, 13, 2, -16 },
  { 208, 6, 16, 13, 2, -16 },
  { 220, 10, 16, 13, 1, -16 },
  { 240, 10, 16, 13, 1, -16 },
  { 260, 11, 16, 13, 1, -16 },
  { 282, 10, 16, 13, 2, -16 },
  { 302, 9, 16, 13, 2, -16 },
  { 320, 11, 16, 13, 1, -16 },
  { 342, 10, 16, 13, 2, -16 },
  { 362, 9, 16, 13, 2, -16 },
  { 380, 3, 11, 13, 6, -11 },
  { 385, 3, 14, 13, 6, -11 },
  { 391, 9, 10, 13, 2, -12 },
  { 403, 9, 6, 13, 2, -10 },
  { 410, 9, 10, 13, 2, -12 },
  { 422, 9, 16, 13, 2, -16 },
  { 440, 12, 16, 13, 1, -16 },
  { 464, 11, 16, 13, 1, -16 },
  { 486, 10, 16, 13, 2, -16 },
  { 506, 11, 16, 13, 1, -16 },
  { 528, 10, 16, 13, 2, -16 },
  { 548, 9, 16, 13, 2, -16 },
  { 566, 10, 16, 13, 2, -16 },
  { 586, 11, 16, 13, 1, -16 },
  { 608, 10, 16, 13, 2, -16 },
  { 628, 9, 16, 13, 2, -16 },
  { 646, 10, 16, 13, 1, -16 },
  { 666, 11, 16, 13, 2, -16 },
  { 688, 10, 16, 13, 2, -16 },
  { 708, 10, 16, 13, 2, -16 },
  { 728, 9, 16, 13, 2, -16 },
  { 746, 11, 16, 13, 1, -16 },
  { 768, 10, 16, 13, 2, -16 },
  { 788, 11, 19, 13, 1, -16 },
  { 815, 10, 16, 13, 2, -16 },
  { 835, 11, 16, 13, 1, -16 },
  { 857, 11, 16, 13, 1, -16 },
  { 879, 10, 16, 13, 2, -16 },
  { 899, 11, 16, 13, 1, -16 },
  { 921, 12, 16, 13, 1, -16 },
  { 945, 11, 16, 13, 1, -16 },
  { 967, 11, 16, 13, 1, -16 },
  { 989, 10, 16, 13, 1, -16 },
  { 1009, 4, 21, 13, 5, -18 },
  { 1020, 8, 17, 13, 3, -16 },
  { 1037, 3, 21, 13, 5, -18 },
  { 1045, 8, 9, 13, 3, -16 },
  { 1054, 9, 1, 13, 2, 0 },
  { 1056, 3, 3, 13, 5, -16 },
  { 1058, 9, 12, 13, 2, -12 },
  { 1072, 10, 17, 13, 2, -17 },
  { 1094, 9, 12, 13, 2, -12 },
  { 1108, 9, 17, 13, 2, -17 },
  { 1128, 10, 12, 13, 2, -12 },
  { 1143, 10, 17, 13, 2, -17 },
  { 1165, 9, 17, 13, 2, -12 },
  { 1185, 9, 17, 13, 2, -17 },
  { 1205, 10, 16, 13, 2, -16 },
  { 1225, 7, 21, 13, 2, -16 },
  { 1244, 10, 17, 13, 2, -17 },
  { 1266, 10, 17, 13, 2, -17 },
  { 1288, 11, 12, 13, 1, -12 },
  { 1305, 9, 12, 13, 2, -12 },
  { 1319, 11, 12, 13, 1, -12 },
  { 1336, 9, 16, 13, 2, -12 },
  { 1354, 9, 16, 13, 2, -12 },
  { 1372, 8, 12, 13, 4, -12 },
  { 1384, 9, 12, 13, 2, -12 },
  { 1398, 9, 15, 13, 2, -15 },
  { 1415, 9, 12, 13, 2, -12 },
  { 1429, 11, 12, 13, 1, -12 },
  { 1446, 12, 12, 13, 1, -12 },
  { 1464, 11, 12, 13, 1, -12 },
  { 1481, 11, 17, 13, 1, -12 },
  { 1505, 10, 12, 13, 2, -12 },
  { 1520, 7, 21, 13, 4, -17 },
  { 1539, 1, 20, 13, 6, -16 },
  { 1542, 7, 21, 13, 4, -17 },
  { 1561, 12, 3, 13, 1, -8 },
};

const GFXfont RobotoMono_Light22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light22pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_LIGHT22PT7B_H_
