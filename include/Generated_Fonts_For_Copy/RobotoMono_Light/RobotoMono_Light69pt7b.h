#ifndef _ROBOTOMONO_LIGHT69PT7B_H_
#define _ROBOTOMONO_LIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF,
  0xFF, 0x78, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x02, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0E,
  0x00, 0x78, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x01, 0xC0,
  0x70, 0x00, 0x78, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x0E, 0x00, 0x00, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xFF, 0xC0,
  0x70, 0x00, 0x00, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0x00, 0x00,
  0x78, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x7E, 0xFC, 0x00, 0x03, 0xC1, 0xE0,
  0x78, 0x00, 0x07, 0x03, 0x80, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x02, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xBC, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x38,
  0x7C, 0x07, 0xC0, 0x07, 0x0F, 0x80, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x80,
  0x3C, 0x78, 0x00, 0xF8, 0x07, 0x9F, 0x00, 0x0F, 0x80, 0xF3, 0xC0, 0x00,
  0xF8, 0x1E, 0x78, 0x00, 0x0F, 0x07, 0x8F, 0x00, 0x01, 0xF0, 0xF1, 0xE0,
  0x00, 0x1F, 0x3E, 0x3C, 0x00, 0x01, 0xF7, 0x87, 0x80, 0x00, 0x1F, 0xF0,
  0xF0, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x7E, 0x00,
  0x1F, 0xFC, 0x07, 0xF0, 0x0F, 0xE7, 0xC0, 0x7F, 0xFF, 0xF8, 0x7C, 0x07,
  0xFF, 0xFC, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x19, 0xF0, 0x0E, 0x00, 0xF3,
  0xF8, 0x1C, 0x0F, 0xFF, 0xFE, 0x38, 0xFF, 0xE3, 0xFF, 0xF7, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7F, 0x80, 0x00, 0x7C, 0xFF,
  0x00, 0x01, 0xF1, 0xFE, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x1F, 0x07, 0xF8,
  0x00, 0x7C, 0x0F, 0xF0, 0x01, 0xE0, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0,
  0x1E, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x01, 0xFE, 0x0F,
  0x80, 0x03, 0xFC, 0x3E, 0x00, 0x07, 0xFC, 0xF8, 0x00, 0x0F, 0xFB, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3D, 0xFC, 0x00, 0x00, 0x7B, 0xF0, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3,
  0xFE, 0xF3, 0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xFC, 0x01,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC7, 0xFF, 0x80, 0x0F, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x08, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0xE0, 0x07, 0x87, 0xFF, 0xE0, 0x1E,
  0x3F, 0xFF, 0xE0, 0x73, 0xFC, 0x3F, 0xC3, 0xDF, 0x00, 0x1F, 0x8F, 0x78,
  0x00, 0x3E, 0x3F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0E, 0xE0, 0xF8, 0x00, 0x7D, 0xC1, 0xFC,
  0x03, 0xF7, 0x81, 0xFF, 0xFF, 0xCF, 0x00, 0xFF, 0xFE, 0x1E, 0x00, 0xFF,
  0xF8, 0x3C, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFB, 0xE0, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8,
  0x78, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x0F, 0xC0, 0x1C, 0x3C, 0x01, 0xFF, 0x80, 0xE1, 0xC0, 0x1F,
  0xFE, 0x07, 0x0E, 0x01, 0xE0, 0xF0, 0x1C, 0xE0, 0x1E, 0x03, 0x80, 0xE7,
  0x01, 0xE0, 0x1C, 0x07, 0x38, 0x0E, 0x00, 0xE0, 0x3B, 0x80, 0xF0, 0x07,
  0x01, 0xDC, 0x07, 0x00, 0x38, 0x0E, 0xE0, 0x38, 0x01, 0x80, 0x77, 0x03,
  0xC0, 0x0C, 0x03, 0xF0, 0x1C, 0x00, 0x60, 0x0F, 0x80, 0xE0, 0x07, 0x00,
  0x7C, 0x07, 0x00, 0x38, 0x07, 0xE0, 0x38, 0x01, 0xC0, 0x3F, 0x01, 0xC0,
  0x0E, 0x01, 0xF8, 0x0E, 0x00, 0x70, 0x0F, 0xC0, 0x70, 0x03, 0x80, 0x7E,
  0x03, 0x80, 0x1C, 0x03, 0xF0, 0x1C, 0x01, 0xE0, 0x1B, 0x80, 0xE0, 0x0E,
  0x00, 0xDC, 0x07, 0x00, 0x70, 0x0E, 0xE0, 0x38, 0x07, 0xC0, 0x77, 0x81,
  0xC0, 0x7E, 0x07, 0x1C, 0x0F, 0x07, 0x70, 0x38, 0xE0, 0x3C, 0xFB, 0xC3,
  0x87, 0x01, 0xFF, 0x8F, 0xF8, 0x3C, 0x07, 0xF8, 0x3F, 0x80, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xFE, 0x0F, 0x00, 0x00, 0xFE, 0x3C,
  0x00, 0x00, 0xFC, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0xE3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x7F, 0x00, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3F, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x3C, 0x0F, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x01, 0xE7, 0xF8, 0x00,
  0x00, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0x80, 0x00, 0x3F, 0xC7, 0xC0,
  0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0x80,
  0x01, 0xEF, 0xEF, 0x00, 0x03, 0xDF, 0xDE, 0x00, 0x07, 0x3F, 0x9E, 0x00,
  0x1E, 0x7F, 0x3C, 0x00, 0x3C, 0xFE, 0x38, 0x00, 0xF1, 0xFC, 0x78, 0x01,
  0xE3, 0xF8, 0xF0, 0x03, 0x87, 0xF0, 0xE0, 0x0F, 0x0F, 0xE1, 0xE0, 0x1E,
  0x1F, 0xC3, 0xC0, 0x38, 0x3F, 0x83, 0x80, 0xF0, 0x7F, 0x07, 0x81, 0xE0,
  0xFE, 0x0F, 0x07, 0x81, 0xFC, 0x0F, 0x0F, 0x03, 0xFC, 0x1E, 0x1C, 0x07,
  0xF8, 0x3C, 0x78, 0x0F, 0xF0, 0x3C, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0x3F,
  0xC0, 0x77, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x0F, 0xF0,
  0x07, 0x80, 0x1F, 0xE0, 0x0E, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xF7, 0x80, 0x00, 0x1F, 0xEF, 0x80, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x7F,
  0x8F, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x01, 0xFE, 0x1E, 0x00, 0x03, 0xFC,
  0x3C, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x1F, 0xE0,
  0x78, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFF, 0x01,
  0xF0, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0xF8, 0x03,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x07,
  0x80, 0x7F, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0x0F, 0x01, 0xFE, 0x00, 0x1F,
  0x03, 0xFC, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x3C,
  0x1F, 0xE0, 0x00, 0x3C, 0x3F, 0xC0, 0x00, 0x78, 0x7F, 0x80, 0x00, 0x78,
  0xFF, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x01, 0xF7,
  0xF8, 0x00, 0x01, 0xEF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x03,
  0xFE, 0x0F, 0x00, 0x00, 0x7E, 0x1E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x0F, 0xE1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x0F, 0xFC, 0x0F, 0x00,
  0x01, 0xFC, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x3F, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xFE,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0xBC, 0x00, 0x3E,
  0x00, 0x1D, 0xE0, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x80, 0x0F, 0x38,
  0x00, 0xFC, 0x00, 0x79, 0xE0, 0x07, 0xE0, 0x03, 0xCF, 0x00, 0x3F, 0x80,
  0x1E, 0x78, 0x01, 0xFC, 0x00, 0xE3, 0xC0, 0x0E, 0xE0, 0x07, 0x1E, 0x00,
  0x77, 0x00, 0x78, 0xF0, 0x07, 0xB8, 0x03, 0xC3, 0x80, 0x3D, 0xC0, 0x1E,
  0x1E, 0x01, 0xCF, 0x00, 0xF0, 0xF0, 0x0E, 0x78, 0x07, 0x87, 0x80, 0x71,
  0xC0, 0x3C, 0x3C, 0x07, 0x8E, 0x01, 0xC1, 0xE0, 0x3C, 0x70, 0x0E, 0x0F,
  0x01, 0xC3, 0xC0, 0xF0, 0x38, 0x0E, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x70,
  0x3C, 0x0F, 0x07, 0x83, 0x81, 0xE0, 0x78, 0x3C, 0x1C, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x70, 0x1E, 0x0E, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x3C, 0x3C,
  0x03, 0x83, 0x80, 0xE1, 0xE0, 0x1C, 0x3C, 0x07, 0x0F, 0x00, 0xF1, 0xE0,
  0x38, 0x78, 0x07, 0x8E, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x01,
  0xE3, 0x80, 0x38, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x0E,
  0x78, 0x01, 0xCE, 0x00, 0x7B, 0xC0, 0x0E, 0x70, 0x03, 0xDE, 0x00, 0x7B,
  0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x77, 0x00, 0x1F, 0xE0, 0x03, 0xB8,
  0x00, 0xFF, 0x00, 0x1D, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x03, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x87, 0xF8, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x79, 0xF8,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F,
  0x9F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x1F, 0x78, 0xFE, 0x03, 0xF9, 0xE1,
  0xFF, 0xFF, 0xC7, 0x83, 0xFF, 0xFC, 0x1F, 0x03, 0xFF, 0xC0, 0x7C, 0x01,
  0xE8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xFC,
  0x00, 0xF0, 0xFF, 0xF8, 0x07, 0x8F, 0xFF, 0xF0, 0x3D, 0xFE, 0x7F, 0xC1,
  0xEF, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3E, 0x7E, 0x00,
  0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x1F, 0xE0, 0x01, 0xF0, 0xF7, 0xC0, 0x3F,
  0x07, 0x9F, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0x01, 0xE0, 0xFF, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x0F, 0x00, 0xFF, 0xF8, 0x3C,
  0x07, 0xFF, 0xF8, 0xF0, 0x3F, 0xEF, 0xF3, 0xC1, 0xF8, 0x03, 0xEF, 0x0F,
  0x80, 0x03, 0xFC, 0x7C, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xBC,
  0x0F, 0xFF, 0xFC, 0xF0, 0x1F, 0xFF, 0xC3, 0xC0, 0x1F, 0xFE, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x07,
  0xC0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x01, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0xF0, 0x1F,
  0xFF, 0xE3, 0xC0, 0xFF, 0x9F, 0xCF, 0x07, 0xE0, 0x0F, 0xBC, 0x3E, 0x00,
  0x0F, 0xF1, 0xF0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0xF0, 0x3F,
  0xFF, 0xF3, 0xC0, 0x7F, 0xFF, 0x0F, 0x00, 0x7F, 0xF8, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x7F, 0xFE, 0x0F, 0x0F, 0xFF, 0xF0, 0xF1, 0xFC, 0x7F,
  0x8F, 0x3C, 0x00, 0xFC, 0xF7, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xF0, 0x00, 0x03, 0xF3, 0xC0,
  0x00, 0x1F, 0x8F, 0x00, 0x00, 0xFC, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x7E, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0xF7, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFB, 0xE0, 0x00, 0x3F, 0x87, 0xC0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xFC, 0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x1E, 0x7F, 0xF0, 0x7F, 0xE3, 0xDF, 0xFF,
  0x1F, 0xFE, 0x7F, 0xC7, 0xE7, 0xCF, 0xEF, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8,
  0x03, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x0F,
  0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC0,
  0x03, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07, 0xF0,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x03,
  0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xE0,
  0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07, 0xF0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x01,
  0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0xF8, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x07, 0x81,
  0xFF, 0xF8, 0x3C, 0x1F, 0xFF, 0xE1, 0xE1, 0xFC, 0x7F, 0x8F, 0x1E, 0x00,
  0x7E, 0x79, 0xC0, 0x01, 0xFB, 0xDC, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x1E,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0x07, 0xFF, 0xC0, 0x38, 0xFF, 0xFF, 0x81, 0xCF, 0xE7,
  0xFE, 0x0F, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0xF8, 0xFF, 0x00, 0x1F, 0x87, 0xFE,
  0x01, 0xF8, 0x3D, 0xFF, 0xFF, 0x81, 0xE3, 0xFF, 0xF8, 0x0F, 0x07, 0xFF,
  0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0xF0,
  0x1F, 0xFF, 0xE3, 0xC1, 0xFF, 0x1F, 0xCF, 0x07, 0xE0, 0x0F, 0xBC, 0x3E,
  0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x3E, 0xF0,
  0x3F, 0xFF, 0xF3, 0xC0, 0x7F, 0xFF, 0x8F, 0x00, 0x7F, 0xF8, 0x3C, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x02, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x03, 0xF7, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xF3, 0xE0, 0x01,
  0xEF, 0x1F, 0x80, 0x7C, 0xF0, 0xFF, 0xFF, 0x8F, 0x07, 0xFF, 0xF0, 0xF0,
  0x3F, 0xFC, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xC0, 0x01, 0xE0,
  0x00, 0xE7, 0x00, 0x07, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x00, 0x1E, 0x78,
  0x00, 0xFC, 0x00, 0x79, 0xE0, 0x03, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0xC0,
  0x07, 0x0E, 0x00, 0x3F, 0x00, 0x3C, 0x3C, 0x01, 0xDE, 0x00, 0xF0, 0xF0,
  0x07, 0x38, 0x03, 0xC1, 0xC0, 0x1C, 0xE0, 0x0E, 0x07, 0x00, 0x73, 0x80,
  0x38, 0x1E, 0x03, 0x8F, 0x01, 0xE0, 0x78, 0x0E, 0x1C, 0x07, 0x81, 0xE0,
  0x38, 0x70, 0x1C, 0x03, 0x81, 0xE1, 0xC0, 0x70, 0x0E, 0x07, 0x07, 0x81,
  0xC0, 0x3C, 0x1C, 0x0E, 0x0F, 0x00, 0xF0, 0x70, 0x38, 0x3C, 0x01, 0xC1,
  0xC0, 0xE0, 0xE0, 0x07, 0x0E, 0x03, 0xC3, 0x80, 0x1C, 0x38, 0x07, 0x0E,
  0x00, 0x78, 0xE0, 0x1C, 0x78, 0x01, 0xE3, 0x80, 0x71, 0xC0, 0x03, 0x9C,
  0x01, 0xE7, 0x00, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x00, 0xF7, 0x00, 0x3B, 0xC0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFA, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x3F, 0xFF, 0x80, 0x00, 0x73, 0xE0,
  0xFE, 0x00, 0x03, 0xBE, 0x01, 0xF8, 0x00, 0x3D, 0xE0, 0x03, 0xE0, 0x01,
  0xCE, 0x00, 0x0F, 0xC0, 0x1E, 0xF0, 0x00, 0x3F, 0x83, 0xE7, 0x00, 0x00,
  0xFF, 0xFF, 0x38, 0x00, 0x01, 0xFF, 0xF0, 0x20, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00,
};

const GFXglyph RobotoMono_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 6, 49, 41, 17, -49 },
  { 38, 13, 15, 41, 14, -52 },
  { 63, 38, 49, 41, 2, -49 },
  { 296, 30, 64, 41, 6, -57 },
  { 536, 39, 51, 41, 1, -50 },
  { 785, 35, 51, 41, 5, -50 },
  { 1009, 4, 15, 41, 17, -52 },
  { 1017, 16, 71, 41, 13, -55 },
  { 1159, 16, 71, 41, 12, -55 },
  { 1301, 31, 30, 41, 6, -49 },
  { 1418, 34, 36, 41, 4, -41 },
  { 1571, 7, 16, 41, 13, -6 },
  { 1585, 25, 4, 41, 8, -24 },
  { 1598, 7, 6, 41, 18, -6 },
  { 1604, 25, 53, 41, 9, -49 },
  { 1770, 31, 51, 41, 5, -50 },
  { 1968, 18, 49, 41, 7, -49 },
  { 2079, 32, 50, 41, 3, -50 },
  { 2279, 31, 51, 41, 3, -50 },
  { 2477, 35, 49, 41, 3, -49 },
  { 2692, 30, 50, 41, 7, -49 },
  { 2880, 30, 50, 41, 5, -49 },
  { 3068, 32, 49, 41, 4, -49 },
  { 3264, 31, 51, 41, 6, -50 },
  { 3462, 31, 50, 41, 5, -50 },
  { 3656, 7, 36, 41, 20, -36 },
  { 3688, 9, 46, 41, 18, -36 },
  { 3740, 28, 29, 41, 6, -37 },
  { 3842, 30, 17, 41, 6, -31 },
  { 3906, 30, 29, 41, 6, -37 },
  { 4015, 28, 50, 41, 7, -50 },
  { 4190, 37, 49, 41, 2, -49 },
  { 4417, 36, 49, 41, 3, -49 },
  { 4638, 30, 49, 41, 7, -49 },
  { 4822, 33, 51, 41, 4, -50 },
  { 5033, 32, 49, 41, 6, -49 },
  { 5229, 29, 49, 41, 7, -49 },
  { 5407, 29, 49, 41, 7, -49 },
  { 5585, 33, 51, 41, 4, -50 },
  { 5796, 31, 49, 41, 5, -49 },
  { 5986, 29, 49, 41, 6, -49 },
  { 6164, 31, 50, 41, 4, -49 },
  { 6358, 33, 49, 41, 7, -49 },
  { 6561, 29, 49, 41, 7, -49 },
  { 6739, 31, 49, 41, 6, -49 },
  { 6929, 31, 49, 41, 5, -49 },
  { 7119, 33, 51, 41, 4, -50 },
  { 7330, 31, 49, 41, 7, -49 },
  { 7520, 34, 59, 41, 4, -50 },
  { 7771, 31, 49, 41, 7, -49 },
  { 7961, 33, 51, 41, 5, -50 },
  { 8172, 35, 49, 41, 3, -49 },
  { 8387, 31, 50, 41, 5, -49 },
  { 8581, 35, 49, 41, 3, -49 },
  { 8796, 37, 49, 41, 3, -49 },
  { 9023, 35, 49, 41, 4, -49 },
  { 9238, 35, 49, 41, 3, -49 },
  { 9453, 32, 49, 41, 4, -49 },
  { 9649, 12, 67, 41, 15, -56 },
  { 9750, 24, 53, 41, 9, -49 },
  { 9909, 12, 67, 41, 14, -56 },
  { 10010, 25, 27, 41, 8, -49 },
  { 10095, 30, 3, 41, 6, 0 },
  { 10107, 11, 9, 41, 15, -51 },
  { 10120, 30, 38, 41, 6, -37 },
  { 10263, 29, 53, 41, 7, -52 },
  { 10456, 31, 38, 41, 5, -37 },
  { 10604, 30, 53, 41, 5, -52 },
  { 10803, 31, 38, 41, 5, -37 },
  { 10951, 32, 53, 41, 6, -53 },
  { 11163, 30, 52, 41, 5, -37 },
  { 11358, 28, 52, 41, 7, -52 },
  { 11540, 30, 50, 41, 7, -50 },
  { 11728, 21, 65, 41, 7, -50 },
  { 11899, 30, 52, 41, 7, -52 },
  { 12094, 30, 52, 41, 7, -52 },
  { 12289, 35, 37, 41, 3, -37 },
  { 12451, 29, 37, 41, 6, -37 },
  { 12586, 33, 38, 41, 4, -37 },
  { 12743, 29, 51, 41, 7, -37 },
  { 12928, 30, 51, 41, 5, -37 },
  { 13120, 24, 37, 41, 12, -37 },
  { 13231, 30, 38, 41, 6, -37 },
  { 13374, 29, 47, 41, 6, -46 },
  { 13545, 28, 37, 41, 7, -36 },
  { 13675, 34, 36, 41, 4, -36 },
  { 13828, 38, 36, 41, 2, -36 },
  { 13999, 34, 36, 41, 4, -36 },
  { 14152, 36, 51, 41, 3, -36 },
  { 14382, 32, 36, 41, 5, -36 },
  { 14526, 23, 68, 41, 11, -54 },
  { 14722, 3, 60, 41, 19, -49 },
  { 14745, 22, 68, 41, 11, -54 },
  { 14932, 37, 13, 41, 2, -27 },
};

const GFXfont RobotoMono_Light69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light69pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_LIGHT69PT7B_H_
