#ifndef _ROBOTOMONO_LIGHT57PT7B_H_
#define _ROBOTOMONO_LIGHT57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x78, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x60, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x0F,
  0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x1C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0x8F, 0x00, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0xFE, 0x3F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x60, 0x1C, 0x01, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0xE0, 0x0C, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x00,
  0xE0, 0x0C, 0x07, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0xE0, 0x1C, 0x0E, 0x00,
  0xE0, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x38, 0x00,
  0x3C, 0x78, 0x30, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x0F, 0xC0, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x07, 0x07, 0xF8, 0x00, 0x0E, 0x0F, 0xFC, 0x00, 0x0C, 0x1C, 0x1E,
  0x00, 0x1C, 0x18, 0x0E, 0x00, 0x38, 0x38, 0x06, 0x00, 0x38, 0x38, 0x07,
  0x00, 0x70, 0x30, 0x07, 0x00, 0x70, 0x30, 0x07, 0x00, 0xE0, 0x30, 0x07,
  0x00, 0xE0, 0x30, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x80, 0x38, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x0E, 0x3C, 0x0F, 0x00, 0xF3, 0xC0, 0x3C, 0x07, 0x9C, 0x00,
  0xF0, 0x39, 0xE0, 0x07, 0x81, 0xCF, 0x00, 0x1E, 0x0E, 0x70, 0x00, 0x78,
  0xF3, 0x80, 0x01, 0xE7, 0x1C, 0x00, 0x0F, 0x78, 0xE0, 0x00, 0x3F, 0x87,
  0x80, 0x00, 0xFC, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3F, 0x07, 0x80,
  0x03, 0xF8, 0x1F, 0x00, 0x3D, 0xE0, 0x7E, 0x1F, 0xC7, 0x81, 0xFF, 0xFC,
  0x1E, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xB6, 0xFF,
  0xFF, 0xFE, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x80, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x0C, 0x01, 0x9F, 0x03, 0x03, 0xEF, 0xF0, 0xC3, 0xFC,
  0xFF, 0xB7, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0x8E, 0x79, 0xC7, 0x38, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0xDC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xEF, 0xF0,
  0x00, 0xF3, 0xFC, 0x00, 0x78, 0x7F, 0x00, 0x3C, 0x1F, 0xC0, 0x1E, 0x07,
  0xF0, 0x0F, 0x01, 0xFC, 0x07, 0x00, 0x7F, 0x07, 0x80, 0x1F, 0xC3, 0xC0,
  0x07, 0xF1, 0xE0, 0x01, 0xFC, 0xF0, 0x00, 0x7F, 0x78, 0x00, 0x1D, 0xFC,
  0x00, 0x07, 0x7E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x1C, 0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0xE7, 0xFB, 0xFF,
  0x87, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xE0, 0x03, 0xC1, 0xE0,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x78,
  0x00, 0x03, 0xBC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3,
  0xC0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x7F, 0x00,
  0x3B, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0x8F, 0xF8, 0x7C, 0x01, 0xFC,
  0x30, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0xE1, 0xFF, 0xC0, 0x71, 0xFF, 0xF0, 0x3B,
  0xF0, 0xFE, 0x3F, 0xC0, 0x0F, 0x1F, 0xC0, 0x03, 0xCF, 0xC0, 0x00, 0xF7,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x78, 0x00,
  0x07, 0x9C, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xE0,
  0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0xC7, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E,
  0x03, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x38, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x7C, 0x78, 0x00, 0x7E, 0x3E, 0x00, 0xF7, 0x0F, 0xC1, 0xF3,
  0x83, 0xFF, 0xF1, 0xC0, 0x7F, 0xE0, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0x80, 0x3C, 0x7D,
  0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8E, 0x1C, 0x78, 0xE1, 0xC7, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xF8, 0x0F, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x78,
  0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x07, 0xE0, 0x30, 0xE0, 0x3F, 0xE0, 0x71, 0x80, 0xF0, 0xE0, 0xE7,
  0x03, 0xC0, 0xC0, 0xCE, 0x07, 0x01, 0x81, 0x98, 0x1C, 0x07, 0x03, 0x30,
  0x38, 0x0E, 0x06, 0xE0, 0x60, 0x1C, 0x0D, 0xC1, 0xC0, 0x30, 0x1B, 0x03,
  0x80, 0x60, 0x36, 0x06, 0x00, 0xC0, 0x6C, 0x0C, 0x01, 0x80, 0xD8, 0x18,
  0x03, 0x01, 0xB0, 0x30, 0x06, 0x03, 0x60, 0x60, 0x0C, 0x06, 0xC0, 0xC0,
  0x38, 0x0D, 0x81, 0x80, 0x70, 0x3B, 0x03, 0x01, 0xE0, 0x66, 0x06, 0x03,
  0xC0, 0xCE, 0x0E, 0x0D, 0x83, 0x9C, 0x1E, 0x3B, 0x8E, 0x18, 0x1F, 0xE7,
  0xF8, 0x38, 0x1F, 0x87, 0xE0, 0x70, 0x08, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x38, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x3F, 0xE0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x7F, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x3F,
  0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x03,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x1E, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x01, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03,
  0x80, 0x7F, 0x80, 0xE0, 0x01, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xF0, 0xE0,
  0x00, 0xF8, 0x38, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x03,
  0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x1F, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x3E, 0x07, 0x00,
  0x07, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0x38, 0x0F,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x73, 0xF0, 0x00, 0x0E, 0xFF, 0x00, 0x01, 0xFE, 0xF0,
  0x00, 0x3F, 0x9E, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x1E,
  0x03, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x3C,
  0x01, 0xC0, 0x07, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x77, 0xEE, 0x00,
  0x3B, 0xF7, 0x00, 0x3D, 0xFB, 0xC0, 0x1C, 0xFC, 0xE0, 0x0E, 0x7E, 0x70,
  0x0E, 0x3F, 0x3C, 0x07, 0x1F, 0x8E, 0x07, 0x8F, 0xC7, 0x03, 0x87, 0xE1,
  0xC1, 0xC3, 0xF0, 0xE1, 0xC1, 0xF8, 0x70, 0xE0, 0xFC, 0x1C, 0x70, 0x7E,
  0x0E, 0x70, 0x3F, 0x07, 0x38, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x1E, 0x01, 0xF8, 0x0F, 0x00, 0xFC, 0x07, 0x80,
  0x7E, 0x01, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xEE, 0x00, 0x07, 0xF7, 0x80,
  0x03, 0xF9, 0xC0, 0x01, 0xFC, 0xF0, 0x00, 0xFE, 0x38, 0x00, 0x7F, 0x1E,
  0x00, 0x3F, 0x87, 0x00, 0x1F, 0xC1, 0xC0, 0x0F, 0xE0, 0xF0, 0x07, 0xF0,
  0x38, 0x03, 0xF8, 0x1E, 0x01, 0xFC, 0x07, 0x00, 0xFE, 0x03, 0xC0, 0x7F,
  0x00, 0xE0, 0x3F, 0x80, 0x78, 0x1F, 0xC0, 0x1C, 0x0F, 0xE0, 0x0F, 0x07,
  0xF0, 0x03, 0x83, 0xF8, 0x00, 0xE1, 0xFC, 0x00, 0x78, 0xFE, 0x00, 0x1C,
  0x7F, 0x00, 0x0F, 0x3F, 0x80, 0x03, 0x9F, 0xC0, 0x01, 0xEF, 0xE0, 0x00,
  0x77, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0xF0, 0xE0, 0x00, 0x3E, 0x38, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78, 0xE0,
  0x00, 0x7C, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x61, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0xFE, 0x0E, 0x00, 0x0F, 0x87,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x8E, 0x00,
  0x1F, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xE0,
  0x07, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x03,
  0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0x3F, 0x00,
  0x3F, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x1F, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x03, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x1D, 0xC0, 0x0E, 0x00, 0x7B, 0x80,
  0x1E, 0x00, 0xE7, 0x00, 0x7C, 0x01, 0xCE, 0x00, 0xF8, 0x03, 0x9C, 0x01,
  0xF0, 0x07, 0x38, 0x03, 0xE0, 0x0E, 0x78, 0x06, 0xE0, 0x1C, 0x70, 0x1D,
  0xC0, 0x78, 0xE0, 0x3B, 0x80, 0xE1, 0xC0, 0x77, 0x01, 0xC3, 0x80, 0xE6,
  0x03, 0x87, 0x01, 0xCE, 0x07, 0x0E, 0x07, 0x1C, 0x0E, 0x1E, 0x0E, 0x38,
  0x1C, 0x1C, 0x1C, 0x70, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0x70, 0x70, 0xC1,
  0xC0, 0xE0, 0xC1, 0xC3, 0x81, 0xC3, 0x83, 0x87, 0x03, 0x87, 0x07, 0x0E,
  0x07, 0x8E, 0x0E, 0x1C, 0x07, 0x1C, 0x0C, 0x38, 0x0E, 0x30, 0x1C, 0xE0,
  0x1C, 0xE0, 0x39, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0x73, 0x80, 0xE7, 0x00,
  0xE7, 0x01, 0xCE, 0x01, 0xCE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xB8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03,
  0x9E, 0x00, 0x70, 0xE0, 0x07, 0x0F, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01,
  0xE0, 0x78, 0x1C, 0x03, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x0F, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F, 0x1E, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0xBE, 0x00, 0x1F, 0xCF, 0x80, 0x3F, 0xE3, 0xFD, 0xFE, 0x70, 0xFF,
  0xFC, 0x38, 0x1F, 0xF8, 0x1E, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0xE1,
  0xFF, 0x80, 0xE7, 0xFF, 0xE0, 0xEF, 0xC7, 0xF0, 0xFE, 0x00, 0xF8, 0xF8,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0,
  0x00, 0x3C, 0xF8, 0x00, 0x78, 0xFE, 0x00, 0xF8, 0xEF, 0xEF, 0xF0, 0xE7,
  0xFF, 0xC0, 0xE1, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x07, 0xC0,
  0x7E, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x78, 0x0F, 0xFC, 0x3C, 0x0F, 0xFF, 0x9E, 0x0F,
  0xC3, 0xEF, 0x0F, 0x00, 0x3F, 0x8F, 0x00, 0x0F, 0xCF, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0xF3, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x7C, 0x78,
  0x00, 0x7E, 0x1F, 0x00, 0xFF, 0x07, 0xF3, 0xF7, 0x81, 0xFF, 0xF3, 0xC0,
  0x3F, 0xE1, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0xC1, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0x3C, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x87, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC1, 0xC0, 0xFF, 0xF8, 0xE0, 0xFC,
  0x3E, 0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC7, 0x80,
  0x07, 0xE1, 0xF0, 0x0F, 0xF0, 0x7F, 0x3F, 0x78, 0x1F, 0xFF, 0x3C, 0x07,
  0xFE, 0x1E, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE1, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xE0, 0xF1, 0xFF,
  0xF8, 0xF3, 0xE1, 0xFC, 0xF7, 0x80, 0x3C, 0xFE, 0x00, 0x1E, 0xFC, 0x00,
  0x0E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF3,
  0x80, 0x01, 0xF1, 0xC0, 0x01, 0xF0, 0xE0, 0x01, 0xF0, 0x70, 0x01, 0xF0,
  0x38, 0x01, 0xF0, 0x1C, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x07, 0x01, 0xE0,
  0x03, 0x81, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0x71, 0xE0,
  0x00, 0x39, 0xF8, 0x00, 0x1D, 0xFE, 0x00, 0x0F, 0xEF, 0x80, 0x07, 0xE3,
  0xC0, 0x03, 0xE0, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0xC0, 0x38, 0x01, 0xF0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x3E,
  0x70, 0x00, 0x0F, 0xB8, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x83, 0xCF, 0xF0, 0x7F, 0x8F,
  0x7F, 0xE7, 0xFF, 0x3F, 0xC7, 0xDE, 0x3E, 0xF8, 0x0F, 0xC0, 0x7B, 0xE0,
  0x1F, 0x00, 0xEF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xE0,
  0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x78, 0x01,
  0xFC, 0x01, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x7F,
  0x00, 0x78, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0,
  0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0xF0, 0x03,
  0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xE0,
  0x07, 0xF0, 0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x7F, 0xE0, 0xF1, 0xFF, 0xF8, 0xF3, 0xE1,
  0xFC, 0xF7, 0x80, 0x3C, 0xFE, 0x00, 0x1E, 0xFC, 0x00, 0x0E, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x1F, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x7F, 0xE0, 0x3C, 0xFF, 0xFC, 0x1E, 0xF8, 0x7F, 0x0F, 0xF0,
  0x07, 0xC7, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3F, 0x00, 0x0F, 0x1F, 0xC0,
  0x0F, 0x0F, 0x7E, 0x3F, 0x07, 0x9F, 0xFF, 0x03, 0xC3, 0xFF, 0x01, 0xE0,
  0x30, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE3, 0xC0, 0xFF, 0xF9, 0xE1, 0xFC,
  0x3E, 0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC7, 0x80,
  0x07, 0xE1, 0xF0, 0x07, 0xF0, 0x7E, 0x3F, 0x78, 0x1F, 0xFF, 0x3C, 0x03,
  0xFE, 0x1E, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xCE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xC0, 0x0E, 0xF0, 0x00, 0xEC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0x81, 0xE0,
  0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x4E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x9F, 0x00, 0x03, 0xC7, 0xC0,
  0x07, 0xC1, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x8F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0xDC, 0xF0, 0x07, 0xB9, 0xF8, 0xFE, 0x71, 0xFF, 0xF8, 0xE0, 0xFF,
  0xC1, 0xC0, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x03,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x3B, 0x80, 0x1E,
  0x00, 0x73, 0x80, 0x3C, 0x00, 0xE7, 0x00, 0x7C, 0x01, 0xCE, 0x00, 0xF8,
  0x03, 0x9C, 0x03, 0xB0, 0x0E, 0x38, 0x07, 0x60, 0x1C, 0x38, 0x0E, 0xE0,
  0x38, 0x70, 0x19, 0xC0, 0x70, 0xE0, 0x73, 0x80, 0xE1, 0xC0, 0xE3, 0x03,
  0x81, 0x81, 0xC7, 0x07, 0x03, 0x83, 0x0E, 0x0E, 0x07, 0x0E, 0x1C, 0x1C,
  0x0E, 0x1C, 0x18, 0x30, 0x1C, 0x38, 0x38, 0xE0, 0x18, 0x60, 0x71, 0xC0,
  0x39, 0xC0, 0xE3, 0x80, 0x73, 0x80, 0xC7, 0x00, 0xE7, 0x01, 0xCC, 0x00,
  0xCC, 0x03, 0xB8, 0x01, 0x98, 0x03, 0x70, 0x03, 0xF0, 0x06, 0xE0, 0x07,
  0xE0, 0x0D, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x38, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x00, 0x1F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1C, 0xFF, 0xF0, 0x00, 0x33, 0xE1, 0xF8, 0x00, 0xE7, 0x00, 0xF8,
  0x01, 0xDC, 0x00, 0xF8, 0x07, 0xB8, 0x00, 0xFC, 0x1E, 0x60, 0x00, 0x7F,
  0xF8, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
};

const GFXglyph RobotoMono_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 5, 41, 34, 14, -41 },
  { 27, 12, 13, 34, 11, -43 },
  { 47, 31, 41, 34, 2, -41 },
  { 206, 25, 53, 34, 5, -47 },
  { 372, 32, 42, 34, 1, -41 },
  { 540, 29, 42, 34, 4, -41 },
  { 693, 3, 13, 34, 14, -43 },
  { 698, 13, 58, 34, 11, -45 },
  { 793, 13, 58, 34, 10, -45 },
  { 888, 26, 25, 34, 5, -41 },
  { 970, 28, 30, 34, 3, -34 },
  { 1075, 6, 13, 34, 11, -5 },
  { 1085, 20, 3, 34, 7, -20 },
  { 1093, 6, 5, 34, 15, -5 },
  { 1097, 20, 44, 34, 8, -41 },
  { 1207, 26, 42, 34, 4, -41 },
  { 1344, 15, 41, 34, 6, -41 },
  { 1421, 26, 41, 34, 3, -41 },
  { 1555, 25, 42, 34, 3, -41 },
  { 1687, 29, 41, 34, 2, -41 },
  { 1836, 24, 42, 34, 6, -41 },
  { 1962, 25, 42, 34, 4, -41 },
  { 2094, 27, 41, 34, 3, -41 },
  { 2233, 26, 42, 34, 5, -41 },
  { 2370, 25, 41, 34, 4, -41 },
  { 2499, 5, 29, 34, 17, -29 },
  { 2518, 7, 37, 34, 15, -29 },
  { 2551, 23, 24, 34, 5, -30 },
  { 2620, 25, 15, 34, 5, -26 },
  { 2667, 24, 24, 34, 5, -30 },
  { 2739, 23, 41, 34, 6, -41 },
  { 2857, 31, 41, 34, 2, -41 },
  { 3016, 29, 41, 34, 3, -41 },
  { 3165, 26, 41, 34, 5, -41 },
  { 3299, 28, 42, 34, 3, -41 },
  { 3446, 26, 41, 34, 5, -41 },
  { 3580, 24, 41, 34, 6, -41 },
  { 3703, 24, 41, 34, 6, -41 },
  { 3826, 28, 42, 34, 3, -41 },
  { 3973, 26, 41, 34, 4, -41 },
  { 4107, 24, 41, 34, 5, -41 },
  { 4230, 26, 42, 34, 3, -41 },
  { 4367, 27, 41, 34, 6, -41 },
  { 4506, 24, 41, 34, 6, -41 },
  { 4629, 25, 41, 34, 5, -41 },
  { 4758, 25, 41, 34, 5, -41 },
  { 4887, 28, 42, 34, 3, -41 },
  { 5034, 26, 41, 34, 6, -41 },
  { 5168, 28, 48, 34, 3, -41 },
  { 5336, 25, 41, 34, 6, -41 },
  { 5465, 27, 42, 34, 4, -41 },
  { 5607, 29, 41, 34, 3, -41 },
  { 5756, 26, 42, 34, 4, -41 },
  { 5893, 30, 41, 34, 2, -41 },
  { 6047, 31, 41, 34, 2, -41 },
  { 6206, 29, 41, 34, 3, -41 },
  { 6355, 29, 41, 34, 2, -41 },
  { 6504, 26, 41, 34, 4, -41 },
  { 6638, 9, 55, 34, 13, -46 },
  { 6700, 20, 44, 34, 7, -41 },
  { 6810, 10, 55, 34, 12, -46 },
  { 6879, 20, 22, 34, 7, -41 },
  { 6934, 24, 3, 34, 5, 0 },
  { 6943, 9, 8, 34, 13, -42 },
  { 6952, 25, 32, 34, 5, -31 },
  { 7052, 24, 44, 34, 6, -43 },
  { 7184, 25, 32, 34, 4, -31 },
  { 7284, 25, 44, 34, 4, -43 },
  { 7422, 26, 32, 34, 4, -31 },
  { 7526, 26, 44, 34, 5, -44 },
  { 7669, 25, 43, 34, 4, -31 },
  { 7804, 24, 43, 34, 5, -43 },
  { 7933, 24, 41, 34, 6, -41 },
  { 8056, 18, 53, 34, 5, -41 },
  { 8176, 25, 43, 34, 6, -43 },
  { 8311, 24, 43, 34, 6, -43 },
  { 8440, 30, 31, 34, 2, -31 },
  { 8557, 24, 31, 34, 5, -31 },
  { 8650, 27, 32, 34, 4, -31 },
  { 8758, 25, 43, 34, 5, -31 },
  { 8893, 25, 43, 34, 4, -31 },
  { 9028, 20, 31, 34, 10, -31 },
  { 9106, 25, 32, 34, 5, -31 },
  { 9206, 24, 39, 34, 5, -38 },
  { 9323, 23, 31, 34, 6, -30 },
  { 9413, 28, 30, 34, 3, -30 },
  { 9518, 31, 30, 34, 2, -30 },
  { 9635, 27, 30, 34, 4, -30 },
  { 9737, 30, 42, 34, 2, -30 },
  { 9895, 27, 30, 34, 4, -30 },
  { 9997, 19, 55, 34, 9, -44 },
  { 10128, 3, 50, 34, 16, -41 },
  { 10147, 19, 55, 34, 9, -44 },
  { 10278, 31, 10, 34, 2, -22 },
};

const GFXfont RobotoMono_Light57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light57pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_LIGHT57PT7B_H_
