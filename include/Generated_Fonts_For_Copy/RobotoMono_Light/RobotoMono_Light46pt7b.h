#ifndef _ROBOTOMONO_LIGHT46PT7B_H_
#define _ROBOTOMONO_LIGHT46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xBF, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x07,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x0F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x80, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x1C,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x01, 0xF8, 0xF8, 0x1C, 0x01, 0xC3, 0x80, 0x0E,
  0x38, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F,
  0x38, 0x01, 0xE3, 0xE0, 0x3C, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0xC0, 0x30, 0x18, 0x30, 0x0E, 0x06, 0x18, 0x01, 0x83,
  0x86, 0x00, 0x7B, 0xC3, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC1, 0xF8, 0x00, 0x30, 0xFF, 0x00, 0x18, 0x70, 0xE0, 0x0E,
  0x18, 0x18, 0x03, 0x0E, 0x06, 0x01, 0xC3, 0x01, 0xC0, 0x60, 0xC0, 0x70,
  0x38, 0x30, 0x1C, 0x0C, 0x0C, 0x07, 0x07, 0x03, 0x81, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x1C,
  0x03, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x00, 0x1C,
  0x03, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0x70, 0x0E, 0x38, 0x38, 0x0E, 0x70,
  0x1C, 0x0C, 0x70, 0x1E, 0x0C, 0xE0, 0x0E, 0x1C, 0xE0, 0x07, 0x1C, 0xE0,
  0x03, 0x98, 0xE0, 0x03, 0xF8, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0xF0, 0x78, 0x01, 0xF8, 0x3C, 0x07, 0xBC, 0x1F, 0xFF, 0x1C, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x30, 0x1C, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x01, 0x01, 0xC0, 0x4E, 0x0E, 0x0E, 0xFE, 0x73, 0xF9, 0xFF,
  0x7F, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00,
  0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00,
  0x70, 0x18, 0x03, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x39, 0xCE,
  0x63, 0x39, 0xCE, 0xE6, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x77, 0xFE, 0xE0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1E, 0x0F, 0x83, 0xC0,
  0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0xEE, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x7C,
  0x00, 0xE7, 0xC0, 0x1C, 0x7C, 0x03, 0x87, 0xC0, 0x70, 0x7C, 0x0E, 0x07,
  0xC3, 0xC0, 0x7C, 0x70, 0x07, 0xCE, 0x00, 0x7D, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x01, 0xC3, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFF, 0x7E, 0x7F, 0x87, 0xE0,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xC3, 0xE0,
  0x78, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xE1, 0xF0, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0,
  0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x1E,
  0x00, 0x70, 0x78, 0x0F, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x38, 0x00, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x3F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xC0, 0x7C, 0x20,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xF7, 0x00, 0x3C, 0xF0, 0x0F, 0x8F, 0xC7, 0xE0, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x1F, 0xE0, 0x33, 0xFF, 0xC1, 0xBC, 0x0F, 0x0F, 0x80, 0x3C, 0xF8, 0x00,
  0xE7, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x33, 0x80, 0x01,
  0x9C, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x0E, 0x00, 0xF0, 0x3C,
  0x0F, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xC3, 0xE0, 0x78, 0x03, 0x83, 0x80, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xC3, 0x80, 0x0E, 0x1E, 0x00, 0xE0, 0x78,
  0x1E, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0xFC, 0x0F, 0x00, 0x70,
  0x70, 0x01, 0xC7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xE7,
  0x00, 0x07, 0x1C, 0x00, 0x70, 0xF8, 0x0F, 0x01, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x38, 0x07, 0x83,
  0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0,
  0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x30, 0x00, 0x79, 0xC0, 0x07,
  0xC7, 0x00, 0x7E, 0x3E, 0x0F, 0x70, 0xFF, 0xF3, 0x01, 0xFE, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xEE, 0x39, 0xF7, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3,
  0x8E, 0x38, 0xC7, 0x1C, 0x63, 0x84, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xE1, 0xF1, 0xE0, 0x1E, 0x70, 0x03, 0xB8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x70, 0x00, 0x0C,
  0x30, 0x1F, 0x06, 0x38, 0x3F, 0xC3, 0x18, 0x38, 0x60, 0xCC, 0x18, 0x30,
  0x6C, 0x18, 0x18, 0x36, 0x0C, 0x0C, 0x1B, 0x0C, 0x06, 0x0D, 0x86, 0x03,
  0x06, 0x83, 0x01, 0x83, 0xC1, 0x80, 0xC1, 0xE0, 0xC0, 0x60, 0xF0, 0x60,
  0x30, 0x78, 0x30, 0x10, 0x3C, 0x18, 0x18, 0x1F, 0x0C, 0x0C, 0x19, 0x86,
  0x0E, 0x0C, 0xC3, 0x8D, 0x8C, 0x60, 0xFC, 0xFE, 0x38, 0x3C, 0x3E, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x01, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC1,
  0x80, 0x01, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x07, 0x8E,
  0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x01, 0x9C, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0xE3, 0x80, 0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0x00, 0x3E,
  0x38, 0x00, 0x79, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0D,
  0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x3F, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7C,
  0x07, 0x80, 0x78, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x07, 0x60, 0x00,
  0x19, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x70,
  0x70, 0x03, 0x80, 0xF0, 0x3C, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xC0, 0x1E, 0x0E, 0x00, 0x38,
  0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x06, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x03,
  0xCE, 0x00, 0x3C, 0x70, 0x03, 0xC3, 0x80, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x98, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x7C,
  0x07, 0x80, 0x78, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x3C, 0x00, 0x1C,
  0x78, 0x00, 0xE0, 0xF0, 0x0F, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x6E, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x3C, 0x3E, 0x07, 0x81, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x7B, 0x00, 0x03, 0xCC, 0x00, 0x1E,
  0x30, 0x00, 0x70, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x30,
  0x07, 0x00, 0xC0, 0x3C, 0x03, 0x01, 0xE0, 0x0C, 0x0F, 0x00, 0x30, 0x38,
  0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x33, 0xE0, 0x00,
  0xDF, 0xC0, 0x03, 0xF7, 0x00, 0x0F, 0x8E, 0x00, 0x3C, 0x3C, 0x00, 0xE0,
  0x70, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x07, 0x80, 0xC0, 0x0E,
  0x03, 0x00, 0x1C, 0x0C, 0x00, 0x78, 0x30, 0x00, 0xF0, 0xC0, 0x01, 0xC3,
  0x00, 0x03, 0x8C, 0x00, 0x0F, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFD, 0x80, 0x1B, 0xD8, 0x03, 0xBD,
  0xC0, 0x3B, 0xCC, 0x03, 0x3C, 0xE0, 0x73, 0xCE, 0x06, 0x3C, 0x60, 0x63,
  0xC7, 0x0E, 0x3C, 0x70, 0xC3, 0xC3, 0x1C, 0x3C, 0x39, 0xC3, 0xC3, 0x98,
  0x3C, 0x1B, 0x83, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0xC0, 0x60, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xDC, 0x00, 0x7D, 0xC0,
  0x07, 0xCE, 0x00, 0x7C, 0xE0, 0x07, 0xC7, 0x00, 0x7C, 0x30, 0x07, 0xC3,
  0x80, 0x7C, 0x1C, 0x07, 0xC1, 0xC0, 0x7C, 0x0E, 0x07, 0xC0, 0xE0, 0x7C,
  0x07, 0x07, 0xC0, 0x70, 0x7C, 0x03, 0x87, 0xC0, 0x18, 0x7C, 0x01, 0xC7,
  0xC0, 0x0C, 0x7C, 0x00, 0xE7, 0xC0, 0x07, 0x7C, 0x00, 0x77, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0xF8,
  0x07, 0x80, 0x70, 0x3C, 0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x60, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0x60, 0x00,
  0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0,
  0x70, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1E,
  0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00,
  0x01, 0xF8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00, 0x3B,
  0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x03, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x78,
  0x07, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x00, 0x00,
  0x76, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0xC0,
  0x03, 0x81, 0xC0, 0x1E, 0x01, 0xE0, 0x78, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0C, 0x00, 0x78, 0xC0, 0x03, 0xCC, 0x00, 0x1C, 0xC0, 0x00,
  0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0,
  0x0F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0C, 0x03, 0x80, 0xC0, 0x1C, 0x0C,
  0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00,
  0xEC, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xF8, 0x7E, 0x07, 0x80, 0x3C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x78,
  0x00, 0x38, 0xF0, 0x01, 0xE1, 0xF0, 0x1F, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x67,
  0x00, 0x0E, 0x70, 0x01, 0xC3, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x67, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x60,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0C,
  0x00, 0x38, 0x38, 0x00, 0x30, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80,
  0x00, 0xC7, 0x00, 0x01, 0xCC, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x3C, 0x07, 0x60, 0x3C, 0x07, 0x60, 0x3E, 0x07, 0x60,
  0x36, 0x06, 0x70, 0x76, 0x06, 0x70, 0x76, 0x06, 0x70, 0x66, 0x06, 0x70,
  0x67, 0x0E, 0x30, 0x67, 0x0E, 0x30, 0x63, 0x0E, 0x30, 0xE3, 0x0C, 0x38,
  0xC3, 0x0C, 0x38, 0xC3, 0x0C, 0x38, 0xC3, 0x8C, 0x38, 0xC1, 0x9C, 0x19,
  0xC1, 0x9C, 0x19, 0xC1, 0x9C, 0x19, 0x81, 0x98, 0x19, 0x81, 0xD8, 0x1D,
  0x81, 0xD8, 0x1F, 0x80, 0xD8, 0x1F, 0x80, 0xD8, 0x0F, 0x00, 0xF8, 0x0F,
  0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x01,
  0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60,
  0x00, 0x71, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0C,
  0x70, 0x1C, 0x30, 0x1C, 0x38, 0x18, 0x38, 0x38, 0x18, 0x30, 0x1C, 0x70,
  0x0C, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xC1, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0xE0,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x3F, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0, 0x0E, 0x78, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01,
  0xEF, 0x00, 0x3E, 0x78, 0x0F, 0x63, 0xFF, 0xC7, 0x0F, 0xF0, 0x70, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0xF0, 0x0E, 0x3F, 0xE0, 0xEF, 0xFF, 0x8E, 0xE0, 0x78, 0xF8, 0x01,
  0xCF, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEF,
  0x00, 0x0E, 0xF0, 0x01, 0xCF, 0x80, 0x3C, 0xEE, 0x07, 0x8E, 0x7F, 0xF0,
  0xE3, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xC0,
  0x3C, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x6E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07,
  0xE0, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1E, 0x07,
  0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x83, 0x83, 0xFE, 0x71, 0xFF,
  0xEE, 0x78, 0x0F, 0xCE, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x79, 0xC0, 0x1F, 0x1E, 0x07,
  0x61, 0xFF, 0xCC, 0x1F, 0xE1, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xF0, 0x1E, 0x03, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00,
  0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x03, 0x0F, 0x00, 0x3C, 0x3E, 0x07, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x02, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0x8C, 0x7F, 0xF9, 0x9E, 0x03, 0xB3, 0x80, 0x1E, 0xE0, 0x03, 0xDC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E, 0x70, 0x07,
  0xC7, 0x81, 0xF8, 0x7F, 0xF7, 0x07, 0xF8, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x40, 0x03, 0x9C, 0x00, 0xF1, 0xE0, 0x3C,
  0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x0E,
  0x1F, 0xF0, 0xE7, 0xFF, 0x8E, 0xE0, 0x3C, 0xEC, 0x01, 0xEF, 0x80, 0x0E,
  0xF0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x7F, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x2E,
  0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0,
  0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x9C, 0x00, 0xF0, 0xE0, 0x0E, 0x0F,
  0x00, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0,
  0x07, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0xCF, 0xE3, 0xFC, 0xDF, 0xF7,
  0xFE, 0xF0, 0x7E, 0x0E, 0xE0, 0x3C, 0x06, 0xE0, 0x38, 0x07, 0xE0, 0x38,
  0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18,
  0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18,
  0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18,
  0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18,
  0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0x00, 0x38, 0x0E, 0x1F, 0xF0,
  0xE7, 0xFF, 0x8E, 0xE0, 0x3C, 0xEC, 0x01, 0xEF, 0x80, 0x0E, 0xF0, 0x00,
  0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xE0,
  0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x19, 0x80, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x03, 0x81, 0xF0,
  0x3C, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x0E, 0x3F, 0xE0,
  0xEF, 0xFF, 0x0F, 0xC0, 0x78, 0xF8, 0x01, 0xCF, 0x00, 0x1E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x01, 0xCF,
  0x80, 0x3C, 0xFE, 0x07, 0x8E, 0x7F, 0xF0, 0xE3, 0xFE, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF,
  0x8C, 0x7F, 0xF9, 0x9E, 0x03, 0xB3, 0x80, 0x1E, 0xE0, 0x01, 0xDC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x03,
  0xC7, 0x81, 0xF8, 0x7F, 0xF7, 0x07, 0xF8, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3E, 0xE1, 0xFF, 0xE7, 0xFF, 0xEF,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x83, 0xC0, 0x3C, 0x38, 0x00, 0xE7, 0x00, 0x06, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x80, 0x0E, 0x3C, 0x03, 0xE1, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF3,
  0x80, 0x36, 0x78, 0x1E, 0xC7, 0xFF, 0x98, 0x3F, 0xC3, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x18, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x70,
  0x30, 0x00, 0x60, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x98, 0x00, 0x03, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0C, 0x01, 0xD8, 0x03, 0x00,
  0x66, 0x01, 0xE0, 0x39, 0xC0, 0x78, 0x0E, 0x70, 0x1E, 0x03, 0x0C, 0x07,
  0x80, 0xC3, 0x03, 0x70, 0x30, 0xE0, 0xCC, 0x1C, 0x38, 0x33, 0x07, 0x06,
  0x0C, 0xC1, 0x81, 0x86, 0x38, 0x60, 0x61, 0x86, 0x18, 0x1C, 0x61, 0x8E,
  0x07, 0x18, 0x63, 0x00, 0xCC, 0x1C, 0xC0, 0x33, 0x03, 0x30, 0x0C, 0xC0,
  0xCC, 0x03, 0xB0, 0x37, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0xF0, 0x00, 0x3C, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x0E,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x01, 0xCE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x03, 0x87, 0x00, 0x1C,
  0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x01,
  0xC7, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0,
  0x01, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x1F, 0x80, 0x3E,
  0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x07, 0xC0, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xCF, 0xFC, 0x00, 0x6E, 0x0F, 0x80, 0x36, 0x01, 0xE0, 0x3B, 0x00,
  0x78, 0x3B, 0x80, 0x1F, 0xF9, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x00,
};

const GFXglyph RobotoMono_Light46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 3, 33, 28, 12, -33 },
  { 14, 9, 11, 28, 9, -35 },
  { 27, 25, 33, 28, 1, -33 },
  { 131, 20, 43, 28, 4, -38 },
  { 239, 26, 33, 28, 1, -33 },
  { 347, 24, 33, 28, 3, -33 },
  { 446, 2, 11, 28, 12, -35 },
  { 449, 10, 48, 28, 9, -37 },
  { 509, 11, 48, 28, 8, -37 },
  { 575, 21, 20, 28, 4, -33 },
  { 628, 22, 24, 28, 3, -27 },
  { 694, 5, 11, 28, 9, -4 },
  { 701, 17, 3, 28, 5, -16 },
  { 708, 5, 4, 28, 12, -4 },
  { 711, 16, 36, 28, 6, -33 },
  { 783, 20, 33, 28, 4, -33 },
  { 866, 12, 33, 28, 5, -33 },
  { 916, 21, 33, 28, 2, -33 },
  { 1003, 21, 33, 28, 2, -33 },
  { 1090, 23, 33, 28, 2, -33 },
  { 1185, 19, 33, 28, 5, -33 },
  { 1264, 21, 33, 28, 3, -33 },
  { 1351, 21, 33, 28, 3, -33 },
  { 1438, 21, 33, 28, 4, -33 },
  { 1525, 21, 33, 28, 3, -33 },
  { 1612, 5, 24, 28, 13, -24 },
  { 1627, 6, 31, 28, 12, -24 },
  { 1651, 19, 19, 28, 4, -24 },
  { 1697, 20, 12, 28, 4, -21 },
  { 1727, 20, 19, 28, 4, -24 },
  { 1775, 18, 33, 28, 5, -33 },
  { 1850, 25, 33, 28, 1, -33 },
  { 1954, 24, 33, 28, 2, -33 },
  { 2053, 21, 33, 28, 4, -33 },
  { 2140, 22, 33, 28, 3, -33 },
  { 2231, 21, 33, 28, 4, -33 },
  { 2318, 19, 33, 28, 5, -33 },
  { 2397, 19, 33, 28, 5, -33 },
  { 2476, 22, 33, 28, 3, -33 },
  { 2567, 20, 33, 28, 4, -33 },
  { 2650, 19, 33, 28, 4, -33 },
  { 2729, 20, 33, 28, 3, -33 },
  { 2812, 22, 33, 28, 5, -33 },
  { 2903, 19, 33, 28, 5, -33 },
  { 2982, 20, 33, 28, 4, -33 },
  { 3065, 20, 33, 28, 4, -33 },
  { 3148, 22, 33, 28, 3, -33 },
  { 3239, 21, 33, 28, 5, -33 },
  { 3326, 23, 39, 28, 2, -33 },
  { 3439, 20, 33, 28, 5, -33 },
  { 3522, 22, 33, 28, 3, -33 },
  { 3613, 24, 33, 28, 2, -33 },
  { 3712, 20, 33, 28, 4, -33 },
  { 3795, 23, 33, 28, 2, -33 },
  { 3890, 24, 33, 28, 2, -33 },
  { 3989, 24, 33, 28, 2, -33 },
  { 4088, 23, 33, 28, 2, -33 },
  { 4183, 21, 33, 28, 3, -33 },
  { 4270, 8, 44, 28, 10, -37 },
  { 4314, 16, 36, 28, 6, -33 },
  { 4386, 7, 44, 28, 10, -37 },
  { 4425, 16, 18, 28, 6, -33 },
  { 4461, 20, 2, 28, 4, 0 },
  { 4466, 7, 6, 28, 10, -34 },
  { 4472, 20, 25, 28, 4, -25 },
  { 4535, 20, 35, 28, 4, -35 },
  { 4623, 20, 25, 28, 4, -25 },
  { 4686, 19, 35, 28, 4, -35 },
  { 4770, 21, 25, 28, 3, -25 },
  { 4836, 21, 35, 28, 4, -35 },
  { 4928, 19, 35, 28, 4, -25 },
  { 5012, 20, 35, 28, 4, -35 },
  { 5100, 20, 33, 28, 5, -33 },
  { 5183, 15, 43, 28, 4, -33 },
  { 5264, 20, 35, 28, 5, -35 },
  { 5352, 20, 35, 28, 5, -35 },
  { 5440, 24, 25, 28, 2, -25 },
  { 5515, 20, 25, 28, 4, -25 },
  { 5578, 22, 25, 28, 3, -25 },
  { 5647, 20, 34, 28, 4, -25 },
  { 5732, 19, 34, 28, 4, -25 },
  { 5813, 16, 25, 28, 8, -25 },
  { 5863, 20, 25, 28, 4, -25 },
  { 5926, 19, 31, 28, 4, -31 },
  { 6000, 19, 24, 28, 4, -24 },
  { 6057, 23, 24, 28, 2, -24 },
  { 6126, 26, 24, 28, 1, -24 },
  { 6204, 22, 24, 28, 3, -24 },
  { 6270, 24, 34, 28, 2, -24 },
  { 6372, 22, 24, 28, 3, -24 },
  { 6438, 15, 45, 28, 7, -36 },
  { 6523, 2, 41, 28, 13, -33 },
  { 6534, 15, 45, 28, 7, -36 },
  { 6619, 25, 9, 28, 1, -18 },
};

const GFXfont RobotoMono_Light46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light46pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_LIGHT46PT7B_H_
