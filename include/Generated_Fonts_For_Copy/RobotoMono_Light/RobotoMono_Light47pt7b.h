#ifndef _ROBOTOMONO_LIGHT47PT7B_H_
#define _ROBOTOMONO_LIGHT47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE0, 0x00, 0x00, 0x04, 0xFF, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1B, 0x06, 0xC1, 0xB0, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00,
  0x0C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x18,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80,
  0x01, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00,
  0x18, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF8, 0x1E, 0x03, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x3C,
  0x60, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x19, 0xC0, 0x00, 0xEE, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x03,
  0x9E, 0x00, 0x1C, 0x78, 0x01, 0xC1, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x10, 0x30, 0x1C, 0x0E, 0x0C, 0x07,
  0x03, 0x03, 0x01, 0xC1, 0xC0, 0xC0, 0x70, 0x60, 0x30, 0x1C, 0x38, 0x0E,
  0x06, 0x0C, 0x01, 0x81, 0x86, 0x00, 0x70, 0xE1, 0x80, 0x0F, 0xF0, 0xC0,
  0x01, 0xF8, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x38, 0x7F, 0x00,
  0x0C, 0x3D, 0xE0, 0x06, 0x1C, 0x18, 0x01, 0x86, 0x07, 0x00, 0xC1, 0x80,
  0xC0, 0x70, 0xE0, 0x30, 0x18, 0x38, 0x0C, 0x0E, 0x0E, 0x03, 0x03, 0x03,
  0x80, 0xC1, 0xC0, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x06, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x00,
  0x0C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x1C, 0x78, 0x06, 0x38, 0x3C, 0x0E, 0x70, 0x1C, 0x0E,
  0x70, 0x0E, 0x0E, 0xE0, 0x07, 0x0E, 0xE0, 0x07, 0x8C, 0xE0, 0x03, 0xDC,
  0xE0, 0x01, 0xD8, 0xE0, 0x00, 0xF8, 0x60, 0x00, 0x70, 0x70, 0x00, 0xF8,
  0x78, 0x01, 0xF8, 0x3E, 0x07, 0x9C, 0x1F, 0xFF, 0x0E, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x1C, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0xC0, 0xFF, 0x86, 0x1F,
  0x7F, 0xB7, 0xF8, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0D,
  0xC0, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80,
  0x70, 0x0E, 0x07, 0x00, 0x78, 0x08, 0x01, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x39, 0xCE, 0x73, 0x9D,
  0xCE, 0x67, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFE, 0xF0, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xF7, 0xE0,
  0x38, 0x07, 0x83, 0x80, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0x80, 0x03, 0xFC,
  0x00, 0x3B, 0xE0, 0x03, 0x9F, 0x00, 0x38, 0xF8, 0x03, 0x87, 0xC0, 0x38,
  0x3E, 0x03, 0x81, 0xF0, 0x78, 0x0F, 0x87, 0x00, 0x7C, 0x70, 0x03, 0xF7,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x37, 0x00, 0x03,
  0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xF0,
  0x07, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x70,
  0x1F, 0x07, 0xF3, 0xF7, 0xFC, 0x7F, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0x80, 0xF0, 0x38,
  0x00, 0xE1, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3C, 0x03, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x77,
  0x00, 0x03, 0xBC, 0x00, 0x38, 0xF0, 0x03, 0xC3, 0xE0, 0x7C, 0x0F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0,
  0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x77, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x3F, 0x87, 0x80, 0x7C, 0x10,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xE3, 0xC0, 0x3C, 0x1F, 0xBF,
  0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x07, 0xE0, 0x39, 0xFF, 0xC1, 0x9F, 0xBF, 0x0D, 0xC0, 0x3C,
  0x7C, 0x00, 0xE7, 0xC0, 0x03, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x63, 0x80, 0x07, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0x81, 0xE0, 0x78, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3C, 0x07, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x33, 0x80, 0x01, 0x9C, 0x00, 0x0C,
  0xE0, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x01, 0xF9,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xC0, 0xF0, 0x78, 0x01, 0xC7,
  0x80, 0x07, 0x38, 0x00, 0x1B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xB8,
  0x00, 0x38, 0xE0, 0x03, 0xC3, 0xC0, 0x7C, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xC0, 0x78, 0x38,
  0x01, 0xC7, 0x00, 0x1E, 0x70, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x0F, 0x78, 0x01,
  0xB3, 0xC0, 0x3F, 0x1F, 0x1F, 0x70, 0xFF, 0xE7, 0x03, 0xF0, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x9C, 0x73,
  0x84, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC7, 0x00, 0x3C, 0xE0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x1C, 0x0E, 0x18, 0x1F, 0xC1,
  0x8C, 0x0F, 0x78, 0x63, 0x07, 0x06, 0x18, 0xC1, 0x81, 0x83, 0x60, 0xC0,
  0x60, 0xD8, 0x30, 0x10, 0x36, 0x1C, 0x0C, 0x0D, 0x86, 0x03, 0x03, 0x61,
  0x80, 0xC0, 0xF0, 0x60, 0x30, 0x3C, 0x18, 0x0C, 0x0F, 0x06, 0x03, 0x02,
  0xC1, 0x80, 0xC1, 0xB8, 0x60, 0x70, 0x66, 0x18, 0x1C, 0x19, 0x87, 0x0F,
  0x0C, 0x60, 0xC6, 0xC3, 0x18, 0x3F, 0x1F, 0x87, 0x07, 0x83, 0xC0, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x00,
  0x1E, 0x01, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0x63, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xC1, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC1,
  0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x00,
  0xE0, 0x07, 0x00, 0x60, 0x07, 0x00, 0x70, 0x06, 0x00, 0x70, 0x0E, 0x00,
  0x30, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x01, 0xF1, 0xC0, 0x03, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70,
  0x01, 0xE3, 0x80, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0x00, 0x1F,
  0x38, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x80, 0x3F, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0xFC,
  0x03, 0x80, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x9C,
  0x00, 0x06, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xF0, 0x01, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x07, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0E, 0x01, 0xF0, 0x38, 0x00,
  0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x03, 0xC3, 0x80, 0x1E,
  0x0E, 0x03, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0x98, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xC0, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00,
  0x07, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D,
  0xC0, 0x00, 0x37, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x0C, 0x70,
  0x00, 0x71, 0xE0, 0x03, 0xC3, 0xE0, 0x3E, 0x07, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x37, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0xE0, 0xF8, 0x1E,
  0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x7B, 0x00, 0x03, 0xCC,
  0x00, 0x1E, 0x30, 0x00, 0xF0, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0C, 0x00,
  0xE0, 0x30, 0x07, 0x00, 0xC0, 0x3C, 0x03, 0x01, 0xE0, 0x0C, 0x0F, 0x00,
  0x30, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x78, 0x00, 0x33,
  0xE0, 0x00, 0xDF, 0xC0, 0x03, 0xF7, 0x80, 0x0F, 0x8F, 0x00, 0x3C, 0x1C,
  0x00, 0xE0, 0x38, 0x03, 0x00, 0xF0, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x80,
  0xC0, 0x07, 0x03, 0x00, 0x1E, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0xE3, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFD, 0x80,
  0x1F, 0xEC, 0x00, 0xFF, 0x70, 0x06, 0xF9, 0x80, 0x77, 0xCE, 0x03, 0x3E,
  0x70, 0x39, 0xF1, 0x81, 0xCF, 0x8E, 0x0C, 0x7C, 0x70, 0xE3, 0xE1, 0x87,
  0x1F, 0x0E, 0x30, 0xF8, 0x73, 0x87, 0xE1, 0x98, 0x3F, 0x0F, 0xC1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xEE, 0x00, 0x1F, 0x70, 0x00, 0xF9, 0xC0, 0x07,
  0xCE, 0x00, 0x3E, 0x38, 0x01, 0xF0, 0xC0, 0x0F, 0x87, 0x00, 0x7C, 0x1C,
  0x03, 0xE0, 0xE0, 0x1F, 0x03, 0x80, 0xF8, 0x1C, 0x07, 0xC0, 0x70, 0x3E,
  0x03, 0x81, 0xF0, 0x0E, 0x0F, 0x80, 0x70, 0x7C, 0x01, 0xC3, 0xE0, 0x06,
  0x1F, 0x00, 0x38, 0xF8, 0x00, 0xE7, 0xC0, 0x07, 0x3E, 0x00, 0x1D, 0xF0,
  0x00, 0xEF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xFC, 0x03, 0xC0, 0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80,
  0x03, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xE0, 0x1E, 0x03, 0xE0, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x00, 0xF1,
  0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x07,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x0F, 0x00, 0x70, 0x07, 0xC1, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x04, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x30, 0x03, 0xE1, 0x80, 0x07, 0x8C, 0x00, 0x1E, 0x60, 0x00, 0x73, 0x00,
  0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1D,
  0x80, 0x00, 0xEC, 0x00, 0x0E, 0x60, 0x00, 0x73, 0x00, 0x07, 0x18, 0x00,
  0x78, 0xC0, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0x80, 0x38, 0x0C,
  0x01, 0xC0, 0x60, 0x07, 0x03, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xC0, 0x03,
  0x06, 0x00, 0x1C, 0x30, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x60,
  0x00, 0x73, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07,
  0x87, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x07,
  0x8F, 0x00, 0x1E, 0x0F, 0x80, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x03, 0xB8,
  0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0xE0, 0x78, 0x1E,
  0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x06,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x0C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC3, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x1C, 0x03,
  0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x66, 0x03, 0xE0,
  0x33, 0x01, 0xB0, 0x19, 0x80, 0xD8, 0x0C, 0xE0, 0x6C, 0x0E, 0x70, 0x36,
  0x07, 0x38, 0x3B, 0x83, 0x9C, 0x1D, 0xC1, 0xC6, 0x0C, 0x60, 0xC3, 0x06,
  0x30, 0x61, 0x83, 0x18, 0x30, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x1C, 0x38,
  0xC1, 0x8E, 0x1C, 0x60, 0xC7, 0x06, 0x30, 0x63, 0x03, 0x18, 0x31, 0x81,
  0x9C, 0x1C, 0xC0, 0xEE, 0x0E, 0x60, 0x76, 0x03, 0x70, 0x3B, 0x01, 0xB8,
  0x1D, 0x80, 0xDC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x00, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x07,
  0x00, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC1, 0xC0, 0x01,
  0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x01,
  0xC1, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x01,
  0xC3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x76, 0x00, 0x33, 0x80, 0x39, 0xC0, 0x18,
  0x60, 0x1C, 0x38, 0x0E, 0x0C, 0x06, 0x07, 0x07, 0x03, 0x83, 0x00, 0xC3,
  0x80, 0x71, 0xC0, 0x18, 0xC0, 0x0E, 0xE0, 0x07, 0x60, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x1E, 0x07, 0xC3, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x60, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xC0, 0x07, 0x70, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xF7, 0x00, 0x3F, 0x7C, 0x0F, 0x73, 0xFF, 0xE7, 0x0F, 0xF8,
  0x70, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC3, 0xFC, 0x0C, 0xFF, 0xE0, 0xDE, 0x0F, 0x0F, 0x80, 0x78,
  0xF0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00,
  0xEC, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0,
  0x00, 0xEE, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x80, 0x38, 0xDC, 0x0F, 0x8C,
  0xFF, 0xE0, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0x07,
  0xC3, 0xC0, 0x1E, 0x38, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0xE3, 0xC0, 0x1E,
  0x1E, 0x03, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x03, 0xF8, 0x70,
  0xFF, 0xE7, 0x1F, 0x0F, 0x73, 0xC0, 0x3F, 0x78, 0x01, 0xF7, 0x00, 0x0F,
  0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x78,
  0x00, 0xF3, 0xC0, 0x1F, 0x1E, 0x07, 0x70, 0xFF, 0xE7, 0x07, 0xFC, 0x70,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x3E, 0x03, 0x80, 0x3C, 0x1C,
  0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x06, 0x70, 0x00,
  0x1D, 0x80, 0x00, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x78, 0x00,
  0xE0, 0xF8, 0x0F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xF0, 0x07, 0xF3, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xF8, 0x70, 0xFF, 0xE7, 0x1F, 0x0F, 0x73, 0xC0, 0x3F, 0x78, 0x01,
  0xF7, 0x00, 0x0F, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x77,
  0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x1F, 0x1E, 0x07, 0x70, 0xFF, 0xE7,
  0x07, 0xFC, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE2, 0x00, 0x0E, 0x70, 0x01, 0xC3, 0xC0, 0x38, 0x1F, 0xBF, 0x00, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xFF, 0x0E, 0x3F, 0xF8, 0xE7, 0x87,
  0xCE, 0xE0, 0x1E, 0xF8, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x87, 0xE1, 0xFF, 0x87, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xEE,
  0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0,
  0xE0, 0x78, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9E, 0x00, 0xF0, 0xF0, 0x0E, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0,
  0x07, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xE1, 0xFC, 0xEF, 0xF3, 0xFE, 0xF8, 0x7F,
  0x0E, 0xF0, 0x3E, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18,
  0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18,
  0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18,
  0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18,
  0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18,
  0x03, 0xE0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0xFF, 0x0E, 0x3F, 0xF8,
  0xE7, 0x87, 0xCE, 0xE0, 0x1E, 0xF8, 0x00, 0xEF, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x3C, 0x07, 0x80, 0x38, 0x3C, 0x00, 0x70,
  0xE0, 0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x67,
  0x00, 0x03, 0x9E, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0,
  0x3E, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xC3, 0xFC, 0x0C, 0xFF, 0xE0,
  0xDE, 0x1F, 0x0F, 0x80, 0x78, 0xF0, 0x03, 0xCE, 0x00, 0x1C, 0xC0, 0x00,
  0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCF,
  0x00, 0x38, 0xDC, 0x0F, 0x0C, 0xFF, 0xE0, 0xC7, 0xFC, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x70, 0xFF, 0xE7, 0x1F, 0x0F, 0x73, 0xC0, 0x3F, 0x78, 0x01, 0xF7,
  0x00, 0x0F, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00,
  0x07, 0x78, 0x00, 0xF3, 0xC0, 0x1F, 0x1E, 0x07, 0xF0, 0xFF, 0xE7, 0x07,
  0xFC, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0xE0, 0xFF, 0xF1, 0xFF, 0xB9, 0xFC, 0xDD, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xC1, 0xF0, 0x78, 0x01, 0xC3, 0x80, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xC0,
  0x00, 0x67, 0x00, 0x07, 0x3C, 0x00, 0x78, 0xF8, 0x0F, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0xE0,
  0x07, 0xDF, 0x03, 0xB9, 0xFF, 0xE7, 0x0F, 0xF0, 0xE0, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC3, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x0C, 0x01, 0xD8, 0x03, 0x80, 0x76, 0x00, 0xE0, 0x1D, 0xC0, 0x78,
  0x06, 0x70, 0x1E, 0x01, 0x8C, 0x07, 0xC0, 0xE3, 0x01, 0xB0, 0x38, 0xE0,
  0xEC, 0x0C, 0x38, 0x33, 0x03, 0x06, 0x0C, 0xE0, 0xC1, 0x83, 0x18, 0x70,
  0x61, 0xC6, 0x1C, 0x1C, 0x61, 0x86, 0x07, 0x18, 0x71, 0x80, 0xC6, 0x0C,
  0x60, 0x33, 0x83, 0x38, 0x0C, 0xC0, 0xCC, 0x03, 0xB0, 0x3B, 0x00, 0xEC,
  0x06, 0xC0, 0x1B, 0x01, 0xB0, 0x07, 0x80, 0x6C, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0xE0, 0x07, 0x80, 0xE0, 0x0E,
  0x01, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0xC0, 0x01, 0xC7, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xC7, 0x00, 0x07,
  0x07, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x0E, 0x03, 0x80,
  0x0E, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x2F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x0F, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x33, 0xCF, 0x80, 0x1D, 0xC0, 0xF0, 0x06, 0x60, 0x0F,
  0x03, 0x98, 0x01, 0xE1, 0xCE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 4, 33, 28, 12, -33 },
  { 18, 10, 10, 28, 9, -35 },
  { 31, 26, 33, 28, 1, -33 },
  { 139, 21, 44, 28, 4, -39 },
  { 255, 26, 34, 28, 1, -34 },
  { 366, 24, 34, 28, 3, -34 },
  { 468, 2, 10, 28, 12, -35 },
  { 471, 11, 48, 28, 9, -37 },
  { 537, 11, 48, 28, 8, -37 },
  { 603, 21, 20, 28, 4, -33 },
  { 656, 23, 25, 28, 3, -28 },
  { 728, 5, 11, 28, 9, -4 },
  { 735, 17, 2, 28, 5, -16 },
  { 740, 5, 4, 28, 12, -4 },
  { 743, 17, 36, 28, 6, -33 },
  { 820, 21, 34, 28, 4, -34 },
  { 910, 12, 33, 28, 5, -33 },
  { 960, 22, 34, 28, 2, -34 },
  { 1054, 21, 34, 28, 2, -34 },
  { 1144, 24, 33, 28, 2, -33 },
  { 1243, 20, 33, 28, 5, -33 },
  { 1326, 21, 34, 28, 3, -34 },
  { 1416, 22, 33, 28, 3, -33 },
  { 1507, 21, 34, 28, 4, -34 },
  { 1597, 20, 34, 28, 4, -34 },
  { 1682, 4, 24, 28, 14, -24 },
  { 1694, 6, 31, 28, 12, -24 },
  { 1718, 19, 20, 28, 4, -25 },
  { 1766, 20, 12, 28, 4, -21 },
  { 1796, 20, 20, 28, 4, -25 },
  { 1846, 19, 34, 28, 5, -34 },
  { 1927, 26, 34, 28, 1, -34 },
  { 2038, 24, 33, 28, 2, -33 },
  { 2137, 21, 33, 28, 4, -33 },
  { 2224, 22, 34, 28, 3, -34 },
  { 2318, 22, 33, 28, 4, -33 },
  { 2409, 19, 33, 28, 5, -33 },
  { 2488, 20, 33, 28, 5, -33 },
  { 2571, 22, 34, 28, 3, -34 },
  { 2665, 21, 33, 28, 4, -33 },
  { 2752, 20, 33, 28, 4, -33 },
  { 2835, 21, 33, 28, 3, -33 },
  { 2922, 22, 33, 28, 5, -33 },
  { 3013, 20, 33, 28, 5, -33 },
  { 3096, 21, 33, 28, 4, -33 },
  { 3183, 21, 33, 28, 4, -33 },
  { 3270, 22, 34, 28, 3, -34 },
  { 3364, 21, 33, 28, 5, -33 },
  { 3451, 24, 40, 28, 2, -34 },
  { 3571, 21, 33, 28, 5, -33 },
  { 3658, 23, 34, 28, 3, -34 },
  { 3756, 24, 33, 28, 2, -33 },
  { 3855, 21, 33, 28, 4, -33 },
  { 3942, 24, 33, 28, 2, -33 },
  { 4041, 25, 33, 28, 2, -33 },
  { 4145, 24, 33, 28, 2, -33 },
  { 4244, 24, 33, 28, 2, -33 },
  { 4343, 21, 33, 28, 3, -33 },
  { 4430, 8, 45, 28, 10, -38 },
  { 4475, 16, 36, 28, 6, -33 },
  { 4547, 8, 45, 28, 10, -38 },
  { 4592, 17, 18, 28, 6, -33 },
  { 4631, 20, 2, 28, 4, 0 },
  { 4636, 8, 6, 28, 10, -34 },
  { 4642, 20, 25, 28, 4, -25 },
  { 4705, 20, 35, 28, 5, -35 },
  { 4793, 20, 25, 28, 4, -25 },
  { 4856, 20, 35, 28, 4, -35 },
  { 4944, 22, 25, 28, 3, -25 },
  { 5013, 22, 36, 28, 4, -36 },
  { 5112, 20, 35, 28, 4, -25 },
  { 5200, 20, 35, 28, 4, -35 },
  { 5288, 20, 34, 28, 5, -34 },
  { 5373, 15, 44, 28, 4, -34 },
  { 5456, 20, 35, 28, 5, -35 },
  { 5544, 20, 35, 28, 5, -35 },
  { 5632, 24, 25, 28, 2, -25 },
  { 5707, 20, 25, 28, 4, -25 },
  { 5770, 22, 25, 28, 3, -25 },
  { 5839, 20, 35, 28, 5, -25 },
  { 5927, 20, 35, 28, 4, -25 },
  { 6015, 17, 25, 28, 8, -25 },
  { 6069, 21, 25, 28, 4, -25 },
  { 6135, 20, 31, 28, 4, -31 },
  { 6213, 19, 25, 28, 5, -25 },
  { 6273, 24, 25, 28, 2, -25 },
  { 6348, 26, 25, 28, 1, -25 },
  { 6430, 23, 25, 28, 3, -25 },
  { 6502, 24, 35, 28, 2, -25 },
  { 6607, 22, 25, 28, 3, -25 },
  { 6676, 15, 46, 28, 8, -37 },
  { 6763, 2, 41, 28, 13, -33 },
  { 6774, 15, 46, 28, 8, -37 },
  { 6861, 26, 8, 28, 1, -18 },
};

const GFXfont RobotoMono_Light47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light47pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_LIGHT47PT7B_H_
