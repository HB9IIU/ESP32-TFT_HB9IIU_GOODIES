#ifndef _ROBOTOMONO_LIGHT11PT7B_H_
#define _ROBOTOMONO_LIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF0, 0x24, 0xA7, 0xCA, 0x2B, 0xF4, 0x94, 0x23, 0xA3, 0x04,
  0x18, 0x31, 0x51, 0x00, 0x62, 0xAA, 0x94, 0x18, 0xD5, 0x43, 0x64, 0xA4,
  0xCA, 0xCE, 0x7F, 0xC0, 0x29, 0x49, 0x24, 0x89, 0x10, 0xA5, 0x55, 0x5A,
  0x21, 0x3E, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0xE0, 0xF0, 0x80, 0x11,
  0x12, 0x22, 0x44, 0x80, 0x74, 0x63, 0x7C, 0xC6, 0x2E, 0x3C, 0x92, 0x49,
  0x64, 0x84, 0x22, 0x22, 0x1F, 0x69, 0x11, 0x71, 0x9F, 0x08, 0x62, 0x8A,
  0x4B, 0xF0, 0x82, 0x7C, 0x21, 0xE0, 0x86, 0x2E, 0x32, 0x21, 0xE8, 0xC6,
  0x2E, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x74, 0x62, 0xE5, 0x46, 0x2E, 0x74,
  0x63, 0x19, 0xB4, 0x4C, 0x84, 0x87, 0x1B, 0x20, 0xC1, 0x80, 0xF8, 0x3E,
  0x83, 0x06, 0xC8, 0x00, 0x74, 0x42, 0x22, 0x10, 0x04, 0x39, 0x1B, 0xEB,
  0xAE, 0xD8, 0x9E, 0x21, 0x14, 0xA9, 0x7A, 0x31, 0xF4, 0x63, 0xE9, 0x46,
  0x3E, 0x74, 0x63, 0x08, 0x42, 0x2E, 0xE4, 0xA3, 0x18, 0xC6, 0x3E, 0xFC,
  0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x74, 0x61, 0x0B,
  0xC6, 0x2E, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F,
  0x08, 0x42, 0x10, 0x86, 0x5E, 0x8C, 0xA9, 0x8A, 0x4A, 0x51, 0x84, 0x21,
  0x08, 0x42, 0x1F, 0x8C, 0xF7, 0xBA, 0xD6, 0x31, 0x8C, 0x73, 0x9A, 0xCE,
  0x71, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74,
  0x63, 0x18, 0xC6, 0x2E, 0x08, 0xF4, 0x63, 0x1F, 0x4A, 0x51, 0x74, 0x60,
  0x83, 0x06, 0x2E, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x8C, 0x63, 0x18,
  0xC6, 0x2E, 0x85, 0x14, 0x92, 0x28, 0xA1, 0x04, 0x96, 0x57, 0x5B, 0x6D,
  0xB4, 0x92, 0x8C, 0x94, 0x42, 0x2A, 0x51, 0x85, 0x14, 0x8C, 0x10, 0x41,
  0x04, 0xF8, 0x84, 0x44, 0x22, 0x1F, 0xEA, 0xAA, 0xAC, 0x84, 0x44, 0x22,
  0x11, 0x10, 0xD5, 0x55, 0x5C, 0x22, 0x59, 0xF8, 0xC0, 0x74, 0x4F, 0x98,
  0xFC, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x74, 0x61, 0x08, 0xB8, 0x08, 0x5F,
  0x18, 0xC6, 0x2F, 0x74, 0x7F, 0x08, 0x3C, 0x3A, 0x3E, 0x84, 0x21, 0x08,
  0x7C, 0x63, 0x18, 0xBC, 0x3E, 0x84, 0x3D, 0x18, 0xC6, 0x31, 0x20, 0x38,
  0x42, 0x10, 0x9F, 0x21, 0x92, 0x49, 0x3C, 0x84, 0x27, 0x4C, 0x52, 0x51,
  0xE1, 0x08, 0x42, 0x10, 0x9F, 0xEE, 0x59, 0x65, 0x96, 0x50, 0xF4, 0x63,
  0x18, 0xC4, 0x74, 0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x7C,
  0x63, 0x18, 0xBC, 0x21, 0xF8, 0x88, 0x88, 0x74, 0x50, 0x68, 0xB8, 0x47,
  0x90, 0x84, 0x20, 0xE0, 0x8C, 0x63, 0x18, 0xBC, 0x8C, 0x64, 0xA6, 0x10,
  0x96, 0x57, 0x5B, 0x69, 0x20, 0x8A, 0x88, 0x45, 0x44, 0x85, 0x14, 0x8A,
  0x30, 0x41, 0x18, 0xF8, 0x88, 0x84, 0x7C, 0x29, 0x25, 0x12, 0x48, 0x80,
  0xFF, 0xC0, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xF6, 0x30,
};

const GFXglyph RobotoMono_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 2, 2, 7, 2, -8 },
  { 3, 6, 8, 7, 0, -8 },
  { 9, 5, 10, 7, 1, -9 },
  { 16, 6, 8, 7, 0, -8 },
  { 22, 5, 8, 7, 1, -8 },
  { 27, 1, 2, 7, 3, -8 },
  { 28, 3, 12, 7, 2, -9 },
  { 33, 2, 12, 7, 2, -9 },
  { 36, 5, 5, 7, 1, -8 },
  { 40, 5, 5, 7, 1, -6 },
  { 44, 1, 3, 7, 2, -1 },
  { 45, 4, 1, 7, 1, -4 },
  { 46, 1, 1, 7, 3, -1 },
  { 47, 4, 9, 7, 1, -8 },
  { 52, 5, 8, 7, 1, -8 },
  { 57, 3, 8, 7, 1, -8 },
  { 60, 5, 8, 7, 1, -8 },
  { 65, 4, 8, 7, 1, -8 },
  { 69, 6, 8, 7, 0, -8 },
  { 75, 5, 8, 7, 1, -8 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 5, 8, 7, 1, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 1, 6, 7, 3, -6 },
  { 101, 1, 8, 7, 3, -6 },
  { 102, 5, 5, 7, 1, -6 },
  { 106, 5, 3, 7, 1, -5 },
  { 108, 5, 5, 7, 1, -6 },
  { 112, 5, 8, 7, 1, -8 },
  { 117, 6, 8, 7, 0, -8 },
  { 123, 5, 8, 7, 1, -8 },
  { 128, 5, 8, 7, 1, -8 },
  { 133, 5, 8, 7, 1, -8 },
  { 138, 5, 8, 7, 1, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 8, 7, 1, -8 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 5, 8, 7, 1, -8 },
  { 183, 5, 8, 7, 1, -8 },
  { 188, 5, 8, 7, 1, -8 },
  { 193, 5, 8, 7, 1, -8 },
  { 198, 5, 8, 7, 1, -8 },
  { 203, 5, 9, 7, 1, -8 },
  { 209, 5, 8, 7, 1, -8 },
  { 214, 5, 8, 7, 1, -8 },
  { 219, 6, 8, 7, 0, -8 },
  { 225, 5, 8, 7, 1, -8 },
  { 230, 6, 8, 7, 0, -8 },
  { 236, 6, 8, 7, 0, -8 },
  { 242, 5, 8, 7, 1, -8 },
  { 247, 6, 8, 7, 0, -8 },
  { 253, 5, 8, 7, 1, -8 },
  { 258, 2, 11, 7, 2, -9 },
  { 261, 4, 9, 7, 1, -8 },
  { 266, 2, 11, 7, 2, -9 },
  { 269, 4, 4, 7, 1, -8 },
  { 271, 5, 1, 7, 1, 0 },
  { 272, 2, 1, 7, 2, -8 },
  { 273, 5, 6, 7, 1, -6 },
  { 277, 5, 8, 7, 1, -8 },
  { 282, 5, 6, 7, 1, -6 },
  { 286, 5, 8, 7, 1, -8 },
  { 291, 5, 6, 7, 1, -6 },
  { 295, 5, 8, 7, 1, -8 },
  { 300, 5, 8, 7, 1, -6 },
  { 305, 5, 8, 7, 1, -8 },
  { 310, 5, 8, 7, 1, -8 },
  { 315, 3, 10, 7, 1, -8 },
  { 319, 5, 8, 7, 1, -8 },
  { 324, 5, 8, 7, 1, -8 },
  { 329, 6, 6, 7, 0, -6 },
  { 334, 5, 6, 7, 1, -6 },
  { 338, 5, 6, 7, 1, -6 },
  { 342, 5, 8, 7, 1, -6 },
  { 347, 5, 8, 7, 1, -6 },
  { 352, 4, 6, 7, 2, -6 },
  { 355, 5, 6, 7, 1, -6 },
  { 359, 5, 7, 7, 1, -7 },
  { 364, 5, 6, 7, 1, -6 },
  { 368, 5, 6, 7, 1, -6 },
  { 372, 6, 6, 7, 0, -6 },
  { 377, 5, 6, 7, 1, -6 },
  { 381, 6, 8, 7, 0, -6 },
  { 387, 5, 6, 7, 1, -6 },
  { 391, 3, 11, 7, 2, -9 },
  { 396, 1, 10, 7, 3, -8 },
  { 398, 3, 11, 7, 2, -9 },
  { 403, 6, 2, 7, 0, -4 },
};

const GFXfont RobotoMono_Light11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light11pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_LIGHT11PT7B_H_
