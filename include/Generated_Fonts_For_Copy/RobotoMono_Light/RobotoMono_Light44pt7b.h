#ifndef _ROBOTOMONO_LIGHT44PT7B_H_
#define _ROBOTOMONO_LIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x38,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x70, 0x00, 0xE0, 0x60, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x81, 0xC0,
  0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0x01, 0x80,
  0x03, 0x03, 0x80, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0xE0, 0x3C, 0x38, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3B, 0x80, 0x07, 0x78, 0x01, 0xC7, 0x80, 0xF0, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0xE0, 0x40, 0xC0, 0x60, 0x60, 0xC0, 0x60, 0x60, 0xC0, 0x60, 0xC0, 0xC0,
  0x61, 0xC0, 0xC0, 0x61, 0x80, 0xC0, 0xC3, 0x80, 0x60, 0xC3, 0x00, 0x7B,
  0x86, 0x00, 0x3F, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x70, 0xFC, 0x00,
  0x61, 0xCE, 0x00, 0xE3, 0x07, 0x00, 0xC3, 0x03, 0x01, 0x83, 0x03, 0x01,
  0x87, 0x03, 0x03, 0x07, 0x03, 0x03, 0x07, 0x03, 0x06, 0x03, 0x03, 0x02,
  0x03, 0x03, 0x00, 0x03, 0x87, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x06,
  0x00, 0x70, 0x1C, 0x01, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x18, 0x06, 0x00,
  0x70, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x73, 0x80,
  0x03, 0x87, 0x01, 0x9C, 0x1E, 0x06, 0x70, 0x38, 0x1B, 0x80, 0x70, 0x6E,
  0x00, 0xE3, 0xB8, 0x01, 0xCE, 0xC0, 0x07, 0xF3, 0x80, 0x0F, 0xCE, 0x00,
  0x1E, 0x18, 0x00, 0x78, 0x70, 0x03, 0xF0, 0xF0, 0x3D, 0xC1, 0xFF, 0xE3,
  0x83, 0xFE, 0x07, 0xFF, 0xED, 0xB6, 0xD8, 0x00, 0x40, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x70, 0x04, 0x40, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x08,
  0x06, 0x02, 0xF0, 0x60, 0xEF, 0xC6, 0x7F, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0x98, 0x00, 0x31, 0xC0, 0x07, 0x0E,
  0x00, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x08, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x39, 0xCE, 0x73, 0x9C, 0xCE, 0x67, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xE0, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x06, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0x7E, 0x00, 0xE7, 0xE0, 0x1C, 0x7E, 0x03, 0x83, 0xE0, 0x70, 0x3E,
  0x0E, 0x03, 0xE1, 0xC0, 0x3E, 0x70, 0x03, 0xEE, 0x00, 0x3F, 0xC0, 0x07,
  0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC1, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x60, 0x7C, 0x3F, 0xBF, 0x7F, 0x8F, 0xC1, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x03, 0xC0, 0x78, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x60,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0E,
  0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x67,
  0x00, 0x0E, 0x38, 0x01, 0xC3, 0xE0, 0x3C, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00,
  0x1D, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0xE1,
  0x80, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80,
  0x1C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x8F, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0x01, 0xF0,
  0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x3E, 0x3F, 0x07, 0xFF, 0x80, 0x7F, 0x80,
  0x00, 0x03, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x02, 0x00, 0x63, 0xFE, 0x06, 0x7F, 0xF0, 0xEE,
  0x07, 0x8F, 0x80, 0x1C, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0x60, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1C, 0x01,
  0xC1, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xC0, 0x78,
  0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00,
  0xE6, 0x00, 0x0E, 0x60, 0x00, 0xE7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80,
  0x38, 0x1F, 0x0F, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xE0, 0xF8, 0x38,
  0x03, 0xC7, 0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x67, 0x00, 0x0E,
  0x78, 0x01, 0xC3, 0xC0, 0x78, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77,
  0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x1F, 0x1C, 0x07, 0x70, 0xFF, 0xE6,
  0x07, 0xFC, 0x60, 0x1E, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x38, 0xF3, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xE3, 0x8E,
  0x38, 0xC7, 0x18, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x0F,
  0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x18, 0x1F, 0x06,
  0x30, 0x3F, 0x86, 0x30, 0x71, 0xC3, 0x20, 0xE0, 0x83, 0x60, 0xC0, 0x83,
  0x61, 0x81, 0x83, 0x61, 0x81, 0x83, 0x41, 0x81, 0x83, 0xC1, 0x81, 0x83,
  0xC3, 0x01, 0x83, 0xC3, 0x01, 0x83, 0xC3, 0x01, 0x83, 0xC3, 0x01, 0x83,
  0xC3, 0x03, 0x82, 0xC1, 0x83, 0x86, 0x61, 0x87, 0x86, 0x61, 0xFD, 0xCC,
  0x60, 0xF8, 0xF8, 0x70, 0x20, 0x20, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x63, 0x00, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xE0, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x60, 0x03, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCC,
  0x00, 0x01, 0xB8, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xE0,
  0x0F, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x07, 0x8E, 0x01, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x07,
  0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x3C, 0xE0, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xF7, 0xE0, 0x3C, 0x07, 0x83, 0x80,
  0x1E, 0x1C, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x60, 0x00, 0x37,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0x70,
  0x01, 0xC1, 0xC0, 0x1C, 0x0F, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x1E, 0x0C, 0x00, 0x70, 0xC0, 0x03,
  0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E,
  0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0xF0, 0xC0, 0x7E,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3C, 0x07, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x01,
  0xCC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x77, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x80, 0x1C, 0x1E, 0x07, 0x80, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x38, 0x00, 0x71,
  0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x78, 0x1C, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0E,
  0x3C, 0x00, 0x73, 0xC0, 0x03, 0x9E, 0x00, 0x1D, 0xF8, 0x00, 0xFC, 0xE0,
  0x07, 0xC7, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1C,
  0x38, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80,
  0x00, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xB0, 0x06, 0xF6, 0x01, 0xDE, 0xE0, 0x33, 0xCC, 0x06, 0x79, 0x81, 0xCF,
  0x38, 0x31, 0xE3, 0x0E, 0x3C, 0x61, 0x87, 0x8E, 0x30, 0xF0, 0xCE, 0x1E,
  0x1D, 0x83, 0xC1, 0xB0, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x3C,
  0x0C, 0x07, 0x81, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x18, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xEE, 0x00, 0x7E, 0x60, 0x07, 0xE7, 0x00,
  0x7E, 0x30, 0x07, 0xE3, 0x80, 0x7E, 0x18, 0x07, 0xE1, 0xC0, 0x7E, 0x0E,
  0x07, 0xE0, 0xE0, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x03, 0x87, 0xE0,
  0x18, 0x7E, 0x01, 0xC7, 0xE0, 0x0C, 0x7E, 0x00, 0xE7, 0xE0, 0x07, 0x7E,
  0x00, 0x77, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3C, 0x07, 0x03, 0xC0, 0x1C, 0x1C, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x60, 0x00, 0x77, 0x00, 0x01, 0xB8, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0x60,
  0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0x70, 0x01, 0x81, 0xC0, 0x1C,
  0x0F, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0x00, 0x3E, 0x60, 0x01, 0xEC, 0x00, 0x1D, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xB0, 0x00, 0xF6, 0x00, 0x7C, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x78, 0x1C, 0x00, 0xE0,
  0x60, 0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E, 0x70, 0x00, 0x19, 0xC0,
  0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00,
  0x01, 0xDC, 0x00, 0x06, 0x70, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03,
  0x07, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xE0, 0x0F, 0x8E,
  0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x60, 0xE0,
  0x07, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00, 0x18, 0xE0, 0x01, 0xCE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0x80, 0x0E, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x3B, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE3,
  0x80, 0x0F, 0x0F, 0x01, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x00, 0xE3,
  0xC0, 0x1C, 0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x77, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38,
  0xC0, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70,
  0x01, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x1C, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x80, 0x0C, 0x0E, 0x00,
  0x30, 0x30, 0x00, 0xE1, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x1C,
  0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x0F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x38, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0xE0, 0x1F, 0x01, 0xC0, 0x7E,
  0x03, 0xC0, 0xEC, 0x0F, 0x81, 0xD8, 0x1B, 0x03, 0x30, 0x36, 0x06, 0x60,
  0x6C, 0x0C, 0xE0, 0xDC, 0x19, 0xC3, 0x98, 0x73, 0x86, 0x30, 0xE3, 0x0C,
  0x61, 0xC6, 0x18, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0xE3, 0x8C, 0x39, 0x83,
  0x18, 0x73, 0x06, 0x30, 0xE6, 0x0C, 0xE0, 0xCC, 0x19, 0xC1, 0x98, 0x3B,
  0x03, 0x70, 0x36, 0x06, 0xC0, 0x6C, 0x0D, 0x80, 0xD8, 0x1F, 0x01, 0xB0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x00, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x07, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x70, 0x00, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0x60, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x18, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x87, 0x00,
  0x06, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x37, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0xF8, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x70, 0x0C,
  0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC1, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xFC, 0x1C, 0x03, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0xB8, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xFF, 0x07, 0xFF, 0xE3, 0xFE,
  0x0C, 0xF0, 0x01, 0xBC, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x7C, 0xF0, 0x3D, 0x8F, 0xFF,
  0x38, 0xFF, 0x87, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x1C, 0x03, 0x9F, 0xF0, 0x77, 0xFF, 0x8F, 0xC0, 0x79, 0xF0, 0x07,
  0x3C, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x70, 0x00, 0xEF, 0x00, 0x1D,
  0xF0, 0x07, 0x3F, 0x03, 0xC7, 0x7F, 0xF0, 0xE3, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xE0, 0x3C, 0x1C, 0x01, 0xE3, 0x80,
  0x0E, 0x70, 0x00, 0x67, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x30, 0x00, 0x63, 0x80, 0x0E,
  0x1C, 0x01, 0xC0, 0xE0, 0x3C, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x0C, 0x1F, 0xF1,
  0x87, 0xFF, 0x31, 0xE0, 0x36, 0x70, 0x03, 0xCE, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0xC0, 0x01, 0xB8, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x03, 0xC7, 0x81, 0xD8,
  0x7F, 0xF3, 0x03, 0xFC, 0x60, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x81, 0xE0, 0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0x67, 0x00,
  0x07, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x02, 0x1C, 0x00, 0x70, 0xF0, 0x1E,
  0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x8C, 0x3F,
  0xF9, 0x8F, 0x01, 0xB3, 0x80, 0x1E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6E, 0x00,
  0x0D, 0xC0, 0x03, 0x9C, 0x00, 0x73, 0xC0, 0x1E, 0x3C, 0x0E, 0xC3, 0xFF,
  0x98, 0x1F, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x63, 0x00, 0x1C, 0x70, 0x07, 0x07, 0x81, 0xE0, 0x7F, 0xF8, 0x03, 0xFC,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x07,
  0x03, 0x8F, 0xF8, 0x73, 0xFF, 0x8E, 0xE0, 0x39, 0xF0, 0x03, 0xBC, 0x00,
  0x77, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x3F, 0xF0, 0xFF, 0x80, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0B, 0x00, 0x0E, 0x60, 0x03,
  0x8C, 0x01, 0xE1, 0x80, 0x78, 0x30, 0x1E, 0x06, 0x07, 0x80, 0xC1, 0xE0,
  0x18, 0x78, 0x03, 0x1C, 0x00, 0x67, 0x00, 0x0D, 0xF0, 0x01, 0xF7, 0x00,
  0x3C, 0x70, 0x07, 0x0F, 0x00, 0xC0, 0xF0, 0x18, 0x0E, 0x03, 0x00, 0xE0,
  0x60, 0x0E, 0x0C, 0x00, 0xE1, 0x80, 0x0E, 0x30, 0x01, 0xE6, 0x00, 0x1E,
  0xC0, 0x01, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0xE1, 0x9F, 0xC7, 0xF3,
  0x7F, 0xDF, 0xF7, 0x83, 0xE0, 0xEE, 0x03, 0x80, 0xDC, 0x07, 0x01, 0xB0,
  0x0C, 0x03, 0xE0, 0x18, 0x07, 0xC0, 0x30, 0x0F, 0x80, 0x60, 0x1F, 0x00,
  0xC0, 0x3E, 0x01, 0x80, 0x7C, 0x03, 0x00, 0xF8, 0x06, 0x01, 0xF0, 0x0C,
  0x03, 0xE0, 0x18, 0x07, 0xC0, 0x30, 0x0F, 0x80, 0x60, 0x1F, 0x00, 0xC0,
  0x3E, 0x01, 0x80, 0x7C, 0x03, 0x00, 0xF8, 0x06, 0x01, 0xF0, 0x0C, 0x03,
  0xE0, 0x18, 0x07, 0x00, 0x30, 0x1C, 0x7F, 0xC3, 0x9F, 0xFC, 0x77, 0x01,
  0xCF, 0x80, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00,
  0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0x80,
  0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x73, 0x00, 0x03, 0x9C,
  0x00, 0x18, 0x70, 0x01, 0xC3, 0xC0, 0x1C, 0x0F, 0x03, 0xC0, 0x3F, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x1C, 0xFF, 0x83, 0xBF, 0xFC, 0x7E, 0x03,
  0x8F, 0x00, 0x39, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x07,
  0x78, 0x00, 0xCF, 0x00, 0x39, 0xF8, 0x1E, 0x3B, 0xFF, 0x87, 0x1F, 0xE0,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x8C, 0x3F, 0xF9, 0x8F, 0x01, 0xB3, 0x80, 0x1E, 0x70, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03,
  0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x03, 0x9C, 0x00, 0x73, 0xC0, 0x1E,
  0x3C, 0x0E, 0xC3, 0xFF, 0x98, 0x1F, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x7D, 0x87, 0xFF, 0x1F, 0xFE, 0x70,
  0x0D, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1E, 0x01, 0xC7,
  0x00, 0x1C, 0xE0, 0x01, 0xD8, 0x00, 0x3B, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x77, 0x00, 0x1C, 0x78, 0x07, 0x87, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x77, 0x00, 0x1D,
  0xC0, 0x0F, 0x3C, 0x0E, 0xC7, 0xFF, 0x30, 0xFF, 0x8C, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x67, 0x00, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x60,
  0x01, 0xC1, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x03, 0x80, 0x0E, 0x0C, 0x00,
  0x18, 0x70, 0x00, 0x61, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x38, 0x00, 0x0E,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x18, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x1C, 0x07, 0x70, 0x3C,
  0x07, 0x70, 0x34, 0x06, 0x30, 0x36, 0x06, 0x30, 0x36, 0x06, 0x30, 0x76,
  0x0E, 0x38, 0x66, 0x0C, 0x38, 0x63, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0xE3,
  0x0C, 0x18, 0xC3, 0x1C, 0x1C, 0xC1, 0x98, 0x0C, 0xC1, 0x98, 0x0D, 0xC1,
  0x98, 0x0D, 0x81, 0x98, 0x0D, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x00,
  0xF0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0xF0, 0x00,
  0x7B, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x38, 0x03,
  0x83, 0x80, 0x1C, 0x3C, 0x00, 0x71, 0xC0, 0x01, 0xDC, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00, 0x0E,
  0x38, 0x00, 0x71, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x70,
  0x38, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x3B, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x18, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x38,
  0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7C, 0x00,
  0xF0, 0x0F, 0x80, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x08,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0x3D, 0xF0, 0x03, 0x70,
  0x38, 0x07, 0x60, 0x1E, 0x06, 0xE0, 0x0F, 0xBE, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0xF0,
};

const GFXglyph RobotoMono_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 4, 31, 26, 11, -31 },
  { 17, 8, 10, 26, 9, -33 },
  { 27, 24, 31, 26, 1, -31 },
  { 120, 19, 40, 26, 4, -36 },
  { 215, 24, 32, 26, 1, -32 },
  { 311, 22, 32, 26, 3, -32 },
  { 399, 3, 10, 26, 11, -33 },
  { 403, 11, 45, 26, 8, -35 },
  { 465, 11, 45, 26, 7, -35 },
  { 527, 20, 19, 26, 4, -31 },
  { 575, 21, 23, 26, 3, -26 },
  { 636, 5, 10, 26, 8, -4 },
  { 643, 16, 2, 26, 5, -15 },
  { 647, 4, 4, 26, 12, -4 },
  { 649, 15, 34, 26, 6, -31 },
  { 713, 20, 32, 26, 3, -32 },
  { 793, 11, 31, 26, 5, -31 },
  { 836, 20, 32, 26, 2, -32 },
  { 916, 20, 32, 26, 2, -32 },
  { 996, 22, 31, 26, 2, -31 },
  { 1082, 18, 31, 26, 5, -31 },
  { 1152, 20, 32, 26, 3, -32 },
  { 1232, 20, 31, 26, 3, -31 },
  { 1310, 20, 32, 26, 4, -32 },
  { 1390, 20, 32, 26, 3, -32 },
  { 1470, 4, 23, 26, 13, -23 },
  { 1482, 6, 29, 26, 11, -23 },
  { 1504, 18, 18, 26, 4, -23 },
  { 1545, 19, 11, 26, 4, -20 },
  { 1572, 19, 18, 26, 4, -23 },
  { 1615, 17, 32, 26, 5, -32 },
  { 1683, 24, 31, 26, 1, -31 },
  { 1776, 23, 31, 26, 2, -31 },
  { 1866, 20, 31, 26, 4, -31 },
  { 1944, 21, 32, 26, 3, -32 },
  { 2028, 20, 31, 26, 4, -31 },
  { 2106, 19, 31, 26, 4, -31 },
  { 2180, 18, 31, 26, 5, -31 },
  { 2250, 21, 32, 26, 3, -32 },
  { 2334, 20, 31, 26, 3, -31 },
  { 2412, 18, 31, 26, 4, -31 },
  { 2482, 20, 31, 26, 2, -31 },
  { 2560, 21, 31, 26, 4, -31 },
  { 2642, 18, 31, 26, 5, -31 },
  { 2712, 19, 31, 26, 4, -31 },
  { 2786, 20, 31, 26, 3, -31 },
  { 2864, 21, 32, 26, 3, -32 },
  { 2948, 19, 31, 26, 5, -31 },
  { 3022, 22, 37, 26, 2, -32 },
  { 3124, 20, 31, 26, 4, -31 },
  { 3202, 21, 32, 26, 3, -32 },
  { 3286, 23, 31, 26, 2, -31 },
  { 3376, 20, 31, 26, 3, -31 },
  { 3454, 22, 31, 26, 2, -31 },
  { 3540, 23, 31, 26, 2, -31 },
  { 3630, 23, 31, 26, 2, -31 },
  { 3720, 22, 31, 26, 2, -31 },
  { 3806, 20, 31, 26, 3, -31 },
  { 3884, 7, 43, 26, 10, -36 },
  { 3922, 15, 34, 26, 6, -31 },
  { 3986, 8, 43, 26, 9, -36 },
  { 4029, 16, 17, 26, 5, -31 },
  { 4063, 19, 2, 26, 4, 0 },
  { 4068, 7, 6, 26, 10, -32 },
  { 4074, 19, 24, 26, 4, -24 },
  { 4131, 19, 33, 26, 4, -33 },
  { 4210, 20, 24, 26, 3, -24 },
  { 4270, 19, 33, 26, 3, -33 },
  { 4349, 20, 24, 26, 3, -24 },
  { 4409, 20, 34, 26, 4, -34 },
  { 4494, 19, 33, 26, 3, -24 },
  { 4573, 19, 33, 26, 4, -33 },
  { 4652, 18, 32, 26, 5, -32 },
  { 4724, 14, 41, 26, 4, -32 },
  { 4796, 19, 33, 26, 5, -33 },
  { 4875, 18, 33, 26, 5, -33 },
  { 4950, 23, 24, 26, 2, -24 },
  { 5019, 19, 24, 26, 4, -24 },
  { 5076, 21, 24, 26, 3, -24 },
  { 5139, 19, 33, 26, 4, -24 },
  { 5218, 19, 33, 26, 3, -24 },
  { 5297, 15, 24, 26, 8, -24 },
  { 5342, 19, 24, 26, 4, -24 },
  { 5399, 18, 29, 26, 4, -29 },
  { 5465, 18, 23, 26, 4, -23 },
  { 5517, 22, 23, 26, 2, -23 },
  { 5581, 24, 23, 26, 1, -23 },
  { 5650, 21, 23, 26, 3, -23 },
  { 5711, 23, 32, 26, 2, -23 },
  { 5803, 21, 23, 26, 3, -23 },
  { 5864, 14, 43, 26, 7, -34 },
  { 5940, 2, 38, 26, 12, -31 },
  { 5950, 14, 43, 26, 7, -34 },
  { 6026, 24, 8, 26, 1, -17 },
};

const GFXfont RobotoMono_Light44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light44pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_LIGHT44PT7B_H_
