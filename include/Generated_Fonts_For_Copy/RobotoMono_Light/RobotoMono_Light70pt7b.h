#ifndef _ROBOTOMONO_LIGHT70PT7B_H_
#define _ROBOTOMONO_LIGHT70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light70pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x07, 0x00, 0xF0,
  0x07, 0x80, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x00,
  0x78, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x70,
  0x00, 0x78, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x07, 0x80, 0x00, 0xF8,
  0x7C, 0x0E, 0x00, 0x00, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x70,
  0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x07, 0xFC, 0x00, 0x00, 0x78,
  0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x7C, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x3C,
  0x00, 0x07, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x78, 0x00, 0x38,
  0x1E, 0x00, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x7C,
  0x07, 0xC0, 0x07, 0x8F, 0x80, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xC0, 0x1E,
  0x78, 0x00, 0x7C, 0x03, 0x9F, 0x00, 0x07, 0x80, 0xF3, 0xC0, 0x00, 0xF8,
  0x1E, 0x78, 0x00, 0x0F, 0x83, 0xCF, 0x00, 0x00, 0xF8, 0xF1, 0xE0, 0x00,
  0x0F, 0x9E, 0x3C, 0x00, 0x00, 0xF7, 0xC7, 0x80, 0x00, 0x1F, 0xF0, 0xF0,
  0x00, 0x01, 0xFE, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x0F,
  0xBE, 0x07, 0xF0, 0x0F, 0xE3, 0xE0, 0x7F, 0xFF, 0xF8, 0x3E, 0x07, 0xFF,
  0xFC, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x78, 0x03,
  0xC0, 0x1E, 0x7E, 0x03, 0xC0, 0x7E, 0xFF, 0xC3, 0xC3, 0xFE, 0x7F, 0xF9,
  0xDF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80,
  0x01, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0xF0, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7D, 0xFB, 0xFF,
  0xFF, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x7E, 0x78, 0x00, 0x00, 0xFF, 0x78, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xDF, 0xF8, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x3E,
  0x0F, 0xF8, 0x00, 0x7C, 0x0F, 0xF8, 0x00, 0xF8, 0x0F, 0xF8, 0x01, 0xE0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF8, 0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0x00,
  0x0F, 0xF8, 0x3E, 0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x0F, 0xF8, 0xF8, 0x00,
  0x0F, 0xF9, 0xF0, 0x00, 0x0F, 0xFB, 0xE0, 0x00, 0x0F, 0x7F, 0x80, 0x00,
  0x0F, 0x7F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0xFE, 0x00, 0x0F, 0x3F, 0xFF, 0x00, 0x3D,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xC0,
  0x07, 0xF8, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x7F, 0xF0, 0x03, 0xC3, 0xFF,
  0xF8, 0x07, 0x9F, 0xFF, 0xFC, 0x0E, 0x7E, 0x01, 0xFC, 0x3D, 0xF0, 0x00,
  0xFC, 0x7F, 0x80, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00,
  0xF3, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x7D, 0xE0, 0xFE, 0x03,
  0xF3, 0xC0, 0xFF, 0xFF, 0xC7, 0x80, 0xFF, 0xFE, 0x0E, 0x00, 0x7F, 0xF8,
  0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xF7, 0xEF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3F, 0xFF,
  0xFD, 0xFB, 0xE0, 0x1F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF8, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x83,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x07, 0x03, 0x80, 0x1F, 0xE0, 0x1C, 0x1E, 0x01, 0xFF, 0xE0,
  0x38, 0x70, 0x0F, 0xCF, 0xC0, 0xE3, 0xC0, 0x3C, 0x06, 0x03, 0x8E, 0x01,
  0xE0, 0x18, 0x0E, 0x38, 0x0F, 0x00, 0xE0, 0x19, 0xE0, 0x38, 0x03, 0x80,
  0x77, 0x01, 0xE0, 0x0E, 0x01, 0xDC, 0x07, 0x00, 0x38, 0x07, 0x70, 0x1C,
  0x00, 0xE0, 0x1D, 0xC0, 0x70, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x0E, 0x01,
  0xF8, 0x0E, 0x00, 0x38, 0x07, 0xE0, 0x38, 0x00, 0xC0, 0x1F, 0x80, 0xE0,
  0x03, 0x00, 0x7E, 0x03, 0x80, 0x0C, 0x01, 0xF8, 0x0E, 0x00, 0x70, 0x06,
  0xE0, 0x38, 0x01, 0xC0, 0x1B, 0x80, 0xE0, 0x07, 0x00, 0xEE, 0x03, 0x80,
  0x1C, 0x03, 0xB8, 0x0E, 0x00, 0xF0, 0x0E, 0xE0, 0x38, 0x03, 0xC0, 0x33,
  0xC0, 0xE0, 0x1F, 0x01, 0xC7, 0x03, 0xC0, 0xFC, 0x07, 0x1C, 0x07, 0x07,
  0x38, 0x38, 0x70, 0x1F, 0xFC, 0xF1, 0xC1, 0xC0, 0x3F, 0xE3, 0xFF, 0x03,
  0x80, 0x7F, 0x07, 0xF8, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x40, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x03,
  0xFC, 0x1E, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x00, 0x7F, 0x07, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x3F,
  0x1E, 0x00, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x01, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x07,
  0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03,
  0xF0, 0xF0, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFB, 0xC0, 0x00,
  0xFF, 0xFE, 0xF0, 0x00, 0x3F, 0xFF, 0xBC, 0x00, 0x0F, 0xFF, 0xEF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x1F, 0x83, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01,
  0xE3, 0xF8, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00, 0x7B, 0xFF, 0x80, 0x00,
  0x3F, 0xE7, 0xC0, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0x80, 0x00,
  0xFF, 0xEF, 0x00, 0x01, 0xDF, 0xDE, 0x00, 0x07, 0xBF, 0xDE, 0x00, 0x0F,
  0x7F, 0xBC, 0x00, 0x3C, 0xFF, 0x38, 0x00, 0x79, 0xFE, 0x78, 0x00, 0xE3,
  0xFC, 0xF0, 0x03, 0xC7, 0xF8, 0xE0, 0x07, 0x8F, 0xF1, 0xE0, 0x1E, 0x1F,
  0xE3, 0xC0, 0x3C, 0x3F, 0xC3, 0xC0, 0x78, 0x7F, 0x87, 0x81, 0xE0, 0xFF,
  0x0F, 0x03, 0xC1, 0xFE, 0x0F, 0x07, 0x03, 0xFC, 0x1E, 0x1E, 0x07, 0xF8,
  0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0xF0, 0x1F, 0xE0, 0x79, 0xE0, 0x3F, 0xC0,
  0x73, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x1C, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xDE,
  0x00, 0x00, 0xFF, 0xBE, 0x00, 0x01, 0xFF, 0x3C, 0x00, 0x03, 0xFE, 0x3C,
  0x00, 0x07, 0xFC, 0x78, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x1F, 0xF0, 0xF8,
  0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x7F, 0xC1, 0xF0, 0x00, 0xFF, 0x81, 0xE0,
  0x01, 0xFF, 0x03, 0xE0, 0x03, 0xFE, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xC0,
  0x0F, 0xF8, 0x07, 0x80, 0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00,
  0x7F, 0xC0, 0x0F, 0x00, 0xFF, 0x80, 0x1F, 0x01, 0xFF, 0x00, 0x1E, 0x03,
  0xFE, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x3C, 0x0F, 0xF8, 0x00, 0x7C, 0x1F,
  0xF0, 0x00, 0x78, 0x3F, 0xE0, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0xF0, 0xFF,
  0x80, 0x00, 0xF1, 0xFF, 0x00, 0x01, 0xE3, 0xFE, 0x00, 0x01, 0xE7, 0xFC,
  0x00, 0x03, 0xEF, 0xF8, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x04, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1F, 0xC0, 0xF0, 0x00,
  0x07, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xB8, 0x00,
  0x7C, 0x00, 0x3D, 0xE0, 0x03, 0xF0, 0x01, 0xCF, 0x00, 0x3F, 0x80, 0x1E,
  0x78, 0x01, 0xFC, 0x00, 0xF3, 0xC0, 0x0E, 0xE0, 0x07, 0x9E, 0x00, 0x77,
  0x00, 0x3C, 0xF0, 0x03, 0xBC, 0x01, 0xE3, 0x80, 0x1D, 0xE0, 0x0F, 0x1E,
  0x01, 0xEF, 0x00, 0x70, 0xF0, 0x0F, 0x38, 0x03, 0x87, 0x80, 0x71, 0xC0,
  0x3C, 0x3C, 0x03, 0x8E, 0x01, 0xE1, 0xE0, 0x1C, 0x78, 0x0F, 0x0F, 0x01,
  0xE3, 0xC0, 0x78, 0x38, 0x0F, 0x0E, 0x03, 0xC1, 0xE0, 0x70, 0x70, 0x1C,
  0x0F, 0x03, 0x83, 0x80, 0xE0, 0x78, 0x1C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x83, 0xC0, 0xF0, 0x78, 0x1C, 0x1E, 0x03,
  0x83, 0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x3C,
  0x38, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x1E, 0x01, 0xE3,
  0x80, 0x38, 0xF0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x3C,
  0x01, 0xCF, 0x00, 0x79, 0xC0, 0x0F, 0x78, 0x01, 0xCE, 0x00, 0x7B, 0xC0,
  0x0E, 0x70, 0x03, 0xDC, 0x00, 0x77, 0x80, 0x1E, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x0F, 0x00,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x00, 0x78, 0xFC, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xFE, 0x7C, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x7D, 0xF3, 0xF8,
  0x07, 0xE7, 0xC7, 0xFF, 0xFF, 0x1F, 0x0F, 0xFF, 0xF8, 0x3C, 0x0F, 0xFF,
  0x80, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x7F, 0xF8, 0x03, 0xC3, 0xFF,
  0xF8, 0x0F, 0x3F, 0xFF, 0xF0, 0x3D, 0xF8, 0x0F, 0xE0, 0xFF, 0x80, 0x0F,
  0xC3, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x8F, 0xC0,
  0x00, 0x3E, 0x3F, 0x80, 0x01, 0xF0, 0xFF, 0x00, 0x0F, 0xC3, 0xDF, 0x80,
  0xFE, 0x0F, 0x3F, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0x80, 0xF0, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x0F, 0x00, 0x7F, 0xF8, 0x3C, 0x03, 0xFF, 0xF8, 0xF0, 0x3F, 0xFF, 0xF3,
  0xC1, 0xFC, 0x07, 0xEF, 0x0F, 0xC0, 0x03, 0xFC, 0x3E, 0x00, 0x07, 0xF1,
  0xF0, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x7F, 0x07, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x7E, 0xF0, 0x3F, 0xFF, 0xF3,
  0xC0, 0x3F, 0xFF, 0x8F, 0x00, 0x7F, 0xF8, 0x3C, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0xF0, 0x0F, 0xFF, 0xE3, 0xC0,
  0xFF, 0xFF, 0xCF, 0x07, 0xF0, 0x1F, 0xBC, 0x3F, 0x00, 0x0F, 0xF0, 0xF8,
  0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xFC, 0x1F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0xFB, 0xC0,
  0xFF, 0xFF, 0xCF, 0x00, 0xFF, 0xFE, 0x3C, 0x01, 0xFF, 0xE0, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x08, 0x00, 0x00,
  0xF8, 0x70, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xFC, 0x07, 0x83, 0xFF, 0xF8,
  0x3C, 0x7F, 0xFF, 0xE1, 0xE7, 0xE0, 0x3F, 0x8F, 0x7C, 0x00, 0x7E, 0x7B,
  0x80, 0x01, 0xF3, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xE0, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x3C, 0x0F, 0x1F, 0xF8, 0x1F, 0xF0, 0xF3, 0xFF, 0xC7,
  0xFF, 0x8F, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0x07, 0xEF, 0x07, 0xEF, 0xC0,
  0x1F, 0xC0, 0x1E, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x00, 0xFF, 0xE0, 0x38, 0x1F,
  0xFF, 0xC1, 0xC3, 0xFF, 0xFF, 0x0F, 0x3F, 0x01, 0xFC, 0x7B, 0xE0, 0x03,
  0xF3, 0xDC, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xFF, 0xE0, 0x0F, 0x1F, 0xFF,
  0xC0, 0x3C, 0xFF, 0xFF, 0xC0, 0xF7, 0xC0, 0x3F, 0x83, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x3F, 0x0F, 0x7C, 0x03,
  0xF8, 0x3C, 0xFF, 0xFF, 0xC0, 0xF1, 0xFF, 0xFC, 0x03, 0xC1, 0xFF, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0xF0, 0x0F, 0xFF, 0xE3, 0xC0, 0xFF, 0xFF, 0xCF, 0x07, 0xF0, 0x0F, 0xBC,
  0x3F, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x3F, 0x1E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0xFB, 0xC0, 0xFF, 0xFF, 0xCF, 0x00, 0xFF, 0xFE, 0x3C,
  0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x78,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xEF, 0x1F, 0xF0, 0x77,
  0x9F, 0x80, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x1F, 0x71, 0xF8, 0x07, 0xE7, 0x0F,
  0xFF, 0xFC, 0x70, 0x7F, 0xFF, 0x07, 0x01, 0xFF, 0xE0, 0x70, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0xF7, 0x00, 0x07, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x00, 0x0F, 0x78, 0x00,
  0x7C, 0x00, 0x39, 0xE0, 0x03, 0xF0, 0x01, 0xE3, 0x80, 0x0F, 0xC0, 0x07,
  0x8E, 0x00, 0x3F, 0x80, 0x1E, 0x3C, 0x00, 0xEE, 0x00, 0x70, 0xF0, 0x07,
  0xB8, 0x01, 0xC3, 0xC0, 0x1C, 0xE0, 0x0F, 0x07, 0x00, 0x73, 0xC0, 0x3C,
  0x1E, 0x01, 0xCF, 0x00, 0xF0, 0x78, 0x0F, 0x1C, 0x03, 0x81, 0xE0, 0x38,
  0x70, 0x0E, 0x03, 0x80, 0xE1, 0xE0, 0x78, 0x0E, 0x03, 0x87, 0x81, 0xE0,
  0x3C, 0x1E, 0x0E, 0x07, 0x00, 0xF0, 0x70, 0x38, 0x1C, 0x03, 0xC1, 0xC0,
  0xF0, 0x70, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x07, 0x0F, 0x00,
  0x78, 0xE0, 0x1C, 0x38, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x0E, 0x78, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x00,
  0xF7, 0x00, 0x39, 0xC0, 0x03, 0xDC, 0x00, 0x77, 0x00, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x71, 0xFF,
  0xF8, 0x00, 0x01, 0xC7, 0xFF, 0xF8, 0x00, 0x0F, 0x3E, 0x07, 0xF0, 0x00,
  0x3D, 0xE0, 0x07, 0xE0, 0x00, 0xE7, 0x80, 0x0F, 0xC0, 0x07, 0x9C, 0x00,
  0x0F, 0xC0, 0x3C, 0xF0, 0x00, 0x1F, 0xC3, 0xF3, 0x80, 0x00, 0x3F, 0xFF,
  0x8E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00,
};

const GFXglyph RobotoMono_Light70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 5, 50, 42, 18, -50 },
  { 33, 14, 16, 42, 14, -53 },
  { 61, 38, 50, 42, 2, -50 },
  { 299, 31, 64, 42, 6, -57 },
  { 547, 39, 51, 42, 1, -50 },
  { 796, 35, 51, 42, 5, -50 },
  { 1020, 3, 16, 42, 18, -53 },
  { 1026, 16, 72, 42, 13, -56 },
  { 1170, 16, 72, 42, 12, -56 },
  { 1314, 32, 31, 42, 6, -50 },
  { 1438, 34, 36, 42, 4, -41 },
  { 1591, 8, 16, 42, 13, -6 },
  { 1607, 25, 3, 42, 8, -24 },
  { 1617, 7, 6, 42, 19, -6 },
  { 1623, 24, 54, 42, 10, -50 },
  { 1785, 32, 51, 42, 5, -50 },
  { 1989, 18, 50, 42, 7, -50 },
  { 2102, 33, 50, 42, 3, -50 },
  { 2309, 32, 51, 42, 3, -50 },
  { 2513, 35, 50, 42, 3, -50 },
  { 2732, 30, 51, 42, 7, -50 },
  { 2924, 31, 51, 42, 5, -50 },
  { 3122, 33, 50, 42, 4, -50 },
  { 3329, 32, 51, 42, 6, -50 },
  { 3533, 31, 50, 42, 5, -50 },
  { 3727, 7, 36, 42, 20, -36 },
  { 3759, 9, 46, 42, 18, -36 },
  { 3811, 29, 29, 42, 6, -37 },
  { 3917, 30, 17, 42, 6, -31 },
  { 3981, 30, 29, 42, 6, -37 },
  { 4090, 27, 50, 42, 8, -50 },
  { 4259, 38, 50, 42, 2, -50 },
  { 4497, 36, 50, 42, 3, -50 },
  { 4722, 31, 50, 42, 7, -50 },
  { 4916, 34, 51, 42, 4, -50 },
  { 5133, 32, 50, 42, 6, -50 },
  { 5333, 29, 50, 42, 7, -50 },
  { 5515, 30, 50, 42, 7, -50 },
  { 5703, 34, 51, 42, 4, -50 },
  { 5920, 32, 50, 42, 5, -50 },
  { 6120, 28, 50, 42, 7, -50 },
  { 6295, 31, 51, 42, 4, -50 },
  { 6493, 33, 50, 42, 7, -50 },
  { 6700, 29, 50, 42, 8, -50 },
  { 6882, 31, 50, 42, 6, -50 },
  { 7076, 31, 50, 42, 6, -50 },
  { 7270, 34, 51, 42, 4, -50 },
  { 7487, 32, 50, 42, 7, -50 },
  { 7687, 35, 59, 42, 4, -50 },
  { 7946, 32, 50, 42, 7, -50 },
  { 8146, 33, 51, 42, 5, -50 },
  { 8357, 36, 50, 42, 3, -50 },
  { 8582, 32, 51, 42, 5, -50 },
  { 8786, 36, 50, 42, 3, -50 },
  { 9011, 37, 50, 42, 3, -50 },
  { 9243, 35, 50, 42, 4, -50 },
  { 9462, 35, 50, 42, 3, -50 },
  { 9681, 32, 50, 42, 4, -50 },
  { 9881, 12, 68, 42, 15, -57 },
  { 9983, 24, 54, 42, 9, -50 },
  { 10145, 12, 68, 42, 15, -57 },
  { 10247, 26, 27, 42, 8, -50 },
  { 10335, 30, 3, 42, 6, 0 },
  { 10347, 10, 9, 42, 16, -51 },
  { 10359, 30, 39, 42, 6, -38 },
  { 10506, 30, 54, 42, 7, -53 },
  { 10709, 31, 39, 42, 5, -38 },
  { 10861, 30, 54, 42, 5, -53 },
  { 11064, 32, 39, 42, 5, -38 },
  { 11220, 32, 54, 42, 6, -54 },
  { 11436, 30, 53, 42, 5, -38 },
  { 11635, 29, 53, 42, 7, -53 },
  { 11828, 29, 50, 42, 8, -50 },
  { 12010, 22, 65, 42, 7, -50 },
  { 12189, 31, 53, 42, 7, -53 },
  { 12395, 29, 53, 42, 8, -53 },
  { 12588, 36, 38, 42, 3, -38 },
  { 12759, 29, 38, 42, 7, -38 },
  { 12897, 33, 39, 42, 5, -38 },
  { 13058, 30, 52, 42, 7, -38 },
  { 13253, 30, 52, 42, 5, -38 },
  { 13448, 25, 38, 42, 12, -38 },
  { 13567, 31, 39, 42, 6, -38 },
  { 13719, 30, 47, 42, 6, -46 },
  { 13896, 28, 38, 42, 7, -37 },
  { 14029, 34, 37, 42, 4, -37 },
  { 14187, 38, 37, 42, 2, -37 },
  { 14363, 34, 37, 42, 4, -37 },
  { 14521, 36, 52, 42, 3, -37 },
  { 14755, 33, 37, 42, 5, -37 },
  { 14908, 23, 69, 42, 11, -55 },
  { 15107, 4, 61, 42, 19, -50 },
  { 15138, 23, 69, 42, 11, -55 },
  { 15337, 38, 13, 42, 2, -27 },
};

const GFXfont RobotoMono_Light70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light70pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_LIGHT70PT7B_H_
