#ifndef _ROBOTOMONO_LIGHT41PT7B_H_
#define _ROBOTOMONO_LIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00,
  0x00, 0x00, 0x6F, 0x60, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x07, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x80, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xE0, 0x3C, 0x70, 0x07, 0x1C, 0x00, 0xE6,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0x67, 0x00, 0x38, 0xE0,
  0x3C, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xCE, 0x00, 0x07,
  0x0C, 0x00, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60,
  0x60, 0xC0, 0xC0, 0xC3, 0x01, 0x81, 0x86, 0x03, 0x87, 0x18, 0x03, 0x9C,
  0x70, 0x03, 0xF0, 0xC0, 0x01, 0x83, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC1, 0xC0, 0x01, 0x8F, 0xE0, 0x06, 0x38,
  0xE0, 0x0C, 0x60, 0xC0, 0x30, 0xC0, 0x80, 0xE1, 0x01, 0x81, 0x86, 0x03,
  0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x10, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x3B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x00, 0x38, 0x38, 0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xC0, 0xC0, 0x07, 0x0E, 0x00, 0x18,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00,
  0x1D, 0xC0, 0x01, 0xC7, 0x01, 0x9C, 0x1C, 0x1D, 0xC0, 0x60, 0xEE, 0x03,
  0x86, 0x60, 0x0E, 0x33, 0x00, 0x3B, 0x98, 0x00, 0xF8, 0xC0, 0x07, 0xC7,
  0x00, 0x1C, 0x1C, 0x01, 0xF0, 0xF0, 0x1D, 0xC3, 0xFF, 0xC7, 0x07, 0xF8,
  0x3C, 0xFF, 0xFF, 0xB6, 0xC0, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xE0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x0E, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x30, 0x2F,
  0x0C, 0x3F, 0xFB, 0x7F, 0x1F, 0xFE, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0D,
  0xC0, 0x07, 0x38, 0x03, 0x86, 0x00, 0xC1, 0xC0, 0x70, 0x38, 0x38, 0x07,
  0x02, 0x01, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x77, 0x77, 0x77, 0x66,
  0xC4, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFF, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0E, 0x03,
  0x83, 0x80, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x00,
  0xDC, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x07, 0x7E, 0x01, 0xCF, 0xC0, 0x71,
  0xF8, 0x1C, 0x3F, 0x07, 0x07, 0xE1, 0xC0, 0xFC, 0x70, 0x1F, 0x9C, 0x03,
  0xF6, 0x00, 0x7F, 0x80, 0x0D, 0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E,
  0x70, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0x7F, 0x8F, 0x81, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x80, 0x01, 0xFF, 0x00,
  0x7F, 0xF8, 0x1C, 0x07, 0x87, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00, 0x67,
  0x00, 0x0C, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x01, 0xFF, 0x01,
  0xFF, 0xE0, 0xF0, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x66, 0x00, 0x1B, 0x80,
  0x07, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x38, 0xF0, 0x1C, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x37, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x01,
  0xC7, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x70, 0x70, 0x06, 0x07, 0x00,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x70, 0x38, 0x07, 0x07, 0x00, 0x70,
  0x60, 0x07, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x0E, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x07, 0xC2,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x0E, 0x70, 0x03,
  0x8E, 0x01, 0xC3, 0xE1, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x3F, 0x83, 0xBF,
  0xF8, 0xFE, 0x0F, 0x36, 0x01, 0xCF, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36,
  0x00, 0x1D, 0x80, 0x06, 0x70, 0x03, 0x8E, 0x00, 0xC1, 0xC0, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0,
  0xE0, 0x3C, 0x70, 0x07, 0x18, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06, 0xE0,
  0x01, 0xB8, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0x07,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x3C, 0x1E, 0x1C, 0x01, 0xC6, 0x00, 0x3B,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF8, 0x00, 0x67, 0x00, 0x39, 0xE0, 0x1C, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x38, 0x07,
  0x1C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0xC0,
  0x07, 0x38, 0x03, 0xCF, 0x03, 0xB1, 0xFF, 0xCC, 0x1F, 0xE7, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x6F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0x33, 0xDE, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x67,
  0x31, 0x80, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x01, 0xC7,
  0x00, 0x73, 0x00, 0x19, 0x80, 0x0D, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x70, 0x0E, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x63,
  0x03, 0xE0, 0xCC, 0x1F, 0xC3, 0x60, 0xC1, 0x0D, 0x86, 0x0C, 0x36, 0x18,
  0x30, 0x50, 0x40, 0xC1, 0xC3, 0x03, 0x07, 0x0C, 0x0C, 0x1C, 0x30, 0x30,
  0x70, 0xC0, 0xC1, 0xC3, 0x02, 0x0F, 0x0C, 0x08, 0x3C, 0x30, 0x60, 0xF0,
  0xC3, 0x82, 0x43, 0x9B, 0x19, 0x87, 0xEF, 0xC6, 0x0E, 0x1E, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x01, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6E, 0x00, 0x07, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x1C, 0x70, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x70,
  0x70, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x07, 0x00, 0x70, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1C, 0x00,
  0x70, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x73, 0x80, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0C, 0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C, 0xC0,
  0x1E, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x00, 0x3C, 0xC0, 0x03, 0xB0, 0x00,
  0x6C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xB0, 0x01, 0xEC, 0x01, 0xF3, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xE0, 0x3C,
  0x1C, 0x01, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0x67, 0x00, 0x07, 0x70, 0x00,
  0x76, 0x00, 0x03, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0x70, 0x00, 0x73,
  0x00, 0x07, 0x30, 0x00, 0x63, 0x80, 0x0E, 0x1C, 0x01, 0xC0, 0xE0, 0x38,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0C, 0x03, 0xC3,
  0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x06, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0,
  0x07, 0x30, 0x03, 0x8C, 0x07, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x80, 0xE0,
  0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0x67, 0x00, 0x07, 0x70,
  0x00, 0x76, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00,
  0x33, 0x00, 0x03, 0x38, 0x00, 0x31, 0x80, 0x03, 0x1C, 0x00, 0x70, 0xF0,
  0x1E, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x33, 0x00, 0x0E, 0x70,
  0x01, 0x87, 0x00, 0x70, 0xF0, 0x1C, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xC0,
  0x01, 0xEC, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x0C,
  0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x0E, 0x00,
  0xC1, 0xC0, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x0C, 0xF0, 0x00, 0xDF, 0x80,
  0x0F, 0x9C, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0x70, 0x0C, 0x03,
  0x80, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x01, 0xBF, 0x80, 0x37, 0xF0, 0x0F, 0xFB, 0x01, 0xBF, 0x60,
  0x37, 0xEE, 0x0E, 0xFC, 0xC1, 0x9F, 0x98, 0x33, 0xF3, 0x8C, 0x7E, 0x31,
  0x8F, 0xC6, 0x71, 0xF8, 0xEC, 0x3F, 0x0D, 0x87, 0xE1, 0xE0, 0xFC, 0x3C,
  0x1F, 0x83, 0x83, 0xF0, 0x60, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3E, 0xC0, 0x0F, 0xB8, 0x03, 0xE6, 0x00, 0xF9,
  0xC0, 0x3E, 0x30, 0x0F, 0x8E, 0x03, 0xE1, 0xC0, 0xF8, 0x30, 0x3E, 0x0E,
  0x0F, 0x81, 0x83, 0xE0, 0x70, 0xF8, 0x0C, 0x3E, 0x03, 0x8F, 0x80, 0x63,
  0xE0, 0x1C, 0xF8, 0x03, 0x3E, 0x00, 0xEF, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xE0, 0x78, 0x1C, 0x01, 0xC3, 0x80, 0x0C,
  0x30, 0x00, 0xE3, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xE3,
  0x80, 0x0C, 0x1C, 0x01, 0xC0, 0xE0, 0x78, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x80, 0x3C, 0x70, 0x01, 0xCE, 0x00, 0x1D,
  0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x03, 0xC7,
  0xFF, 0xF0, 0xFF, 0xF8, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00,
  0x70, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB8,
  0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0xCE, 0x00, 0x0C,
  0x30, 0x00, 0xE1, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x1C, 0x0F, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x08, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x00, 0x78,
  0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0E,
  0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x39,
  0x80, 0x0E, 0x30, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x18, 0x07, 0x03,
  0x00, 0x60, 0x60, 0x0E, 0x0C, 0x00, 0xC1, 0x80, 0x1C, 0x30, 0x01, 0x86,
  0x00, 0x38, 0xC0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xEC,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x03, 0xC3,
  0x80, 0x1C, 0xE0, 0x03, 0x98, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0x6C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x6E, 0x00, 0x1D, 0xE0, 0x07, 0x1E, 0x01, 0xC1, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x07, 0x70, 0x01, 0x8E, 0x00, 0xE1, 0xC0, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xE7,
  0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x87, 0x00, 0x18, 0x18, 0x01,
  0xC0, 0xC0, 0x0E, 0x07, 0x00, 0x60, 0x38, 0x03, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0x80, 0x38, 0x0C, 0x00, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x30,
  0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x38, 0xC0, 0x00, 0xCE, 0x00, 0x06,
  0x60, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0x6C,
  0x07, 0x01, 0xB0, 0x1C, 0x06, 0xE0, 0x78, 0x1B, 0x81, 0xE0, 0x66, 0x0D,
  0x83, 0x98, 0x36, 0x0C, 0x60, 0xD8, 0x31, 0x83, 0x30, 0xC6, 0x0C, 0xC3,
  0x1C, 0x63, 0x0C, 0x71, 0x8C, 0x30, 0xC6, 0x30, 0xC3, 0x18, 0xC7, 0x0C,
  0x61, 0x98, 0x33, 0x86, 0x60, 0xCC, 0x19, 0x83, 0x30, 0x66, 0x0E, 0xC1,
  0x98, 0x1B, 0x03, 0x60, 0x6C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x00, 0x70, 0x0C,
  0x01, 0xC0, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x30, 0x01,
  0xC1, 0xC0, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xE0, 0xE0, 0x03,
  0x07, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x0E,
  0xE0, 0x00, 0x63, 0x80, 0x07, 0x0C, 0x00, 0x70, 0x70, 0x03, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x38, 0x1C, 0x00, 0xC1, 0xC0, 0x07, 0x0C, 0x00,
  0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0x70,
  0x06, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x00, 0x70, 0x38, 0x01, 0xC1, 0x80,
  0x06, 0x1C, 0x00, 0x30, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x1F, 0xFF, 0x80, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0xEC, 0x01, 0x9C, 0x03, 0x18, 0x0E, 0x30, 0x18, 0x70, 0x70, 0x60, 0xC0,
  0xE1, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0xB8, 0x03, 0x60, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xC0, 0xF0, 0xE0, 0x0E, 0x70, 0x01, 0x98, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0xFF, 0xFC, 0x7C, 0x07, 0x38,
  0x01, 0xDC, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00,
  0xF7, 0x00, 0x7D, 0xE0, 0x3F, 0x3F, 0xFD, 0xC3, 0xFC, 0x30, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x61, 0xF8, 0x33, 0xFF, 0x1B, 0x83, 0xCF,
  0x00, 0xF7, 0x00, 0x3B, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xDE, 0x00, 0xED, 0x80, 0xE6,
  0x7F, 0xE3, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0,
  0x0E, 0x30, 0x01, 0x9C, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x03, 0x70, 0x00, 0xCC, 0x00, 0x73, 0x80, 0x38, 0x70,
  0x1C, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0xFC, 0x70, 0xFF, 0xDC, 0x78, 0x3F, 0x38, 0x07, 0xCC,
  0x00, 0xF7, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0x60, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x0F, 0x1C, 0x0F, 0xC3,
  0xFF, 0x70, 0x7F, 0x9C, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x78, 0x3C, 0x1C,
  0x01, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x06, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x10, 0xE0,
  0x03, 0x0F, 0x01, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x03, 0xF1, 0xC3, 0xFF, 0x71,
  0xE0, 0xFC, 0xE0, 0x1F, 0x30, 0x03, 0xDC, 0x00, 0x76, 0x00, 0x1D, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x73,
  0x80, 0x3C, 0x70, 0x3F, 0x0F, 0xFD, 0xC1, 0xFE, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x88, 0x00, 0xE7, 0x00, 0x30, 0xE0, 0x1C, 0x1F, 0x3E,
  0x03, 0xFE, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0xFC, 0x31, 0xFF, 0x99, 0xC1, 0xCD, 0x80, 0x77, 0x80, 0x1B, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x39, 0x0F, 0x8F, 0xF8, 0x3E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x1C,
  0x38, 0x0E, 0x0E, 0x07, 0x03, 0x87, 0x80, 0xE3, 0xC0, 0x39, 0xE0, 0x0E,
  0xF0, 0x03, 0xFC, 0x00, 0xFB, 0x80, 0x3C, 0x70, 0x0E, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x38, 0x38, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07,
  0x38, 0x00, 0xEE, 0x00, 0x1C, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xCF, 0x87, 0xC6, 0xFE, 0x7F, 0xBC, 0x3E, 0x1D, 0xC0,
  0xE0, 0x7C, 0x07, 0x03, 0xE0, 0x30, 0x0F, 0x01, 0x80, 0x78, 0x0C, 0x03,
  0xC0, 0x60, 0x1E, 0x03, 0x00, 0xF0, 0x18, 0x07, 0x80, 0xC0, 0x3C, 0x06,
  0x01, 0xE0, 0x30, 0x0F, 0x01, 0x80, 0x78, 0x0C, 0x03, 0xC0, 0x60, 0x1E,
  0x03, 0x00, 0xF0, 0x18, 0x07, 0x80, 0xC0, 0x3C, 0x06, 0x01, 0xE0, 0x30,
  0x0C, 0xC1, 0xF8, 0x63, 0xFE, 0x33, 0x83, 0x9B, 0x00, 0xEF, 0x00, 0x37,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x78, 0x3C, 0x1C, 0x03, 0xC7, 0x00, 0x38,
  0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x06, 0x60, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x1E, 0x03, 0x80,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xC3, 0xF0, 0x67, 0xFE, 0x37, 0x07, 0x9E,
  0x01, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xBC, 0x01, 0xDF, 0x03, 0xCD,
  0xFF, 0xC6, 0x3F, 0xC3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF1, 0xC3,
  0xFF, 0x71, 0xE0, 0xFC, 0xE0, 0x1F, 0x30, 0x03, 0xDC, 0x00, 0x76, 0x00,
  0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xDC,
  0x00, 0x73, 0x80, 0x3C, 0x70, 0x1F, 0x0F, 0xFD, 0xC1, 0xFE, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0xE0, 0xFF, 0xC7, 0xFB, 0xBE, 0x17, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0x03, 0xCE, 0x00, 0xE6, 0x00, 0x3B, 0x00, 0x0D,
  0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xEF, 0x00, 0xE3, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xEF,
  0xFF, 0xF8, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xDC, 0x01, 0xEF, 0x03, 0xF3, 0xFF, 0xB8, 0x7F, 0x0C, 0xE0, 0x00,
  0x36, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x80,
  0x0C, 0x18, 0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0E,
  0x03, 0x00, 0x60, 0x70, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00,
  0x18, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x10, 0x0E, 0xC0, 0x70, 0x19, 0x80,
  0xE0, 0x33, 0x01, 0xC0, 0x66, 0x02, 0x80, 0xCE, 0x0D, 0x83, 0x0C, 0x1B,
  0x06, 0x18, 0x36, 0x0C, 0x30, 0x4C, 0x18, 0x61, 0x8C, 0x30, 0xE3, 0x18,
  0xC0, 0xC6, 0x31, 0x81, 0x88, 0x63, 0x03, 0x30, 0x66, 0x06, 0x60, 0xC8,
  0x06, 0xC1, 0xB0, 0x0D, 0x03, 0x60, 0x1E, 0x02, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x00, 0xEE,
  0x00, 0x38, 0xC0, 0x06, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x1C, 0x01,
  0xC3, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x07, 0x70, 0x01, 0xC7, 0x00, 0x30, 0x60, 0x0E,
  0x0E, 0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x18, 0x00, 0xE7, 0x00, 0x1D, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x03, 0x00, 0x38, 0x1C,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x70, 0x70,
  0x01, 0x83, 0x00, 0x0E, 0x38, 0x00, 0x31, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x05, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x38, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x0F, 0x01,
  0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xF0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x18, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x37, 0x9E, 0x00, 0xD8, 0x1E, 0x03, 0xE0,
  0x3C, 0x1F, 0x00, 0x3F, 0xEC, 0x00, 0x7F, 0x00, 0x00, 0x20,
};

const GFXglyph RobotoMono_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 4, 29, 25, 10, -29 },
  { 16, 8, 9, 25, 8, -31 },
  { 25, 23, 29, 25, 1, -29 },
  { 109, 18, 38, 25, 4, -34 },
  { 195, 23, 30, 25, 1, -30 },
  { 282, 21, 30, 25, 3, -30 },
  { 361, 3, 9, 25, 10, -31 },
  { 365, 9, 42, 25, 8, -33 },
  { 413, 10, 42, 25, 7, -33 },
  { 466, 18, 18, 25, 4, -29 },
  { 507, 20, 21, 25, 2, -24 },
  { 560, 4, 10, 25, 8, -4 },
  { 565, 15, 2, 25, 5, -14 },
  { 569, 4, 4, 25, 11, -4 },
  { 571, 14, 32, 25, 6, -29 },
  { 627, 19, 30, 25, 3, -30 },
  { 699, 11, 29, 25, 4, -29 },
  { 739, 19, 30, 25, 2, -30 },
  { 811, 18, 30, 25, 2, -30 },
  { 879, 20, 29, 25, 2, -29 },
  { 952, 18, 29, 25, 4, -29 },
  { 1018, 18, 29, 25, 3, -29 },
  { 1084, 20, 29, 25, 2, -29 },
  { 1157, 18, 30, 25, 4, -30 },
  { 1225, 18, 30, 25, 3, -30 },
  { 1293, 4, 22, 25, 12, -22 },
  { 1304, 5, 28, 25, 11, -22 },
  { 1322, 17, 17, 25, 3, -22 },
  { 1359, 18, 10, 25, 3, -18 },
  { 1382, 17, 17, 25, 4, -22 },
  { 1419, 17, 30, 25, 4, -30 },
  { 1483, 22, 29, 25, 1, -29 },
  { 1563, 21, 29, 25, 2, -29 },
  { 1640, 18, 29, 25, 4, -29 },
  { 1706, 20, 30, 25, 2, -30 },
  { 1781, 18, 29, 25, 4, -29 },
  { 1847, 17, 29, 25, 4, -29 },
  { 1909, 17, 29, 25, 4, -29 },
  { 1971, 20, 30, 25, 2, -30 },
  { 2046, 18, 29, 25, 3, -29 },
  { 2112, 17, 29, 25, 4, -29 },
  { 2174, 19, 29, 25, 2, -29 },
  { 2243, 20, 29, 25, 4, -29 },
  { 2316, 18, 29, 25, 4, -29 },
  { 2382, 19, 29, 25, 3, -29 },
  { 2451, 18, 29, 25, 3, -29 },
  { 2517, 20, 30, 25, 2, -30 },
  { 2592, 19, 29, 25, 4, -29 },
  { 2661, 21, 35, 25, 2, -30 },
  { 2753, 19, 29, 25, 4, -29 },
  { 2822, 19, 30, 25, 3, -30 },
  { 2894, 21, 29, 25, 2, -29 },
  { 2971, 18, 29, 25, 3, -29 },
  { 3037, 21, 29, 25, 2, -29 },
  { 3114, 22, 29, 25, 2, -29 },
  { 3194, 21, 29, 25, 2, -29 },
  { 3271, 21, 29, 25, 2, -29 },
  { 3348, 18, 29, 25, 3, -29 },
  { 3414, 7, 39, 25, 9, -33 },
  { 3449, 15, 32, 25, 5, -29 },
  { 3509, 7, 39, 25, 9, -33 },
  { 3544, 15, 16, 25, 5, -29 },
  { 3574, 18, 2, 25, 3, 0 },
  { 3579, 7, 5, 25, 9, -30 },
  { 3584, 18, 22, 25, 3, -22 },
  { 3634, 17, 31, 25, 4, -31 },
  { 3700, 18, 22, 25, 3, -22 },
  { 3750, 18, 31, 25, 3, -31 },
  { 3820, 19, 22, 25, 3, -22 },
  { 3873, 18, 31, 25, 4, -31 },
  { 3943, 18, 31, 25, 3, -22 },
  { 4013, 17, 31, 25, 4, -31 },
  { 4079, 18, 29, 25, 4, -29 },
  { 4145, 13, 38, 25, 4, -29 },
  { 4207, 18, 31, 25, 4, -31 },
  { 4277, 18, 31, 25, 4, -31 },
  { 4347, 21, 22, 25, 2, -22 },
  { 4405, 17, 22, 25, 4, -22 },
  { 4452, 19, 22, 25, 3, -22 },
  { 4505, 17, 30, 25, 4, -22 },
  { 4569, 18, 30, 25, 3, -22 },
  { 4637, 15, 22, 25, 7, -22 },
  { 4679, 17, 22, 25, 4, -22 },
  { 4726, 18, 27, 25, 3, -27 },
  { 4787, 17, 22, 25, 4, -22 },
  { 4834, 20, 22, 25, 2, -22 },
  { 4889, 23, 22, 25, 1, -22 },
  { 4953, 19, 22, 25, 3, -22 },
  { 5006, 21, 31, 25, 2, -22 },
  { 5088, 19, 22, 25, 3, -22 },
  { 5141, 13, 40, 25, 7, -32 },
  { 5206, 2, 36, 25, 11, -29 },
  { 5215, 13, 40, 25, 7, -32 },
  { 5280, 22, 8, 25, 1, -16 },
};

const GFXfont RobotoMono_Light41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light41pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_LIGHT41PT7B_H_
