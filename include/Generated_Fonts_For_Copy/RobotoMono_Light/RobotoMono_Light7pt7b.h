#ifndef _ROBOTOMONO_LIGHT7PT7B_H_
#define _ROBOTOMONO_LIGHT7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Light.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Light7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0x5F, 0x6F, 0x60, 0x56, 0x23, 0x50, 0xCE, 0x27, 0x30,
  0x66, 0x4B, 0xF0, 0x80, 0x5A, 0xA5, 0x95, 0x56, 0x5F, 0x00, 0x2F, 0x22,
  0xC0, 0xC0, 0x80, 0x56, 0x80, 0xD7, 0xDE, 0xD5, 0x40, 0xE1, 0x24, 0xF0,
  0xE5, 0x9E, 0x26, 0x6F, 0x20, 0xF3, 0x9E, 0xDA, 0xDC, 0xF2, 0x22, 0x40,
  0xF7, 0x5E, 0xD6, 0xBC, 0x90, 0x98, 0x71, 0x80, 0xFC, 0x8E, 0x00, 0xE5,
  0x24, 0x7F, 0xBD, 0xE0, 0x26, 0x66, 0x90, 0xD7, 0x5E, 0x79, 0x89, 0x70,
  0xD6, 0xDC, 0xF3, 0x4E, 0xF3, 0x48, 0x78, 0xA9, 0x70, 0xB7, 0xDA, 0xE9,
  0x2E, 0x11, 0x11, 0xE0, 0xBA, 0x6A, 0x92, 0x4E, 0xB7, 0xDA, 0xB6, 0xFA,
  0x69, 0x99, 0x60, 0xF7, 0xC8, 0x79, 0x99, 0x71, 0xD7, 0x6A, 0x78, 0x69,
  0x70, 0xF2, 0x22, 0x20, 0xB6, 0xDE, 0x99, 0x66, 0x20, 0xBB, 0xB5, 0x50,
  0x96, 0x26, 0x90, 0x96, 0x22, 0x20, 0x72, 0x44, 0xF0, 0xFE, 0xA5, 0x40,
  0xD5, 0x5C, 0x7C, 0xE0, 0x80, 0xC7, 0xF0, 0x9A, 0xDE, 0xD6, 0x70, 0x3E,
  0xDE, 0xD7, 0x70, 0xFE, 0x48, 0xF6, 0xDE, 0x9A, 0xDA, 0x51, 0x2E, 0x75,
  0x58, 0x97, 0x6A, 0xC9, 0x2E, 0xFB, 0xBB, 0xD6, 0xD0, 0x69, 0x97, 0xD6,
  0xF8, 0xF6, 0xF2, 0xF2, 0x40, 0xD5, 0xF0, 0x9A, 0x4E, 0xB6, 0xF0, 0x95,
  0x64, 0xBB, 0x75, 0x96, 0x2D, 0x95, 0x62, 0x48, 0xEA, 0x70, 0x5D, 0x50,
  0xFC, 0xD5, 0x70, 0x5A,
};

const GFXglyph RobotoMono_Light7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 1, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 1, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 1, 4, 1, -5 },
  { 16, 2, 8, 4, 1, -6 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 3, 3, 4, 1, -5 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 1, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -3 },
  { 26, 1, 1, 4, 2, -1 },
  { 27, 2, 5, 4, 1, -5 },
  { 29, 3, 5, 4, 1, -5 },
  { 31, 2, 5, 4, 1, -5 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 1, -5 },
  { 43, 3, 5, 4, 1, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 3, 5, 4, 1, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 1, 4, 4, 2, -4 },
  { 53, 1, 5, 4, 2, -4 },
  { 54, 3, 3, 4, 1, -4 },
  { 56, 3, 2, 4, 1, -3 },
  { 57, 3, 3, 4, 1, -4 },
  { 59, 3, 5, 4, 1, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 3, 5, 4, 1, -5 },
  { 74, 3, 5, 4, 1, -5 },
  { 76, 3, 5, 4, 1, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 3, 5, 4, 1, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 3, 5, 4, 1, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 4, 6, 4, 0, -5 },
  { 104, 3, 5, 4, 1, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 1, 7, 4, 2, -6 },
  { 130, 2, 5, 4, 1, -5 },
  { 132, 2, 7, 4, 1, -6 },
  { 134, 2, 3, 4, 1, -5 },
  { 135, 3, 1, 4, 1, 0 },
  { 136, 1, 1, 4, 2, -5 },
  { 137, 3, 4, 4, 1, -4 },
  { 139, 3, 5, 4, 1, -5 },
  { 141, 3, 4, 4, 1, -4 },
  { 143, 3, 5, 4, 1, -5 },
  { 145, 3, 4, 4, 1, -4 },
  { 147, 3, 5, 4, 1, -5 },
  { 149, 3, 5, 4, 1, -4 },
  { 151, 3, 5, 4, 1, -5 },
  { 153, 3, 5, 4, 1, -5 },
  { 155, 2, 7, 4, 1, -5 },
  { 157, 3, 5, 4, 1, -5 },
  { 159, 3, 5, 4, 1, -5 },
  { 161, 4, 4, 4, 0, -4 },
  { 163, 3, 4, 4, 1, -4 },
  { 165, 4, 4, 4, 0, -4 },
  { 167, 3, 5, 4, 1, -4 },
  { 169, 3, 5, 4, 1, -4 },
  { 171, 3, 4, 4, 1, -4 },
  { 173, 3, 4, 4, 1, -4 },
  { 175, 3, 5, 4, 1, -5 },
  { 177, 3, 4, 4, 1, -4 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 4, 6, 4, 0, -4 },
  { 188, 3, 4, 4, 1, -4 },
  { 190, 2, 6, 4, 1, -5 },
  { 192, 1, 6, 4, 2, -5 },
  { 193, 2, 6, 4, 1, -5 },
  { 195, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_Light7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Light7pt7bBitmaps,
  (GFXglyph *)RobotoMono_Light7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_LIGHT7PT7B_H_
