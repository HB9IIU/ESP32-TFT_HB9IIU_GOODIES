#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC55PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xC0, 0x3C, 0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x71, 0xC0, 0x38, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x70, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x8C, 0x7E, 0x01, 0xE0, 0xC1,
  0xE0, 0x3C, 0x1C, 0x1E, 0x03, 0xC1, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07,
  0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0x3E, 0x38, 0x00, 0x03, 0xF3, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x06, 0x3E, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0C, 0x07,
  0x80, 0x00, 0xC0, 0x78, 0xF0, 0x0C, 0x07, 0x8F, 0x01, 0xC0, 0x70, 0xF0,
  0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x1E, 0x07, 0xC1, 0x83,
  0xC0, 0x3E, 0x18, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x78,
  0x07, 0xFF, 0x00, 0x07, 0x80, 0x7E, 0xF8, 0x00, 0x78, 0x07, 0x81, 0xE0,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x3C,
  0x00, 0x38, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0x0E, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x0E, 0x1C, 0x00, 0x03, 0x80, 0xE1, 0xC0, 0x00,
  0x1E, 0x0F, 0x1E, 0x00, 0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x03, 0xFF, 0x0E,
  0x00, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0x80, 0x00, 0x07,
  0x1F, 0xFE, 0x00, 0x00, 0x70, 0xE0, 0x78, 0x00, 0x07, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x70, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x70, 0x00, 0x78, 0x38,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x1C, 0x03,
  0x80, 0x3C, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x83, 0xC0, 0x1C, 0x00,
  0x3F, 0xFC, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x1C, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x3C, 0xF0, 0x3C, 0x03, 0xC7,
  0x81, 0xE0, 0x1E, 0x38, 0x07, 0x81, 0xE3, 0xC0, 0x3E, 0x1E, 0x1E, 0x00,
  0xF0, 0xE0, 0xF0, 0x03, 0xCF, 0x07, 0x80, 0x1E, 0xF0, 0x38, 0x00, 0x7F,
  0x01, 0xC0, 0x03, 0xF8, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x07,
  0x80, 0x03, 0xE0, 0x3C, 0x00, 0x3F, 0x81, 0xE0, 0x03, 0xFC, 0x0F, 0x80,
  0x3C, 0xF0, 0x3E, 0x07, 0xC3, 0x81, 0xFF, 0xFC, 0x1E, 0x07, 0xFF, 0x80,
  0x78, 0x1F, 0xF8, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x3E, 0x78, 0xF1,
  0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x3C, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x01, 0x80, 0x3C, 0x03, 0x9F, 0x81,
  0xC0, 0xFF, 0xFF, 0x0E, 0x1F, 0xF7, 0xFE, 0x73, 0xFF, 0x07, 0xFF, 0x7F,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x1F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x1F, 0x9F, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70,
  0xF0, 0x78, 0x0E, 0x1E, 0x0F, 0x83, 0xC3, 0x83, 0xF0, 0x78, 0xF0, 0x7E,
  0x0F, 0x1E, 0x07, 0xC1, 0xE3, 0xC0, 0x70, 0x3C, 0x78, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x3C,
  0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x70, 0x00, 0x7E, 0x70,
  0x00, 0xF8, 0xF0, 0x03, 0xF0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0xF0,
  0x06, 0x00, 0xF0, 0x04, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x87, 0xFC, 0x00,
  0x73, 0xFF, 0xE0, 0x1E, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x7E, 0x00,
  0x78, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xCF, 0xF8, 0x01,
  0xEF, 0xFF, 0x00, 0x77, 0xFF, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00,
  0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0xC0, 0x07,
  0xC1, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xE0, 0x07, 0xFD,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x1F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0x81, 0xF8, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x0E, 0x00, 0x7F, 0xCE, 0x0E, 0x00, 0xFF, 0xCE, 0x1E, 0x01, 0xF0, 0xEE,
  0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x03, 0x80, 0x3C, 0x1C, 0x07, 0x80, 0x3C,
  0x1C, 0x07, 0x00, 0x3C, 0x1C, 0x07, 0x00, 0x3C, 0x3C, 0x07, 0x00, 0x3C,
  0x3C, 0x07, 0x00, 0x38, 0x3C, 0x0F, 0x00, 0x38, 0x38, 0x0F, 0x00, 0x38,
  0x38, 0x0E, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x78, 0x78, 0x0E, 0x00, 0x78,
  0x78, 0x0E, 0x00, 0x78, 0x78, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x00, 0xF0,
  0x70, 0x0F, 0x01, 0xF0, 0x70, 0x0F, 0x83, 0x70, 0x70, 0x0F, 0xFF, 0x70,
  0xF0, 0x07, 0xFE, 0x70, 0xF0, 0x01, 0xF8, 0x80, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x0E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x07,
  0x80, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x01,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xFC,
  0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x00, 0xE0, 0x0F,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0xF8, 0x1C, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x07, 0xC0, 0x70, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x00, 0xFC, 0x07, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0xFC, 0x07, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0xFF, 0x0F,
  0x03, 0xFF, 0xE1, 0xC0, 0x7F, 0xFC, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x04, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x70, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x77, 0x03, 0xB8, 0x01, 0xDC,
  0x0E, 0xE0, 0x0E, 0xE0, 0x3B, 0x80, 0x3B, 0x81, 0xEE, 0x01, 0xCE, 0x07,
  0x38, 0x07, 0x38, 0x1C, 0x60, 0x39, 0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xC7,
  0x07, 0x1C, 0x07, 0x1C, 0x1C, 0x70, 0x1C, 0x70, 0xE1, 0xC0, 0xF0, 0xC3,
  0x8F, 0x03, 0xC3, 0x9C, 0x3C, 0x0F, 0x0E, 0x70, 0xF0, 0x38, 0x3B, 0x83,
  0x80, 0xE0, 0xEE, 0x0E, 0x03, 0x83, 0xF0, 0x38, 0x1E, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x00, 0x70, 0x3F, 0x00, 0x07, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x0E, 0x07, 0xB8, 0x00, 0xE0,
  0x7B, 0x80, 0x0E, 0x07, 0xB8, 0x01, 0xE0, 0x73, 0xC0, 0x1E, 0x07, 0x1C,
  0x01, 0xE0, 0x71, 0xC0, 0x1E, 0x07, 0x1C, 0x01, 0xC0, 0xF1, 0xC0, 0x1C,
  0x0F, 0x1E, 0x01, 0xC0, 0xF0, 0xE0, 0x3C, 0x0E, 0x0E, 0x03, 0xC0, 0xE0,
  0xE0, 0x3C, 0x0E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03,
  0x81, 0xE0, 0x70, 0x78, 0x1C, 0x07, 0x07, 0x81, 0xC0, 0x78, 0x78, 0x1C,
  0x03, 0x87, 0x03, 0xC0, 0x38, 0x70, 0x3C, 0x03, 0x87, 0x03, 0xC0, 0x3C,
  0xF0, 0x3C, 0x01, 0xCF, 0x03, 0x80, 0x1C, 0xF0, 0x38, 0x01, 0xCE, 0x03,
  0x80, 0x1E, 0xE0, 0x78, 0x01, 0xEE, 0x07, 0x80, 0x0E, 0xE0, 0x78, 0x00,
  0xEE, 0x07, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0xFE, 0x07, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0x80,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0x80, 0x0F, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0x7C, 0x0E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xF0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x38, 0x00, 0x3E,
  0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3E, 0x03,
  0x80, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x07,
  0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x03, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x78,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38,
  0x03, 0xE0, 0x1E, 0x70, 0x07, 0xC0, 0x3C, 0xE0, 0x0F, 0x80, 0x71, 0xC0,
  0x3F, 0x00, 0xE3, 0x80, 0x7C, 0x03, 0xC7, 0x00, 0xD8, 0x07, 0x8E, 0x03,
  0xB0, 0x0E, 0x1C, 0x07, 0x60, 0x1C, 0x78, 0x0C, 0xC0, 0x78, 0xF0, 0x19,
  0x80, 0xE1, 0xE0, 0x73, 0x01, 0xC3, 0xC0, 0xE6, 0x03, 0x87, 0x81, 0x8C,
  0x0F, 0x0F, 0x07, 0x18, 0x1C, 0x1E, 0x0E, 0x30, 0x38, 0x38, 0x18, 0x60,
  0xF0, 0x70, 0x30, 0xC1, 0xC0, 0xE0, 0xE1, 0x83, 0x81, 0xC1, 0x83, 0x07,
  0x03, 0x83, 0x06, 0x1E, 0x07, 0x0E, 0x0C, 0x38, 0x0E, 0x1C, 0x18, 0x70,
  0x1C, 0x30, 0x70, 0xE0, 0x38, 0xE0, 0xE3, 0x80, 0x71, 0xC1, 0xC7, 0x00,
  0xE3, 0x03, 0x8E, 0x01, 0xC6, 0x07, 0x3C, 0x03, 0x9C, 0x0E, 0x70, 0x07,
  0x38, 0x1C, 0xE0, 0x0E, 0x60, 0x39, 0xC0, 0x1D, 0xC0, 0x77, 0x00, 0x3B,
  0x80, 0xEE, 0x00, 0x76, 0x01, 0xDC, 0x00, 0xEC, 0x03, 0xB8, 0x03, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0E, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3B, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0x70, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00,
  0x38, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x1C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xF8, 0xF0, 0x1F, 0xFF, 0x38, 0x0F, 0xE3, 0xEE,
  0x07, 0xC0, 0x3B, 0x83, 0xE0, 0x07, 0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0x3E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x0F, 0xC1, 0xF8, 0x0E, 0xF0, 0x3F, 0xFF, 0x38, 0x07, 0xFF, 0x8E,
  0x00, 0xFF, 0xC7, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0xFC, 0x00, 0x78, 0xFF, 0xC0, 0x1C, 0xFF, 0xF8, 0x07, 0x7C,
  0x7F, 0x03, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03,
  0xC1, 0xF8, 0x01, 0xF0, 0x77, 0x00, 0xF8, 0x1D, 0xFF, 0xFC, 0x0F, 0x3F,
  0xFE, 0x03, 0xC3, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7C, 0x01,
  0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x01,
  0xFF, 0x8F, 0x00, 0xFF, 0xF9, 0xE0, 0x3F, 0x8F, 0xB8, 0x0F, 0x80, 0x77,
  0x03, 0xE0, 0x07, 0xE0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x7E, 0x07, 0xE0, 0x3B, 0xC0, 0x7F, 0xFE, 0x70, 0x07, 0xFF, 0x8E,
  0x00, 0x7F, 0xE3, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x7C, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00,
  0x71, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xF8, 0xF0, 0x1F, 0xFF, 0x38, 0x0F, 0xE3, 0xEE, 0x07, 0xC0,
  0x3B, 0x83, 0xE0, 0x07, 0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xF0, 0x01, 0x70, 0x3E, 0x01, 0xFC, 0x0F, 0xE1, 0xEF, 0x01, 0xFF, 0xF3,
  0xC0, 0x3F, 0xF8, 0xF0, 0x03, 0xF0, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xFC, 0x00, 0x78, 0xFF, 0xC0, 0x1C,
  0xFF, 0xF8, 0x07, 0x7C, 0x7F, 0x03, 0xD8, 0x03, 0xE0, 0xFC, 0x00, 0x78,
  0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x41, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x01, 0xE0,
  0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x1C, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1E, 0x03, 0x80, 0x7B,
  0xF8, 0x7F, 0x03, 0xBF, 0xE7, 0xFC, 0x1D, 0x8F, 0x63, 0xE0, 0xF0, 0x3E,
  0x0F, 0x07, 0x81, 0xE0, 0x38, 0x38, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0x0E,
  0x1E, 0x03, 0x80, 0x70, 0xE0, 0x1C, 0x07, 0x87, 0x00, 0xE0, 0x3C, 0x38,
  0x07, 0x01, 0xE1, 0xC0, 0x78, 0x0E, 0x1E, 0x03, 0x80, 0x70, 0xF0, 0x1C,
  0x03, 0x87, 0x80, 0xE0, 0x1C, 0x38, 0x07, 0x01, 0xE1, 0xC0, 0x38, 0x0F,
  0x0E, 0x03, 0xC0, 0x70, 0xF0, 0x1E, 0x03, 0x87, 0x80, 0xE0, 0x1C, 0x3C,
  0x07, 0x00, 0xE1, 0xC0, 0x38, 0x0F, 0x0E, 0x01, 0xC0, 0x78, 0x70, 0x1E,
  0x03, 0xC3, 0x80, 0xF0, 0x1C, 0x3C, 0x07, 0x00, 0xE1, 0xE0, 0x38, 0x07,
  0x0E, 0x01, 0xC0, 0x78, 0x70, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xE3, 0xFF, 0x00, 0x73, 0xFF, 0xE0, 0x1D, 0xF1,
  0xFC, 0x0F, 0x60, 0x0F, 0x83, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x03,
  0x8F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x3C, 0x00,
  0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x78, 0xFF, 0xC0, 0x0E, 0x7F, 0xFC, 0x01, 0xDF, 0x1F, 0xC0, 0x7F,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03,
  0xC0, 0xFC, 0x00, 0xF8, 0x1D, 0xC0, 0x3E, 0x03, 0xBF, 0xFF, 0x80, 0xF3,
  0xFF, 0xE0, 0x1E, 0x1F, 0xF0, 0x03, 0xC0, 0x60, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0xF0, 0x1F,
  0xFF, 0x38, 0x0F, 0xE3, 0xEE, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x07, 0xE0,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E,
  0x1C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0xC1, 0xF8, 0x0E, 0xE0, 0x3F,
  0xFF, 0x38, 0x07, 0xFF, 0x8E, 0x00, 0xFF, 0xC7, 0x80, 0x06, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xE3, 0xFF,
  0x00, 0x73, 0xFF, 0xE0, 0x1D, 0xF0, 0xFC, 0x0F, 0xE0, 0x0F, 0x83, 0xF0,
  0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xE0,
  0xF8, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1F,
  0x80, 0x1F, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78,
  0x00, 0x78, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xDC, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0xFE, 0x01, 0xF0, 0x0E, 0xE0, 0x1F, 0x00, 0xEE, 0x01,
  0xF0, 0x1E, 0xE0, 0x3F, 0x01, 0xCE, 0x03, 0xF0, 0x1C, 0xE0, 0x37, 0x01,
  0xCE, 0x07, 0x70, 0x38, 0xE0, 0x77, 0x03, 0x8E, 0x06, 0x70, 0x38, 0xE0,
  0xE3, 0x07, 0x0E, 0x0E, 0x30, 0x70, 0xE0, 0xC3, 0x07, 0x0E, 0x1C, 0x30,
  0xE0, 0xE1, 0xC3, 0x0E, 0x0E, 0x18, 0x30, 0xE0, 0xE3, 0x83, 0x1C, 0x0E,
  0x38, 0x31, 0xC0, 0xE3, 0x03, 0x1C, 0x0E, 0x70, 0x33, 0x80, 0xE7, 0x03,
  0x38, 0x0E, 0x60, 0x33, 0x80, 0xEE, 0x03, 0x78, 0x0E, 0xE0, 0x37, 0x00,
  0xEC, 0x03, 0x70, 0x0F, 0xC0, 0x37, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x87,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0x3F, 0x87, 0xBC, 0x07,
  0xFF, 0xCE, 0x00, 0xFF, 0xE3, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xC3, 0xFC, 0x00, 0x71, 0xFF, 0x80, 0x1C, 0xF9, 0xF0,
  0x0F, 0x78, 0x3C, 0x03, 0xDC, 0x07, 0x80, 0xE7, 0x00, 0xF0, 0x39, 0xC0,
  0x3E, 0x3E, 0xF0, 0x07, 0xFF, 0x3C, 0x00, 0xFF, 0x8F, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 12, 40, 33, 11, -40 },
  { 61, 17, 16, 33, 11, -40 },
  { 95, 32, 40, 33, 1, -40 },
  { 255, 28, 56, 33, 3, -48 },
  { 451, 37, 40, 33, -1, -40 },
  { 636, 29, 42, 33, 2, -41 },
  { 789, 7, 16, 33, 16, -40 },
  { 803, 23, 53, 33, 9, -46 },
  { 956, 22, 53, 33, 3, -46 },
  { 1102, 29, 29, 33, 3, -34 },
  { 1208, 26, 26, 33, 4, -31 },
  { 1293, 13, 17, 33, 6, -8 },
  { 1321, 18, 3, 33, 8, -20 },
  { 1328, 9, 9, 33, 10, -8 },
  { 1339, 32, 52, 33, 1, -46 },
  { 1547, 27, 42, 33, 4, -41 },
  { 1689, 24, 40, 33, 3, -40 },
  { 1809, 28, 41, 33, 3, -41 },
  { 1953, 27, 41, 33, 3, -40 },
  { 2092, 25, 40, 33, 4, -40 },
  { 2217, 27, 41, 33, 4, -40 },
  { 2356, 26, 41, 33, 3, -40 },
  { 2490, 26, 40, 33, 7, -40 },
  { 2620, 28, 42, 33, 3, -41 },
  { 2767, 25, 41, 33, 6, -41 },
  { 2896, 13, 32, 33, 10, -31 },
  { 2948, 17, 40, 33, 6, -31 },
  { 3033, 26, 28, 33, 5, -32 },
  { 3124, 26, 16, 33, 4, -26 },
  { 3176, 26, 28, 33, 3, -32 },
  { 3267, 21, 40, 33, 9, -40 },
  { 3372, 32, 51, 33, 1, -41 },
  { 3576, 26, 40, 33, 1, -40 },
  { 3706, 28, 40, 33, 3, -40 },
  { 3846, 27, 42, 33, 4, -41 },
  { 3988, 27, 40, 33, 3, -40 },
  { 4123, 28, 40, 33, 4, -40 },
  { 4263, 30, 40, 33, 3, -40 },
  { 4413, 27, 42, 33, 4, -41 },
  { 4555, 28, 40, 33, 3, -40 },
  { 4695, 27, 40, 33, 4, -40 },
  { 4830, 29, 41, 33, 2, -40 },
  { 4979, 31, 40, 33, 3, -40 },
  { 5134, 23, 40, 33, 4, -40 },
  { 5249, 30, 40, 33, 2, -40 },
  { 5399, 28, 40, 33, 3, -40 },
  { 5539, 26, 42, 33, 4, -41 },
  { 5676, 29, 40, 33, 3, -40 },
  { 5821, 27, 51, 33, 4, -41 },
  { 5994, 29, 40, 33, 3, -40 },
  { 6139, 28, 42, 33, 3, -41 },
  { 6286, 27, 40, 33, 7, -40 },
  { 6421, 27, 41, 33, 4, -40 },
  { 6560, 27, 40, 33, 7, -40 },
  { 6695, 31, 40, 33, 4, -40 },
  { 6850, 34, 40, 33, 0, -40 },
  { 7020, 29, 40, 33, 6, -40 },
  { 7165, 29, 40, 33, 2, -40 },
  { 7310, 21, 52, 33, 8, -46 },
  { 7447, 15, 52, 33, 10, -46 },
  { 7545, 21, 52, 33, 5, -46 },
  { 7682, 22, 21, 33, 6, -40 },
  { 7740, 27, 4, 33, 0, 1 },
  { 7754, 9, 8, 33, 15, -43 },
  { 7763, 26, 32, 33, 4, -31 },
  { 7867, 26, 41, 33, 3, -40 },
  { 8001, 25, 32, 33, 4, -31 },
  { 8101, 27, 41, 33, 4, -40 },
  { 8240, 25, 32, 33, 4, -31 },
  { 8340, 36, 50, 33, -2, -40 },
  { 8565, 26, 41, 33, 4, -31 },
  { 8699, 26, 40, 33, 3, -40 },
  { 8829, 26, 42, 33, 2, -42 },
  { 8966, 28, 52, 33, 1, -42 },
  { 9148, 29, 40, 33, 3, -40 },
  { 9293, 22, 40, 33, 6, -40 },
  { 9403, 29, 31, 33, 2, -31 },
  { 9516, 26, 31, 33, 3, -31 },
  { 9617, 25, 32, 33, 4, -31 },
  { 9717, 27, 41, 33, 2, -31 },
  { 9856, 26, 41, 33, 4, -31 },
  { 9990, 26, 31, 33, 4, -31 },
  { 10091, 25, 32, 33, 4, -31 },
  { 10191, 25, 39, 33, 5, -39 },
  { 10313, 26, 31, 33, 4, -30 },
  { 10414, 26, 30, 33, 6, -30 },
  { 10512, 28, 30, 33, 5, -30 },
  { 10617, 30, 30, 33, 1, -30 },
  { 10730, 26, 40, 33, 4, -30 },
  { 10860, 26, 30, 33, 3, -30 },
  { 10958, 27, 52, 33, 6, -46 },
  { 11134, 12, 52, 33, 11, -46 },
  { 11212, 27, 52, 33, 2, -46 },
  { 11388, 26, 11, 33, 4, -25 },
};

const GFXfont JetBrainsMono_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC55PT7B_H_
