#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC9PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB7, 0x00, 0x29, 0x5E, 0xAF, 0xAA, 0x80, 0x11, 0x96,
  0xA3, 0x16, 0xAE, 0x20, 0x66, 0xAB, 0x14, 0x39, 0xAB, 0x80, 0x32, 0x50,
  0xCA, 0xCB, 0xA0, 0xE0, 0x2A, 0x49, 0x24, 0x40, 0x61, 0x11, 0x11, 0x12,
  0xC0, 0x2B, 0x4A, 0x24, 0xF4, 0x60, 0xE0, 0x80, 0x08, 0x44, 0x42, 0x21,
  0x10, 0x69, 0x9D, 0x99, 0xE0, 0x17, 0x11, 0x22, 0xF0, 0x32, 0x42, 0x13,
  0x23, 0xC0, 0x71, 0x62, 0x19, 0xE0, 0x12, 0x49, 0x9E, 0x20, 0x78, 0x8F,
  0x11, 0xE0, 0x22, 0x4E, 0x99, 0xE0, 0xF9, 0x12, 0x24, 0xC0, 0x69, 0x96,
  0x99, 0xE0, 0x69, 0x99, 0x64, 0xC0, 0xC0, 0x80, 0x60, 0x05, 0x00, 0x3C,
  0xC2, 0xFF, 0x60, 0x87, 0xC0, 0x61, 0x12, 0x40, 0xC0, 0x32, 0x57, 0x5A,
  0xD6, 0x50, 0x60, 0x11, 0x35, 0x75, 0x90, 0x69, 0x9E, 0x99, 0xE0, 0x69,
  0x88, 0x89, 0xE0, 0x69, 0x99, 0x99, 0xE0, 0x78, 0x8F, 0x88, 0xE0, 0x78,
  0x8F, 0x88, 0x80, 0x69, 0x88, 0xB9, 0xE0, 0x99, 0x9F, 0x99, 0xA0, 0x72,
  0x24, 0x44, 0xE0, 0x18, 0x42, 0x10, 0xC9, 0xC0, 0x99, 0xAC, 0xAA, 0x90,
  0x92, 0x49, 0x38, 0x4A, 0x5E, 0xD4, 0xC6, 0x20, 0x9D, 0xDD, 0xDA, 0xA0,
  0x69, 0x99, 0x99, 0xE0, 0x69, 0x9F, 0x88, 0x80, 0x69, 0x99, 0x99, 0xE2,
  0x20, 0x69, 0x9D, 0xAA, 0xA0, 0x32, 0x50, 0x60, 0xC5, 0xC0, 0xF9, 0x08,
  0x84, 0x21, 0x00, 0x99, 0x99, 0x99, 0xE0, 0x8C, 0xA5, 0x4A, 0x21, 0x00,
  0xAD, 0x7D, 0xEB, 0x52, 0x80, 0x45, 0x23, 0x08, 0x31, 0x48, 0x80, 0x8C,
  0x98, 0xC4, 0x21, 0x00, 0x78, 0x44, 0x42, 0x23, 0xC0, 0x74, 0x44, 0x44,
  0x8E, 0xAA, 0x95, 0x64, 0x92, 0x56, 0x26, 0x69, 0xF0, 0xC0, 0x79, 0x99,
  0xE0, 0x88, 0xE9, 0x99, 0xE0, 0x69, 0x89, 0xE0, 0x11, 0x79, 0x99, 0xE0,
  0x69, 0xF8, 0xE0, 0x1C, 0x87, 0x88, 0x20, 0x82, 0x10, 0x80, 0x79, 0x9A,
  0xE2, 0xC0, 0x88, 0xE9, 0x99, 0xA0, 0x10, 0x1C, 0x22, 0x13, 0xE0, 0x08,
  0x1C, 0x21, 0x08, 0x44, 0xC0, 0x88, 0x9A, 0xCA, 0xA0, 0xC4, 0x44, 0x44,
  0x70, 0x7B, 0x6B, 0x5A, 0x80, 0xE9, 0x99, 0xA0, 0x69, 0x99, 0xE0, 0x72,
  0x52, 0x97, 0x42, 0x00, 0x79, 0x99, 0xE2, 0x20, 0xF9, 0x88, 0x80, 0x78,
  0x61, 0xE0, 0x4F, 0x44, 0x46, 0x99, 0x99, 0xE0, 0x99, 0xAA, 0x40, 0xDD,
  0xBA, 0xA0, 0x49, 0x88, 0xA9, 0x00, 0x99, 0x9A, 0xE2, 0xC0, 0x78, 0x88,
  0x8F, 0x00, 0x32, 0x2C, 0x44, 0x46, 0x56, 0xAA, 0x31, 0x08, 0x32, 0x10,
  0x98, 0xDA,
};

const GFXglyph JetBrainsMono_ExtraLightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 7, 5, 2, -7 },
  { 3, 3, 3, 5, 2, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 5, 0, -7 },
  { 22, 5, 7, 5, 0, -7 },
  { 27, 1, 3, 5, 3, -7 },
  { 28, 3, 9, 5, 2, -8 },
  { 32, 4, 9, 5, 0, -8 },
  { 37, 4, 4, 5, 1, -5 },
  { 39, 4, 4, 5, 1, -5 },
  { 41, 2, 2, 5, 1, -1 },
  { 42, 3, 1, 5, 1, -3 },
  { 43, 1, 1, 5, 2, -1 },
  { 44, 5, 8, 5, 0, -7 },
  { 49, 4, 7, 5, 1, -7 },
  { 53, 4, 7, 5, 0, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 4, 7, 5, 1, -7 },
  { 70, 4, 7, 5, 1, -7 },
  { 74, 4, 7, 5, 1, -7 },
  { 78, 4, 7, 5, 1, -7 },
  { 82, 4, 7, 5, 1, -7 },
  { 86, 4, 7, 5, 1, -7 },
  { 90, 2, 5, 5, 2, -5 },
  { 92, 3, 6, 5, 1, -5 },
  { 95, 4, 4, 5, 1, -5 },
  { 97, 4, 2, 5, 1, -4 },
  { 98, 5, 4, 5, 0, -5 },
  { 101, 4, 7, 5, 1, -7 },
  { 105, 5, 9, 5, 0, -7 },
  { 111, 4, 7, 5, 0, -7 },
  { 115, 4, 7, 5, 1, -7 },
  { 119, 4, 7, 5, 1, -7 },
  { 123, 4, 7, 5, 1, -7 },
  { 127, 4, 7, 5, 1, -7 },
  { 131, 4, 7, 5, 1, -7 },
  { 135, 4, 7, 5, 1, -7 },
  { 139, 4, 7, 5, 1, -7 },
  { 143, 4, 7, 5, 1, -7 },
  { 147, 5, 7, 5, 0, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 3, 7, 5, 1, -7 },
  { 159, 5, 7, 5, 0, -7 },
  { 164, 4, 7, 5, 1, -7 },
  { 168, 4, 7, 5, 1, -7 },
  { 172, 4, 7, 5, 1, -7 },
  { 176, 4, 9, 5, 1, -7 },
  { 181, 4, 7, 5, 1, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 5, 7, 5, 1, -7 },
  { 195, 4, 7, 5, 1, -7 },
  { 199, 5, 7, 5, 1, -7 },
  { 204, 5, 7, 5, 1, -7 },
  { 209, 6, 7, 5, 0, -7 },
  { 215, 5, 7, 5, 1, -7 },
  { 220, 5, 7, 5, 0, -7 },
  { 225, 4, 8, 5, 1, -7 },
  { 229, 2, 8, 5, 2, -7 },
  { 231, 3, 8, 5, 1, -7 },
  { 234, 4, 4, 5, 1, -7 },
  { 236, 4, 1, 5, 0, 0 },
  { 237, 2, 1, 5, 2, -7 },
  { 238, 4, 5, 5, 1, -5 },
  { 241, 4, 7, 5, 1, -7 },
  { 245, 4, 5, 5, 1, -5 },
  { 248, 4, 7, 5, 1, -7 },
  { 252, 4, 5, 5, 1, -5 },
  { 255, 6, 9, 5, 0, -7 },
  { 262, 4, 7, 5, 1, -5 },
  { 266, 4, 7, 5, 1, -7 },
  { 270, 5, 7, 5, 0, -7 },
  { 275, 5, 9, 5, 0, -7 },
  { 281, 4, 7, 5, 1, -7 },
  { 285, 4, 7, 5, 1, -7 },
  { 289, 5, 5, 5, 0, -5 },
  { 293, 4, 5, 5, 1, -5 },
  { 296, 4, 5, 5, 1, -5 },
  { 299, 5, 7, 5, 0, -5 },
  { 304, 4, 7, 5, 1, -5 },
  { 308, 4, 5, 5, 1, -5 },
  { 311, 4, 5, 5, 1, -5 },
  { 314, 4, 6, 5, 1, -6 },
  { 317, 4, 5, 5, 1, -5 },
  { 320, 4, 5, 5, 1, -5 },
  { 323, 4, 5, 5, 1, -5 },
  { 326, 5, 5, 5, 0, -5 },
  { 330, 4, 7, 5, 1, -5 },
  { 334, 5, 5, 5, 0, -5 },
  { 338, 4, 8, 5, 1, -7 },
  { 342, 2, 8, 5, 2, -7 },
  { 344, 5, 8, 5, 0, -7 },
  { 349, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_ExtraLightItalic9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC9PT7B_H_
