#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC34PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x30, 0x60, 0x00, 0x00, 0x0E, 0x3C, 0x78, 0xF0, 0x70,
  0xD8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0xE0,
  0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x18, 0x01, 0x81, 0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x30,
  0x30, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x03, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0xE0, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x0E, 0x4E, 0x0C, 0x63, 0x8E, 0x30,
  0xC6, 0x18, 0x63, 0x0C, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x71, 0x00, 0x1D,
  0x80, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x13, 0x80, 0x08, 0xE0,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0xC1, 0x86, 0x60, 0x87, 0x38, 0x43,
  0x0E, 0x67, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x06, 0x0F, 0xE0, 0x18,
  0x38, 0xE0, 0x60, 0x60, 0xC1, 0x80, 0xC1, 0x83, 0x03, 0x02, 0x0C, 0x06,
  0x0C, 0x30, 0x0C, 0x18, 0xC0, 0x18, 0x33, 0x00, 0x3D, 0xCC, 0x00, 0x3F,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0xF8, 0x00, 0x67, 0xF8, 0x01, 0x8C, 0x30, 0x07, 0x30, 0x60, 0x0C, 0x60,
  0xC0, 0x30, 0xC1, 0x80, 0xC1, 0x83, 0x03, 0x03, 0x06, 0x0C, 0x06, 0x18,
  0x30, 0x0F, 0xE0, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x30,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x3D, 0x80, 0x0C,
  0x70, 0x77, 0x0E, 0x19, 0x81, 0x8C, 0x60, 0x77, 0x18, 0x0D, 0x86, 0x03,
  0xC3, 0x80, 0x60, 0xE0, 0x3C, 0x38, 0x0F, 0x8E, 0x0E, 0x61, 0xFF, 0x1C,
  0x3F, 0x03, 0x80, 0x77, 0x76, 0x6E, 0xEE, 0xCC, 0x00, 0x04, 0x00, 0xE0,
  0x0F, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x38, 0x01, 0xE0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x10,
  0x30, 0x2F, 0x0C, 0x3F, 0xF3, 0x7F, 0x1F, 0xBE, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x1D, 0x80, 0x0E, 0x70, 0x03, 0x1C, 0x01, 0xC3, 0x80, 0xE0, 0xE0,
  0x70, 0x1C, 0x08, 0x04, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0F,
  0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xC0, 0xFF, 0xFF, 0xFC,
  0x39, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0xC1, 0xC1, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x07, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x38, 0x67, 0x1E, 0x33,
  0x8E, 0x39, 0x80, 0x1C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x38, 0x01,
  0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0xC0, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xE0, 0x39, 0x81, 0xE3, 0x03,
  0x06, 0x04, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x80, 0x71, 0x80, 0x39,
  0xC0, 0x0C, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x47, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x38, 0x03, 0x18,
  0x01, 0x8E, 0x00, 0xC7, 0x00, 0xC1, 0xC0, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x63,
  0x80, 0xC6, 0x01, 0x9C, 0x03, 0x70, 0x0E, 0xC0, 0x1D, 0xFF, 0xF3, 0xFF,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0xFC, 0x07, 0xFF, 0x07,
  0x81, 0xC3, 0x80, 0x61, 0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE1, 0xC0,
  0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0D, 0xF8, 0x1B, 0xFC, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x06,
  0x60, 0x07, 0x60, 0x07, 0xE0, 0x06, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x0C,
  0x60, 0x1C, 0x70, 0x38, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF,
  0x60, 0x03, 0x60, 0x07, 0x60, 0x06, 0xE0, 0x0C, 0xE0, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0x60,
  0x0E, 0x30, 0x06, 0x1C, 0x07, 0x06, 0x07, 0x01, 0xCE, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x7B, 0xC0, 0x70, 0x70, 0x60, 0x1C, 0x70, 0x0E, 0x30, 0x03,
  0x38, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x61, 0xC0, 0xE0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0xF0, 0x71, 0x80, 0x76,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x37, 0x00, 0xEF, 0x03, 0x8F, 0xFF, 0x0F, 0xEC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x78, 0xFC, 0xF8, 0x78, 0x03, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x18, 0x06, 0x03, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x08, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x20, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x1F, 0xC0, 0x7C, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x3E,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1C, 0x07, 0x07, 0x00,
  0x60, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x66, 0x07, 0xEC, 0xC1, 0xC5, 0x98, 0x70, 0x67, 0x0C, 0x0C, 0xC1, 0x81,
  0x98, 0x70, 0x33, 0x0C, 0x06, 0x61, 0x81, 0xCC, 0x30, 0x33, 0x86, 0x06,
  0x60, 0xC0, 0xCC, 0x18, 0x39, 0x83, 0xFB, 0x30, 0x3E, 0x66, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xEC, 0x00, 0xCC, 0x01, 0xCC, 0x01, 0x8C, 0x01, 0x8C, 0x03,
  0x0C, 0x03, 0x0C, 0x07, 0x0C, 0x06, 0x0C, 0x0E, 0x0E, 0x0C, 0x06, 0x0C,
  0x06, 0x1F, 0xFE, 0x1F, 0xFE, 0x38, 0x06, 0x30, 0x06, 0x70, 0x06, 0x60,
  0x06, 0x60, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0x03, 0xC3, 0x80, 0x61, 0x80, 0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x06,
  0x18, 0x03, 0x1C, 0x03, 0x0E, 0x03, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0x80,
  0xE0, 0xC0, 0x38, 0xE0, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xE3, 0x00, 0xE3, 0x80, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x07, 0x38, 0x07, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x70, 0x7F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0x07, 0x83, 0x80, 0xE1,
  0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x01,
  0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x18, 0xE0,
  0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01, 0x86, 0x01, 0xC3,
  0x01, 0xC3, 0x81, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x07, 0x38,
  0x07, 0x30, 0x03, 0x30, 0x03, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x61, 0xFE, 0xE1, 0xFE, 0xE0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xE0,
  0x70, 0x7F, 0xE0, 0x3F, 0xC0, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63,
  0x80, 0x31, 0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x1C, 0x01, 0x8E, 0x01, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0x80, 0x30, 0xC0,
  0x18, 0xE0, 0x0C, 0x70, 0x0E, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x38, 0xC0, 0x1C, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x86, 0x00, 0x63,
  0x80, 0x18, 0x60, 0x0C, 0x18, 0x07, 0x07, 0x03, 0x80, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x0C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x06, 0x0E, 0x01, 0xC1,
  0xC0, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x18, 0x07,
  0x07, 0x00, 0xE1, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x60, 0xC0, 0x0C,
  0x1C, 0x03, 0x81, 0x80, 0x70, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x03, 0x06, 0x00, 0x70, 0xC0,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0x00,
  0xE1, 0xE0, 0x3C, 0x3C, 0x05, 0x87, 0x81, 0xA0, 0xF0, 0x2C, 0x12, 0x0D,
  0x86, 0x61, 0x30, 0xCC, 0x66, 0x19, 0x89, 0xC3, 0x33, 0x30, 0x62, 0x46,
  0x0C, 0x78, 0xC3, 0x8E, 0x18, 0x61, 0xC3, 0x0C, 0x00, 0xE1, 0x80, 0x1C,
  0x30, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x00, 0x0E, 0x01,
  0x87, 0x00, 0xC3, 0x80, 0x63, 0x60, 0x31, 0xB0, 0x18, 0xD8, 0x1C, 0x6C,
  0x0C, 0x33, 0x06, 0x19, 0x83, 0x1C, 0xC1, 0x8C, 0x60, 0xC6, 0x30, 0xE3,
  0x0C, 0x61, 0x86, 0x30, 0xC3, 0x18, 0xE1, 0x8C, 0x70, 0x66, 0x30, 0x37,
  0x18, 0x1B, 0x0C, 0x0D, 0x86, 0x06, 0xC3, 0x01, 0xE3, 0x80, 0xF1, 0x80,
  0x78, 0xC0, 0x3C, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06,
  0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38,
  0xE0, 0x70, 0x7F, 0xE0, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xC0,
  0x78, 0x70, 0x06, 0x1C, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x07,
  0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38, 0xC0, 0x1C, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61,
  0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x0E, 0x30, 0x06, 0x38, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01, 0xC6, 0x00, 0xC3,
  0x00, 0xE1, 0xC0, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0xC0, 0xF0, 0x70, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xC0, 0x38,
  0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x70, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x60, 0x18, 0x18, 0x06, 0x0E, 0x01,
  0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xC1,
  0xC1, 0x80, 0x71, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x98, 0x00,
  0xCE, 0x00, 0xE7, 0x00, 0x61, 0xC0, 0x70, 0xFF, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00,
  0x63, 0x80, 0x31, 0x80, 0x38, 0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x1C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x06, 0x30, 0x07, 0x18, 0x03, 0x8C, 0x01,
  0x86, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00,
  0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C,
  0xC0, 0x18, 0xE0, 0x38, 0xE0, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0x60, 0xC0, 0x61, 0xC0, 0x61, 0x80, 0x61, 0x80, 0x73, 0x00,
  0x33, 0x00, 0x37, 0x00, 0x36, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x60, 0xE0, 0xEC, 0x1C, 0x19, 0x83, 0x83, 0x70, 0xF0, 0x6C,
  0x1E, 0x19, 0x82, 0xC3, 0x30, 0x58, 0x66, 0x1B, 0x0C, 0xC3, 0x63, 0x18,
  0x4C, 0x63, 0x19, 0x8C, 0x63, 0x31, 0x8C, 0x46, 0x61, 0x98, 0xCC, 0x33,
  0x19, 0x86, 0x43, 0x60, 0xC8, 0x6C, 0x1B, 0x09, 0x83, 0x61, 0x30, 0x68,
  0x2C, 0x0F, 0x05, 0x81, 0xE0, 0xB0, 0x38, 0x14, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x00, 0x06, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x38, 0x1C, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x18, 0xC0, 0x00,
  0xCE, 0x00, 0x07, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x03, 0x8C, 0x00, 0x18,
  0x60, 0x01, 0x83, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x80,
  0xC0, 0x0C, 0x0E, 0x00, 0x70, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0xF0, 0x01,
  0xD8, 0x01, 0xCC, 0x00, 0xC7, 0x00, 0xE1, 0x80, 0xE0, 0xC0, 0x60, 0x70,
  0x70, 0x18, 0x30, 0x0C, 0x30, 0x07, 0x38, 0x01, 0x98, 0x00, 0xD8, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC1,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xFC, 0x1F, 0xE0,
  0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x83, 0xFC, 0x1F, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0xC0, 0x0D, 0x80,
  0x33, 0x00, 0xE6, 0x01, 0x86, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0xE0,
  0x31, 0x80, 0x6E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0xC3,
  0x0E, 0x1C, 0x03, 0xF3, 0x07, 0xFB, 0x0E, 0x0B, 0x1C, 0x07, 0x38, 0x07,
  0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x60, 0x06,
  0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x70, 0x2C,
  0x3F, 0xFC, 0x1F, 0x9C, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0xF8, 0x1B, 0xFC, 0x1E, 0x0E, 0x3C, 0x06,
  0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x70, 0x1C,
  0xF0, 0x38, 0xDF, 0xF0, 0xCF, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71,
  0xC0, 0x77, 0x00, 0xEC, 0x00, 0xD8, 0x02, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x03, 0xB0, 0x06, 0x60, 0x1C,
  0xE0, 0x70, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x0F, 0xCC, 0x0F, 0xF6, 0x0E,
  0x0B, 0x0E, 0x03, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0xE1, 0xC0, 0xB0, 0x7F, 0xF8, 0x1F, 0x9C, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x71, 0x80, 0x67, 0x00, 0xEC, 0x01, 0xD8,
  0x03, 0xB0, 0x06, 0xFF, 0xFD, 0xFF, 0xFB, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x06, 0x60, 0x1C, 0xE0, 0x70, 0xFF, 0xC0, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE6, 0x1F, 0xEC, 0x70, 0x59, 0xC0, 0x77, 0x00, 0xEC,
  0x01, 0xD8, 0x03, 0x30, 0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00,
  0xEC, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x3C, 0x6C, 0x3F, 0x98, 0x3C, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x3F, 0xE0, 0xFF,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0xF8, 0x1B, 0xFC, 0x1E, 0x0E, 0x3C, 0x06, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06, 0x60,
  0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0,
  0x1C, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0E, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x1C, 0x60, 0x0E, 0x18, 0x07, 0x06, 0x03, 0x83, 0x81,
  0xC0, 0xE0, 0xE0, 0x30, 0x30, 0x0C, 0x18, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x70, 0xC0, 0x1C, 0x38, 0x06, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x0E, 0x01, 0x83, 0x80, 0x70, 0xC0, 0x0E, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0xFF,
  0x0F, 0xF8, 0x1B, 0xC7, 0x87, 0xFB, 0xE1, 0x87, 0x1C, 0xE1, 0x83, 0x30,
  0x60, 0xCC, 0x18, 0x73, 0x06, 0x18, 0xC1, 0x86, 0x30, 0xC1, 0x8C, 0x30,
  0x66, 0x0C, 0x19, 0x83, 0x0E, 0x60, 0xC3, 0x18, 0x30, 0xC6, 0x18, 0x31,
  0x86, 0x0C, 0xE1, 0x83, 0x30, 0x60, 0xCC, 0x18, 0x60, 0x18, 0xF8, 0x1B,
  0xFC, 0x1E, 0x0E, 0x3C, 0x06, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xC0, 0x1C, 0x03,
  0xF0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x67, 0x00, 0xEC, 0x01, 0xD8, 0x03,
  0xB0, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0xD8,
  0x03, 0x30, 0x06, 0x60, 0x1C, 0xE0, 0x70, 0xFF, 0xC0, 0xFE, 0x00, 0x0C,
  0x7C, 0x06, 0xFF, 0x03, 0xC1, 0xC3, 0xC0, 0x61, 0xC0, 0x38, 0xE0, 0x1C,
  0x60, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x70, 0x1C, 0x78, 0x1C, 0x37,
  0xFC, 0x19, 0xFC, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF3, 0x07, 0xFB, 0x0E, 0x0B, 0x18,
  0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70,
  0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x1C, 0x70, 0x2C, 0x3F, 0xFC, 0x1F, 0x98, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x19, 0xF8, 0x3B, 0xFC, 0x36,
  0x0E, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x0F,
  0xFE, 0x1C, 0x0E, 0x18, 0x07, 0x38, 0x03, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0x70, 0x1C, 0x7F, 0xF8, 0x3F, 0xF0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x07, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x06, 0x60, 0x0E, 0x60,
  0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x70, 0x18, 0x70, 0x38, 0x3F, 0xF0, 0x1F,
  0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x37, 0x00, 0x66, 0x01, 0x8C, 0x03,
  0x18, 0x0C, 0x30, 0x18, 0x60, 0x60, 0x60, 0xC0, 0xC3, 0x01, 0x86, 0x03,
  0x18, 0x06, 0x30, 0x0C, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x6C, 0x3C, 0x36,
  0x16, 0x1B, 0x1B, 0x19, 0x8D, 0x8C, 0xC4, 0xC6, 0x66, 0x66, 0x33, 0x33,
  0x19, 0x19, 0x8D, 0x8D, 0x86, 0xC2, 0xC3, 0x41, 0x61, 0xE0, 0xA0, 0xF0,
  0x70, 0x70, 0x38, 0x38, 0x18, 0x00, 0x1C, 0x01, 0xC3, 0x00, 0x60, 0xE0,
  0x30, 0x18, 0x1C, 0x07, 0x0E, 0x00, 0xC7, 0x00, 0x39, 0x80, 0x06, 0xC0,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x30, 0x03,
  0x8E, 0x00, 0xC1, 0x80, 0x60, 0x70, 0x38, 0x0C, 0x1C, 0x03, 0x8E, 0x00,
  0x70, 0x30, 0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x80, 0x76, 0x00, 0xEC, 0x01,
  0x98, 0x03, 0x30, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x00, 0x76, 0x00, 0xEC,
  0x01, 0x98, 0x07, 0x38, 0x1E, 0x3C, 0xEC, 0x3F, 0xB8, 0x18, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x7F, 0xE0, 0xFF, 0x80,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x06, 0x0C,
  0x18, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x0C,
  0x38, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C,
  0x30, 0x60, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x07,
  0x7F, 0x06, 0xC3, 0x86, 0xC1, 0x86, 0xC1, 0xFC, 0xC0, 0xFC,
};

const GFXglyph JetBrainsMono_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 7, 25, 20, 7, -25 },
  { 23, 10, 10, 20, 7, -25 },
  { 36, 20, 25, 20, 1, -25 },
  { 99, 17, 35, 20, 2, -30 },
  { 174, 23, 25, 20, -1, -25 },
  { 246, 18, 25, 20, 1, -25 },
  { 303, 4, 10, 20, 10, -25 },
  { 308, 14, 33, 20, 6, -29 },
  { 366, 13, 33, 20, 2, -29 },
  { 420, 18, 18, 20, 2, -21 },
  { 461, 15, 16, 20, 3, -19 },
  { 491, 8, 10, 20, 4, -5 },
  { 501, 11, 2, 20, 5, -12 },
  { 504, 6, 5, 20, 6, -5 },
  { 508, 19, 32, 20, 1, -28 },
  { 584, 17, 25, 20, 2, -25 },
  { 638, 15, 25, 20, 2, -25 },
  { 685, 17, 25, 20, 2, -25 },
  { 739, 17, 25, 20, 2, -25 },
  { 793, 15, 25, 20, 3, -25 },
  { 840, 17, 25, 20, 2, -25 },
  { 894, 16, 25, 20, 2, -25 },
  { 944, 16, 25, 20, 4, -25 },
  { 994, 17, 25, 20, 2, -25 },
  { 1048, 15, 25, 20, 4, -25 },
  { 1095, 8, 19, 20, 6, -19 },
  { 1114, 10, 24, 20, 4, -19 },
  { 1144, 16, 17, 20, 3, -20 },
  { 1178, 15, 10, 20, 3, -16 },
  { 1197, 16, 17, 20, 2, -20 },
  { 1231, 14, 25, 20, 5, -25 },
  { 1275, 19, 31, 20, 1, -25 },
  { 1349, 16, 25, 20, 1, -25 },
  { 1399, 17, 25, 20, 2, -25 },
  { 1453, 16, 25, 20, 3, -25 },
  { 1503, 17, 25, 20, 2, -25 },
  { 1557, 18, 25, 20, 2, -25 },
  { 1614, 18, 25, 20, 2, -25 },
  { 1671, 16, 25, 20, 3, -25 },
  { 1721, 17, 25, 20, 2, -25 },
  { 1775, 17, 25, 20, 2, -25 },
  { 1829, 18, 25, 20, 1, -25 },
  { 1886, 19, 25, 20, 2, -25 },
  { 1946, 14, 25, 20, 3, -25 },
  { 1990, 19, 25, 20, 1, -25 },
  { 2050, 17, 25, 20, 2, -25 },
  { 2104, 16, 25, 20, 3, -25 },
  { 2154, 18, 25, 20, 2, -25 },
  { 2211, 17, 31, 20, 2, -25 },
  { 2277, 18, 25, 20, 2, -25 },
  { 2334, 17, 25, 20, 2, -25 },
  { 2388, 17, 25, 20, 4, -25 },
  { 2442, 17, 25, 20, 2, -25 },
  { 2496, 16, 25, 20, 5, -25 },
  { 2546, 19, 25, 20, 3, -25 },
  { 2606, 21, 25, 20, 0, -25 },
  { 2672, 17, 25, 20, 4, -25 },
  { 2726, 17, 25, 20, 2, -25 },
  { 2780, 13, 32, 20, 5, -28 },
  { 2832, 9, 32, 20, 6, -28 },
  { 2868, 13, 32, 20, 3, -28 },
  { 2920, 15, 13, 20, 3, -25 },
  { 2945, 17, 2, 20, 0, 1 },
  { 2950, 6, 5, 20, 9, -27 },
  { 2954, 16, 19, 20, 2, -19 },
  { 2992, 16, 25, 20, 2, -25 },
  { 3042, 15, 19, 20, 3, -19 },
  { 3078, 17, 25, 20, 2, -25 },
  { 3132, 15, 19, 20, 3, -19 },
  { 3168, 22, 31, 20, -1, -25 },
  { 3254, 15, 25, 20, 3, -19 },
  { 3301, 16, 25, 20, 2, -25 },
  { 3351, 15, 26, 20, 2, -26 },
  { 3400, 17, 32, 20, 1, -26 },
  { 3468, 18, 25, 20, 2, -25 },
  { 3525, 13, 25, 20, 4, -25 },
  { 3566, 18, 19, 20, 1, -19 },
  { 3609, 16, 19, 20, 2, -19 },
  { 3647, 15, 19, 20, 3, -19 },
  { 3683, 17, 25, 20, 1, -19 },
  { 3737, 16, 25, 20, 2, -19 },
  { 3787, 16, 19, 20, 3, -19 },
  { 3825, 16, 19, 20, 2, -19 },
  { 3863, 16, 24, 20, 3, -24 },
  { 3911, 16, 19, 20, 2, -19 },
  { 3949, 15, 19, 20, 4, -19 },
  { 3985, 17, 19, 20, 3, -19 },
  { 4026, 18, 19, 20, 1, -19 },
  { 4069, 15, 25, 20, 3, -19 },
  { 4116, 16, 19, 20, 2, -19 },
  { 4154, 17, 32, 20, 3, -28 },
  { 4222, 7, 32, 20, 7, -28 },
  { 4250, 17, 32, 20, 1, -28 },
  { 4318, 16, 6, 20, 3, -15 },
};

const GFXfont JetBrainsMono_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC34PT7B_H_
