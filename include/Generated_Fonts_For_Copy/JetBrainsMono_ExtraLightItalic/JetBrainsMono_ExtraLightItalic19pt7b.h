#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC19PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x22, 0x64, 0x44, 0x00, 0xCC, 0xCF, 0x28, 0xA2, 0x8A,
  0x20, 0x06, 0x20, 0x84, 0x11, 0x06, 0x23, 0xFE, 0x11, 0x06, 0x20, 0x8C,
  0x11, 0x1F, 0xF8, 0x8C, 0x11, 0x04, 0x20, 0x88, 0x00, 0x02, 0x00, 0x80,
  0x20, 0x3C, 0x14, 0x89, 0x32, 0x4C, 0x90, 0x34, 0x07, 0x00, 0x70, 0x24,
  0x09, 0xA2, 0x6C, 0x93, 0x2C, 0x7E, 0x04, 0x01, 0x00, 0x40, 0x0E, 0x08,
  0x90, 0x8C, 0xC8, 0x44, 0xC2, 0x24, 0x1F, 0x40, 0x04, 0x00, 0x40, 0x04,
  0xE0, 0x48, 0x86, 0x44, 0x26, 0x42, 0x32, 0x60, 0xE0, 0x0F, 0x04, 0x42,
  0x18, 0x80, 0x20, 0x0C, 0x07, 0x81, 0x23, 0x8C, 0xA1, 0x48, 0x62, 0x18,
  0x8D, 0x3E, 0x60, 0xFA, 0xA0, 0x03, 0x06, 0x18, 0x10, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x60, 0x30, 0x18, 0x10,
  0x0C, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x08, 0x18, 0x30, 0xC0, 0x04, 0x01, 0x00, 0x41, 0x11, 0xF7, 0xC7,
  0x81, 0xC0, 0xD8, 0x22, 0x10, 0xC0, 0x04, 0x02, 0x01, 0x01, 0x87, 0xFC,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x39, 0x88, 0xC4, 0x60, 0xFC, 0x67, 0x60,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x00, 0x0F, 0x04, 0x62, 0x0C, 0x83, 0x60, 0x90, 0x24, 0xC9, 0x32, 0x41,
  0x90, 0x6C, 0x13, 0x04, 0x43, 0x1F, 0x00, 0x06, 0x0A, 0x32, 0x22, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0xFF, 0x0F, 0x0C, 0x62,
  0x0D, 0x83, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x4C, 0x13, 0x04, 0x42, 0x1F, 0x00, 0x01, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0xC6, 0x43, 0x41, 0x20, 0xBF, 0xC0, 0x20, 0x30,
  0x18, 0x3F, 0xCC, 0x02, 0x00, 0x80, 0x20, 0x0B, 0xC7, 0x11, 0x86, 0x01,
  0x80, 0x40, 0x13, 0x04, 0x42, 0x1F, 0x00, 0x03, 0x03, 0x01, 0x01, 0x01,
  0x81, 0x80, 0xFC, 0xC3, 0x41, 0xE0, 0x70, 0x78, 0x24, 0x31, 0xE0, 0x7F,
  0xA0, 0x50, 0x78, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0x03, 0x00, 0x0F, 0x04, 0x62, 0x08, 0x82, 0x20, 0x8C, 0x41, 0xE0,
  0x78, 0x61, 0x10, 0x6C, 0x13, 0x04, 0x43, 0x1F, 0x80, 0x1E, 0x31, 0x90,
  0x78, 0x38, 0x1C, 0x0B, 0x0C, 0xDC, 0x36, 0x06, 0x02, 0x02, 0x03, 0x03,
  0x00, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x23, 0x98, 0x08, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0xC2, 0x18, 0x43, 0x00, 0x01, 0x83, 0x87, 0x0E, 0x08,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x1C, 0x30, 0x60, 0xC0, 0x40,
  0x00, 0x7C, 0x0C, 0x08, 0x10, 0x20, 0xC3, 0x1C, 0x60, 0x80, 0x00, 0x0E,
  0x18, 0x00, 0x07, 0xC3, 0x0C, 0x40, 0x90, 0x12, 0x02, 0x47, 0x59, 0x1A,
  0x23, 0x44, 0x49, 0x89, 0x31, 0x26, 0x64, 0x75, 0x80, 0x10, 0x03, 0x00,
  0x3C, 0x00, 0x03, 0x01, 0x81, 0x40, 0xA0, 0xD0, 0x48, 0x26, 0x21, 0x10,
  0x9F, 0xC8, 0x2C, 0x14, 0x0E, 0x04, 0x3F, 0x08, 0x62, 0x08, 0x82, 0x20,
  0x98, 0x67, 0xE1, 0x0C, 0x41, 0x90, 0x64, 0x19, 0x04, 0xC3, 0x3F, 0x00,
  0x0F, 0x04, 0x22, 0x0C, 0x83, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x19, 0x04, 0x43, 0x0F, 0x00, 0x3F, 0x10, 0xC8, 0x24, 0x12, 0x0B,
  0x05, 0x82, 0x83, 0x41, 0xA0, 0x90, 0x48, 0x6C, 0x67, 0xE0, 0x3F, 0xCC,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x07, 0xF9, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x3F, 0xC0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x07,
  0xF9, 0xFE, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0x04,
  0x22, 0x0C, 0x83, 0x20, 0x18, 0x04, 0x01, 0x1E, 0x48, 0x90, 0x64, 0x11,
  0x04, 0x43, 0x0F, 0x00, 0x30, 0x48, 0x32, 0x08, 0x82, 0x20, 0x98, 0x27,
  0xF9, 0x06, 0x41, 0x10, 0x44, 0x11, 0x04, 0xC1, 0x20, 0xC0, 0x3F, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x3F, 0xC0, 0x07, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x48, 0x12, 0x0C, 0xC6, 0x1F, 0x00, 0x30, 0x64,
  0x18, 0x82, 0x10, 0x82, 0x30, 0xC4, 0x1F, 0x02, 0x20, 0x46, 0x08, 0x41,
  0x08, 0x21, 0x8C, 0x11, 0x03, 0x00, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xFF, 0x30, 0xCC, 0x33, 0x15,
  0xC7, 0x4A, 0x92, 0xA4, 0xC9, 0x32, 0x40, 0x90, 0x6C, 0x12, 0x04, 0x81,
  0x20, 0x40, 0x30, 0x4C, 0x33, 0x88, 0xA2, 0x28, 0x9A, 0x24, 0x89, 0x16,
  0x45, 0x11, 0x44, 0x51, 0x1C, 0xC3, 0x20, 0xC0, 0x0F, 0x04, 0x62, 0x08,
  0x82, 0x20, 0x98, 0x24, 0x09, 0x06, 0x41, 0x90, 0x44, 0x11, 0x04, 0x42,
  0x0F, 0x00, 0x3F, 0x08, 0x32, 0x04, 0x81, 0x20, 0x58, 0x36, 0x19, 0xFC,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x0F, 0x04, 0x62, 0x08,
  0x82, 0x60, 0x98, 0x24, 0x09, 0x02, 0x41, 0x90, 0x44, 0x13, 0x04, 0x42,
  0x0F, 0x00, 0x40, 0x18, 0x02, 0x00, 0x3F, 0x08, 0x62, 0x0C, 0x81, 0x20,
  0xD8, 0x26, 0x19, 0xF8, 0x44, 0x11, 0x84, 0x21, 0x08, 0xC3, 0x20, 0x40,
  0x0F, 0x04, 0x22, 0x0C, 0x83, 0x20, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x00,
  0x68, 0x1B, 0x04, 0xC3, 0x1F, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00,
  0x30, 0x48, 0x32, 0x08, 0x82, 0x20, 0x98, 0x26, 0x09, 0x06, 0x41, 0x90,
  0x44, 0x11, 0x04, 0x42, 0x0F, 0x00, 0x81, 0xC0, 0xA0, 0xD0, 0x48, 0x64,
  0x22, 0x11, 0x90, 0xC8, 0x2C, 0x14, 0x0A, 0x06, 0x03, 0x00, 0x46, 0x28,
  0xC5, 0x19, 0x25, 0x24, 0xA4, 0x95, 0x94, 0xA2, 0x94, 0x52, 0x8A, 0x61,
  0x8C, 0x31, 0x86, 0x31, 0x84, 0x00, 0x10, 0x31, 0x06, 0x08, 0x40, 0x88,
  0x0D, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0A, 0x01, 0x90, 0x11, 0x02, 0x18,
  0x60, 0x8C, 0x0C, 0xC0, 0xD0, 0x24, 0x11, 0x8C, 0x22, 0x09, 0x03, 0xC0,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x3F, 0xC0, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x3F, 0xC0, 0x1E, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x08, 0x30, 0x60, 0x89, 0xE0, 0xC1, 0x04, 0x10, 0x61, 0x82,
  0x08, 0x20, 0xC1, 0x04, 0x10, 0x60, 0x82, 0x08, 0x30, 0x3E, 0x04, 0x18,
  0x20, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x11,
  0xE0, 0x0C, 0x0C, 0x14, 0x32, 0x22, 0x42, 0x43, 0x81, 0xFF, 0xFF, 0xC0,
  0xC8, 0x80, 0x0C, 0x1D, 0xC8, 0x6C, 0x34, 0x1A, 0x09, 0x04, 0x82, 0x41,
  0x21, 0x9F, 0xC0, 0x30, 0x10, 0x08, 0x04, 0xC3, 0xB3, 0x0D, 0x82, 0x83,
  0x41, 0xA0, 0x90, 0x48, 0x2C, 0x25, 0xE0, 0x0E, 0x1F, 0x88, 0x6C, 0x14,
  0x02, 0x01, 0x00, 0x80, 0x41, 0x21, 0x8F, 0x00, 0x00, 0x40, 0x30, 0x08,
  0x32, 0x3B, 0x88, 0x66, 0x19, 0x06, 0x41, 0x10, 0x44, 0x11, 0x04, 0x43,
  0x1F, 0xC0, 0x0E, 0x1D, 0x88, 0x6C, 0x14, 0x1B, 0xFD, 0x00, 0x80, 0x41,
  0x21, 0x0F, 0x00, 0x00, 0xF8, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x0F,
  0xF8, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0xF8, 0x00, 0x0C, 0x1D, 0xC8, 0x6C, 0x34,
  0x1A, 0x09, 0x04, 0x82, 0x43, 0x3E, 0x80, 0xC0, 0x60, 0x23, 0xF0, 0x30,
  0x10, 0x08, 0x04, 0xC3, 0xB3, 0x0D, 0x82, 0x83, 0x41, 0xA0, 0x90, 0x48,
  0x2C, 0x14, 0x18, 0x02, 0x03, 0x00, 0x80, 0x00, 0x21, 0xE0, 0x10, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x00, 0x80, 0x70, 0x08,
  0x00, 0x00, 0x07, 0xE0, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x3F, 0x00, 0x30, 0x08, 0x02, 0x00, 0x81,
  0x20, 0x88, 0x46, 0x21, 0x18, 0x7C, 0x11, 0x04, 0x61, 0x08, 0xC3, 0x30,
  0x40, 0xF8, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x3F, 0x19, 0x9B, 0xA4, 0x4D, 0x12, 0x48, 0xB2, 0x28, 0x8A,
  0x22, 0x89, 0xA2, 0x49, 0x90, 0x06, 0x1D, 0x98, 0x6C, 0x14, 0x1A, 0x0D,
  0x04, 0x82, 0x41, 0x60, 0xA0, 0xC0, 0x0E, 0x1D, 0x88, 0x6C, 0x14, 0x1A,
  0x0D, 0x04, 0x82, 0x41, 0x21, 0x0F, 0x00, 0x06, 0x1D, 0x98, 0x6C, 0x14,
  0x1A, 0x0D, 0x04, 0x82, 0x41, 0x61, 0x2F, 0x10, 0x08, 0x04, 0x00, 0x0C,
  0x1D, 0xC8, 0x6C, 0x34, 0x1A, 0x09, 0x04, 0x82, 0x41, 0x21, 0x9F, 0xC0,
  0x60, 0x20, 0x10, 0x06, 0x15, 0xCC, 0x24, 0x16, 0x0B, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x30, 0x00, 0x0E, 0x1D, 0xC8, 0x2C, 0x06, 0x01, 0xF0, 0x0C,
  0x02, 0xC1, 0x61, 0x9F, 0x80, 0x18, 0x08, 0x04, 0x3F, 0xE1, 0x00, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x03, 0xE0, 0x20, 0xB0, 0x58, 0x28,
  0x34, 0x1A, 0x09, 0x04, 0x82, 0x42, 0x1E, 0x00, 0xC1, 0xE0, 0x90, 0x88,
  0x44, 0x42, 0x21, 0xA0, 0x50, 0x30, 0x18, 0x00, 0x88, 0xCC, 0x66, 0x55,
  0x2A, 0x95, 0x53, 0x29, 0x94, 0xCC, 0x46, 0x00, 0x30, 0xE3, 0x10, 0x24,
  0x07, 0x00, 0x60, 0x1C, 0x06, 0x80, 0x88, 0x21, 0x98, 0x10, 0x20, 0xB0,
  0x50, 0x68, 0x34, 0x12, 0x09, 0x04, 0x86, 0x7D, 0x01, 0x80, 0x80, 0x47,
  0xC0, 0x3F, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F,
  0x80, 0x01, 0x83, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x18, 0x78,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x0F, 0x00, 0x11, 0x32,
  0x22, 0x22, 0x66, 0x44, 0x44, 0xCC, 0x88, 0x38, 0x06, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x0C, 0x07, 0xC2, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x70, 0x00, 0x10, 0xBC, 0x53, 0x38, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 14, 11, 4, -14 },
  { 8, 6, 6, 11, 4, -14 },
  { 13, 11, 14, 11, 0, -14 },
  { 33, 10, 20, 11, 1, -17 },
  { 58, 13, 14, 11, -1, -14 },
  { 81, 10, 14, 11, 1, -14 },
  { 99, 2, 6, 11, 6, -14 },
  { 101, 8, 18, 11, 3, -16 },
  { 119, 8, 18, 11, 1, -16 },
  { 137, 10, 10, 11, 1, -12 },
  { 150, 9, 9, 11, 1, -11 },
  { 161, 5, 6, 11, 2, -3 },
  { 165, 6, 1, 11, 3, -7 },
  { 166, 4, 3, 11, 3, -3 },
  { 168, 11, 18, 11, 0, -16 },
  { 193, 10, 14, 11, 1, -14 },
  { 211, 8, 14, 11, 1, -14 },
  { 225, 10, 14, 11, 1, -14 },
  { 243, 10, 14, 11, 1, -14 },
  { 261, 9, 14, 11, 1, -14 },
  { 277, 10, 14, 11, 1, -14 },
  { 295, 9, 14, 11, 1, -14 },
  { 311, 9, 14, 11, 2, -14 },
  { 327, 10, 14, 11, 1, -14 },
  { 345, 9, 14, 11, 2, -14 },
  { 361, 5, 11, 11, 3, -11 },
  { 368, 6, 14, 11, 2, -11 },
  { 379, 9, 10, 11, 2, -11 },
  { 391, 9, 5, 11, 1, -9 },
  { 397, 9, 10, 11, 1, -11 },
  { 409, 7, 14, 11, 3, -14 },
  { 422, 11, 17, 11, 0, -14 },
  { 446, 9, 14, 11, 0, -14 },
  { 462, 10, 14, 11, 1, -14 },
  { 480, 10, 14, 11, 1, -14 },
  { 498, 9, 14, 11, 1, -14 },
  { 514, 10, 14, 11, 1, -14 },
  { 532, 10, 14, 11, 1, -14 },
  { 550, 10, 14, 11, 1, -14 },
  { 568, 10, 14, 11, 1, -14 },
  { 586, 10, 14, 11, 1, -14 },
  { 604, 10, 14, 11, 1, -14 },
  { 622, 11, 14, 11, 1, -14 },
  { 642, 8, 14, 11, 1, -14 },
  { 656, 10, 14, 11, 1, -14 },
  { 674, 10, 14, 11, 1, -14 },
  { 692, 10, 14, 11, 1, -14 },
  { 710, 10, 14, 11, 1, -14 },
  { 728, 10, 17, 11, 1, -14 },
  { 750, 10, 14, 11, 1, -14 },
  { 768, 10, 14, 11, 1, -14 },
  { 786, 10, 14, 11, 2, -14 },
  { 804, 10, 14, 11, 1, -14 },
  { 822, 9, 14, 11, 3, -14 },
  { 838, 11, 14, 11, 1, -14 },
  { 858, 12, 14, 11, 0, -14 },
  { 879, 10, 14, 11, 2, -14 },
  { 897, 10, 14, 11, 1, -14 },
  { 915, 7, 18, 11, 3, -16 },
  { 931, 6, 18, 11, 3, -16 },
  { 945, 7, 18, 11, 2, -16 },
  { 961, 8, 8, 11, 2, -14 },
  { 969, 9, 2, 11, 0, 0 },
  { 972, 3, 3, 11, 5, -15 },
  { 974, 9, 11, 11, 1, -11 },
  { 987, 9, 14, 11, 1, -14 },
  { 1003, 9, 11, 11, 1, -11 },
  { 1016, 10, 14, 11, 1, -14 },
  { 1034, 9, 11, 11, 1, -11 },
  { 1047, 13, 17, 11, -1, -14 },
  { 1075, 9, 14, 11, 1, -11 },
  { 1091, 9, 14, 11, 1, -14 },
  { 1107, 9, 15, 11, 1, -15 },
  { 1124, 10, 18, 11, 0, -15 },
  { 1147, 10, 14, 11, 1, -14 },
  { 1165, 8, 14, 11, 2, -14 },
  { 1179, 10, 11, 11, 1, -11 },
  { 1193, 9, 11, 11, 1, -11 },
  { 1206, 9, 11, 11, 1, -11 },
  { 1219, 9, 14, 11, 1, -11 },
  { 1235, 9, 14, 11, 1, -11 },
  { 1251, 9, 11, 11, 1, -11 },
  { 1264, 9, 11, 11, 1, -11 },
  { 1277, 9, 13, 11, 2, -13 },
  { 1292, 9, 10, 11, 1, -10 },
  { 1304, 9, 10, 11, 2, -10 },
  { 1316, 9, 10, 11, 2, -10 },
  { 1328, 11, 10, 11, 0, -10 },
  { 1342, 9, 13, 11, 1, -10 },
  { 1357, 9, 10, 11, 1, -10 },
  { 1369, 9, 18, 11, 2, -16 },
  { 1390, 4, 18, 11, 4, -16 },
  { 1399, 9, 18, 11, 1, -16 },
  { 1420, 9, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC19PT7B_H_
