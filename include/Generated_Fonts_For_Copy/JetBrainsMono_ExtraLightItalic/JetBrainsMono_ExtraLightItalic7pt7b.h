#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC7PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x80, 0xB4, 0x37, 0x6F, 0xA0, 0x27, 0x62, 0x3E, 0x40, 0xFD,
  0x18, 0xEB, 0x00, 0x74, 0xDA, 0xF0, 0xC0, 0x2A, 0x49, 0x10, 0x44, 0x92,
  0x70, 0x2F, 0x60, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x11, 0x22, 0x44, 0x80,
  0x75, 0xB9, 0xE0, 0x62, 0x22, 0xF0, 0x71, 0x24, 0xE0, 0x72, 0x11, 0xE0,
  0x6A, 0xE4, 0x76, 0x51, 0xE0, 0x24, 0x79, 0xE0, 0xE5, 0x28, 0x75, 0x69,
  0xE0, 0xF6, 0xA8, 0x42, 0x42, 0x80, 0x71, 0x00, 0xFC, 0x43, 0xE0, 0x65,
  0x48, 0x79, 0xBD, 0xBC, 0x2D, 0xBA, 0x75, 0x69, 0xE0, 0xF2, 0x5C, 0x75,
  0x59, 0xE0, 0x74, 0x78, 0xE0, 0x74, 0x78, 0x80, 0xF3, 0xDC, 0x55, 0x79,
  0x90, 0x72, 0x22, 0xE0, 0x31, 0x11, 0xE0, 0x56, 0x6A, 0x90, 0xAA, 0xC0,
  0x55, 0xB9, 0x90, 0x55, 0x5A, 0xA0, 0xF6, 0xDC, 0x75, 0x68, 0x80, 0x75,
  0x99, 0xE2, 0x75, 0x6A, 0xA0, 0x74, 0x21, 0xE0, 0xE9, 0x28, 0xB6, 0xDC,
  0xB7, 0x68, 0xFF, 0xEC, 0x56, 0x26, 0x90, 0xB5, 0x28, 0x72, 0x24, 0xE0,
  0x6A, 0x49, 0x30, 0xA9, 0x54, 0x55, 0x58, 0x56, 0x80, 0xE0, 0x80, 0x75,
  0x9E, 0x46, 0x59, 0xE0, 0xF2, 0x60, 0x17, 0x59, 0xE0, 0xF7, 0x60, 0x33,
  0x44, 0x4C, 0xF6, 0xFC, 0x47, 0x59, 0x90, 0x26, 0x22, 0xF0, 0x16, 0x22,
  0x2E, 0x45, 0x6A, 0xA0, 0xD2, 0x4E, 0xFB, 0xBD, 0x75, 0x99, 0xD6, 0xE0,
  0x75, 0x9E, 0x80, 0x79, 0x9E, 0x20, 0xF6, 0x40, 0x74, 0x3E, 0x5E, 0x4C,
  0xB6, 0xE0, 0xB7, 0x40, 0xFF, 0x60, 0x52, 0x6A, 0xB6, 0xEC, 0x72, 0x4E,
  0x29, 0x44, 0x90, 0x55, 0x68, 0x42, 0x23, 0x44, 0x80, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 7, 4, 1, -6 },
  { 22, 3, 7, 4, 0, -6 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 3, 3, 4, 1, -4 },
  { 29, 1, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 1, 1, 4, 1, -1 },
  { 32, 4, 7, 4, 0, -6 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 3, 5, 4, 1, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 3, 5, 4, 1, -5 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 5, 4, 1, -4 },
  { 66, 3, 3, 4, 1, -4 },
  { 68, 3, 2, 4, 1, -3 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 3, 5, 4, 1, -5 },
  { 73, 4, 6, 4, 0, -5 },
  { 76, 3, 5, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 3, 5, 4, 1, -5 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 2, 5, 4, 1, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 3, 5, 4, 1, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 6, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 3, 5, 4, 1, -5 },
  { 132, 3, 5, 4, 1, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 3, 5, 4, 1, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 3, 7, 4, 1, -6 },
  { 147, 2, 7, 4, 1, -6 },
  { 149, 2, 7, 4, 1, -6 },
  { 151, 3, 3, 4, 1, -5 },
  { 153, 3, 1, 4, 0, 0 },
  { 154, 1, 1, 4, 2, -6 },
  { 155, 4, 4, 4, 0, -4 },
  { 157, 4, 5, 4, 0, -5 },
  { 160, 3, 4, 4, 1, -4 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 3, 4, 4, 1, -4 },
  { 167, 4, 6, 4, 0, -5 },
  { 170, 3, 5, 4, 1, -4 },
  { 172, 4, 5, 4, 0, -5 },
  { 175, 4, 5, 4, 0, -5 },
  { 178, 4, 6, 4, 0, -5 },
  { 181, 4, 5, 4, 0, -5 },
  { 184, 3, 5, 4, 1, -5 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 3, 4, 4, 1, -4 },
  { 192, 4, 5, 4, 0, -4 },
  { 195, 4, 5, 4, 0, -4 },
  { 198, 3, 4, 4, 1, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 3, 5, 4, 1, -5 },
  { 204, 3, 4, 4, 1, -4 },
  { 206, 3, 4, 4, 1, -4 },
  { 208, 3, 4, 4, 1, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 3, 5, 4, 1, -4 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 3, 7, 4, 1, -6 },
  { 219, 2, 7, 4, 1, -6 },
  { 221, 4, 7, 4, 0, -6 },
  { 225, 3, 1, 4, 1, -3 },
};

const GFXfont JetBrainsMono_ExtraLightItalic7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC7PT7B_H_
