#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC56PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x0F, 0xF0, 0xFE, 0x0F,
  0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x1E,
  0x7C, 0x07, 0x9F, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x03, 0x8F, 0x01,
  0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x82, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xF9, 0xCF, 0xC0, 0x1F, 0x0E, 0x1E, 0x00, 0xF0, 0x70, 0x78, 0x0F,
  0x03, 0x03, 0xC0, 0x70, 0x18, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x18, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x03,
  0xE3, 0x80, 0x00, 0x0F, 0xDC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xE7, 0xE0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x30, 0x3C, 0x00,
  0x01, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x0E, 0x01, 0x80, 0xF0, 0xF0, 0x0C, 0x07,
  0x83, 0x80, 0xE0, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x3E, 0x07,
  0xC1, 0xC3, 0xE0, 0x1F, 0x8E, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3C, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x0F, 0xFE, 0x00,
  0x0F, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x0E,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0xF0, 0x00, 0x70,
  0x0F, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x03, 0x87, 0x00, 0x00, 0x70, 0x1C, 0x38, 0x00, 0x01, 0xF1,
  0xF1, 0xE0, 0x00, 0x03, 0xFF, 0x8F, 0x00, 0x00, 0x07, 0xF8, 0x38, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0x87, 0xFE, 0x00, 0x00, 0x1C,
  0x3E, 0xFC, 0x00, 0x00, 0xE1, 0xE0, 0x70, 0x00, 0x07, 0x0F, 0x01, 0xC0,
  0x00, 0x3C, 0x38, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x1C, 0x00, 0x0F, 0x03,
  0x80, 0x70, 0x00, 0x38, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x1C,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x78, 0x03,
  0x80, 0x03, 0xFF, 0xC0, 0x1C, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x04, 0x78, 0x3C, 0x01,
  0xE3, 0xC0, 0xF0, 0x07, 0x8F, 0x01, 0xE0, 0x3C, 0x38, 0x07, 0xC1, 0xE1,
  0xE0, 0x0F, 0x07, 0x07, 0x80, 0x3E, 0x3C, 0x1E, 0x00, 0x79, 0xE0, 0x78,
  0x00, 0xFF, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0x00, 0x07, 0xE0, 0x3C, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF8, 0x0F, 0x00, 0x0F,
  0xE0, 0x3C, 0x00, 0x7B, 0xC0, 0xF8, 0x03, 0xCF, 0x01, 0xF0, 0x3E, 0x1E,
  0x07, 0xFF, 0xF0, 0x3C, 0x0F, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x01, 0xE0,
  0x04, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x9F, 0x3E, 0x7C,
  0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x20, 0x03,
  0x80, 0x0B, 0xE0, 0x1C, 0x03, 0xDF, 0xC0, 0xE0, 0xFF, 0xFF, 0x86, 0x3F,
  0xF3, 0xFF, 0x33, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0x0F, 0xE7, 0xF9, 0xFE, 0x7F, 0xBF, 0xE7, 0xF1, 0xF8,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x80, 0x78, 0xF0, 0x7C, 0x0F, 0x1E, 0x0F, 0xC1, 0xE3, 0xC1, 0xF8, 0x38,
  0x70, 0x3F, 0x0F, 0x1E, 0x07, 0xC1, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xE7, 0x80, 0x07, 0xE3, 0xC0, 0x07, 0xC1, 0xC0, 0x0F, 0xC0, 0xE0,
  0x07, 0x80, 0xF0, 0x03, 0x80, 0x78, 0x01, 0x00, 0x3C, 0x01, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xE0,
  0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0x7C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC1, 0xF8, 0x00, 0x71, 0xFF, 0xC0, 0x0E, 0x7F, 0xFC, 0x03, 0xDF,
  0xBF, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x3E, 0x07, 0x80, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0xF7, 0xFF, 0x00, 0x7B, 0xFF,
  0xE0, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x0F,
  0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0xE0,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xC0, 0x03, 0xF8, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x3F, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0x81, 0xF8, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x3F, 0x8F, 0x0E, 0x00, 0x7F, 0xEE,
  0x0E, 0x01, 0xFF, 0xEE, 0x1E, 0x01, 0xE0, 0x2E, 0x1E, 0x03, 0xC0, 0x3E,
  0x1E, 0x03, 0x80, 0x1E, 0x1C, 0x07, 0x80, 0x1E, 0x1C, 0x07, 0x80, 0x1C,
  0x1C, 0x07, 0x80, 0x1C, 0x3C, 0x07, 0x00, 0x1C, 0x3C, 0x07, 0x00, 0x1C,
  0x3C, 0x07, 0x00, 0x3C, 0x38, 0x0F, 0x00, 0x3C, 0x38, 0x0F, 0x00, 0x3C,
  0x38, 0x0F, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x38, 0x78, 0x0E, 0x00, 0x78,
  0x78, 0x0E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0x70, 0x0F, 0x00, 0xF8,
  0x70, 0x0F, 0x83, 0xF0, 0x70, 0x07, 0xFF, 0x70, 0xF0, 0x03, 0xFE, 0x70,
  0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x3C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x00, 0x70,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1C, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3C, 0x07, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0x80, 0x01, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x7E,
  0x07, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3C, 0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0,
  0x78, 0x01, 0xF8, 0x07, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x3E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0xF8, 0x3C, 0x0F, 0xFF,
  0x83, 0xC0, 0xFF, 0xF8, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x1F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1D, 0xC0,
  0x07, 0xE0, 0x3B, 0x80, 0x1F, 0xC0, 0x77, 0x00, 0x3B, 0x80, 0xEE, 0x00,
  0xF7, 0x01, 0xDC, 0x01, 0xDE, 0x07, 0x98, 0x07, 0xB8, 0x0F, 0x38, 0x0E,
  0x70, 0x1C, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x71, 0xC0, 0x71, 0xC1, 0xC7,
  0x80, 0xE3, 0x83, 0x8F, 0x01, 0xC3, 0x8E, 0x1E, 0x07, 0x87, 0x1C, 0x38,
  0x0F, 0x0E, 0x70, 0x70, 0x1E, 0x1C, 0xE1, 0xE0, 0x3C, 0x3B, 0x83, 0xC0,
  0x70, 0x37, 0x07, 0x80, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x1C, 0x07,
  0x81, 0xE0, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0xFC, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0xE0, 0x3F, 0x80, 0x07, 0x01, 0xDC, 0x00, 0x78, 0x0E,
  0xE0, 0x03, 0xC0, 0x77, 0x00, 0x1E, 0x07, 0xBC, 0x00, 0xF0, 0x3C, 0xE0,
  0x07, 0x01, 0xE7, 0x00, 0x38, 0x0E, 0x38, 0x01, 0xC0, 0x71, 0xC0, 0x1E,
  0x03, 0x8F, 0x00, 0xF0, 0x3C, 0x38, 0x07, 0x81, 0xE1, 0xC0, 0x38, 0x0F,
  0x0E, 0x01, 0xC0, 0x78, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x1C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x0E,
  0x03, 0xC0, 0x70, 0x70, 0x1C, 0x03, 0x87, 0x80, 0xE0, 0x1C, 0x3C, 0x07,
  0x00, 0xF1, 0xE0, 0x78, 0x03, 0x8F, 0x03, 0xC0, 0x1C, 0x70, 0x1E, 0x00,
  0xE3, 0x80, 0xF0, 0x07, 0x1C, 0x07, 0x00, 0x3D, 0xE0, 0x38, 0x00, 0xEF,
  0x03, 0xC0, 0x07, 0x78, 0x1E, 0x00, 0x3B, 0x80, 0xF0, 0x01, 0xFC, 0x07,
  0x80, 0x0F, 0xE0, 0x38, 0x00, 0x3F, 0x01, 0xC0, 0x01, 0xF8, 0x1E, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xC0, 0x01, 0xF0, 0x0F,
  0x00, 0x03, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3E, 0x03, 0x80, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x7F, 0xC0, 0x3C, 0x00,
  0x3F, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x03, 0xF0, 0x1C, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x7C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x38,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0xF0,
  0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x38, 0x03, 0xE0, 0x0E, 0x38, 0x03,
  0xE0, 0x0E, 0x38, 0x03, 0xE0, 0x1E, 0x38, 0x07, 0xE0, 0x1E, 0x38, 0x07,
  0xE0, 0x1C, 0x38, 0x06, 0xE0, 0x1C, 0x38, 0x06, 0xE0, 0x3C, 0x38, 0x0E,
  0xE0, 0x38, 0x38, 0x0E, 0xE0, 0x38, 0x38, 0x0C, 0xE0, 0x78, 0x78, 0x1C,
  0xE0, 0x78, 0x78, 0x1C, 0xE0, 0x70, 0x78, 0x18, 0xE0, 0x70, 0x78, 0x18,
  0xE0, 0xF0, 0x78, 0x38, 0xE0, 0xE0, 0x78, 0x38, 0xE0, 0xE0, 0x78, 0x30,
  0xE0, 0xE0, 0x78, 0x70, 0xC1, 0xE0, 0x70, 0x70, 0xC1, 0xC0, 0x70, 0x60,
  0xC1, 0xC0, 0x70, 0xE0, 0xC3, 0xC0, 0x70, 0xE0, 0xC3, 0x80, 0x70, 0xC0,
  0xC3, 0x80, 0x70, 0xC0, 0xC3, 0x80, 0x71, 0xC0, 0xC7, 0x80, 0x71, 0xC0,
  0xC7, 0x00, 0x71, 0x80, 0xC7, 0x00, 0x73, 0x80, 0xC7, 0x00, 0x73, 0x80,
  0xCE, 0x00, 0x73, 0x00, 0xCE, 0x00, 0x77, 0x00, 0xCE, 0x00, 0x77, 0x00,
  0xDE, 0x00, 0x76, 0x00, 0xDC, 0x00, 0x76, 0x01, 0xDC, 0x00, 0x7E, 0x01,
  0xDC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x70, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x38, 0xF0, 0x00, 0xF0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0xC0, 0x1E,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x00,
  0xE7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x00, 0x3F, 0xC1, 0xC0, 0x3F, 0xFC,
  0xF0, 0x1F, 0xFF, 0xBC, 0x0F, 0x80, 0xEF, 0x07, 0x80, 0x1F, 0xC3, 0xC0,
  0x03, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF8,
  0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x07,
  0xF0, 0x3F, 0xFF, 0xBC, 0x07, 0xFF, 0xCF, 0x00, 0xFF, 0xC3, 0xC0, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x1F, 0xF0, 0x03, 0xCF, 0xFF, 0x00, 0x73, 0xFF, 0xF0, 0x0E, 0xE0,
  0x3F, 0x03, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xC0, 0xFE, 0x01, 0xF0, 0x1C, 0xFF,
  0xFC, 0x03, 0x9F, 0xFF, 0x00, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC7,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xC1, 0xC0, 0x0F,
  0xFF, 0x3C, 0x01, 0xFF, 0xFB, 0xC0, 0x3E, 0x03, 0xBC, 0x07, 0x80, 0x1F,
  0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xBC,
  0x01, 0xFF, 0xF3, 0xC0, 0x0F, 0xFC, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7C, 0x07, 0xE0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x07,
  0xC0, 0x3E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xC0, 0x3F, 0xFC, 0xF0,
  0x1F, 0xFF, 0xBC, 0x0F, 0x80, 0xEF, 0x07, 0x80, 0x1F, 0xC3, 0xC0, 0x03,
  0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0xDC, 0x0F, 0xE1, 0xF7, 0x01, 0xFF, 0xFB, 0xC0, 0x3F, 0xF8, 0xF0,
  0x01, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xF0, 0x03, 0xCF, 0xFF, 0x00,
  0x7B, 0xFF, 0xF0, 0x0E, 0xE0, 0x3F, 0x03, 0xF8, 0x01, 0xE0, 0x7E, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xE0, 0x0F, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFE, 0x00, 0x40, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x0F, 0x3F, 0x07, 0xE0, 0x7B, 0xFC, 0x7F, 0x83, 0xBF, 0xF7,
  0xFC, 0x1D, 0x07, 0xE0, 0xF0, 0xF0, 0x3E, 0x07, 0x87, 0x00, 0xE0, 0x3C,
  0x38, 0x07, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x1E, 0x03, 0xC0, 0x78, 0xF0,
  0x1C, 0x03, 0x87, 0x00, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38,
  0x0F, 0x1E, 0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x03, 0xC7, 0x80, 0xE0, 0x1C,
  0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x78, 0xF0,
  0x0E, 0x03, 0xC7, 0x80, 0xF0, 0x1E, 0x3C, 0x07, 0x00, 0xE1, 0xE0, 0x38,
  0x07, 0x0E, 0x01, 0xC0, 0x38, 0x70, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x1E,
  0x3C, 0x07, 0x80, 0xF1, 0xE0, 0x3C, 0x07, 0x8F, 0x01, 0xC0, 0x38, 0x70,
  0x0E, 0x01, 0xC3, 0x80, 0x70, 0x0E, 0x00, 0x07, 0x87, 0xFC, 0x00, 0xF3,
  0xFF, 0xC0, 0x1E, 0xFF, 0xFC, 0x03, 0xB8, 0x0F, 0xC0, 0xF6, 0x00, 0x78,
  0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC3, 0xFE, 0x00,
  0x3C, 0xFF, 0xF0, 0x03, 0xDF, 0xFF, 0x80, 0x3B, 0x80, 0xFC, 0x07, 0xF0,
  0x03, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xF8, 0x07, 0xC0, 0x39, 0xFF,
  0xF8, 0x03, 0x9F, 0xFF, 0x00, 0x78, 0x7F, 0xC0, 0x07, 0x80, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xC0,
  0x3F, 0xFC, 0xF0, 0x3F, 0xFF, 0xBC, 0x0F, 0x80, 0xEF, 0x07, 0x80, 0x1F,
  0xC3, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00,
  0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC0,
  0xF8, 0x07, 0xF0, 0x3F, 0xFF, 0xBC, 0x07, 0xFF, 0xCF, 0x00, 0xFF, 0xC3,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87,
  0xFC, 0x00, 0xF3, 0xFF, 0xC0, 0x1C, 0xFF, 0xFC, 0x03, 0xB8, 0x0F, 0xC0,
  0xFE, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x07, 0x83,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x01, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC1, 0xF0,
  0x03, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0x87, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0F,
  0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x78, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x7F, 0x00, 0x78, 0x03, 0xB8, 0x03, 0xC0, 0x3D, 0xC0, 0x3E,
  0x01, 0xCE, 0x01, 0xB0, 0x0E, 0x70, 0x1D, 0x80, 0x73, 0x80, 0xEC, 0x07,
  0x9C, 0x06, 0x60, 0x38, 0xE0, 0x73, 0x01, 0xC7, 0x03, 0x98, 0x1E, 0x38,
  0x18, 0xC0, 0xE1, 0xC1, 0xC6, 0x07, 0x0E, 0x0E, 0x30, 0x78, 0x70, 0x61,
  0x83, 0x83, 0x87, 0x0C, 0x1C, 0x1C, 0x38, 0x61, 0xE0, 0xE1, 0x83, 0x0E,
  0x07, 0x1C, 0x18, 0x70, 0x38, 0xE0, 0xC7, 0x81, 0xC6, 0x06, 0x38, 0x0E,
  0x70, 0x31, 0xC0, 0x73, 0x81, 0x9E, 0x03, 0x98, 0x0C, 0xE0, 0x1D, 0xC0,
  0x77, 0x00, 0xEE, 0x03, 0xB8, 0x07, 0x60, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8,
  0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00,
  0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0x70, 0x3E,
  0x01, 0xDC, 0x0F, 0xE3, 0xEF, 0x01, 0xFF, 0xF3, 0xC0, 0x3F, 0xF8, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xE1, 0xFF, 0x00, 0x3C, 0xFF, 0xF0, 0x07,
  0x1E, 0x1E, 0x00, 0xE7, 0x81, 0xE0, 0x1C, 0xE0, 0x1E, 0x07, 0x9C, 0x03,
  0xE0, 0xE3, 0x80, 0x3F, 0x7C, 0xF0, 0x03, 0xFF, 0x1E, 0x00, 0x3F, 0xC3,
  0xC0, 0x01, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 12, 41, 34, 11, -41 },
  { 63, 18, 17, 34, 11, -41 },
  { 102, 33, 41, 34, 1, -41 },
  { 272, 29, 57, 34, 3, -49 },
  { 479, 38, 41, 34, -1, -41 },
  { 674, 30, 42, 34, 2, -41 },
  { 832, 7, 17, 34, 16, -41 },
  { 847, 22, 54, 34, 10, -47 },
  { 996, 22, 54, 34, 3, -47 },
  { 1145, 29, 28, 34, 3, -34 },
  { 1247, 26, 27, 34, 4, -32 },
  { 1335, 13, 17, 34, 6, -8 },
  { 1363, 18, 3, 34, 8, -20 },
  { 1370, 10, 9, 34, 10, -8 },
  { 1382, 33, 52, 34, 1, -46 },
  { 1597, 27, 42, 34, 4, -41 },
  { 1739, 25, 41, 34, 3, -41 },
  { 1868, 28, 41, 34, 3, -41 },
  { 2012, 28, 42, 34, 3, -41 },
  { 2159, 26, 41, 34, 4, -41 },
  { 2293, 27, 42, 34, 4, -41 },
  { 2435, 26, 42, 34, 3, -41 },
  { 2572, 27, 41, 34, 7, -41 },
  { 2711, 28, 42, 34, 3, -41 },
  { 2858, 26, 41, 34, 6, -41 },
  { 2992, 13, 32, 34, 10, -31 },
  { 3044, 17, 40, 34, 6, -31 },
  { 3129, 26, 29, 34, 5, -33 },
  { 3224, 26, 17, 34, 4, -27 },
  { 3280, 26, 29, 34, 3, -33 },
  { 3375, 22, 41, 34, 9, -41 },
  { 3488, 32, 51, 34, 1, -41 },
  { 3692, 27, 41, 34, 1, -41 },
  { 3831, 28, 41, 34, 3, -41 },
  { 3975, 28, 42, 34, 4, -41 },
  { 4122, 28, 41, 34, 3, -41 },
  { 4266, 29, 41, 34, 4, -41 },
  { 4415, 29, 41, 34, 4, -41 },
  { 4564, 28, 42, 34, 4, -41 },
  { 4711, 29, 41, 34, 3, -41 },
  { 4860, 27, 41, 34, 4, -41 },
  { 4999, 29, 42, 34, 2, -41 },
  { 5152, 31, 41, 34, 3, -41 },
  { 5311, 24, 41, 34, 4, -41 },
  { 5434, 31, 41, 34, 2, -41 },
  { 5593, 29, 41, 34, 3, -41 },
  { 5742, 27, 42, 34, 4, -41 },
  { 5884, 30, 41, 34, 3, -41 },
  { 6038, 27, 51, 34, 4, -41 },
  { 6211, 29, 41, 34, 3, -41 },
  { 6360, 29, 42, 34, 3, -41 },
  { 6513, 27, 41, 34, 7, -41 },
  { 6652, 28, 42, 34, 4, -41 },
  { 6799, 27, 41, 34, 7, -41 },
  { 6938, 32, 41, 34, 4, -41 },
  { 7102, 34, 41, 34, 0, -41 },
  { 7277, 29, 41, 34, 6, -41 },
  { 7426, 29, 41, 34, 3, -41 },
  { 7575, 21, 52, 34, 9, -46 },
  { 7712, 15, 52, 34, 10, -46 },
  { 7810, 21, 52, 34, 5, -46 },
  { 7947, 23, 22, 34, 6, -41 },
  { 8011, 28, 4, 34, 0, 1 },
  { 8025, 9, 8, 34, 15, -44 },
  { 8034, 26, 32, 34, 4, -31 },
  { 8138, 27, 42, 34, 3, -41 },
  { 8280, 26, 32, 34, 4, -31 },
  { 8384, 28, 42, 34, 4, -41 },
  { 8531, 25, 32, 34, 4, -31 },
  { 8631, 36, 51, 34, -2, -41 },
  { 8861, 26, 41, 34, 4, -31 },
  { 8995, 27, 41, 34, 3, -41 },
  { 9134, 25, 43, 34, 3, -43 },
  { 9269, 28, 53, 34, 1, -43 },
  { 9455, 29, 41, 34, 3, -41 },
  { 9604, 23, 41, 34, 6, -41 },
  { 9722, 29, 31, 34, 2, -31 },
  { 9835, 27, 31, 34, 3, -31 },
  { 9940, 25, 32, 34, 4, -31 },
  { 10040, 28, 41, 34, 2, -31 },
  { 10184, 26, 41, 34, 4, -31 },
  { 10318, 27, 31, 34, 4, -31 },
  { 10423, 26, 32, 34, 4, -31 },
  { 10527, 26, 39, 34, 5, -39 },
  { 10654, 26, 32, 34, 4, -31 },
  { 10758, 26, 31, 34, 6, -31 },
  { 10859, 29, 31, 34, 5, -31 },
  { 10972, 31, 31, 34, 1, -31 },
  { 11093, 26, 41, 34, 4, -31 },
  { 11227, 27, 31, 34, 3, -31 },
  { 11332, 27, 52, 34, 6, -46 },
  { 11508, 12, 52, 34, 12, -46 },
  { 11586, 27, 52, 34, 2, -46 },
  { 11762, 27, 11, 34, 4, -25 },
};

const GFXfont JetBrainsMono_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC56PT7B_H_
