#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC8PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xFC, 0x29, 0x96, 0xAE, 0x50, 0x11, 0x9A, 0xC3, 0x59, 0x44,
  0x6D, 0x98, 0x66, 0xD8, 0x32, 0x11, 0x79, 0x78, 0xE0, 0x34, 0x44, 0x88,
  0x84, 0x42, 0x11, 0x22, 0x2C, 0x27, 0xC8, 0xA0, 0x4B, 0xA0, 0xE0, 0xE0,
  0x40, 0x08, 0x84, 0x42, 0x21, 0x10, 0x69, 0x9E, 0xAE, 0x35, 0x22, 0x2F,
  0x32, 0x44, 0x64, 0x78, 0x71, 0x21, 0x96, 0x29, 0x5E, 0x40, 0xF3, 0x93,
  0xC0, 0x12, 0x65, 0x97, 0xFA, 0x24, 0x48, 0x35, 0x75, 0x97, 0x69, 0x9E,
  0x48, 0x41, 0x43, 0x80, 0x2A, 0x30, 0xE3, 0x80, 0x42, 0x1E, 0x64, 0xA1,
  0x00, 0x32, 0x6F, 0x5A, 0xDB, 0x80, 0x22, 0x55, 0x79, 0x75, 0x75, 0x9F,
  0x69, 0x88, 0xAE, 0x75, 0x55, 0x9E, 0xF8, 0xE8, 0x8E, 0x7A, 0x10, 0xE8,
  0x40, 0x69, 0x8E, 0xAE, 0x4A, 0x5C, 0xA9, 0x48, 0xE9, 0x25, 0xC0, 0x31,
  0x11, 0x9E, 0x4A, 0x94, 0xC9, 0x48, 0x92, 0x49, 0xC0, 0x4A, 0x9B, 0x29,
  0x48, 0x4A, 0x5C, 0xE9, 0x48, 0x76, 0xDB, 0xC0, 0x72, 0x52, 0xE8, 0x40,
  0x76, 0xDB, 0x58, 0x72, 0x54, 0xC9, 0x48, 0x32, 0x50, 0x69, 0x38, 0xF4,
  0x44, 0x44, 0x99, 0xAA, 0xAE, 0x99, 0xAA, 0xC4, 0xDD, 0xAA, 0xAA, 0x4A,
  0x88, 0x45, 0x48, 0x9A, 0xA4, 0x44, 0x78, 0x88, 0x44, 0x78, 0x69, 0x25,
  0x26, 0x91, 0x24, 0x89, 0x64, 0x94, 0x96, 0x4E, 0x80, 0xF0, 0x80, 0xF6,
  0xF0, 0x46, 0x55, 0x9F, 0xF2, 0x70, 0x15, 0xAA, 0xAE, 0xFE, 0x70, 0x19,
  0x1E, 0x44, 0x23, 0x00, 0xF6, 0xFE, 0x46, 0x55, 0x99, 0x14, 0x22, 0x2F,
  0x16, 0x11, 0x12, 0xE0, 0x42, 0x54, 0xCA, 0x48, 0xC9, 0x28, 0xC0, 0x7B,
  0xBB, 0x75, 0x99, 0xF6, 0xF0, 0x75, 0x97, 0x80, 0xF6, 0xF2, 0xF2, 0x40,
  0xF8, 0xF0, 0x5D, 0x28, 0xC0, 0xB6, 0xF0, 0xBA, 0xC4, 0xDE, 0xAA, 0x59,
  0x19, 0x20, 0xB6, 0xFE, 0x72, 0x4F, 0x12, 0x24, 0xC4, 0x46, 0xFF, 0x62,
  0x22, 0x32, 0x4C, 0xBC,
};

const GFXglyph JetBrainsMono_ExtraLightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 3, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 8, 5, 0, -7 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 3, 5, 2, -6 },
  { 21, 4, 8, 5, 1, -7 },
  { 25, 4, 8, 5, 0, -7 },
  { 29, 5, 4, 5, 0, -5 },
  { 32, 3, 4, 5, 1, -5 },
  { 34, 2, 2, 5, 1, -1 },
  { 35, 3, 1, 5, 1, -3 },
  { 36, 2, 1, 5, 1, -1 },
  { 37, 5, 8, 5, 0, -7 },
  { 42, 4, 6, 5, 1, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 3, 6, 5, 1, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 4, 6, 5, 0, -6 },
  { 70, 4, 6, 5, 1, -6 },
  { 73, 2, 4, 5, 1, -4 },
  { 74, 2, 5, 5, 1, -4 },
  { 76, 3, 4, 5, 1, -5 },
  { 78, 3, 3, 5, 1, -4 },
  { 80, 4, 4, 5, 0, -5 },
  { 82, 3, 6, 5, 1, -6 },
  { 85, 5, 7, 5, 0, -6 },
  { 90, 4, 6, 5, 0, -6 },
  { 93, 4, 6, 5, 0, -6 },
  { 96, 4, 6, 5, 1, -6 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 3, 6, 5, 1, -6 },
  { 119, 4, 6, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 5, 6, 5, 0, -6 },
  { 144, 3, 7, 5, 1, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 5, 6, 5, 0, -6 },
  { 155, 4, 6, 5, 1, -6 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 4, 6, 5, 1, -6 },
  { 167, 5, 6, 5, 0, -6 },
  { 171, 4, 6, 5, 1, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 3, 8, 5, 1, -7 },
  { 181, 3, 8, 5, 1, -7 },
  { 184, 3, 8, 5, 1, -7 },
  { 187, 3, 3, 5, 1, -6 },
  { 189, 4, 1, 5, 0, 0 },
  { 190, 1, 1, 5, 2, -6 },
  { 191, 3, 4, 5, 1, -4 },
  { 193, 4, 6, 5, 0, -6 },
  { 196, 3, 4, 5, 1, -4 },
  { 198, 4, 6, 5, 1, -6 },
  { 201, 3, 4, 5, 1, -4 },
  { 203, 5, 7, 5, 0, -6 },
  { 208, 3, 5, 5, 1, -4 },
  { 210, 4, 6, 5, 0, -6 },
  { 213, 4, 6, 5, 0, -6 },
  { 216, 4, 7, 5, 0, -6 },
  { 220, 5, 6, 5, 0, -6 },
  { 224, 3, 6, 5, 1, -6 },
  { 227, 4, 4, 5, 0, -4 },
  { 229, 4, 4, 5, 0, -4 },
  { 231, 3, 4, 5, 1, -4 },
  { 233, 4, 5, 5, 0, -4 },
  { 236, 3, 5, 5, 1, -4 },
  { 238, 3, 4, 5, 1, -4 },
  { 240, 3, 4, 5, 1, -4 },
  { 242, 3, 6, 5, 1, -6 },
  { 245, 3, 4, 5, 1, -4 },
  { 247, 4, 4, 5, 1, -4 },
  { 249, 4, 4, 5, 1, -4 },
  { 251, 5, 4, 5, 0, -4 },
  { 254, 3, 5, 5, 1, -4 },
  { 256, 4, 4, 5, 0, -4 },
  { 258, 4, 8, 5, 1, -7 },
  { 262, 1, 8, 5, 2, -7 },
  { 263, 4, 8, 5, 0, -7 },
  { 267, 3, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_ExtraLightItalic8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC8PT7B_H_
