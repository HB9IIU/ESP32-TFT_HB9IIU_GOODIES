#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC11PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x86, 0x9A, 0xA0, 0x14, 0x29, 0xF9, 0x44, 0x9F, 0x94,
  0x48, 0x10, 0x9E, 0xDA, 0x30, 0xC5, 0xAF, 0x90, 0x80, 0x72, 0xA9, 0x63,
  0x81, 0xC6, 0x95, 0x4E, 0x38, 0x92, 0x08, 0x56, 0x68, 0x9D, 0xE8, 0x34,
  0x48, 0x88, 0x88, 0x86, 0x61, 0x11, 0x11, 0x22, 0x2C, 0x21, 0x3E, 0x45,
  0x48, 0x21, 0x3E, 0x42, 0x00, 0x29, 0x40, 0xE0, 0x70, 0x06, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x41, 0x80, 0x7C, 0x63, 0x5A, 0xC6, 0x5E, 0x35,
  0x12, 0x22, 0x2F, 0x7C, 0x42, 0x11, 0x13, 0x1E, 0x78, 0x88, 0x60, 0x86,
  0x5C, 0x18, 0x88, 0x98, 0xF8, 0x42, 0x7A, 0x21, 0xE0, 0x86, 0x5E, 0x11,
  0x10, 0xE8, 0xC6, 0x5E, 0x7E, 0x20, 0x84, 0x10, 0x84, 0x10, 0x7A, 0x52,
  0xE5, 0x46, 0x5E, 0x7C, 0x63, 0x17, 0x08, 0x88, 0x60, 0x05, 0x80, 0x30,
  0x00, 0x24, 0x48, 0x1B, 0x20, 0xC1, 0x00, 0xF8, 0x3E, 0xC1, 0x86, 0xC8,
  0x00, 0xE1, 0x12, 0xC8, 0x08, 0x3C, 0x85, 0x2A, 0xA5, 0x54, 0xA9, 0x4C,
  0x80, 0xE0, 0x18, 0xCA, 0x52, 0xBD, 0x31, 0x7A, 0x63, 0xE9, 0x46, 0x3E,
  0x7A, 0x61, 0x08, 0x46, 0x5E, 0x72, 0x63, 0x18, 0xC6, 0x5C, 0x7A, 0x21,
  0xF8, 0x42, 0x1E, 0x7D, 0x08, 0x3E, 0x82, 0x08, 0x20, 0x7A, 0x61, 0x0B,
  0xC6, 0x5E, 0x4A, 0x63, 0xF8, 0xC6, 0x52, 0x79, 0x08, 0x42, 0x10, 0x9E,
  0x1C, 0x10, 0x41, 0x04, 0x28, 0x9C, 0x4D, 0x29, 0x38, 0xA2, 0x49, 0x26,
  0x44, 0x48, 0x88, 0x8F, 0x25, 0xB6, 0xD5, 0x45, 0x14, 0x62, 0x4E, 0x6B,
  0x5A, 0xD6, 0x52, 0x7A, 0x63, 0x18, 0xC6, 0x5E, 0x7A, 0x63, 0x1F, 0x42,
  0x10, 0x7A, 0x63, 0x18, 0xC6, 0x5E, 0x20, 0x80, 0x7A, 0x63, 0x3E, 0x4A,
  0x52, 0x7A, 0x60, 0xC1, 0x06, 0x3E, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x10,
  0x4A, 0x63, 0x18, 0xC6, 0x5E, 0x86, 0x24, 0x94, 0x51, 0x86, 0x18, 0x96,
  0x9A, 0xB6, 0xDB, 0x49, 0x24, 0x66, 0x48, 0xA0, 0x81, 0x05, 0x12, 0x46,
  0x85, 0x25, 0x14, 0x20, 0x82, 0x10, 0x3C, 0x10, 0x84, 0x10, 0x84, 0x3E,
  0x74, 0x44, 0x88, 0x88, 0x8C, 0x92, 0x24, 0x92, 0x24, 0x31, 0x11, 0x12,
  0x22, 0x2E, 0x31, 0x95, 0x10, 0xF8, 0x90, 0x7C, 0x63, 0x19, 0x78, 0x42,
  0x1D, 0x18, 0xC6, 0x5E, 0x74, 0x61, 0x09, 0x78, 0x08, 0x5F, 0x18, 0xC6,
  0x5E, 0x74, 0x7F, 0x09, 0x78, 0x0E, 0x21, 0xF0, 0x82, 0x04, 0x08, 0x10,
  0x21, 0x80, 0x7C, 0x63, 0x19, 0x38, 0x5C, 0x42, 0x1D, 0x18, 0xC6, 0x52,
  0x08, 0x03, 0x04, 0x10, 0x41, 0x3F, 0x0C, 0x03, 0x82, 0x08, 0x20, 0x84,
  0x13, 0x80, 0x42, 0x23, 0x2E, 0x52, 0x52, 0xE1, 0x08, 0x84, 0x21, 0x0F,
  0x7D, 0x55, 0x55, 0x96, 0x90, 0x74, 0x63, 0x19, 0x48, 0x74, 0x63, 0x19,
  0x78, 0x39, 0x14, 0x51, 0x49, 0xE8, 0x20, 0x7C, 0x63, 0x19, 0x78, 0x42,
  0x7C, 0x61, 0x08, 0x40, 0x7C, 0x18, 0x20, 0xF8, 0x21, 0x3E, 0x44, 0x21,
  0x0E, 0x8C, 0x63, 0x19, 0x78, 0x8C, 0x54, 0xA6, 0x30, 0xA6, 0xAE, 0xBA,
  0x92, 0x40, 0x64, 0xA1, 0x0C, 0x4B, 0x20, 0x8C, 0x63, 0x29, 0x38, 0x5C,
  0x78, 0x88, 0x88, 0x78, 0x1C, 0x41, 0x04, 0x23, 0x82, 0x08, 0x20, 0xC0,
  0x29, 0x24, 0x92, 0x90, 0x30, 0x41, 0x04, 0x10, 0x72, 0x08, 0x23, 0x80,
  0xCD, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 5, 12, 7, 1, -10 },
  { 21, 7, 8, 7, 0, -8 },
  { 28, 6, 8, 7, 0, -8 },
  { 34, 2, 3, 7, 3, -8 },
  { 35, 4, 10, 7, 2, -9 },
  { 40, 4, 10, 7, 1, -9 },
  { 45, 5, 6, 7, 1, -7 },
  { 49, 5, 5, 7, 1, -6 },
  { 53, 3, 4, 7, 1, -2 },
  { 55, 3, 1, 7, 2, -4 },
  { 56, 2, 2, 7, 2, -2 },
  { 57, 7, 10, 7, 0, -9 },
  { 66, 5, 8, 7, 1, -8 },
  { 71, 4, 8, 7, 1, -8 },
  { 75, 5, 8, 7, 1, -8 },
  { 80, 5, 8, 7, 1, -8 },
  { 85, 5, 8, 7, 1, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 6, 8, 7, 1, -8 },
  { 106, 5, 8, 7, 1, -8 },
  { 111, 5, 8, 7, 1, -8 },
  { 116, 3, 6, 7, 2, -6 },
  { 119, 4, 8, 7, 1, -6 },
  { 123, 5, 5, 7, 1, -6 },
  { 127, 5, 3, 7, 1, -5 },
  { 129, 5, 5, 7, 1, -6 },
  { 133, 4, 8, 7, 2, -8 },
  { 137, 7, 10, 7, 0, -8 },
  { 146, 5, 8, 7, 0, -8 },
  { 151, 5, 8, 7, 1, -8 },
  { 156, 5, 8, 7, 1, -8 },
  { 161, 5, 8, 7, 1, -8 },
  { 166, 5, 8, 7, 1, -8 },
  { 171, 6, 8, 7, 1, -8 },
  { 177, 5, 8, 7, 1, -8 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 5, 8, 7, 1, -8 },
  { 192, 6, 8, 7, 0, -8 },
  { 198, 6, 8, 7, 1, -8 },
  { 204, 4, 8, 7, 1, -8 },
  { 208, 6, 8, 7, 0, -8 },
  { 214, 5, 8, 7, 1, -8 },
  { 219, 5, 8, 7, 1, -8 },
  { 224, 5, 8, 7, 1, -8 },
  { 229, 5, 10, 7, 1, -8 },
  { 236, 5, 8, 7, 1, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 6, 8, 7, 1, -8 },
  { 252, 5, 8, 7, 1, -8 },
  { 257, 6, 8, 7, 1, -8 },
  { 263, 6, 8, 7, 1, -8 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 6, 8, 7, 1, -8 },
  { 282, 6, 8, 7, 0, -8 },
  { 288, 4, 10, 7, 2, -9 },
  { 293, 3, 10, 7, 2, -9 },
  { 297, 4, 10, 7, 1, -9 },
  { 302, 5, 4, 7, 1, -8 },
  { 305, 5, 1, 7, 0, 0 },
  { 306, 2, 2, 7, 3, -9 },
  { 307, 5, 6, 7, 1, -6 },
  { 311, 5, 8, 7, 1, -8 },
  { 316, 5, 6, 7, 1, -6 },
  { 320, 5, 8, 7, 1, -8 },
  { 325, 5, 6, 7, 1, -6 },
  { 329, 7, 10, 7, 0, -8 },
  { 338, 5, 8, 7, 1, -6 },
  { 343, 5, 8, 7, 1, -8 },
  { 348, 6, 8, 7, 0, -8 },
  { 354, 6, 10, 7, 0, -8 },
  { 362, 5, 8, 7, 1, -8 },
  { 367, 5, 8, 7, 1, -8 },
  { 372, 6, 6, 7, 0, -6 },
  { 377, 5, 6, 7, 1, -6 },
  { 381, 5, 6, 7, 1, -6 },
  { 385, 6, 8, 7, 0, -6 },
  { 391, 5, 8, 7, 1, -6 },
  { 396, 5, 6, 7, 1, -6 },
  { 400, 5, 6, 7, 1, -6 },
  { 404, 5, 8, 7, 1, -8 },
  { 409, 5, 6, 7, 1, -6 },
  { 413, 5, 6, 7, 1, -6 },
  { 417, 6, 6, 7, 1, -6 },
  { 422, 6, 6, 7, 0, -6 },
  { 427, 5, 8, 7, 1, -6 },
  { 432, 5, 6, 7, 1, -6 },
  { 436, 6, 10, 7, 1, -9 },
  { 444, 3, 10, 7, 2, -9 },
  { 448, 6, 10, 7, 0, -9 },
  { 456, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC11PT7B_H_
