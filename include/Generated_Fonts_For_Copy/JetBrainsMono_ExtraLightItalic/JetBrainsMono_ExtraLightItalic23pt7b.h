#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC23PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x33, 0x33, 0x22, 0x26, 0x64, 0x00, 0x4E, 0xC0, 0x63, 0x63,
  0x62, 0x66, 0x46, 0x46, 0xC6, 0x02, 0x18, 0x30, 0x81, 0x0C, 0x08, 0x40,
  0xC2, 0x3F, 0xFC, 0x21, 0x03, 0x08, 0x10, 0xC0, 0x84, 0x0C, 0x21, 0xFF,
  0xC2, 0x10, 0x31, 0x81, 0x0C, 0x18, 0x40, 0xC6, 0x00, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x7C, 0x0D, 0x61, 0x93, 0x31, 0x33, 0x30, 0x32, 0x03, 0x20,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x64, 0x04, 0x60, 0x46, 0xC4, 0x44, 0x4C,
  0x65, 0x83, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0x03, 0x19, 0x82,
  0x10, 0x84, 0x10, 0x88, 0x11, 0x90, 0x31, 0x30, 0x1B, 0x60, 0x0E, 0xC0,
  0x00, 0x80, 0x01, 0x30, 0x02, 0x7C, 0x04, 0x84, 0x0C, 0x84, 0x18, 0x8C,
  0x10, 0x8C, 0x20, 0x88, 0xC0, 0xF0, 0x07, 0x80, 0xCC, 0x18, 0x61, 0x06,
  0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x7C, 0x04, 0x63, 0xC6, 0x6C, 0x3C,
  0xC1, 0x88, 0x18, 0x83, 0x8C, 0x6C, 0x7C, 0x60, 0x7F, 0xE8, 0x01, 0x83,
  0x83, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x06, 0x01, 0xC0, 0x20, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x08, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x03, 0x0F, 0x04, 0x00,
  0x03, 0x00, 0x30, 0x02, 0x04, 0x21, 0xF2, 0x73, 0xFC, 0x06, 0x00, 0xF0,
  0x19, 0x03, 0x18, 0x60, 0xC2, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x3F, 0xF0, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x39, 0x98, 0xCC, 0x62,
  0x00, 0xFF, 0x7F, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x00, 0x0F, 0x83, 0x38, 0xC1, 0xB0, 0x36, 0x06, 0x80,
  0xD0, 0x12, 0x22, 0xCE, 0x59, 0x9B, 0x03, 0x40, 0x68, 0x09, 0x01, 0x30,
  0x67, 0x18, 0x7E, 0x00, 0x01, 0x81, 0xE0, 0xD8, 0xC6, 0x21, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18,
  0xFF, 0xC0, 0x07, 0xC1, 0xC6, 0x10, 0x33, 0x03, 0x20, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x00, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x78, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x44,
  0x0C, 0x40, 0x86, 0x18, 0x3F, 0x00, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x43, 0x30, 0xD8, 0x2C, 0x0B, 0x02, 0xFF, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x3F, 0xE7, 0xFC, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x1B, 0xC3, 0x8C, 0x60, 0xC8, 0x18, 0x03, 0x00, 0x40, 0x09, 0x01, 0x20,
  0x66, 0x18, 0x7E, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18,
  0x06, 0x00, 0xBE, 0x38, 0xCC, 0x0D, 0x81, 0xA0, 0x34, 0x06, 0x80, 0x90,
  0x33, 0x0C, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0x60, 0x68, 0x18, 0x03,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x31, 0x03, 0x30, 0x33,
  0x02, 0x18, 0x40, 0xD8, 0x07, 0x01, 0x98, 0x20, 0xC6, 0x04, 0x40, 0x64,
  0x04, 0x40, 0xC6, 0x18, 0x3F, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0xB0, 0x34,
  0x06, 0x80, 0xD0, 0x1A, 0x06, 0x61, 0xC7, 0xF0, 0x04, 0x01, 0x80, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x00, 0x18, 0xE3, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x3C, 0xE0, 0x0C, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0x80, 0x00, 0x60, 0x38, 0x1C, 0x0E,
  0x07, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x0C, 0x0C, 0x3C, 0x38, 0x18,
  0x0C, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0xE0, 0x18, 0xE0,
  0x80, 0x86, 0x02, 0x10, 0x0C, 0xC0, 0x22, 0x1E, 0x88, 0xC6, 0x22, 0x09,
  0x88, 0x66, 0x21, 0x99, 0x86, 0x46, 0x11, 0x18, 0x44, 0x37, 0x10, 0x64,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xA0, 0x24, 0x0C, 0x81, 0x10, 0x62, 0x0C, 0x41, 0x0C, 0x61,
  0x8F, 0xF3, 0x06, 0x40, 0x58, 0x0B, 0x01, 0xC0, 0x20, 0x1F, 0x81, 0xFE,
  0x10, 0x21, 0x03, 0x30, 0x33, 0x02, 0x30, 0x62, 0x0C, 0x3F, 0x82, 0x0C,
  0x60, 0x66, 0x06, 0x60, 0x64, 0x04, 0x40, 0xC4, 0x38, 0xFF, 0x00, 0x0F,
  0x83, 0x18, 0xC1, 0x90, 0x36, 0x06, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x0D, 0x01, 0x30, 0x67, 0x18, 0x7E, 0x00, 0x1F,
  0x81, 0xFC, 0x10, 0x61, 0x02, 0x30, 0x23, 0x02, 0x30, 0x22, 0x02, 0x20,
  0x62, 0x06, 0x60, 0x66, 0x04, 0x60, 0x44, 0x0C, 0x40, 0x84, 0x30, 0xFE,
  0x00, 0x3F, 0xE7, 0xFC, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x02,
  0x7F, 0x88, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0xFF, 0xC4, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x3F, 0xE1, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x90, 0x36, 0x06,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0xFB, 0x03, 0x60, 0x68, 0x0D, 0x01,
  0x30, 0x67, 0x18, 0x7E, 0x00, 0x18, 0x11, 0x03, 0x10, 0x31, 0x03, 0x30,
  0x23, 0x02, 0x30, 0x22, 0x06, 0x3F, 0xE2, 0x06, 0x60, 0x46, 0x04, 0x60,
  0x44, 0x0C, 0x40, 0xC4, 0x0C, 0xC0, 0xC0, 0x3F, 0xE7, 0xFC, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0xC0, 0xCC, 0x0C, 0xC1, 0x86, 0x30, 0x7E, 0x00, 0x18, 0x18, 0x81,
  0x84, 0x0C, 0x20, 0xC3, 0x0C, 0x18, 0x60, 0xC6, 0x04, 0x20, 0x3F, 0x01,
  0x18, 0x18, 0x40, 0xC3, 0x06, 0x18, 0x20, 0x41, 0x03, 0x08, 0x18, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xFF, 0x80, 0x18, 0x33, 0x83,
  0x38, 0x52, 0x85, 0x2C, 0xB2, 0xCB, 0x25, 0x26, 0x52, 0x66, 0x26, 0x62,
  0x40, 0x64, 0x06, 0x40, 0x64, 0x04, 0xC0, 0x4C, 0x04, 0xC0, 0xC0, 0x18,
  0x11, 0x83, 0x1C, 0x33, 0xC3, 0x34, 0x23, 0x42, 0x24, 0x22, 0x66, 0x22,
  0x62, 0x26, 0x62, 0x46, 0x34, 0x63, 0x44, 0x14, 0x41, 0xC4, 0x1C, 0xC1,
  0xC0, 0x0F, 0x83, 0x38, 0xC1, 0x10, 0x36, 0x06, 0xC0, 0x90, 0x12, 0x02,
  0x40, 0xD8, 0x1B, 0x03, 0x60, 0x48, 0x09, 0x03, 0x30, 0x66, 0x18, 0x7E,
  0x00, 0x1F, 0xC0, 0xFF, 0x84, 0x0C, 0x20, 0x23, 0x01, 0x18, 0x08, 0xC0,
  0xC4, 0x0C, 0x3F, 0xC1, 0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0x38, 0xC1, 0x30, 0x36, 0x06,
  0xC0, 0x90, 0x12, 0x02, 0x40, 0xD8, 0x1B, 0x03, 0x60, 0x48, 0x09, 0x01,
  0x30, 0x66, 0x18, 0x7E, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x1F, 0xC1,
  0xFE, 0x10, 0x31, 0x01, 0x30, 0x13, 0x03, 0x30, 0x32, 0x06, 0x3F, 0xC3,
  0xF0, 0x63, 0x06, 0x10, 0x61, 0x84, 0x18, 0x40, 0x84, 0x0C, 0xC0, 0xC0,
  0x07, 0xC0, 0xC6, 0x18, 0x33, 0x03, 0x30, 0x03, 0x00, 0x10, 0x01, 0xC0,
  0x0F, 0x80, 0x1C, 0x00, 0x40, 0x06, 0x00, 0x6C, 0x04, 0x40, 0xC6, 0x18,
  0x3F, 0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x24, 0x0C, 0x81, 0xB0, 0x36, 0x04, 0xC0, 0x98, 0x12,
  0x06, 0x40, 0xC8, 0x1B, 0x02, 0x60, 0x4C, 0x09, 0x03, 0x30, 0x66, 0x18,
  0x7E, 0x00, 0xC0, 0x78, 0x0B, 0x01, 0x60, 0x64, 0x08, 0x83, 0x10, 0x42,
  0x18, 0x43, 0x0C, 0x41, 0x98, 0x32, 0x06, 0xC0, 0xD0, 0x0A, 0x01, 0xC0,
  0x30, 0x00, 0xC2, 0x1E, 0x30, 0xB1, 0x85, 0x8C, 0x6C, 0xE2, 0x65, 0x13,
  0x28, 0x99, 0x4C, 0x92, 0x44, 0x92, 0x24, 0xB1, 0x45, 0x0A, 0x28, 0x51,
  0x42, 0x8E, 0x18, 0x60, 0xC3, 0x00, 0x18, 0x0C, 0x20, 0x60, 0xC1, 0x03,
  0x0C, 0x04, 0x60, 0x19, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00,
  0x48, 0x03, 0x20, 0x18, 0xC0, 0x41, 0x03, 0x06, 0x18, 0x18, 0xC0, 0x30,
  0x80, 0x38, 0x0F, 0x03, 0x20, 0x46, 0x18, 0xC6, 0x08, 0x81, 0xB0, 0x3C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0xFF, 0xC0, 0x1F, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0xF8, 0xF8,
  0xC3, 0x04, 0x10, 0x61, 0x86, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x61, 0x82,
  0x08, 0x20, 0xC3, 0x04, 0x10, 0x1F, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x8F, 0xC7, 0xC0, 0x02, 0x01, 0xC0, 0xD0, 0x24, 0x19,
  0x84, 0x63, 0x09, 0x82, 0xC0, 0xC0, 0xFF, 0xE0, 0xC6, 0x30, 0x0E, 0x4E,
  0xD6, 0x0D, 0x03, 0x40, 0xF0, 0x3C, 0x0B, 0x02, 0x80, 0xA0, 0x6C, 0x1B,
  0x0E, 0x7D, 0x80, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x38, 0x7B, 0x8C,
  0x19, 0x83, 0x20, 0x64, 0x0D, 0x81, 0xB0, 0x26, 0x04, 0xC1, 0x98, 0x33,
  0x8C, 0xDF, 0x00, 0x0F, 0x0F, 0xE6, 0x0D, 0x01, 0x40, 0xB0, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x2C, 0x1B, 0x8C, 0x7E, 0x00, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0xE4, 0x76, 0x98, 0x32, 0x06, 0x40, 0xD8, 0x1B, 0x02, 0x60,
  0x48, 0x09, 0x03, 0x30, 0x66, 0x1C, 0x7D, 0x80, 0x0F, 0x0E, 0x66, 0x0D,
  0x03, 0x40, 0xF0, 0x3F, 0xFF, 0x00, 0x80, 0x20, 0x0C, 0x1B, 0x0C, 0x7E,
  0x00, 0x00, 0x3E, 0x01, 0xFC, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x07, 0xFF, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x0F, 0x80, 0x00, 0x0E, 0x4E, 0xD6, 0x0D, 0x03, 0x40, 0xF0,
  0x3C, 0x0B, 0x02, 0xC0, 0xB0, 0x66, 0x39, 0xF6, 0x01, 0x80, 0x40, 0x10,
  0x1C, 0xFC, 0x00, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x78, 0x79, 0x8C,
  0x19, 0x83, 0x20, 0x64, 0x0D, 0x81, 0xB0, 0x26, 0x04, 0x80, 0x90, 0x32,
  0x06, 0xC0, 0xC0, 0x01, 0x80, 0x70, 0x06, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x1F, 0xFC, 0x00, 0x20, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x07, 0x0F,
  0xC0, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x33, 0x06, 0x30, 0x42,
  0x0C, 0x21, 0x82, 0x30, 0x7E, 0x06, 0x30, 0x63, 0x06, 0x18, 0x41, 0x84,
  0x0C, 0xC0, 0xC0, 0x7C, 0x3F, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x60, 0x1F,
  0xC0, 0x2E, 0xE3, 0x73, 0x62, 0x36, 0x23, 0x42, 0x24, 0x62, 0x46, 0x24,
  0x42, 0xC4, 0x6C, 0x46, 0xC4, 0x48, 0xC4, 0x8C, 0x40, 0x37, 0x87, 0x98,
  0xC1, 0x98, 0x32, 0x06, 0x40, 0xD8, 0x1B, 0x02, 0x60, 0x48, 0x09, 0x03,
  0x20, 0x6C, 0x0C, 0x0F, 0x0E, 0xE6, 0x0D, 0x03, 0x40, 0xF0, 0x3C, 0x0F,
  0x02, 0x80, 0xA0, 0x6C, 0x1B, 0x0C, 0x7E, 0x00, 0x33, 0x87, 0x98, 0xC1,
  0x98, 0x32, 0x06, 0x40, 0xD8, 0x1B, 0x02, 0x60, 0x4C, 0x19, 0x83, 0x38,
  0xCD, 0xF1, 0x80, 0x30, 0x04, 0x00, 0x80, 0x00, 0x0E, 0x4E, 0xD6, 0x0D,
  0x03, 0x40, 0xF0, 0x3C, 0x0B, 0x02, 0x80, 0xA0, 0x6C, 0x1B, 0x0E, 0x7D,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x27, 0x85, 0x39, 0xC3, 0x30, 0x26,
  0x04, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00,
  0x0F, 0x83, 0x9C, 0xC1, 0x90, 0x02, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00,
  0x40, 0x09, 0x03, 0x30, 0xE3, 0xF0, 0x04, 0x01, 0x80, 0x30, 0x7F, 0xFF,
  0xFE, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x06, 0x00, 0xFC, 0x60, 0x58, 0x14, 0x05, 0x03, 0x40, 0xD0, 0x3C,
  0x0F, 0x02, 0xC0, 0xA0, 0x6C, 0x1B, 0x8C, 0x7E, 0x00, 0x80, 0xE0, 0x38,
  0x0B, 0x06, 0xC1, 0x10, 0xC4, 0x21, 0x18, 0x44, 0x1B, 0x06, 0x80, 0xE0,
  0x30, 0x00, 0x86, 0x38, 0x62, 0x8A, 0x28, 0xA6, 0x8A, 0x49, 0x24, 0x92,
  0xC9, 0x28, 0xA2, 0x8A, 0x38, 0xA3, 0x0C, 0x30, 0xC3, 0x00, 0x30, 0x33,
  0x06, 0x18, 0xC1, 0x88, 0x0D, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1B, 0x03,
  0x10, 0x21, 0x86, 0x08, 0xC0, 0xC0, 0x60, 0x58, 0x14, 0x0D, 0x03, 0x40,
  0xF0, 0x3C, 0x0B, 0x02, 0xC1, 0xB0, 0x6E, 0x39, 0xF6, 0x01, 0x00, 0x40,
  0x30, 0x18, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0F, 0xFC, 0x00, 0xF0,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0xFC, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x18, 0x84, 0x23, 0x18, 0xC4,
  0x21, 0x18, 0xC6, 0x31, 0x08, 0x46, 0x31, 0x88, 0x40, 0x1E, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x0F,
  0x83, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x0F, 0x01, 0x80, 0x00, 0x78, 0x79, 0x8A, 0x1B, 0x41, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 8, 7, 14, 4, -17 },
  { 17, 13, 17, 14, 1, -17 },
  { 45, 12, 23, 14, 1, -20 },
  { 80, 16, 17, 14, -1, -17 },
  { 114, 12, 17, 14, 1, -17 },
  { 140, 2, 7, 14, 7, -17 },
  { 142, 9, 22, 14, 4, -19 },
  { 167, 9, 22, 14, 1, -19 },
  { 192, 12, 12, 14, 1, -14 },
  { 210, 10, 11, 14, 2, -13 },
  { 224, 5, 7, 14, 3, -3 },
  { 229, 8, 1, 14, 3, -8 },
  { 230, 4, 3, 14, 4, -3 },
  { 232, 13, 22, 14, 1, -19 },
  { 268, 11, 17, 14, 2, -17 },
  { 292, 10, 17, 14, 1, -17 },
  { 314, 12, 17, 14, 1, -17 },
  { 340, 12, 17, 14, 1, -17 },
  { 366, 10, 17, 14, 2, -17 },
  { 388, 11, 17, 14, 2, -17 },
  { 412, 11, 17, 14, 1, -17 },
  { 436, 11, 17, 14, 3, -17 },
  { 460, 12, 17, 14, 1, -17 },
  { 486, 11, 17, 14, 2, -17 },
  { 510, 6, 13, 14, 4, -13 },
  { 520, 7, 17, 14, 3, -13 },
  { 535, 11, 11, 14, 2, -13 },
  { 551, 10, 7, 14, 2, -11 },
  { 560, 11, 11, 14, 1, -13 },
  { 576, 9, 17, 14, 4, -17 },
  { 596, 14, 21, 14, 0, -17 },
  { 633, 11, 17, 14, 0, -17 },
  { 657, 12, 17, 14, 1, -17 },
  { 683, 11, 17, 14, 2, -17 },
  { 707, 12, 17, 14, 1, -17 },
  { 733, 11, 17, 14, 2, -17 },
  { 757, 13, 17, 14, 1, -17 },
  { 785, 11, 17, 14, 2, -17 },
  { 809, 12, 17, 14, 1, -17 },
  { 835, 11, 17, 14, 2, -17 },
  { 859, 12, 17, 14, 1, -17 },
  { 885, 13, 17, 14, 1, -17 },
  { 913, 9, 17, 14, 2, -17 },
  { 933, 12, 17, 14, 1, -17 },
  { 959, 12, 17, 14, 1, -17 },
  { 985, 11, 17, 14, 2, -17 },
  { 1009, 13, 17, 14, 1, -17 },
  { 1037, 11, 21, 14, 2, -17 },
  { 1066, 12, 17, 14, 1, -17 },
  { 1092, 12, 17, 14, 1, -17 },
  { 1118, 11, 17, 14, 3, -17 },
  { 1142, 11, 17, 14, 2, -17 },
  { 1166, 11, 17, 14, 3, -17 },
  { 1190, 13, 17, 14, 2, -17 },
  { 1218, 14, 17, 14, 0, -17 },
  { 1248, 11, 17, 14, 3, -17 },
  { 1272, 12, 17, 14, 1, -17 },
  { 1298, 8, 22, 14, 4, -19 },
  { 1320, 6, 22, 14, 4, -19 },
  { 1337, 9, 22, 14, 2, -19 },
  { 1362, 10, 9, 14, 2, -17 },
  { 1374, 11, 1, 14, 0, 1 },
  { 1376, 4, 3, 14, 6, -18 },
  { 1378, 10, 13, 14, 2, -13 },
  { 1395, 11, 17, 14, 1, -17 },
  { 1419, 10, 13, 14, 2, -13 },
  { 1436, 11, 17, 14, 2, -17 },
  { 1460, 10, 13, 14, 2, -13 },
  { 1477, 15, 21, 14, -1, -17 },
  { 1517, 10, 17, 14, 2, -13 },
  { 1539, 11, 17, 14, 1, -17 },
  { 1563, 11, 18, 14, 1, -18 },
  { 1588, 12, 22, 14, 0, -18 },
  { 1621, 12, 17, 14, 1, -17 },
  { 1647, 10, 17, 14, 2, -17 },
  { 1669, 12, 13, 14, 1, -13 },
  { 1689, 11, 13, 14, 1, -13 },
  { 1707, 10, 13, 14, 2, -13 },
  { 1724, 11, 17, 14, 1, -13 },
  { 1748, 10, 17, 14, 2, -13 },
  { 1770, 11, 13, 14, 2, -13 },
  { 1788, 11, 13, 14, 1, -13 },
  { 1806, 11, 16, 14, 2, -16 },
  { 1828, 10, 13, 14, 2, -13 },
  { 1845, 10, 13, 14, 3, -13 },
  { 1862, 12, 13, 14, 2, -13 },
  { 1882, 12, 13, 14, 1, -13 },
  { 1902, 10, 17, 14, 2, -13 },
  { 1924, 11, 13, 14, 1, -13 },
  { 1942, 12, 22, 14, 2, -19 },
  { 1975, 5, 22, 14, 5, -19 },
  { 1989, 11, 22, 14, 1, -19 },
  { 2020, 11, 4, 14, 2, -10 },
};

const GFXfont JetBrainsMono_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC23PT7B_H_
