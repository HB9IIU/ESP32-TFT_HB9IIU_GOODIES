#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC20PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x33, 0x32, 0x22, 0x24, 0x40, 0x0E, 0xC0, 0x47, 0x3C, 0xF3,
  0x8A, 0x20, 0x02, 0x30, 0x22, 0x04, 0x20, 0x46, 0x0C, 0x43, 0xFF, 0x08,
  0xC1, 0x88, 0x10, 0x81, 0x1A, 0xFF, 0xC2, 0x10, 0x23, 0x06, 0x20, 0x46,
  0x00, 0x02, 0x00, 0x80, 0x70, 0x6F, 0x32, 0x48, 0x92, 0x40, 0x90, 0x3C,
  0x07, 0x80, 0x70, 0x16, 0x08, 0xB2, 0x2C, 0x99, 0x2C, 0x3E, 0x02, 0x01,
  0x00, 0x40, 0x0E, 0x04, 0x6C, 0x21, 0x11, 0x0C, 0x48, 0x23, 0x60, 0xC9,
  0x01, 0xC8, 0x00, 0x40, 0x02, 0x60, 0x12, 0xC0, 0x91, 0x06, 0x44, 0x11,
  0x10, 0x84, 0xCC, 0x1E, 0x00, 0x0F, 0x06, 0x63, 0x08, 0x82, 0x30, 0x0C,
  0x01, 0x01, 0xE0, 0x4C, 0xF1, 0x28, 0x72, 0x0C, 0x83, 0x33, 0x6F, 0x88,
  0x7F, 0xA0, 0x01, 0x83, 0x83, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x07, 0x00,
  0x80, 0x10, 0x1C, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x0C, 0x18, 0x30, 0xE0, 0x80, 0x06, 0x00, 0x80,
  0x10, 0x72, 0x77, 0xF8, 0x18, 0x07, 0x81, 0x90, 0x63, 0x08, 0x20, 0x06,
  0x01, 0x00, 0x40, 0x10, 0xFF, 0xC3, 0x00, 0x80, 0x20, 0x08, 0x00, 0x19,
  0x88, 0xC4, 0x60, 0xFC, 0xFF, 0x80, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x07, 0x06, 0x73,
  0x0C, 0x81, 0x20, 0x58, 0x36, 0x0D, 0x33, 0x44, 0x90, 0x24, 0x0B, 0x02,
  0xC1, 0x98, 0xC3, 0xE0, 0x03, 0x07, 0x86, 0x84, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x63, 0xFE, 0x07, 0x06, 0x73,
  0x0C, 0x81, 0x40, 0x40, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x0F, 0xF8, 0x1F, 0xCF, 0xF0, 0x08, 0x0C, 0x06, 0x03, 0x00,
  0xF0, 0x06, 0x00, 0x80, 0x20, 0x1B, 0x06, 0xC1, 0x10, 0xC7, 0xE0, 0x00,
  0xC0, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC2, 0x20, 0x90, 0x67,
  0xFB, 0xFC, 0x01, 0x00, 0x40, 0x10, 0x1F, 0xC7, 0xF3, 0x00, 0x80, 0x20,
  0x09, 0x83, 0xF8, 0x86, 0x40, 0x80, 0x20, 0x08, 0x06, 0x41, 0x10, 0xC3,
  0xE0, 0x01, 0x01, 0x81, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x63, 0x60, 0xA0,
  0x70, 0x38, 0x1C, 0x1B, 0x18, 0xF8, 0x7F, 0xDF, 0xF4, 0x09, 0x06, 0x81,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x00, 0x07, 0x06, 0x73, 0x04, 0x81, 0x20, 0xCC, 0x21, 0xB0, 0x38, 0x33,
  0x18, 0x64, 0x0B, 0x02, 0xC1, 0x90, 0xC7, 0xE0, 0x0E, 0x19, 0x98, 0x28,
  0x1C, 0x0E, 0x07, 0x06, 0x86, 0x7F, 0x03, 0x01, 0x01, 0x01, 0x81, 0x81,
  0x80, 0x77, 0x20, 0x00, 0x00, 0x4E, 0xE0, 0x1C, 0x70, 0x80, 0x00, 0x00,
  0x00, 0x18, 0xC3, 0x18, 0x43, 0x00, 0x00, 0x80, 0xC1, 0x83, 0x0E, 0x04,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x40, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x20, 0x30, 0x30,
  0x30, 0x30, 0x08, 0x00, 0x38, 0x7E, 0x03, 0x03, 0x03, 0x02, 0x06, 0x3C,
  0x30, 0x20, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xC6, 0x18, 0x33,
  0x03, 0x20, 0x12, 0x1B, 0x23, 0x66, 0x42, 0x64, 0x24, 0x42, 0x44, 0x24,
  0x46, 0x44, 0x64, 0x7C, 0x40, 0x04, 0x00, 0x60, 0x03, 0xE0, 0x0E, 0x00,
  0x01, 0x00, 0xC0, 0x38, 0x1E, 0x04, 0x83, 0x20, 0x88, 0x22, 0x10, 0x84,
  0x23, 0xF8, 0x83, 0x60, 0xD0, 0x3C, 0x04, 0x3E, 0x0F, 0xE2, 0x0C, 0x81,
  0x20, 0x48, 0x32, 0x19, 0xF8, 0x61, 0x90, 0x24, 0x09, 0x02, 0x41, 0xB0,
  0xCF, 0xE0, 0x0E, 0x19, 0xD8, 0x28, 0x14, 0x02, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x28, 0x36, 0x31, 0xF0, 0x3E, 0x0F, 0xE2, 0x0C, 0x83,
  0x20, 0xC8, 0x32, 0x0D, 0x82, 0x60, 0x90, 0x24, 0x09, 0x06, 0x41, 0x31,
  0x8F, 0xC0, 0x1F, 0xE3, 0xFC, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0xFC, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x3F, 0xE0, 0x1F,
  0xE7, 0xFC, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0xFC, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x00, 0x0E, 0x19, 0xD8, 0x28,
  0x14, 0x02, 0x03, 0x01, 0x81, 0x8F, 0x40, 0xA0, 0x50, 0x28, 0x36, 0x31,
  0xF0, 0x30, 0x4C, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x32, 0x09, 0xFE, 0x60,
  0x90, 0x24, 0x19, 0x06, 0x41, 0x30, 0x4C, 0x10, 0x1F, 0xC7, 0xF0, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x0F, 0xF0, 0x07, 0xC1, 0xF0, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x1A, 0x04, 0x81, 0x30, 0x87, 0xC0, 0x30, 0x26,
  0x08, 0x83, 0x10, 0x42, 0x18, 0x46, 0x08, 0x83, 0xF0, 0x66, 0x08, 0x41,
  0x0C, 0x21, 0x84, 0x11, 0x83, 0x30, 0x60, 0x10, 0x08, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0xFE,
  0x30, 0x66, 0x14, 0xC3, 0x1C, 0xA2, 0x94, 0xD4, 0x92, 0xB2, 0x66, 0x4C,
  0x88, 0x11, 0x02, 0x60, 0x4C, 0x09, 0x03, 0x20, 0x40, 0x30, 0x4C, 0x12,
  0x84, 0xA1, 0x28, 0xCA, 0x32, 0xC9, 0x92, 0x44, 0x91, 0x24, 0x69, 0x0E,
  0x43, 0x30, 0xCC, 0x30, 0x0E, 0x19, 0x98, 0x68, 0x14, 0x0A, 0x0F, 0x07,
  0x82, 0x81, 0x40, 0xA0, 0x50, 0x68, 0x26, 0x31, 0xF0, 0x3F, 0x07, 0xF8,
  0x81, 0x10, 0x32, 0x06, 0x40, 0x88, 0x33, 0x1C, 0x7E, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x00, 0x07, 0x06, 0x63, 0x0C, 0x81, 0x20,
  0x48, 0x36, 0x0D, 0x82, 0x40, 0x90, 0x24, 0x09, 0x06, 0x41, 0x18, 0xC3,
  0xE0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x3F, 0x07, 0xF8, 0x81, 0x10, 0x22,
  0x04, 0x40, 0x88, 0x33, 0xFC, 0x7E, 0x08, 0x41, 0x08, 0x21, 0x84, 0x31,
  0x82, 0x30, 0x60, 0x07, 0x06, 0x73, 0x04, 0x81, 0x20, 0x08, 0x03, 0x00,
  0x78, 0x03, 0x00, 0x60, 0x0B, 0x02, 0xC1, 0x90, 0xC7, 0xE0, 0x7F, 0xFF,
  0xF0, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x30, 0x4C, 0x12, 0x04, 0x81, 0x20, 0xC8,
  0x36, 0x09, 0x82, 0x40, 0x90, 0x24, 0x09, 0x06, 0x41, 0x18, 0xC3, 0xE0,
  0x80, 0xC0, 0xE0, 0x50, 0x28, 0x26, 0x13, 0x19, 0x88, 0x4C, 0x24, 0x12,
  0x0A, 0x05, 0x03, 0x81, 0x80, 0x84, 0x71, 0x8A, 0x31, 0x46, 0x29, 0x4D,
  0x29, 0x25, 0x24, 0xA4, 0xA5, 0x14, 0xA2, 0x94, 0x62, 0x8C, 0x61, 0x8C,
  0x21, 0x80, 0x10, 0x11, 0x82, 0x08, 0x60, 0x84, 0x0C, 0x80, 0x50, 0x07,
  0x00, 0x20, 0x07, 0x00, 0x90, 0x19, 0x01, 0x18, 0x20, 0x86, 0x0C, 0xC0,
  0x40, 0xC0, 0x68, 0x19, 0x02, 0x30, 0xC2, 0x30, 0x44, 0x0D, 0x80, 0xA0,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x3F, 0xCF,
  0xF0, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x2F, 0xF0, 0x1F, 0x1F, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xF8,
  0xC1, 0x04, 0x18, 0x60, 0x82, 0x08, 0x30, 0x41, 0x04, 0x18, 0x60, 0x82,
  0x08, 0x30, 0x40, 0x1E, 0x3C, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x08,
  0x10, 0x60, 0xC1, 0x02, 0x04, 0x08, 0x33, 0xE0, 0x04, 0x0C, 0x0A, 0x12,
  0x32, 0x23, 0x41, 0xC1, 0xFF, 0xFF, 0xF0, 0x99, 0x80, 0x1F, 0xCC, 0x72,
  0x09, 0x82, 0x40, 0x90, 0x24, 0x19, 0x06, 0x41, 0x18, 0xC3, 0xD0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x2F, 0x0C, 0x62, 0x09, 0x82, 0x60, 0x90, 0x24,
  0x09, 0x06, 0x41, 0x38, 0xCF, 0xE0, 0x3E, 0x31, 0x90, 0x58, 0x28, 0x04,
  0x02, 0x01, 0x06, 0x83, 0x63, 0x1F, 0x00, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x1F, 0xCC, 0x72, 0x09, 0x82, 0x40, 0x90, 0x24, 0x19, 0x06, 0x41, 0x18,
  0xC3, 0xD0, 0x3E, 0x63, 0x41, 0xC1, 0x81, 0xFF, 0x80, 0x80, 0x83, 0xC6,
  0x7C, 0x00, 0x78, 0x0F, 0xC0, 0x40, 0x02, 0x00, 0x30, 0x0F, 0xF8, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x07, 0xC0, 0x38, 0x00, 0x3F, 0xB1, 0xD0, 0x58,
  0x28, 0x14, 0x0A, 0x0D, 0x06, 0xC6, 0x3D, 0x00, 0x80, 0x40, 0x67, 0xE3,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x2F, 0x0C, 0x62, 0x09, 0x82, 0x60,
  0x90, 0x24, 0x19, 0x06, 0x41, 0x30, 0x4C, 0x10, 0x07, 0x01, 0x80, 0x00,
  0x03, 0xE0, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x43,
  0xFE, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x1F, 0x0F,
  0x00, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x06, 0x41, 0x08, 0x43, 0x18,
  0x66, 0x0F, 0x81, 0x18, 0x21, 0x04, 0x31, 0x82, 0x30, 0x60, 0xF8, 0xF8,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x30,
  0x1F, 0x7D, 0xD9, 0x94, 0x45, 0x11, 0x44, 0xF3, 0x3C, 0x8A, 0x22, 0x88,
  0xA2, 0x28, 0x98, 0x2F, 0x0C, 0x62, 0x09, 0x82, 0x60, 0x90, 0x24, 0x19,
  0x06, 0x41, 0x30, 0x4C, 0x10, 0x3E, 0x63, 0x41, 0xC1, 0x81, 0x81, 0x81,
  0x83, 0x82, 0xC6, 0x7C, 0x2F, 0x0C, 0x62, 0x09, 0x82, 0x60, 0x90, 0x24,
  0x09, 0x06, 0x41, 0x38, 0xCF, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F,
  0xCC, 0x72, 0x09, 0x82, 0x40, 0x90, 0x24, 0x19, 0x06, 0x41, 0x18, 0xC3,
  0xD0, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x7F, 0x30, 0xD0, 0x68, 0x34, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1F, 0x8C, 0x22, 0x0D, 0x80,
  0x30, 0x07, 0xC0, 0x18, 0x06, 0xC1, 0x90, 0x47, 0xE0, 0x08, 0x04, 0x06,
  0x1F, 0xF1, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x03, 0x00,
  0xF0, 0x20, 0xC8, 0x36, 0x09, 0x82, 0x40, 0x90, 0x24, 0x09, 0x06, 0x41,
  0x18, 0xC3, 0xE0, 0xC0, 0xA0, 0xD0, 0x48, 0x64, 0x23, 0x31, 0x90, 0x58,
  0x28, 0x1C, 0x0C, 0x00, 0x8C, 0x63, 0x29, 0x4A, 0x52, 0x95, 0xA9, 0x4A,
  0x52, 0x9C, 0xC6, 0x31, 0x8C, 0x60, 0x30, 0x63, 0x08, 0x22, 0x06, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xC8, 0x11, 0x04, 0x13, 0x03, 0x00, 0x41, 0xA0,
  0xB0, 0x58, 0x28, 0x14, 0x0A, 0x0D, 0x06, 0xC6, 0x3D, 0x00, 0x80, 0x40,
  0x67, 0xE3, 0xC0, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x0F, 0xF0, 0x00, 0xC0, 0xF0, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x3E, 0x01, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x06, 0x00, 0xE0, 0x11, 0x11, 0x33, 0x22, 0x22, 0x66, 0x44,
  0x44, 0x4C, 0xC0, 0x18, 0x1E, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x03, 0xC3, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x38,
  0x00, 0x38, 0x53, 0x14, 0x4B, 0x0E,
};

const GFXglyph JetBrainsMono_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 4, -15 },
  { 14, 12, 15, 12, 0, -15 },
  { 37, 10, 20, 12, 1, -17 },
  { 62, 14, 15, 12, -1, -15 },
  { 89, 10, 15, 12, 1, -15 },
  { 108, 2, 6, 12, 6, -15 },
  { 110, 9, 20, 12, 3, -17 },
  { 133, 8, 20, 12, 1, -17 },
  { 153, 11, 10, 12, 1, -12 },
  { 167, 10, 9, 12, 1, -11 },
  { 179, 5, 6, 12, 2, -3 },
  { 183, 6, 1, 12, 3, -7 },
  { 184, 3, 3, 12, 4, -3 },
  { 186, 11, 19, 12, 1, -17 },
  { 213, 10, 15, 12, 1, -15 },
  { 232, 9, 15, 12, 1, -15 },
  { 249, 10, 15, 12, 1, -15 },
  { 268, 10, 15, 12, 1, -15 },
  { 287, 10, 15, 12, 1, -15 },
  { 306, 10, 15, 12, 1, -15 },
  { 325, 9, 15, 12, 1, -15 },
  { 342, 10, 15, 12, 2, -15 },
  { 361, 10, 15, 12, 1, -15 },
  { 380, 9, 15, 12, 2, -15 },
  { 397, 4, 11, 12, 4, -11 },
  { 403, 6, 14, 12, 2, -11 },
  { 414, 9, 11, 12, 2, -12 },
  { 427, 9, 6, 12, 2, -10 },
  { 434, 10, 11, 12, 1, -12 },
  { 448, 8, 15, 12, 3, -15 },
  { 463, 12, 19, 12, 0, -15 },
  { 492, 10, 15, 12, 0, -15 },
  { 511, 10, 15, 12, 1, -15 },
  { 530, 9, 15, 12, 2, -15 },
  { 547, 10, 15, 12, 1, -15 },
  { 566, 11, 15, 12, 1, -15 },
  { 587, 11, 15, 12, 1, -15 },
  { 608, 9, 15, 12, 2, -15 },
  { 625, 10, 15, 12, 1, -15 },
  { 644, 10, 15, 12, 1, -15 },
  { 663, 10, 15, 12, 1, -15 },
  { 682, 11, 15, 12, 1, -15 },
  { 703, 9, 15, 12, 1, -15 },
  { 720, 11, 15, 12, 1, -15 },
  { 741, 10, 15, 12, 1, -15 },
  { 760, 9, 15, 12, 2, -15 },
  { 777, 11, 15, 12, 1, -15 },
  { 798, 10, 19, 12, 1, -15 },
  { 822, 11, 15, 12, 1, -15 },
  { 843, 10, 15, 12, 1, -15 },
  { 862, 10, 15, 12, 2, -15 },
  { 881, 10, 15, 12, 1, -15 },
  { 900, 9, 15, 12, 3, -15 },
  { 917, 11, 15, 12, 2, -15 },
  { 938, 12, 15, 12, 0, -15 },
  { 961, 11, 15, 12, 2, -15 },
  { 982, 10, 15, 12, 1, -15 },
  { 1001, 8, 19, 12, 3, -17 },
  { 1020, 6, 19, 12, 3, -17 },
  { 1035, 7, 19, 12, 2, -17 },
  { 1052, 8, 8, 12, 2, -15 },
  { 1060, 10, 2, 12, 0, 0 },
  { 1063, 3, 3, 12, 6, -16 },
  { 1065, 10, 11, 12, 1, -11 },
  { 1079, 10, 15, 12, 1, -15 },
  { 1098, 9, 11, 12, 2, -11 },
  { 1111, 10, 15, 12, 1, -15 },
  { 1130, 8, 11, 12, 2, -11 },
  { 1141, 13, 19, 12, -1, -15 },
  { 1172, 9, 15, 12, 2, -11 },
  { 1189, 10, 15, 12, 1, -15 },
  { 1208, 9, 15, 12, 1, -15 },
  { 1225, 10, 19, 12, 0, -15 },
  { 1249, 11, 15, 12, 1, -15 },
  { 1270, 8, 15, 12, 2, -15 },
  { 1285, 10, 11, 12, 1, -11 },
  { 1299, 10, 11, 12, 1, -11 },
  { 1313, 8, 11, 12, 2, -11 },
  { 1324, 10, 15, 12, 1, -11 },
  { 1343, 10, 15, 12, 1, -11 },
  { 1362, 9, 11, 12, 2, -11 },
  { 1375, 10, 11, 12, 1, -11 },
  { 1389, 9, 14, 12, 2, -14 },
  { 1405, 10, 11, 12, 1, -11 },
  { 1419, 9, 11, 12, 2, -11 },
  { 1432, 10, 11, 12, 2, -11 },
  { 1446, 11, 11, 12, 0, -11 },
  { 1462, 9, 15, 12, 2, -11 },
  { 1479, 10, 11, 12, 1, -11 },
  { 1493, 10, 19, 12, 2, -17 },
  { 1517, 4, 19, 12, 4, -17 },
  { 1527, 9, 19, 12, 1, -17 },
  { 1549, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC20PT7B_H_
