#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC24PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x63, 0x18, 0xC6, 0x21, 0x08, 0x46, 0x00, 0x08, 0xE7,
  0x00, 0x47, 0x8F, 0x1E, 0x3C, 0x78, 0xA1, 0x46, 0x03, 0x08, 0x08, 0x60,
  0x61, 0x01, 0x84, 0x04, 0x30, 0xFF, 0xF7, 0xFF, 0x82, 0x18, 0x18, 0x40,
  0x43, 0x01, 0x0C, 0x0C, 0x20, 0xFF, 0xF0, 0x86, 0x06, 0x10, 0x10, 0xC0,
  0x43, 0x03, 0x08, 0x00, 0x00, 0x80, 0x04, 0x00, 0x20, 0x07, 0x80, 0xFE,
  0x0C, 0x98, 0x44, 0x46, 0x22, 0x31, 0x01, 0x98, 0x06, 0xC0, 0x1E, 0x00,
  0x7C, 0x01, 0x70, 0x09, 0x80, 0x44, 0x06, 0x26, 0x23, 0x11, 0x10, 0xEB,
  0x83, 0xF0, 0x02, 0x00, 0x30, 0x01, 0x00, 0x02, 0x01, 0x87, 0xC1, 0x86,
  0x20, 0x82, 0x10, 0x81, 0x08, 0x80, 0x84, 0x80, 0x46, 0xC0, 0x3E, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x4E, 0x00, 0x4D, 0x80, 0x4C, 0x60, 0x64,
  0x20, 0x62, 0x10, 0x61, 0x08, 0x20, 0xCC, 0x60, 0x3C, 0x00, 0x03, 0x80,
  0x7F, 0x06, 0x18, 0x30, 0x41, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x3C,
  0x03, 0x30, 0xD1, 0x8D, 0x86, 0xCC, 0x34, 0x60, 0xE3, 0x06, 0x18, 0x78,
  0xC6, 0x63, 0xE3, 0x00, 0x6D, 0xED, 0xB4, 0x00, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x07, 0x00, 0x40,
  0x0C, 0x03, 0x80, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x30, 0x18, 0x3C, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x06,
  0x31, 0xFD, 0x7C, 0x7F, 0x00, 0xC0, 0x0D, 0x00, 0xCC, 0x0C, 0x60, 0xC1,
  0x82, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x41, 0xFF, 0xFF,
  0xF8, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x19, 0xCC, 0xE6, 0x23,
  0x10, 0x7F, 0xFF, 0x7F, 0x70, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x00, 0x07, 0x83, 0xF8, 0xC1, 0x90,
  0x16, 0x02, 0xC0, 0x58, 0x1A, 0x03, 0x4E, 0x79, 0xCF, 0x01, 0x60, 0x2C,
  0x0D, 0x01, 0xA0, 0x36, 0x0C, 0xE3, 0x0F, 0xC0, 0x01, 0x80, 0x70, 0x3A,
  0x0C, 0xC3, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x1F, 0xFC, 0x03, 0xC0, 0xFE,
  0x18, 0x33, 0x01, 0x30, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x0F, 0xFE,
  0x1F, 0xF1, 0xFF, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x78,
  0x01, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x64, 0x06, 0x40, 0x44, 0x0C,
  0x71, 0x83, 0xF0, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x44, 0x19, 0x83, 0x60, 0x6C, 0x0D, 0xFF, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x83, 0xFC, 0x70, 0xCC, 0x18, 0x01, 0x00, 0x20, 0x0C, 0x01, 0xA0,
  0x36, 0x0C, 0xE3, 0x0F, 0xC0, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x98, 0x3F, 0xC3, 0x06, 0x60, 0x26, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x66, 0x0C, 0x71, 0x83, 0xF0, 0x7F, 0xEF, 0xFF, 0x01,
  0xE0, 0x2C, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x03, 0xC0, 0xFE,
  0x18, 0x31, 0x01, 0x10, 0x13, 0x03, 0x10, 0x21, 0x8C, 0x0F, 0x80, 0xF8,
  0x18, 0xC2, 0x06, 0x60, 0x64, 0x06, 0x40, 0x66, 0x04, 0x71, 0xC3, 0xF0,
  0x07, 0x81, 0xFC, 0x30, 0x66, 0x02, 0x60, 0x24, 0x02, 0x40, 0x24, 0x06,
  0x60, 0x67, 0x1C, 0x3E, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x3C, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C,
  0x70, 0x1E, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xE1, 0x87,
  0x0C, 0x10, 0x60, 0x80, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x20, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x00, 0x78, 0x3F, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x06, 0x1E,
  0x08, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x80, 0xE0, 0x70, 0x00, 0x01, 0xE0,
  0x1F, 0xE0, 0xC0, 0xC6, 0x03, 0x10, 0x04, 0xC0, 0x13, 0x06, 0x48, 0x7F,
  0x23, 0x0C, 0x8C, 0x36, 0x20, 0x98, 0x82, 0x62, 0x09, 0x98, 0x64, 0x21,
  0x90, 0xFE, 0x41, 0x81, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7C,
  0x00, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x40, 0x26, 0x06, 0x60,
  0x46, 0x0C, 0x60, 0xC6, 0x08, 0x21, 0x82, 0x1F, 0xE3, 0x02, 0x30, 0x26,
  0x03, 0x60, 0x3C, 0x03, 0x1F, 0x01, 0xFE, 0x10, 0x31, 0x03, 0x10, 0x13,
  0x03, 0x30, 0x33, 0x06, 0x3F, 0xC3, 0xFC, 0x20, 0x66, 0x02, 0x60, 0x26,
  0x02, 0x60, 0x64, 0x0C, 0x43, 0x8F, 0xF0, 0x07, 0x81, 0xFC, 0x30, 0x63,
  0x02, 0x60, 0x26, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x0C, 0xC0, 0xCC, 0x18, 0x63, 0x07, 0xE0, 0x1E, 0x01,
  0xFE, 0x10, 0x61, 0x03, 0x10, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x32,
  0x02, 0x20, 0x26, 0x06, 0x60, 0x66, 0x06, 0x60, 0x44, 0x0C, 0x47, 0x8F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x7F, 0xC7, 0xFC, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x4F, 0xF8, 0x3F, 0xF3, 0xFF, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x7F, 0xC7, 0xFC, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x07, 0x81, 0xFC, 0x30, 0x63,
  0x02, 0x60, 0x26, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x7E, 0xC7, 0xCC,
  0x04, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x18, 0x63, 0x07, 0xE0, 0x18, 0x18,
  0xC0, 0xC4, 0x04, 0x20, 0x21, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x3F,
  0xE1, 0xFF, 0x08, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x81, 0x08, 0x08,
  0x40, 0x46, 0x06, 0x00, 0x3F, 0xE7, 0xFC, 0x08, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x1F, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x4C, 0x04, 0xC0, 0xCC, 0x0C, 0x63, 0x83, 0xF0, 0x18, 0x0C, 0x60, 0x61,
  0x03, 0x04, 0x0C, 0x10, 0x60, 0xC1, 0x03, 0x0C, 0x0C, 0x60, 0x3F, 0x00,
  0xFC, 0x02, 0x18, 0x18, 0x60, 0x60, 0x81, 0x83, 0x06, 0x0C, 0x10, 0x10,
  0x40, 0x63, 0x01, 0x80, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3F, 0xF0, 0x18, 0x18, 0xC1, 0xCE, 0x0E, 0x78, 0xF3, 0xC5, 0x12,
  0x68, 0x92, 0x44, 0xB6, 0x25, 0x33, 0x39, 0x98, 0x08, 0xC0, 0x44, 0x02,
  0x20, 0x31, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x02, 0x00, 0x18, 0x18, 0xE0,
  0xC7, 0x04, 0x28, 0x21, 0x43, 0x1A, 0x18, 0xD8, 0xC6, 0xC6, 0x22, 0x21,
  0x11, 0x08, 0xC8, 0xC6, 0xC6, 0x16, 0x30, 0xB1, 0x05, 0x08, 0x38, 0x41,
  0xC6, 0x06, 0x00, 0x07, 0x83, 0xF8, 0xC1, 0x90, 0x36, 0x06, 0xC0, 0xD8,
  0x1B, 0x03, 0x40, 0x68, 0x0B, 0x01, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x26,
  0x0C, 0xE3, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x84, 0x0E, 0x20, 0x31, 0x01,
  0x98, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x71, 0xFE, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x00, 0x07, 0x83,
  0xF8, 0xC1, 0x90, 0x36, 0x02, 0xC0, 0xD8, 0x1A, 0x03, 0x40, 0x68, 0x0B,
  0x01, 0x60, 0x6C, 0x0D, 0x81, 0xA0, 0x36, 0x0C, 0xE3, 0x0F, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x1F, 0x00, 0xFF, 0x04, 0x0C, 0x20, 0x31,
  0x01, 0x98, 0x0C, 0xC0, 0x46, 0x06, 0x30, 0x61, 0xFE, 0x08, 0x40, 0xC3,
  0x06, 0x18, 0x30, 0xC1, 0x83, 0x08, 0x18, 0x40, 0xC6, 0x03, 0x00, 0x03,
  0xC0, 0x7F, 0x86, 0x0C, 0x20, 0x23, 0x01, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x00, 0x13, 0x01, 0x88,
  0x08, 0x71, 0xC1, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x33, 0x03, 0x20,
  0x22, 0x02, 0x20, 0x66, 0x06, 0x60, 0x66, 0x06, 0x40, 0x44, 0x04, 0x40,
  0x4C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18, 0x63, 0x07, 0xE0, 0xC0,
  0x3C, 0x02, 0xC0, 0x64, 0x04, 0x40, 0xC4, 0x0C, 0x41, 0x86, 0x18, 0x61,
  0x06, 0x30, 0x62, 0x06, 0x60, 0x26, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x38,
  0x03, 0x00, 0x43, 0x0E, 0x18, 0x71, 0xC7, 0x8A, 0x2C, 0x51, 0x62, 0x9B,
  0x24, 0xD9, 0x24, 0xC9, 0x26, 0x8B, 0x34, 0xD9, 0xA6, 0x8B, 0x34, 0x51,
  0x62, 0x8A, 0x14, 0x50, 0xC3, 0x86, 0x1C, 0x00, 0x18, 0x06, 0x10, 0x18,
  0x30, 0x60, 0x60, 0x80, 0x43, 0x00, 0xCC, 0x00, 0x90, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0A, 0x00, 0x26, 0x00, 0xCC, 0x03, 0x08, 0x04, 0x18,
  0x18, 0x10, 0x60, 0x31, 0x80, 0x60, 0x80, 0x3C, 0x02, 0xC0, 0x64, 0x0C,
  0x60, 0x86, 0x18, 0x23, 0x03, 0x30, 0x36, 0x01, 0x40, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0x8F, 0xC4, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0xC3, 0xE0, 0xC1, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10,
  0x30, 0x60, 0x40, 0x81, 0x83, 0x06, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40,
  0xC1, 0x80, 0x0F, 0x87, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x47, 0xE3, 0xF0, 0x03, 0x00, 0xC0, 0x50, 0x36, 0x09, 0x86, 0x23,
  0x08, 0xC3, 0x60, 0x70, 0x10, 0xFF, 0xF0, 0xD9, 0x90, 0x1F, 0x66, 0x1D,
  0x81, 0xA0, 0x24, 0x05, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x13, 0x06,
  0x71, 0x47, 0xD8, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x7C,
  0x38, 0x63, 0x02, 0x30, 0x22, 0x02, 0x20, 0x26, 0x06, 0x60, 0x66, 0x06,
  0x60, 0x46, 0x0C, 0x71, 0x8D, 0xF0, 0x1F, 0x86, 0x19, 0x81, 0xA0, 0x34,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x1B, 0x06, 0x71, 0x87, 0xE0,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x61, 0xF6, 0x30, 0xE6, 0x06,
  0x40, 0x44, 0x04, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x8C, 0x18,
  0xE2, 0x87, 0xD8, 0x1F, 0x86, 0x19, 0x81, 0x20, 0x24, 0x05, 0xFF, 0xBF,
  0xF6, 0x00, 0xC0, 0x18, 0x03, 0x06, 0x71, 0x87, 0xE0, 0x00, 0x0F, 0x00,
  0x7F, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0xFC, 0x00, 0x1F, 0x66, 0x1D, 0x81, 0xA0, 0x24, 0x04,
  0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x31, 0x8A, 0x1E, 0x40, 0x18, 0x03,
  0x00, 0x60, 0x18, 0xFE, 0x00, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x7C, 0x38, 0x63, 0x02, 0x30, 0x22, 0x02, 0x20, 0x26, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x64, 0x04, 0x40, 0x4C, 0x0C, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x08, 0x3E, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFC, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x7F, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x1C, 0xC1, 0x86, 0x0C, 0x30, 0xC1,
  0x0C, 0x0F, 0xC0, 0xFE, 0x06, 0x30, 0x30, 0xC1, 0x86, 0x08, 0x18, 0x40,
  0xC6, 0x03, 0x00, 0xFC, 0x7C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x38, 0x0F, 0xC0,
  0x3E, 0xF2, 0x31, 0x63, 0x16, 0x21, 0x62, 0x34, 0x23, 0x46, 0x34, 0x62,
  0xC6, 0x2C, 0x42, 0xC4, 0x68, 0x46, 0x8C, 0x60, 0x37, 0xC3, 0x86, 0x30,
  0x23, 0x02, 0x20, 0x22, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x40,
  0x44, 0x04, 0xC0, 0xC0, 0x1F, 0x86, 0x19, 0x81, 0x20, 0x24, 0x05, 0x80,
  0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x13, 0x06, 0x71, 0x87, 0xE0, 0x37, 0xC3,
  0x86, 0x30, 0x23, 0x02, 0x20, 0x22, 0x02, 0x60, 0x66, 0x06, 0x60, 0x66,
  0x04, 0x60, 0xC7, 0x18, 0xDF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00,
  0x1F, 0x66, 0x1D, 0x81, 0xA0, 0x24, 0x05, 0x81, 0xB0, 0x36, 0x06, 0xC0,
  0xD8, 0x13, 0x06, 0x71, 0x47, 0xD8, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x3F, 0xC7, 0x1D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0xC6, 0x19, 0x81, 0xB0, 0x06,
  0x00, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0xC0, 0x1A, 0x02, 0x60, 0xC7, 0xF0,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x0F, 0xFE, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0xE0, 0x0F, 0x80,
  0x60, 0x6C, 0x0D, 0x81, 0xA0, 0x24, 0x04, 0x80, 0xB0, 0x36, 0x06, 0xC0,
  0xD8, 0x13, 0x06, 0x31, 0x87, 0xE0, 0x80, 0x78, 0x1B, 0x02, 0x60, 0xC4,
  0x10, 0x86, 0x10, 0x83, 0x30, 0x64, 0x0D, 0x80, 0xA0, 0x1C, 0x03, 0x00,
  0x86, 0x18, 0x63, 0x8E, 0x38, 0xA2, 0x8A, 0x69, 0xA6, 0x92, 0x49, 0x2C,
  0xB2, 0xCA, 0x28, 0xA2, 0x8E, 0x38, 0xC3, 0x00, 0x30, 0x38, 0xC3, 0x06,
  0x30, 0x19, 0x80, 0xD8, 0x03, 0x80, 0x18, 0x01, 0xE0, 0x19, 0x01, 0x8C,
  0x08, 0x20, 0xC1, 0x8C, 0x06, 0x00, 0x60, 0x6C, 0x0D, 0x81, 0x20, 0x24,
  0x05, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x31, 0x8A, 0x1E, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0xFE, 0x00, 0x3F, 0xF0, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00,
  0xFF, 0xC0, 0x00, 0x70, 0x1F, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x0F, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xF8, 0x01,
  0x80, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x88, 0x42, 0x31, 0x8C, 0x62,
  0x11, 0x8C, 0x63, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x10, 0x3E, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x0F,
  0x00, 0xC0, 0x00, 0x30, 0x2F, 0x87, 0x11, 0xC3, 0xE8, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 18, 14, 5, -18 },
  { 13, 7, 8, 14, 5, -18 },
  { 20, 14, 18, 14, 1, -18 },
  { 52, 13, 24, 14, 1, -21 },
  { 91, 17, 18, 14, -1, -18 },
  { 130, 13, 18, 14, 1, -18 },
  { 160, 3, 8, 14, 7, -18 },
  { 163, 10, 23, 14, 4, -20 },
  { 192, 10, 23, 14, 1, -20 },
  { 221, 13, 13, 14, 1, -15 },
  { 243, 11, 12, 14, 2, -14 },
  { 260, 5, 8, 14, 3, -4 },
  { 265, 8, 2, 14, 3, -9 },
  { 267, 4, 3, 14, 4, -3 },
  { 269, 13, 23, 14, 1, -20 },
  { 307, 11, 18, 14, 2, -18 },
  { 332, 11, 18, 14, 1, -18 },
  { 357, 12, 18, 14, 1, -18 },
  { 384, 12, 18, 14, 1, -18 },
  { 411, 11, 18, 14, 2, -18 },
  { 436, 11, 18, 14, 2, -18 },
  { 461, 12, 18, 14, 1, -18 },
  { 488, 11, 18, 14, 3, -18 },
  { 513, 12, 18, 14, 1, -18 },
  { 540, 12, 18, 14, 2, -18 },
  { 567, 6, 13, 14, 4, -13 },
  { 577, 7, 17, 14, 3, -13 },
  { 592, 11, 12, 14, 2, -14 },
  { 609, 11, 7, 14, 2, -11 },
  { 619, 12, 12, 14, 1, -14 },
  { 637, 9, 18, 14, 4, -18 },
  { 658, 14, 22, 14, 0, -18 },
  { 697, 12, 18, 14, 0, -18 },
  { 724, 12, 18, 14, 1, -18 },
  { 751, 12, 18, 14, 2, -18 },
  { 778, 12, 18, 14, 1, -18 },
  { 805, 12, 18, 14, 2, -18 },
  { 832, 12, 18, 14, 2, -18 },
  { 859, 12, 18, 14, 2, -18 },
  { 886, 13, 18, 14, 1, -18 },
  { 916, 11, 18, 14, 2, -18 },
  { 941, 12, 18, 14, 1, -18 },
  { 968, 14, 18, 14, 1, -18 },
  { 1000, 10, 18, 14, 2, -18 },
  { 1023, 13, 18, 14, 1, -18 },
  { 1053, 13, 18, 14, 1, -18 },
  { 1083, 11, 18, 14, 2, -18 },
  { 1108, 13, 18, 14, 1, -18 },
  { 1138, 11, 22, 14, 2, -18 },
  { 1169, 13, 18, 14, 1, -18 },
  { 1199, 13, 18, 14, 1, -18 },
  { 1229, 12, 18, 14, 3, -18 },
  { 1256, 12, 18, 14, 2, -18 },
  { 1283, 12, 18, 14, 3, -18 },
  { 1310, 13, 18, 14, 2, -18 },
  { 1340, 15, 18, 14, 0, -18 },
  { 1374, 12, 18, 14, 3, -18 },
  { 1401, 13, 18, 14, 1, -18 },
  { 1431, 9, 23, 14, 4, -20 },
  { 1457, 7, 23, 14, 4, -20 },
  { 1478, 9, 23, 14, 2, -20 },
  { 1504, 10, 10, 14, 2, -18 },
  { 1517, 12, 1, 14, 0, 1 },
  { 1519, 3, 4, 14, 7, -19 },
  { 1521, 11, 13, 14, 2, -13 },
  { 1539, 12, 18, 14, 1, -18 },
  { 1566, 11, 13, 14, 2, -13 },
  { 1584, 12, 18, 14, 2, -18 },
  { 1611, 11, 13, 14, 2, -13 },
  { 1629, 16, 22, 14, -1, -18 },
  { 1673, 11, 17, 14, 2, -13 },
  { 1697, 12, 18, 14, 1, -18 },
  { 1724, 11, 18, 14, 1, -18 },
  { 1749, 13, 22, 14, 0, -18 },
  { 1785, 13, 18, 14, 1, -18 },
  { 1815, 9, 18, 14, 3, -18 },
  { 1836, 12, 13, 14, 1, -13 },
  { 1856, 12, 13, 14, 1, -13 },
  { 1876, 11, 13, 14, 2, -13 },
  { 1894, 12, 17, 14, 1, -13 },
  { 1920, 11, 17, 14, 2, -13 },
  { 1944, 11, 13, 14, 2, -13 },
  { 1962, 11, 13, 14, 2, -13 },
  { 1980, 11, 17, 14, 2, -17 },
  { 2004, 11, 13, 14, 2, -13 },
  { 2022, 11, 13, 14, 3, -13 },
  { 2040, 12, 13, 14, 2, -13 },
  { 2060, 13, 13, 14, 1, -13 },
  { 2082, 11, 17, 14, 2, -13 },
  { 2106, 12, 13, 14, 1, -13 },
  { 2126, 12, 23, 14, 2, -20 },
  { 2161, 5, 23, 14, 5, -20 },
  { 2176, 12, 23, 14, 1, -20 },
  { 2211, 11, 5, 14, 2, -11 },
};

const GFXfont JetBrainsMono_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC24PT7B_H_
