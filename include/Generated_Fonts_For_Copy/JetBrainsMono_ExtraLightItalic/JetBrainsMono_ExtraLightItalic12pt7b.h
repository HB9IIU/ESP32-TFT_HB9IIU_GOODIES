#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC12PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x80, 0xC0, 0x55, 0x99, 0x12, 0x24, 0x53, 0x72, 0x45,
  0x3F, 0x24, 0xD0, 0x10, 0xE5, 0x54, 0x60, 0xC2, 0x8A, 0xAB, 0xC2, 0x10,
  0x31, 0x52, 0x54, 0x78, 0x10, 0x1E, 0x32, 0x52, 0x8C, 0x1C, 0x48, 0x81,
  0x07, 0x2A, 0xA2, 0x44, 0x74, 0xF0, 0x19, 0x10, 0x84, 0x42, 0x10, 0x82,
  0x18, 0x20, 0x61, 0x11, 0x11, 0x11, 0x22, 0xC8, 0x12, 0x9D, 0x88, 0x52,
  0x60, 0x10, 0x82, 0x7E, 0x20, 0x80, 0x29, 0x40, 0xF0, 0x70, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x39, 0x18, 0x61, 0xAA,
  0x28, 0xA2, 0xF0, 0x13, 0xA4, 0x21, 0x08, 0x84, 0xF8, 0x39, 0x18, 0x42,
  0x08, 0x42, 0x30, 0xF8, 0x7C, 0x21, 0x0C, 0x08, 0x20, 0xA2, 0xF0, 0x08,
  0x84, 0x44, 0xC7, 0xE1, 0x08, 0x7D, 0x04, 0x1C, 0xC8, 0x20, 0xA2, 0xF0,
  0x18, 0x88, 0x87, 0xC6, 0x31, 0xF0, 0x7D, 0x18, 0x82, 0x10, 0x42, 0x08,
  0x40, 0x39, 0x14, 0x52, 0x33, 0x28, 0xA2, 0xF0, 0x39, 0x18, 0x61, 0x48,
  0xE1, 0x08, 0x40, 0x6C, 0x00, 0xB0, 0x33, 0x00, 0x02, 0x44, 0x80, 0x0C,
  0xCC, 0x30, 0x30, 0x20, 0xF8, 0x01, 0xF0, 0x41, 0x06, 0x36, 0x40, 0x60,
  0x82, 0x26, 0x22, 0x00, 0x80, 0x1C, 0x45, 0x0A, 0x75, 0x2A, 0x64, 0xCA,
  0x89, 0x01, 0xC0, 0x08, 0x61, 0x8A, 0x24, 0x97, 0xD1, 0x84, 0x79, 0x14,
  0x62, 0xF2, 0x28, 0xA2, 0xF0, 0x39, 0x14, 0x60, 0x82, 0x08, 0x22, 0xF0,
  0x71, 0x24, 0x62, 0x8A, 0x28, 0xA2, 0xF0, 0x7D, 0x04, 0x10, 0x7A, 0x08,
  0x20, 0xF8, 0x7D, 0x04, 0x10, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x14, 0x60,
  0x82, 0xE8, 0xA2, 0xF0, 0x45, 0x14, 0x62, 0xFA, 0x28, 0xA2, 0x88, 0x7C,
  0x41, 0x08, 0x20, 0x82, 0x08, 0xF0, 0x0E, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x44, 0x78, 0x45, 0x14, 0xA4, 0xF2, 0x49, 0x22, 0x88, 0x42, 0x10, 0x88,
  0x42, 0x10, 0xF8, 0x22, 0x4D, 0x5A, 0xD5, 0x48, 0x91, 0x22, 0x84, 0x45,
  0x16, 0x6A, 0xAA, 0xA9, 0xA6, 0x98, 0x39, 0x14, 0x62, 0x8A, 0x28, 0xA2,
  0xF0, 0x79, 0x14, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x39, 0x14, 0x61, 0x8A,
  0x28, 0xA2, 0xF0, 0x41, 0x00, 0x79, 0x14, 0x61, 0xFA, 0x49, 0x24, 0x88,
  0x39, 0x14, 0x10, 0x30, 0x20, 0xA2, 0xF0, 0xFC, 0x41, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x45, 0x14, 0x62, 0x8A, 0x28, 0xA2, 0xF0, 0x8C, 0x65, 0x29,
  0x52, 0x98, 0xC0, 0x93, 0x2A, 0xD5, 0xAB, 0x5B, 0x36, 0x4C, 0x90, 0x22,
  0x48, 0x90, 0xC1, 0x05, 0x0A, 0x22, 0x84, 0x86, 0x89, 0x22, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x7C, 0x20, 0x84, 0x20, 0x84, 0x20, 0xF8, 0x34, 0x44,
  0x44, 0x88, 0x88, 0xE0, 0x91, 0x24, 0x91, 0x24, 0x80, 0x38, 0x44, 0x21,
  0x08, 0x42, 0x21, 0x38, 0x11, 0x8A, 0x98, 0x80, 0xFC, 0xC0, 0x3A, 0x63,
  0x18, 0xC7, 0xE0, 0x42, 0x1C, 0x98, 0xC6, 0x31, 0xF0, 0x32, 0x63, 0x08,
  0x47, 0xC0, 0x04, 0x13, 0x52, 0x8A, 0x28, 0xA2, 0xF8, 0x32, 0x63, 0xF8,
  0x47, 0xC0, 0x0E, 0x20, 0x43, 0xF1, 0x02, 0x04, 0x10, 0x20, 0x43, 0x80,
  0x3A, 0x63, 0x18, 0xCD, 0xA2, 0xF0, 0x42, 0x1C, 0x98, 0xC6, 0x31, 0x88,
  0x10, 0x1C, 0x21, 0x10, 0x84, 0xF8, 0x04, 0x03, 0xC1, 0x08, 0x20, 0x82,
  0x08, 0x2F, 0x00, 0x41, 0x04, 0x52, 0x93, 0x89, 0x24, 0x88, 0xE1, 0x08,
  0x42, 0x11, 0x08, 0x38, 0x74, 0xB5, 0x4A, 0xA5, 0x52, 0xA5, 0x00, 0x72,
  0x63, 0x18, 0xC6, 0x20, 0x32, 0x63, 0x18, 0xC7, 0xC0, 0x38, 0x94, 0x51,
  0x45, 0x17, 0x90, 0x80, 0x3A, 0x63, 0x18, 0xC7, 0xE2, 0x10, 0x79, 0x24,
  0x60, 0x82, 0x08, 0x00, 0x3A, 0x60, 0xE0, 0xC7, 0xC0, 0x23, 0xF2, 0x08,
  0x21, 0x04, 0x0E, 0x46, 0x28, 0xA2, 0x8A, 0x2F, 0x00, 0x86, 0x24, 0x94,
  0x51, 0x86, 0x00, 0x96, 0xDB, 0x76, 0xDB, 0x69, 0x00, 0x42, 0x48, 0xA0,
  0x82, 0x89, 0x31, 0x00, 0x4C, 0x63, 0x18, 0xCD, 0xA2, 0xF0, 0x78, 0x44,
  0x44, 0x43, 0xE0, 0x0C, 0x41, 0x04, 0x13, 0x82, 0x08, 0x20, 0x83, 0x00,
  0x24, 0x94, 0x92, 0x4A, 0x00, 0x30, 0x21, 0x04, 0x10, 0x31, 0x04, 0x20,
  0x8E, 0x00, 0xE6, 0x60,
};

const GFXglyph JetBrainsMono_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 4, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 12, 7, 1, -10 },
  { 24, 8, 9, 7, 0, -9 },
  { 33, 7, 9, 7, 0, -9 },
  { 41, 1, 4, 7, 4, -9 },
  { 42, 5, 12, 7, 2, -10 },
  { 50, 4, 12, 7, 1, -10 },
  { 56, 6, 6, 7, 1, -7 },
  { 61, 6, 6, 7, 1, -7 },
  { 66, 3, 4, 7, 1, -2 },
  { 68, 4, 1, 7, 2, -4 },
  { 69, 2, 2, 7, 2, -2 },
  { 70, 7, 11, 7, 0, -10 },
  { 80, 6, 9, 7, 1, -9 },
  { 87, 5, 9, 7, 1, -9 },
  { 93, 6, 9, 7, 1, -9 },
  { 100, 6, 9, 7, 1, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 6, 9, 7, 1, -9 },
  { 120, 5, 9, 7, 1, -9 },
  { 126, 6, 9, 7, 1, -9 },
  { 133, 6, 9, 7, 1, -9 },
  { 140, 6, 9, 7, 1, -9 },
  { 147, 3, 7, 7, 2, -7 },
  { 150, 4, 9, 7, 1, -7 },
  { 155, 6, 6, 7, 1, -7 },
  { 160, 5, 4, 7, 1, -6 },
  { 163, 5, 6, 7, 1, -7 },
  { 167, 5, 9, 7, 2, -9 },
  { 173, 7, 11, 7, 0, -9 },
  { 183, 6, 9, 7, 0, -9 },
  { 190, 6, 9, 7, 1, -9 },
  { 197, 6, 9, 7, 1, -9 },
  { 204, 6, 9, 7, 1, -9 },
  { 211, 6, 9, 7, 1, -9 },
  { 218, 6, 9, 7, 1, -9 },
  { 225, 6, 9, 7, 1, -9 },
  { 232, 6, 9, 7, 1, -9 },
  { 239, 6, 9, 7, 1, -9 },
  { 246, 7, 9, 7, 0, -9 },
  { 254, 6, 9, 7, 1, -9 },
  { 261, 5, 9, 7, 1, -9 },
  { 267, 7, 9, 7, 0, -9 },
  { 275, 6, 9, 7, 1, -9 },
  { 282, 6, 9, 7, 1, -9 },
  { 289, 6, 9, 7, 1, -9 },
  { 296, 6, 11, 7, 1, -9 },
  { 305, 6, 9, 7, 1, -9 },
  { 312, 6, 9, 7, 1, -9 },
  { 319, 6, 9, 7, 1, -9 },
  { 326, 6, 9, 7, 1, -9 },
  { 333, 5, 9, 7, 2, -9 },
  { 339, 7, 9, 7, 1, -9 },
  { 347, 7, 9, 7, 0, -9 },
  { 355, 7, 9, 7, 1, -9 },
  { 363, 6, 9, 7, 1, -9 },
  { 370, 4, 11, 7, 2, -10 },
  { 376, 3, 11, 7, 2, -10 },
  { 381, 5, 11, 7, 1, -10 },
  { 388, 5, 5, 7, 1, -9 },
  { 392, 6, 1, 7, 0, 0 },
  { 393, 2, 1, 7, 3, -9 },
  { 394, 5, 7, 7, 1, -7 },
  { 399, 5, 9, 7, 1, -9 },
  { 405, 5, 7, 7, 1, -7 },
  { 410, 6, 9, 7, 1, -9 },
  { 417, 5, 7, 7, 1, -7 },
  { 422, 7, 11, 7, 0, -9 },
  { 432, 5, 9, 7, 1, -7 },
  { 438, 5, 9, 7, 1, -9 },
  { 444, 5, 9, 7, 1, -9 },
  { 450, 6, 11, 7, 0, -9 },
  { 459, 6, 9, 7, 1, -9 },
  { 466, 5, 9, 7, 1, -9 },
  { 472, 7, 7, 7, 0, -7 },
  { 479, 5, 7, 7, 1, -7 },
  { 484, 5, 7, 7, 1, -7 },
  { 489, 6, 9, 7, 0, -7 },
  { 496, 5, 9, 7, 1, -7 },
  { 502, 6, 7, 7, 1, -7 },
  { 508, 5, 7, 7, 1, -7 },
  { 513, 6, 8, 7, 1, -8 },
  { 519, 6, 7, 7, 1, -7 },
  { 525, 6, 7, 7, 1, -7 },
  { 531, 6, 7, 7, 1, -7 },
  { 537, 7, 7, 7, 0, -7 },
  { 544, 5, 9, 7, 1, -7 },
  { 550, 5, 7, 7, 1, -7 },
  { 555, 6, 11, 7, 1, -10 },
  { 564, 3, 11, 7, 2, -10 },
  { 569, 6, 11, 7, 0, -10 },
  { 578, 6, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC12PT7B_H_
