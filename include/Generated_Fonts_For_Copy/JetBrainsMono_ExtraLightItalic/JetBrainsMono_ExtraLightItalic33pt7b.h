#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC33PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0x00, 0x00, 0x06, 0x1E, 0x3C, 0x70, 0x30, 0xEE,
  0x1D, 0xC3, 0x38, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0x0C, 0x61, 0x98, 0x30,
  0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x03, 0x06, 0x00, 0xC0, 0xC1, 0xFF, 0xFF, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x07,
  0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03,
  0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x07, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x1F, 0xE0, 0x1F, 0xF8,
  0x1C, 0xCE, 0x1C, 0x63, 0x0C, 0x31, 0x86, 0x10, 0xC3, 0x08, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x73, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x6F, 0x00, 0x31, 0x80, 0x18, 0xE0, 0x0C, 0x70, 0x04, 0x19, 0x82, 0x1C,
  0xC1, 0x0C, 0x71, 0x8E, 0x1C, 0xCE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0,
  0x0E, 0x0E, 0xE0, 0x30, 0x30, 0xC0, 0xC0, 0x61, 0x81, 0x81, 0x83, 0x06,
  0x03, 0x06, 0x18, 0x06, 0x0C, 0x60, 0x0C, 0x19, 0x80, 0x18, 0x66, 0x00,
  0x1F, 0x98, 0x00, 0x1E, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x78, 0x00, 0x33, 0xF8, 0x00, 0xCE, 0x30, 0x01, 0x18, 0x30, 0x06,
  0x30, 0x60, 0x18, 0x61, 0x80, 0x60, 0x83, 0x01, 0x83, 0x06, 0x06, 0x06,
  0x0C, 0x18, 0x07, 0xF0, 0x70, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x70, 0x60, 0x18, 0x1C, 0x0C, 0x03, 0x03, 0x01, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x31, 0x81,
  0xDC, 0x30, 0xE6, 0x0E, 0x31, 0x81, 0x98, 0x60, 0x7E, 0x18, 0x0F, 0x0E,
  0x01, 0x83, 0x80, 0xF0, 0xE0, 0x7C, 0x38, 0x3B, 0x87, 0xFC, 0x60, 0xFC,
  0x1C, 0x76, 0xEE, 0xEE, 0xCC, 0xCC, 0x00, 0x08, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x04, 0x00,
  0x38, 0x03, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x03, 0x06, 0x1F, 0xE2, 0x3E, 0x7D, 0x7C, 0x0F, 0xF0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xCC, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xE0, 0x70,
  0x20, 0x10, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0E,
  0x3C, 0x71, 0xC3, 0x86, 0x1C, 0x30, 0xE1, 0x80, 0xFF, 0xFF, 0xF8, 0x31,
  0xEF, 0xBE, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0x81, 0xC3,
  0x80, 0x61, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x18, 0x03, 0x8C, 0x71, 0xCE, 0x38, 0xC7, 0x1C, 0x63, 0x04, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x03, 0x1C, 0x01, 0x86,
  0x01, 0x83, 0x81, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x70, 0x07, 0xC0,
  0x3B, 0x03, 0x8C, 0x1C, 0x30, 0x41, 0xC2, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0x01, 0xC3, 0x00, 0x63, 0x80,
  0x31, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xE0, 0x18, 0x70,
  0x30, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x18, 0x60, 0x31, 0x80, 0xE7, 0x01, 0x9C, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x0F, 0xFF, 0x0F, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x19, 0xF0, 0x3B, 0xFC, 0x36, 0x1C,
  0x38, 0x0E, 0x30, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0xE0, 0x1C, 0x60, 0x18, 0x70, 0x38, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x19, 0xC0, 0x6F, 0xE1, 0xE1,
  0xE3, 0x80, 0xEE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x37, 0x00, 0x66, 0x01, 0xCE, 0x07, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFF, 0x60, 0x06, 0x60, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x0E, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x06, 0x1C, 0x0E, 0x0E, 0x1C, 0x07, 0x70, 0x01, 0xC0, 0x07,
  0xF0, 0x1C, 0x38, 0x38, 0x1C, 0x70, 0x0C, 0x60, 0x0E, 0xE0, 0x0E, 0xC0,
  0x0C, 0xC0, 0x0C, 0xE0, 0x1C, 0x70, 0x38, 0x7F, 0xF0, 0x1F, 0xC0, 0x07,
  0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x60, 0x07, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x1C, 0x3C,
  0x78, 0x1F, 0xF8, 0x06, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1E,
  0x1F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF8, 0xF8, 0x78, 0x07, 0x83, 0xF0, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x08, 0x7F, 0xFE, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFD, 0xFF, 0xF0, 0x30, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x3F, 0x81, 0xF8, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0xFF, 0x00, 0x78, 0xF0, 0x1C, 0x07, 0x06, 0x00, 0x61,
  0xC0, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x3E, 0xC6,
  0x0F, 0xF8, 0xC3, 0x87, 0x30, 0x60, 0xE6, 0x18, 0x1C, 0xC3, 0x03, 0x18,
  0x60, 0x63, 0x0C, 0x0C, 0x61, 0x81, 0x98, 0x30, 0x33, 0x06, 0x0E, 0x60,
  0xC1, 0x8C, 0x1F, 0xF1, 0x81, 0xF6, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x06, 0xC0, 0x0D, 0x80,
  0x3B, 0x00, 0x66, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x30,
  0x60, 0xE0, 0xC1, 0x81, 0x83, 0x03, 0x0F, 0xFE, 0x1F, 0xFE, 0x70, 0x0C,
  0xC0, 0x1B, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x0F,
  0xF8, 0x0F, 0xFE, 0x1C, 0x0F, 0x18, 0x07, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x07, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x78, 0x3F, 0xF0, 0x3F,
  0xFC, 0x30, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x0E, 0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0x03,
  0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x30, 0xE0, 0x70, 0x7F, 0xE0, 0x3F, 0x80, 0x0F,
  0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x18, 0x07, 0x18, 0x07, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xF1,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFC,
  0x1C, 0x0E, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x61, 0xFC, 0xE1, 0xFC,
  0xC2, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x30, 0xE0, 0x70, 0x7F, 0xE0, 0x3F, 0x80, 0x0C, 0x03, 0x86, 0x01,
  0xC7, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30,
  0x0E, 0x38, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0x80, 0x71, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x30,
  0x07, 0x38, 0x03, 0x1C, 0x01, 0x86, 0x01, 0xC3, 0x81, 0xC0, 0xFF, 0xC0,
  0x3F, 0x80, 0x0C, 0x01, 0xC3, 0x00, 0x61, 0xC0, 0x30, 0x60, 0x1C, 0x18,
  0x06, 0x06, 0x03, 0x01, 0x81, 0xC0, 0x60, 0x60, 0x38, 0x38, 0x0C, 0x1C,
  0x03, 0x06, 0x00, 0xFF, 0x80, 0x30, 0xE0, 0x0C, 0x18, 0x07, 0x06, 0x01,
  0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0x80, 0x60, 0xE0,
  0x18, 0x38, 0x07, 0x0C, 0x00, 0xC3, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x0E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x3C, 0x2C, 0x1B, 0x1B,
  0x06, 0xC6, 0x43, 0x61, 0x90, 0xD8, 0x66, 0x66, 0x19, 0x99, 0x86, 0x6C,
  0x61, 0x9B, 0x18, 0xC3, 0x8E, 0x30, 0xE3, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x80, 0x38, 0x0E, 0x01, 0x8F, 0x01,
  0xC7, 0x80, 0xC3, 0x40, 0x61, 0xB0, 0x30, 0xD8, 0x18, 0x6C, 0x0C, 0x36,
  0x0E, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x61, 0x86, 0x30, 0xC3, 0x08, 0x61,
  0x86, 0x31, 0xC3, 0x38, 0xC1, 0x98, 0x60, 0xCC, 0x30, 0x36, 0x18, 0x1B,
  0x0C, 0x0D, 0x8E, 0x06, 0xC6, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x70, 0x07,
  0xF8, 0x1F, 0xF8, 0x70, 0x38, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01,
  0xB8, 0x03, 0x60, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xDC,
  0x01, 0xB0, 0x07, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01,
  0xCC, 0x03, 0x1C, 0x0E, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF,
  0x87, 0x01, 0xE3, 0x00, 0x71, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x38, 0x03, 0x98, 0x01, 0x8C, 0x01, 0xC6, 0x07, 0xC3, 0xFF, 0x81,
  0xFE, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x0E, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x38,
  0x03, 0x38, 0x03, 0x30, 0x07, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x70,
  0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0x60, 0x18, 0x70, 0x38, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x0F,
  0xFC, 0x07, 0xFF, 0x07, 0x01, 0xC3, 0x00, 0x71, 0x80, 0x38, 0xC0, 0x0C,
  0x60, 0x06, 0x30, 0x07, 0x38, 0x03, 0x18, 0x03, 0x8C, 0x03, 0x87, 0xFF,
  0x83, 0xFF, 0x81, 0x87, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x07, 0x0E, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x71,
  0x80, 0x18, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0x81, 0xC3, 0x80, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x30, 0x03, 0x98, 0x01, 0x8E, 0x01, 0xC3, 0x81,
  0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x70, 0x0E, 0x38, 0x06,
  0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x71, 0xC0,
  0x38, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x86,
  0x01, 0x83, 0x81, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0xE0, 0x03, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x38, 0x70, 0x30, 0x30, 0x70, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0,
  0x30, 0xC0, 0x31, 0xC0, 0x31, 0x80, 0x33, 0x80, 0x33, 0x00, 0x1B, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xC0, 0xE0, 0xF0, 0x38,
  0x3C, 0x1E, 0x1B, 0x07, 0x06, 0xC1, 0x41, 0xB0, 0xD0, 0xCC, 0x34, 0x33,
  0x09, 0x0C, 0xC2, 0x43, 0x31, 0x91, 0x8C, 0x44, 0x63, 0x11, 0x18, 0xCC,
  0x46, 0x33, 0x13, 0x0C, 0x84, 0xC3, 0x61, 0x30, 0xD8, 0x48, 0x34, 0x16,
  0x0D, 0x05, 0x83, 0xC1, 0x60, 0xE0, 0xF0, 0x38, 0x3C, 0x0E, 0x0F, 0x03,
  0x83, 0x80, 0x0E, 0x00, 0x70, 0x60, 0x06, 0x07, 0x00, 0xC0, 0x30, 0x1C,
  0x03, 0x83, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x1C, 0xE0, 0x00, 0xCC,
  0x00, 0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0x98, 0x00, 0x39, 0x80, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0E,
  0x0E, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0x70, 0x70, 0x03, 0x0E,
  0x00, 0x38, 0xC0, 0x03, 0xF0, 0x03, 0x98, 0x01, 0x8C, 0x01, 0x87, 0x01,
  0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x70, 0xE0, 0x18, 0x60, 0x0C, 0x60, 0x07,
  0x30, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0x07,
  0xF8, 0x3F, 0x83, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x06, 0x07, 0xF8, 0x3F, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x7F, 0x83, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xD8, 0x07,
  0x30, 0x18, 0xC0, 0xC3, 0x03, 0x06, 0x18, 0x18, 0xE0, 0x63, 0x01, 0x98,
  0x03, 0xE0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x0C, 0x71, 0x80, 0x07,
  0xF3, 0x0F, 0x3F, 0x1C, 0x0E, 0x38, 0x0E, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x70, 0x38, 0x3F, 0xD8, 0x1F, 0x98, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x7E,
  0x0F, 0xDE, 0x3C, 0x0E, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66,
  0x00, 0xDC, 0x03, 0xB0, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00,
  0xEE, 0x01, 0x9E, 0x07, 0x37, 0xFC, 0x67, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xE0, 0x71, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x01, 0x98, 0x03, 0x30, 0x0C,
  0x70, 0x38, 0x7F, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x1F, 0xCC, 0x1E, 0x7E, 0x1C,
  0x0E, 0x1C, 0x07, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x71,
  0x80, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03,
  0x86, 0x01, 0xC3, 0x81, 0xC0, 0xFF, 0x60, 0x3F, 0x30, 0x0F, 0xF0, 0x79,
  0xE3, 0x81, 0xCC, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x6C, 0x03, 0x38,
  0x1C, 0x7F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x02, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE6, 0x3C, 0xFC, 0xE0, 0x71, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x70, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03,
  0x9C, 0x0B, 0x1C, 0x3E, 0x3F, 0xD8, 0x0E, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x3F, 0xF0, 0x7F, 0x80, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x7E, 0x0F, 0x9E,
  0x3C, 0x0E, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0xDC,
  0x03, 0xB0, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x6E, 0x01,
  0xDC, 0x03, 0x30, 0x06, 0x60, 0x0C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x0E, 0x30, 0x0E, 0x38, 0x0E, 0x1C, 0x0E, 0x0C, 0x0E, 0x06, 0x06, 0x03,
  0x06, 0x01, 0x86, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x60, 0xC0, 0x30, 0x70,
  0x18, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x07, 0x01, 0xC3, 0x00, 0x71, 0x80,
  0x18, 0xFF, 0x07, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x7F, 0xE1, 0xFF, 0x1B, 0xCF, 0x8E, 0x79, 0xCE, 0x18, 0x66, 0x0C,
  0x33, 0x06, 0x19, 0x86, 0x0C, 0xC3, 0x06, 0x61, 0x87, 0x70, 0xC3, 0x30,
  0x61, 0x98, 0x30, 0xCC, 0x10, 0x66, 0x18, 0x33, 0x0C, 0x19, 0x86, 0x19,
  0x83, 0x0C, 0xC1, 0x86, 0x61, 0x83, 0x00, 0x19, 0xF8, 0x3E, 0x78, 0xF0,
  0x39, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x07, 0x70, 0x0E,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0xB8, 0x07, 0x70,
  0x0C, 0xC0, 0x19, 0x80, 0x30, 0x0F, 0xF0, 0x7F, 0xE3, 0x81, 0xCC, 0x03,
  0x60, 0x0D, 0x80, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0x38, 0x1C, 0x7F, 0xE0, 0xFE,
  0x00, 0x0D, 0xFC, 0x0F, 0xDE, 0x1E, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0C, 0x78, 0x1C, 0x6F, 0xF8, 0x67,
  0xE0, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x07, 0xF3, 0x0F, 0x7F, 0x1C, 0x0E, 0x38, 0x0E, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x70, 0x38, 0x3F, 0xD8, 0x1F,
  0x98, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x3B, 0xF8, 0x6E, 0xF8, 0xE0, 0x31, 0xC0, 0x73, 0x00, 0xEE, 0x01,
  0xDC, 0x03, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x07,
  0xFC, 0x1E, 0x7C, 0x60, 0x19, 0xC0, 0x33, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xB8, 0x03, 0x70, 0x0C, 0x7F, 0xF8, 0x7F, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x18, 0x03, 0x38, 0x07, 0x38, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x70,
  0x30, 0x3F, 0xF0, 0x1F, 0xC0, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x77, 0x00,
  0xC6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x30, 0x30, 0x60, 0xE0, 0xE1, 0x80,
  0xC7, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x60, 0x0D, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xC1, 0x81, 0xE0, 0xC1, 0xB0, 0xE0, 0xD8, 0x50, 0x6C,
  0x28, 0x66, 0x36, 0x33, 0x13, 0x19, 0x89, 0x98, 0xCC, 0xCC, 0x64, 0x66,
  0x32, 0x36, 0x1B, 0x1B, 0x0D, 0x0D, 0x86, 0x87, 0x83, 0xC3, 0xC1, 0xC1,
  0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x00, 0x1C, 0x03, 0xC3, 0x00, 0xC0, 0xE0,
  0x60, 0x18, 0x38, 0x07, 0x1C, 0x00, 0xCE, 0x00, 0x1B, 0x00, 0x07, 0x80,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x0E, 0x30, 0x03,
  0x0E, 0x01, 0x81, 0x80, 0xC0, 0x70, 0x70, 0x0C, 0x38, 0x03, 0x80, 0x30,
  0x0E, 0xE0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x07,
  0x70, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x9C,
  0x0F, 0x1C, 0x3C, 0x3F, 0xD8, 0x0C, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x3F, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0x1F, 0xFE,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60,
  0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0x86, 0x0C, 0x18, 0x30, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x7F,
  0x00, 0x7F, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x3F, 0x03,
  0x73, 0x83, 0x61, 0xC7, 0x60, 0xE6, 0x60, 0x7C, 0x80, 0x10,
};

const GFXglyph JetBrainsMono_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 7, 24, 20, 7, -24 },
  { 22, 11, 10, 20, 6, -24 },
  { 36, 19, 24, 20, 1, -24 },
  { 93, 17, 34, 20, 2, -29 },
  { 166, 23, 24, 20, -1, -24 },
  { 235, 18, 24, 20, 1, -24 },
  { 289, 4, 10, 20, 10, -24 },
  { 294, 13, 32, 20, 6, -28 },
  { 346, 13, 32, 20, 2, -28 },
  { 398, 17, 17, 20, 2, -20 },
  { 435, 16, 16, 20, 2, -19 },
  { 467, 7, 10, 20, 4, -5 },
  { 476, 11, 2, 20, 5, -12 },
  { 479, 6, 5, 20, 6, -5 },
  { 483, 19, 31, 20, 1, -27 },
  { 557, 17, 24, 20, 2, -24 },
  { 608, 14, 24, 20, 2, -24 },
  { 650, 17, 24, 20, 2, -24 },
  { 701, 16, 24, 20, 2, -24 },
  { 749, 15, 24, 20, 2, -24 },
  { 794, 16, 24, 20, 2, -24 },
  { 842, 15, 24, 20, 2, -24 },
  { 887, 16, 24, 20, 4, -24 },
  { 935, 16, 24, 20, 2, -24 },
  { 983, 16, 24, 20, 3, -24 },
  { 1031, 8, 18, 20, 6, -18 },
  { 1049, 10, 23, 20, 4, -18 },
  { 1078, 16, 17, 20, 3, -19 },
  { 1112, 15, 10, 20, 3, -16 },
  { 1131, 15, 17, 20, 2, -19 },
  { 1163, 13, 24, 20, 5, -24 },
  { 1202, 19, 30, 20, 1, -24 },
  { 1274, 15, 24, 20, 1, -24 },
  { 1319, 16, 24, 20, 2, -24 },
  { 1367, 16, 24, 20, 3, -24 },
  { 1415, 16, 24, 20, 2, -24 },
  { 1463, 17, 24, 20, 2, -24 },
  { 1514, 18, 24, 20, 2, -24 },
  { 1568, 16, 24, 20, 3, -24 },
  { 1616, 17, 24, 20, 2, -24 },
  { 1667, 16, 24, 20, 2, -24 },
  { 1715, 17, 24, 20, 1, -24 },
  { 1766, 18, 24, 20, 2, -24 },
  { 1820, 14, 24, 20, 2, -24 },
  { 1862, 18, 24, 20, 1, -24 },
  { 1916, 17, 24, 20, 2, -24 },
  { 1967, 15, 24, 20, 3, -24 },
  { 2012, 17, 24, 20, 2, -24 },
  { 2063, 16, 30, 20, 2, -24 },
  { 2123, 17, 24, 20, 2, -24 },
  { 2174, 17, 24, 20, 2, -24 },
  { 2225, 16, 24, 20, 4, -24 },
  { 2273, 17, 24, 20, 2, -24 },
  { 2324, 16, 24, 20, 4, -24 },
  { 2372, 18, 24, 20, 3, -24 },
  { 2426, 20, 24, 20, 0, -24 },
  { 2486, 17, 24, 20, 4, -24 },
  { 2537, 18, 24, 20, 1, -24 },
  { 2591, 13, 31, 20, 5, -27 },
  { 2642, 9, 31, 20, 6, -27 },
  { 2677, 13, 31, 20, 3, -27 },
  { 2728, 14, 13, 20, 3, -24 },
  { 2751, 16, 2, 20, 0, 1 },
  { 2755, 5, 5, 20, 9, -26 },
  { 2759, 16, 18, 20, 2, -18 },
  { 2795, 15, 24, 20, 2, -24 },
  { 2840, 15, 18, 20, 3, -18 },
  { 2874, 17, 24, 20, 2, -24 },
  { 2925, 14, 18, 20, 3, -18 },
  { 2957, 21, 30, 20, -1, -24 },
  { 3036, 15, 24, 20, 3, -18 },
  { 3081, 15, 24, 20, 2, -24 },
  { 3126, 16, 25, 20, 1, -25 },
  { 3176, 16, 31, 20, 1, -25 },
  { 3238, 17, 24, 20, 2, -24 },
  { 3289, 13, 24, 20, 4, -24 },
  { 3328, 17, 18, 20, 1, -18 },
  { 3367, 15, 18, 20, 2, -18 },
  { 3401, 14, 18, 20, 3, -18 },
  { 3433, 16, 24, 20, 1, -18 },
  { 3481, 16, 24, 20, 2, -18 },
  { 3529, 15, 18, 20, 3, -18 },
  { 3563, 15, 18, 20, 2, -18 },
  { 3597, 15, 23, 20, 3, -23 },
  { 3641, 16, 18, 20, 2, -18 },
  { 3677, 15, 18, 20, 4, -18 },
  { 3711, 17, 18, 20, 3, -18 },
  { 3750, 18, 18, 20, 1, -18 },
  { 3791, 15, 24, 20, 3, -18 },
  { 3836, 16, 18, 20, 2, -18 },
  { 3872, 17, 31, 20, 3, -27 },
  { 3938, 7, 31, 20, 7, -27 },
  { 3966, 16, 31, 20, 1, -27 },
  { 4028, 16, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC33PT7B_H_
