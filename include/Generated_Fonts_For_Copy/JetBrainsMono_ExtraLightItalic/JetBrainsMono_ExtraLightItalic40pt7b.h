#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC40PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xC0, 0xCC, 0x0C,
  0x00, 0x18, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0,
  0x07, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x38, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x38,
  0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x03,
  0x80, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x03, 0x81, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x1C, 0x00,
  0x60, 0x38, 0x00, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0x8C, 0xF0,
  0x38, 0x43, 0x83, 0x86, 0x1C, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x20, 0x30, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x30, 0x00, 0x79, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0x9E,
  0x00, 0x0C, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x8E, 0x0C, 0x1C, 0x70, 0x60, 0xE1, 0xC3, 0x0E, 0x0E, 0x18, 0xF0,
  0x3C, 0xCF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0xE0, 0x7F, 0x80, 0x38, 0x1C, 0x38, 0x0E, 0x07, 0x07,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x18, 0x1C, 0x18, 0x03, 0x03, 0x06, 0x00,
  0x60, 0x61, 0xC0, 0x0C, 0x0C, 0x70, 0x01, 0x83, 0x8C, 0x00, 0x38, 0xE3,
  0x00, 0x07, 0xF8, 0xC0, 0x00, 0x3E, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0xFC, 0x00, 0x06, 0x3F,
  0xC0, 0x01, 0x8E, 0x18, 0x00, 0x63, 0x83, 0x80, 0x1C, 0x60, 0x70, 0x07,
  0x0C, 0x0C, 0x01, 0xC1, 0x81, 0x80, 0x30, 0x30, 0x30, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0xC1, 0xC0, 0xC0, 0x18, 0x70, 0x38, 0x03, 0xFC, 0x0E, 0x00,
  0x3F, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x70,
  0x78, 0x03, 0x80, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x38, 0x01, 0x38, 0x70,
  0x38, 0xE0, 0xE0, 0xC3, 0x03, 0x87, 0x1C, 0x07, 0x38, 0x70, 0x1D, 0xC1,
  0xC0, 0x3E, 0x07, 0x00, 0xF8, 0x18, 0x01, 0xC0, 0x60, 0x07, 0x81, 0x80,
  0x3E, 0x07, 0x01, 0xDC, 0x1E, 0x1E, 0x70, 0x7F, 0xF0, 0xE0, 0x7F, 0x01,
  0xC0, 0x77, 0x77, 0xFE, 0xEE, 0xEE, 0xCC, 0x00, 0x01, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0xC0, 0x02, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0,
  0xC0, 0xFF, 0xC6, 0x3F, 0x7F, 0x37, 0xF0, 0x7F, 0xFC, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1D, 0x80, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x01, 0xE1,
  0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x20, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0C, 0x07, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0xFD, 0xFF, 0xF7, 0xCF, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x03, 0x81, 0xE0, 0xE0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03,
  0x98, 0x00, 0x73, 0x00, 0x0E, 0xE1, 0xC1, 0x9C, 0x3C, 0x73, 0x8F, 0x8E,
  0x70, 0xE1, 0xCC, 0x00, 0x39, 0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x00, 0xE3,
  0xC0, 0x38, 0x3C, 0x1E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0x38, 0x07, 0x8E, 0x03, 0x83, 0x80,
  0xC0, 0xC0, 0x40, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0,
  0x78, 0x0E, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x03,
  0x18, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC6,
  0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70,
  0x3C, 0x1E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x01, 0xC3, 0x80, 0x61, 0xC0, 0x18, 0xF0, 0x0E, 0x38, 0x03, 0x9C, 0x00,
  0xE6, 0x00, 0x3B, 0x80, 0x0C, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x63, 0xF8, 0x1D, 0xFF, 0x83, 0xF0, 0xF8, 0x78, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x01, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x9E, 0x00, 0xEF, 0xF0, 0x3F, 0xBF, 0x07, 0x80, 0xF1, 0xE0,
  0x0E, 0x38, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x76, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x73, 0x00, 0x0C, 0x70, 0x03, 0x8F, 0x00,
  0xE0, 0xF0, 0x78, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xC0, 0x03, 0xB0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00,
  0xC7, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0C, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x07,
  0x87, 0x80, 0x3D, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0x9E, 0x00,
  0xE0, 0x78, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x01, 0xC6, 0x00, 0x1C, 0x60, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x07,
  0x03, 0xC0, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x0F, 0x01, 0xC1, 0xC0, 0x1C, 0x70, 0x03, 0x9C, 0x00,
  0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0xC0, 0x78, 0x3F, 0xFF,
  0x03, 0xFD, 0xC0, 0x0C, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x83, 0xE1, 0xF8,
  0x7E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE1, 0xF8, 0xFC, 0x1F, 0x00,
  0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x08, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF8,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83,
  0x80, 0x03, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x31, 0xC0, 0x7E, 0x63, 0x81, 0xFE, 0xC7, 0x07, 0x07, 0x8C, 0x0C,
  0x07, 0x18, 0x38, 0x0E, 0x30, 0x70, 0x18, 0xE0, 0xC0, 0x31, 0xC1, 0x80,
  0x63, 0x83, 0x01, 0xC7, 0x0E, 0x03, 0x8C, 0x1C, 0x07, 0x18, 0x38, 0x0C,
  0x30, 0x70, 0x18, 0xE0, 0xE0, 0x71, 0xC0, 0xF3, 0x63, 0x81, 0xFC, 0xC7,
  0x00, 0xF2, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03, 0x18,
  0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x18,
  0x07, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x38,
  0x38, 0x07, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x03, 0x8E, 0x00, 0x31,
  0xC0, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0E, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x06, 0x03, 0xE0, 0xE0, 0x0F,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00,
  0x71, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x07, 0x81, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0x80, 0x78, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x00, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x70, 0x60, 0x7F, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x78,
  0x1C, 0x0E, 0x00, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x03,
  0x8E, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x81,
  0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x06,
  0x07, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0x71, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x00,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0xC3, 0x00,
  0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x60,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x78, 0x1C, 0x0E,
  0x00, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x7F, 0xC7, 0x07, 0xFC, 0x70, 0x01,
  0xC7, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x81, 0xC0, 0x3F,
  0xF8, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C,
  0x1C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0x80,
  0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0x00, 0x18, 0x38, 0x01,
  0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x00, 0x18, 0x18,
  0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x18, 0x00, 0xE0, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0xC0, 0x38, 0x0F, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x80,
  0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x1C, 0x07,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x06, 0x00,
  0x38, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1F, 0x01, 0xB0, 0xD8, 0x1F, 0x8E, 0xC0,
  0xDC, 0x76, 0x0E, 0xC3, 0x30, 0x66, 0x19, 0xC7, 0x30, 0xC6, 0x33, 0x86,
  0x33, 0x9C, 0x71, 0x98, 0xE3, 0x8D, 0xC6, 0x1C, 0x6C, 0x30, 0xE1, 0xE1,
  0x86, 0x0E, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x07, 0x0C, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xE0, 0x0C, 0x1F, 0x00,
  0x60, 0xFC, 0x07, 0x07, 0xE0, 0x38, 0x33, 0x01, 0xC1, 0x98, 0x0E, 0x0C,
  0xC0, 0x60, 0xE7, 0x03, 0x07, 0x18, 0x18, 0x38, 0xC1, 0xC1, 0xC6, 0x0E,
  0x0C, 0x38, 0x70, 0x61, 0xC3, 0x07, 0x06, 0x18, 0x38, 0x30, 0xC1, 0xC1,
  0x8E, 0x0E, 0x0E, 0x70, 0x60, 0x33, 0x83, 0x01, 0x9C, 0x38, 0x0C, 0xC1,
  0xC0, 0x76, 0x0E, 0x03, 0xB0, 0x70, 0x0F, 0x83, 0x00, 0x7C, 0x18, 0x03,
  0xE0, 0xC0, 0x1E, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x03, 0x81, 0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xC0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x1C, 0x00, 0x63,
  0x80, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0x8E,
  0x00, 0x31, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x18, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x38, 0x3C,
  0x1E, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x60, 0x1F, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0,
  0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x60, 0x0F, 0x81, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0x81,
  0xE0, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03,
  0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x06,
  0x30, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x18,
  0xE0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x38, 0x3C, 0x1E, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0x80, 0x7C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C,
  0x38, 0x01, 0xE1, 0xC0, 0x1E, 0x0C, 0x03, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x38, 0x18, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x01, 0xE0, 0x70,
  0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x40,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xF8,
  0x1E, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0xC0,
  0x07, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x18,
  0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03,
  0x8E, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x07, 0x00,
  0xE0, 0x78, 0x3C, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xE0, 0x00, 0xEC,
  0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x18,
  0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x30, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x31,
  0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x38, 0x0E, 0xE0, 0x70, 0x19,
  0xC0, 0xA0, 0x73, 0x03, 0x40, 0xC6, 0x06, 0x81, 0x8C, 0x0F, 0x07, 0x18,
  0x36, 0x0E, 0x30, 0x6C, 0x18, 0x60, 0xD8, 0x30, 0xC1, 0x30, 0xE1, 0x86,
  0x61, 0xC3, 0x0C, 0xC3, 0x06, 0x19, 0x86, 0x0C, 0x63, 0x1C, 0x18, 0xC6,
  0x30, 0x31, 0x8C, 0x60, 0x66, 0x18, 0xC0, 0xCC, 0x33, 0x81, 0x98, 0x66,
  0x07, 0x20, 0xCC, 0x0E, 0xC1, 0xB8, 0x1D, 0x83, 0x60, 0x3B, 0x06, 0xC0,
  0x7C, 0x0D, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0x40, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x71, 0x80,
  0x00, 0x33, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x67, 0x00,
  0x00, 0xE7, 0x00, 0x01, 0xC3, 0x00, 0x03, 0x83, 0x80, 0x03, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0x60, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x83, 0x00, 0x30,
  0x38, 0x07, 0x03, 0x80, 0xE0, 0x18, 0x0C, 0x01, 0xC1, 0xC0, 0x1C, 0x38,
  0x00, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x19,
  0xC0, 0x1C, 0xE0, 0x0C, 0x30, 0x0E, 0x18, 0x0E, 0x0E, 0x06, 0x03, 0x07,
  0x01, 0x87, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x1B, 0x80, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE1, 0xC3, 0x86, 0x1C, 0x03, 0xF8, 0xE0, 0xFF, 0xD8,
  0x3C, 0x1B, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x73,
  0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC6,
  0x00, 0x38, 0xC0, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE1, 0xC0, 0x3C, 0x3C, 0x1F, 0x83, 0xFF, 0x60, 0x3F, 0x8C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x63, 0xF8, 0x0D, 0xFF, 0x83, 0xB0, 0x78,
  0x78, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x39,
  0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3,
  0x00, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03, 0x8F,
  0x00, 0xE1, 0xB0, 0x78, 0x37, 0xFE, 0x0E, 0x7F, 0x80, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x00,
  0x1D, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0xE0, 0x07, 0x38,
  0x01, 0xC7, 0x00, 0xE1, 0xE0, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x3F, 0x8E, 0x07, 0xFE, 0xC0, 0xF0, 0x6C,
  0x1C, 0x03, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01,
  0x87, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x00,
  0x38, 0x60, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x0F, 0x07, 0x00, 0xF0, 0x78, 0x3F, 0x03, 0xFF, 0x60, 0x1F, 0xC6, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x0E, 0x38, 0x01, 0xCE,
  0x00, 0x73, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFE, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x01, 0xC7, 0x00, 0xE1, 0xE0, 0x70, 0x3F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0xE0, 0xFF, 0xD8,
  0x3C, 0x1B, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x73,
  0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC6,
  0x00, 0x38, 0xC0, 0x07, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x70, 0x0F, 0x0F,
  0x03, 0xE0, 0xFF, 0xDC, 0x0F, 0xF3, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x63, 0xF8, 0x0D,
  0xFF, 0x83, 0xB0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0xC6, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x1C, 0x00, 0x63, 0x80,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x30, 0x01, 0x8E, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x0C, 0x00, 0x70, 0x60, 0x07,
  0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x60,
  0x78, 0x03, 0x03, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x70, 0x70, 0x03, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xC0, 0x07, 0x0E,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x03,
  0xFF, 0x0D, 0xF1, 0xF0, 0xFF, 0xDF, 0xC7, 0x8F, 0x0E, 0x38, 0x38, 0x71,
  0xC1, 0x83, 0x8C, 0x0C, 0x1C, 0x60, 0x60, 0xE7, 0x07, 0x07, 0x38, 0x38,
  0x31, 0xC1, 0x81, 0x8E, 0x0C, 0x0C, 0x60, 0x60, 0xE3, 0x03, 0x07, 0x18,
  0x38, 0x39, 0xC1, 0xC1, 0x8E, 0x0C, 0x0C, 0x70, 0x60, 0x63, 0x03, 0x07,
  0x18, 0x18, 0x38, 0xC1, 0xC1, 0xCE, 0x0E, 0x0E, 0x70, 0x70, 0x60, 0x0C,
  0x7F, 0x01, 0xBF, 0xF0, 0x76, 0x0F, 0x0F, 0x00, 0xE1, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x18, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x63, 0x80,
  0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00,
  0x31, 0xC0, 0x06, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x70,
  0x0E, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0x9C, 0x00, 0x67, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x03, 0x98, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0xE1, 0xE0,
  0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x06, 0x3F, 0x80, 0x6F, 0xFC, 0x0F,
  0xC1, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xC0, 0x07, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x3C, 0x03, 0x83, 0x60, 0xF0, 0x37, 0xFE, 0x07, 0x3F,
  0xC0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0xE0, 0xFF, 0xD8,
  0x3C, 0x1B, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x73,
  0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0xC6,
  0x00, 0x38, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x1B, 0x83, 0xFF, 0x60, 0x3F, 0x8C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x1C, 0xFF, 0x03, 0xBF, 0xF0, 0x7C, 0x0F, 0x0F,
  0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xC7, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0xE1, 0xE0, 0x3C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xB0,
  0x00, 0xCE, 0x00, 0x73, 0xC0, 0x38, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xE0,
  0x0F, 0xF0, 0x18, 0x00, 0xE3, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0x8E,
  0x00, 0x31, 0xC0, 0x0E, 0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x38,
  0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x0C, 0x00, 0xC1, 0xC0, 0x38, 0x3C,
  0x1E, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x18, 0x03, 0x86, 0x00, 0xE1, 0x80,
  0x70, 0x70, 0x1C, 0x1C, 0x06, 0x07, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x70,
  0x0C, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x19, 0xC0, 0x06, 0x60, 0x01,
  0xB8, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x3F,
  0x03, 0x81, 0x98, 0x1C, 0x0C, 0xC1, 0xE0, 0xE6, 0x0F, 0x07, 0x30, 0xD8,
  0x31, 0x86, 0xC1, 0x8C, 0x36, 0x1C, 0x63, 0x30, 0xC3, 0x19, 0x86, 0x18,
  0xCC, 0x70, 0xCC, 0x63, 0x06, 0x61, 0x18, 0x33, 0x09, 0xC1, 0xB0, 0x4C,
  0x0D, 0x82, 0x60, 0x6C, 0x17, 0x03, 0xC0, 0xB0, 0x1E, 0x05, 0x80, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x1C, 0x01,
  0xC0, 0x70, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x07, 0x0E, 0x00,
  0x1C, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0xE0, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x80, 0x38, 0x00, 0xCE, 0x00,
  0x33, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x19,
  0xC0, 0x06, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x0E, 0x60,
  0x03, 0xB8, 0x00, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x0F, 0x1E, 0x0F,
  0xC3, 0xFF, 0x70, 0x7F, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C,
  0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0xE7, 0xF0, 0x1D,
  0xC7, 0x03, 0xB0, 0x70, 0x6E, 0x0E, 0x0D, 0xC0, 0xF7, 0xB8, 0x0F, 0xE6,
  0x00, 0x70,
};

const GFXglyph JetBrainsMono_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 29, 24, 8, -29 },
  { 30, 12, 12, 24, 8, -29 },
  { 48, 23, 29, 24, 1, -29 },
  { 132, 21, 41, 24, 2, -35 },
  { 240, 27, 29, 24, -1, -29 },
  { 338, 22, 30, 24, 1, -30 },
  { 421, 4, 12, 24, 12, -29 },
  { 427, 16, 39, 24, 7, -34 },
  { 505, 16, 39, 24, 2, -34 },
  { 583, 21, 20, 24, 2, -24 },
  { 636, 19, 19, 24, 3, -23 },
  { 682, 10, 12, 24, 4, -6 },
  { 697, 13, 2, 24, 6, -14 },
  { 701, 7, 6, 24, 7, -6 },
  { 707, 23, 37, 24, 1, -33 },
  { 814, 19, 30, 24, 3, -30 },
  { 886, 18, 29, 24, 2, -29 },
  { 952, 20, 30, 24, 2, -30 },
  { 1027, 20, 29, 24, 2, -29 },
  { 1100, 18, 29, 24, 3, -29 },
  { 1166, 19, 29, 24, 3, -29 },
  { 1235, 19, 29, 24, 2, -29 },
  { 1304, 19, 29, 24, 5, -29 },
  { 1373, 20, 30, 24, 2, -30 },
  { 1448, 19, 30, 24, 4, -30 },
  { 1520, 10, 22, 24, 7, -22 },
  { 1548, 12, 28, 24, 5, -22 },
  { 1590, 18, 20, 24, 4, -23 },
  { 1635, 19, 12, 24, 3, -19 },
  { 1664, 19, 20, 24, 2, -23 },
  { 1712, 16, 29, 24, 6, -29 },
  { 1770, 23, 37, 24, 1, -30 },
  { 1877, 19, 29, 24, 1, -29 },
  { 1946, 20, 29, 24, 2, -29 },
  { 2019, 20, 30, 24, 3, -30 },
  { 2094, 20, 29, 24, 2, -29 },
  { 2167, 20, 29, 24, 3, -29 },
  { 2240, 21, 29, 24, 3, -29 },
  { 2317, 20, 30, 24, 3, -30 },
  { 2392, 21, 29, 24, 2, -29 },
  { 2469, 19, 29, 24, 3, -29 },
  { 2538, 21, 29, 24, 1, -29 },
  { 2615, 22, 29, 24, 2, -29 },
  { 2695, 17, 29, 24, 3, -29 },
  { 2757, 21, 29, 24, 2, -29 },
  { 2834, 21, 29, 24, 2, -29 },
  { 2911, 19, 30, 24, 3, -30 },
  { 2983, 22, 29, 24, 2, -29 },
  { 3063, 19, 37, 24, 3, -30 },
  { 3151, 21, 29, 24, 2, -29 },
  { 3228, 21, 30, 24, 2, -30 },
  { 3307, 20, 29, 24, 5, -29 },
  { 3380, 20, 29, 24, 3, -29 },
  { 3453, 19, 29, 24, 5, -29 },
  { 3522, 23, 29, 24, 3, -29 },
  { 3606, 24, 29, 24, 0, -29 },
  { 3693, 20, 29, 24, 5, -29 },
  { 3766, 21, 29, 24, 2, -29 },
  { 3843, 15, 37, 24, 6, -33 },
  { 3913, 11, 37, 24, 7, -33 },
  { 3964, 15, 37, 24, 4, -33 },
  { 4034, 17, 15, 24, 4, -29 },
  { 4066, 20, 2, 24, 0, 1 },
  { 4071, 6, 5, 24, 11, -31 },
  { 4075, 19, 22, 24, 3, -22 },
  { 4128, 19, 29, 24, 2, -29 },
  { 4197, 18, 22, 24, 3, -22 },
  { 4247, 20, 29, 24, 3, -29 },
  { 4320, 18, 22, 24, 3, -22 },
  { 4370, 25, 36, 24, -1, -29 },
  { 4483, 19, 29, 24, 3, -22 },
  { 4552, 19, 29, 24, 2, -29 },
  { 4621, 18, 31, 24, 2, -31 },
  { 4691, 20, 38, 24, 1, -31 },
  { 4786, 21, 29, 24, 2, -29 },
  { 4863, 16, 29, 24, 4, -29 },
  { 4921, 21, 22, 24, 1, -22 },
  { 4979, 19, 22, 24, 2, -22 },
  { 5032, 18, 22, 24, 3, -22 },
  { 5082, 20, 29, 24, 1, -22 },
  { 5155, 19, 29, 24, 3, -22 },
  { 5224, 19, 22, 24, 3, -22 },
  { 5277, 18, 22, 24, 3, -22 },
  { 5327, 18, 28, 24, 4, -28 },
  { 5390, 19, 22, 24, 3, -22 },
  { 5443, 18, 22, 24, 5, -22 },
  { 5493, 21, 22, 24, 3, -22 },
  { 5551, 22, 22, 24, 1, -22 },
  { 5612, 18, 29, 24, 3, -22 },
  { 5678, 19, 22, 24, 2, -22 },
  { 5731, 20, 37, 24, 4, -33 },
  { 5824, 9, 37, 24, 8, -33 },
  { 5866, 20, 37, 24, 1, -33 },
  { 5959, 19, 8, 24, 3, -18 },
};

const GFXfont JetBrainsMono_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC40PT7B_H_
