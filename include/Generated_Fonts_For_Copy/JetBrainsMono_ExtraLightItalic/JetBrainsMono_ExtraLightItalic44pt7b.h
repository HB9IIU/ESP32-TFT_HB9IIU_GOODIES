#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC44PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0F, 0x87, 0xE3, 0xE1,
  0xF0, 0x78, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0xF0, 0x7B, 0xC1, 0xEE,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x30, 0x18, 0xC0, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60,
  0x1C, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x43, 0x80, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x30,
  0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0x30, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0x80, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x03,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xE6, 0x78, 0x07, 0x8C,
  0x78, 0x1C, 0x18, 0x70, 0x38, 0x30, 0xE0, 0x60, 0xE1, 0xC1, 0xC1, 0x83,
  0x83, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x18, 0x00,
  0x1E, 0x30, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x19, 0xE0, 0x00, 0x71, 0xE0, 0x00,
  0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0E, 0x1C, 0x0C,
  0x1C, 0x38, 0x38, 0x38, 0x70, 0x60, 0xF0, 0xE0, 0xC1, 0xC1, 0xE1, 0x87,
  0x01, 0xF3, 0x7C, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0xC0, 0x38,
  0x70, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x06, 0x03, 0x01, 0xC0, 0x38, 0x0C,
  0x0E, 0x00, 0xE0, 0x70, 0x30, 0x03, 0x81, 0xC1, 0x80, 0x0C, 0x07, 0x0C,
  0x00, 0x30, 0x18, 0x70, 0x00, 0xC0, 0xE3, 0x80, 0x03, 0x87, 0x1C, 0x00,
  0x07, 0xFC, 0xE0, 0x00, 0x0F, 0xC3, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x20, 0x00, 0x01,
  0xC7, 0xF0, 0x00, 0x0E, 0x3F, 0xE0, 0x00, 0x31, 0xC1, 0xC0, 0x01, 0x86,
  0x07, 0x00, 0x0E, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x70, 0x03, 0x83, 0x01,
  0xC0, 0x1C, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x18, 0x03, 0x00, 0xC0, 0xE0,
  0x18, 0x03, 0x03, 0x80, 0xE0, 0x0E, 0x1C, 0x07, 0x00, 0x3F, 0xE0, 0x38,
  0x00, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xF0, 0xF8, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x38, 0x07, 0x3C, 0x38, 0x0E,
  0x38, 0x1C, 0x1C, 0x38, 0x1E, 0x1C, 0x30, 0x0E, 0x38, 0x70, 0x0F, 0x70,
  0x70, 0x07, 0xE0, 0x70, 0x03, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x03, 0xC0,
  0x70, 0x03, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x1E, 0x70, 0x7C, 0x7C, 0x70,
  0x3F, 0xF8, 0x38, 0x1F, 0xE0, 0x3C, 0x7B, 0xDE, 0xE7, 0x3B, 0xDE, 0xF7,
  0x39, 0xCE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x30, 0x1C, 0x0E, 0xFC, 0x30, 0x7D, 0xFE, 0x67, 0xFC, 0xFE, 0xDF,
  0xC0, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x76, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0x38, 0x07, 0x80, 0x78, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x38, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF8,
  0x7C, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x83, 0x03, 0x8E, 0x1E, 0x1C, 0x38, 0x78,
  0x71, 0xC1, 0xE1, 0xC7, 0x07, 0x87, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xF0, 0x03, 0x81, 0xE0, 0x1E,
  0x07, 0xE3, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x38, 0x03, 0xE3, 0x80, 0x78, 0x70,
  0x07, 0x07, 0x00, 0xC0, 0x70, 0x08, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x3E, 0x1F, 0x00, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x01, 0x07, 0x80, 0x60, 0xF0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0,
  0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0xFE, 0x01, 0xDF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7C, 0x07, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0,
  0x07, 0x07, 0x00, 0x78, 0x3E, 0x0F, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x18, 0x00, 0xEF, 0xF8, 0x1D,
  0xFF, 0xC1, 0xF0, 0x3E, 0x3C, 0x01, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xF7,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCF, 0x00, 0x3C, 0x78, 0x07,
  0x87, 0xC1, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x38, 0x00, 0x79,
  0xC0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0x00, 0x3C,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0xF8,
  0x07, 0x80, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0xE0, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0xC1, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xF0,
  0x3C, 0x1E, 0x01, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xF7, 0x00, 0x07, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x01, 0xCF, 0x00, 0x3C, 0x70, 0x07, 0x87, 0xC0, 0xF8,
  0x3F, 0xFF, 0x01, 0xFE, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x03, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x60,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x1F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1E, 0x03, 0xC0,
  0x1C, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0xC0, 0x3F, 0x38, 0xC0, 0x7F, 0xD8, 0xE0, 0x78, 0x2C, 0x70, 0x38,
  0x0E, 0x38, 0x38, 0x07, 0x1C, 0x1C, 0x03, 0x8E, 0x0E, 0x01, 0xC6, 0x07,
  0x00, 0xC3, 0x03, 0x00, 0x63, 0x81, 0x80, 0x71, 0xC1, 0xC0, 0x38, 0xE0,
  0xE0, 0x1C, 0x70, 0x70, 0x0E, 0x30, 0x38, 0x07, 0x18, 0x1C, 0x07, 0x1C,
  0x0F, 0x05, 0x8E, 0x03, 0xFE, 0xC7, 0x00, 0xFE, 0xE3, 0x80, 0x08, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x67, 0x00, 0x07, 0x38, 0x00, 0x38, 0xC0, 0x03, 0x86, 0x00, 0x1C,
  0x30, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x0E, 0x00,
  0xC0, 0x70, 0x07, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x03,
  0x38, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0x80, 0x3E, 0x0E, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x60, 0x0F, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xE0, 0x0F, 0x03, 0x80, 0x1E,
  0x0C, 0x00, 0x38, 0x70, 0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00,
  0xF0, 0xE0, 0x07, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x3C, 0x07,
  0x80, 0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x06, 0x1C, 0x00,
  0x18, 0x70, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xE1,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x38,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x01, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x3C, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x06, 0x1C, 0x00, 0x18,
  0x70, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0xFF,
  0xC3, 0x83, 0xFF, 0x0C, 0x0F, 0xFC, 0x70, 0x00, 0x71, 0xC0, 0x01, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xE1, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0C, 0x00,
  0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x78,
  0x01, 0xC0, 0x38, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x1C,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x1C, 0x0F, 0x00, 0x18, 0x0E, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x30,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0,
  0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0x3E, 0x0F, 0xC0, 0x36, 0x0F, 0xC0, 0x76, 0x0E, 0xC0, 0x6E,
  0x0C, 0xC0, 0xEE, 0x0C, 0xC0, 0xCE, 0x0C, 0xE1, 0xCC, 0x1C, 0xE1, 0x8C,
  0x1C, 0x63, 0x9C, 0x1C, 0x63, 0x1C, 0x1C, 0x67, 0x1C, 0x1C, 0x66, 0x1C,
  0x18, 0x7E, 0x18, 0x38, 0x3C, 0x38, 0x38, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x70, 0x00, 0x30,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x3E, 0x00, 0x70,
  0xF8, 0x01, 0xC3, 0xE0, 0x07, 0x0F, 0xC0, 0x18, 0x37, 0x00, 0xE0, 0xDC,
  0x03, 0x87, 0x30, 0x0E, 0x1C, 0xC0, 0x38, 0x73, 0x80, 0xE1, 0xCE, 0x03,
  0x07, 0x18, 0x1C, 0x18, 0x60, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0E,
  0x1C, 0x1C, 0x38, 0x30, 0x60, 0xE0, 0xC3, 0x83, 0x83, 0x8E, 0x0C, 0x0E,
  0x38, 0x70, 0x18, 0xE1, 0xC0, 0x63, 0x87, 0x01, 0xCE, 0x1C, 0x07, 0x30,
  0x70, 0x1D, 0xC1, 0x80, 0x37, 0x0E, 0x00, 0xFC, 0x38, 0x03, 0xF0, 0xE0,
  0x0F, 0xC3, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x30, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x87,
  0x80, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x18,
  0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x38, 0x3C, 0x03, 0xC0, 0xF8, 0x7C, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x70, 0x01,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x03, 0x83, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1C, 0x07, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x87, 0x80,
  0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xE0,
  0x00, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x38, 0x3C, 0x03, 0xC0, 0xF8, 0x7C, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x01, 0xC3,
  0x80, 0x1E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0x81,
  0xC0, 0x0C, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x78, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0x03,
  0xC0, 0x38, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E,
  0x0F, 0x00, 0x38, 0x0F, 0xC3, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78, 0x07, 0x00,
  0xF8, 0x7C, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xF1,
  0x80, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06,
  0x03, 0x80, 0x30, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x18,
  0xC0, 0x00, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x0E, 0x03, 0x98,
  0x0F, 0x01, 0xCC, 0x07, 0x80, 0xCE, 0x03, 0xC0, 0xE7, 0x03, 0x60, 0x73,
  0x81, 0xB0, 0x39, 0xC0, 0xD8, 0x18, 0xE0, 0xEC, 0x1C, 0x70, 0x66, 0x0E,
  0x38, 0x33, 0x06, 0x1C, 0x19, 0x87, 0x0E, 0x18, 0xC3, 0x87, 0x0C, 0x61,
  0xC3, 0x86, 0x30, 0xC1, 0xC6, 0x18, 0xE0, 0xE3, 0x0C, 0x70, 0x71, 0x86,
  0x30, 0x38, 0xC3, 0x18, 0x1C, 0xC1, 0x9C, 0x0C, 0x60, 0xCE, 0x06, 0x30,
  0x46, 0x03, 0x30, 0x67, 0x01, 0x98, 0x33, 0x80, 0xCC, 0x19, 0x80, 0x6E,
  0x0C, 0xC0, 0x36, 0x06, 0xE0, 0x1B, 0x03, 0x70, 0x0D, 0x81, 0xB0, 0x07,
  0x80, 0xD8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE1,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0x60, 0x01, 0x8E, 0x00, 0x71, 0xC0,
  0x1C, 0x38, 0x03, 0x83, 0x00, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC1,
  0xC0, 0x18, 0x38, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x06, 0xF0, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xE0, 0xE1, 0xE1,
  0xC1, 0xC3, 0x83, 0x80, 0x00, 0x30, 0x00, 0x0F, 0xF1, 0xC1, 0xFF, 0xCE,
  0x1F, 0x07, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x3C,
  0x02, 0xE0, 0xF0, 0x7E, 0x07, 0xFF, 0x70, 0x1F, 0xE3, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x1C, 0x7F, 0x81, 0xDF, 0xFC, 0x1F,
  0x81, 0xE1, 0xE0, 0x0E, 0x1E, 0x00, 0xF1, 0xC0, 0x07, 0x38, 0x00, 0x73,
  0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x06, 0x38, 0x00, 0xE3, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x38, 0xF8, 0x07, 0x8F, 0xC1,
  0xF0, 0xEF, 0xFE, 0x0E, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0xE0, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x38, 0x3C, 0x03, 0xC0, 0xF8, 0x7C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0C, 0x0E, 0x01, 0xFE,
  0x38, 0x1F, 0xFC, 0xE0, 0xF8, 0x3F, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xF0,
  0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07,
  0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x05, 0xC0, 0xF0, 0x7E, 0x03, 0xFF,
  0xB8, 0x07, 0xF8, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x78, 0x1E, 0x0E, 0x00, 0xE1, 0xC0, 0x0F, 0x1C, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x67, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x80, 0x78, 0x3C,
  0x1F, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xF1, 0xC1, 0xFF, 0xCE, 0x1F, 0x07, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x78,
  0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xF0, 0x0F,
  0x83, 0xE1, 0xDC, 0x0F, 0xFC, 0xE0, 0x3F, 0xCE, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x1C, 0x7F, 0x81, 0xDF, 0xFC,
  0x1F, 0x81, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xF1, 0xC0, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x3C, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00,
  0x38, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x78, 0x0E, 0x03, 0xC0,
  0x38, 0x1E, 0x00, 0xE0, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x30, 0x10, 0x0E, 0xFC, 0xFC, 0x0D, 0xFD,
  0xFE, 0x0D, 0x1F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x0E, 0x1C, 0x0C,
  0x0E, 0x1C, 0x0C, 0x0E, 0x1C, 0x0C, 0x0E, 0x1C, 0x1C, 0x0E, 0x18, 0x1C,
  0x0C, 0x38, 0x1C, 0x0C, 0x38, 0x1C, 0x1C, 0x38, 0x18, 0x1C, 0x38, 0x18,
  0x1C, 0x38, 0x38, 0x1C, 0x30, 0x38, 0x1C, 0x70, 0x38, 0x18, 0x70, 0x38,
  0x38, 0x70, 0x30, 0x38, 0x70, 0x30, 0x38, 0x70, 0x30, 0x38, 0x60, 0x70,
  0x38, 0x60, 0x70, 0x30, 0xE0, 0x70, 0x70, 0x00, 0x0E, 0x01, 0xC7, 0xF8,
  0x1D, 0xFF, 0xC1, 0xF8, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0x0F, 0x1C, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x0E, 0x00, 0xE1, 0xC0,
  0x0F, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38,
  0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x03, 0x87, 0x80, 0x78, 0x3C, 0x1F, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x1C, 0x7F, 0x80, 0x77, 0xFF, 0x01, 0xF8, 0x1E,
  0x07, 0x80, 0x38, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0C, 0x00,
  0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x30,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xE0, 0xF8,
  0x07, 0x83, 0xB0, 0x7C, 0x0E, 0xFF, 0xE0, 0x39, 0xFE, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0xF1, 0xC1, 0xFF, 0xCE, 0x1F, 0x07, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x78,
  0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x87, 0x00, 0x3C, 0x3C, 0x02, 0xC1, 0xF0, 0x7E, 0x07, 0xFF, 0x70, 0x1F,
  0xE3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x73, 0xFE, 0x03, 0xBF, 0xF8, 0x1F, 0x81, 0xE0, 0xD0, 0x07,
  0x0F, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xF0, 0x1F, 0x1E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCF, 0x00, 0x3C,
  0x78, 0x0F, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x80, 0x70, 0x1F, 0x0F, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00,
  0xE6, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x70, 0x30, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x38,
  0x1C, 0x03, 0x83, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01,
  0xC6, 0x00, 0x1C, 0xE0, 0x00, 0xCC, 0x00, 0x0D, 0xC0, 0x00, 0xD8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x07,
  0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x3B, 0x03, 0x60, 0xEC, 0x19, 0x83,
  0x30, 0x66, 0x1C, 0xC1, 0x98, 0x73, 0x0C, 0x61, 0x8C, 0x31, 0x8E, 0x30,
  0xC6, 0x38, 0xC6, 0x18, 0xC3, 0x18, 0x67, 0x0C, 0x61, 0x9C, 0x33, 0x06,
  0x60, 0xCC, 0x1B, 0x83, 0x30, 0x6E, 0x0D, 0x81, 0xB0, 0x36, 0x07, 0xC0,
  0xD8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x78, 0x01,
  0xC0, 0x70, 0x01, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x00,
  0x77, 0x80, 0x00, 0x77, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xC7, 0x00, 0x03,
  0xC7, 0x80, 0x07, 0x83, 0x80, 0x07, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x61,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1E, 0x01,
  0x70, 0x7C, 0x7B, 0x81, 0xFF, 0xB8, 0x07, 0xF1, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x38, 0xFE, 0x01, 0xCF,
  0xF8, 0x0E, 0xE1, 0xE0, 0x77, 0x07, 0x03, 0x30, 0x1C, 0x39, 0x80, 0x7F,
  0xDC, 0x03, 0xFC, 0xE0, 0x07, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 9, 32, 26, 9, -32 },
  { 37, 14, 13, 26, 9, -32 },
  { 60, 26, 32, 26, 1, -32 },
  { 164, 23, 44, 26, 2, -38 },
  { 291, 30, 32, 26, -1, -32 },
  { 411, 24, 33, 26, 1, -33 },
  { 510, 5, 13, 26, 13, -32 },
  { 519, 18, 43, 26, 7, -37 },
  { 616, 18, 43, 26, 2, -37 },
  { 713, 23, 23, 26, 3, -27 },
  { 780, 21, 21, 26, 3, -25 },
  { 836, 10, 14, 26, 5, -7 },
  { 854, 15, 3, 26, 6, -16 },
  { 860, 7, 6, 26, 8, -6 },
  { 866, 25, 42, 26, 1, -37 },
  { 998, 22, 33, 26, 3, -33 },
  { 1089, 20, 32, 26, 2, -32 },
  { 1169, 23, 33, 26, 2, -33 },
  { 1264, 21, 32, 26, 3, -32 },
  { 1348, 20, 32, 26, 3, -32 },
  { 1428, 21, 32, 26, 3, -32 },
  { 1512, 20, 32, 26, 3, -32 },
  { 1592, 21, 32, 26, 5, -32 },
  { 1676, 22, 33, 26, 3, -33 },
  { 1767, 20, 33, 26, 5, -33 },
  { 1850, 10, 25, 26, 8, -25 },
  { 1882, 13, 32, 26, 5, -25 },
  { 1934, 21, 23, 26, 4, -26 },
  { 1995, 21, 13, 26, 3, -21 },
  { 2030, 21, 23, 26, 2, -26 },
  { 2091, 17, 32, 26, 7, -32 },
  { 2159, 25, 41, 26, 1, -33 },
  { 2288, 21, 32, 26, 1, -32 },
  { 2372, 22, 32, 26, 3, -32 },
  { 2460, 22, 33, 26, 3, -33 },
  { 2551, 21, 32, 26, 3, -32 },
  { 2635, 23, 32, 26, 3, -32 },
  { 2727, 23, 32, 26, 3, -32 },
  { 2819, 22, 33, 26, 3, -33 },
  { 2910, 22, 32, 26, 3, -32 },
  { 2998, 22, 32, 26, 3, -32 },
  { 3086, 24, 32, 26, 1, -32 },
  { 3182, 24, 32, 26, 3, -32 },
  { 3278, 19, 32, 26, 3, -32 },
  { 3354, 24, 32, 26, 2, -32 },
  { 3450, 22, 32, 26, 3, -32 },
  { 3538, 21, 33, 26, 3, -33 },
  { 3625, 23, 32, 26, 3, -32 },
  { 3717, 21, 41, 26, 3, -33 },
  { 3825, 22, 32, 26, 3, -32 },
  { 3913, 23, 33, 26, 2, -33 },
  { 4008, 22, 32, 26, 5, -32 },
  { 4096, 22, 32, 26, 3, -32 },
  { 4184, 21, 32, 26, 6, -32 },
  { 4268, 25, 32, 26, 3, -32 },
  { 4368, 27, 32, 26, 0, -32 },
  { 4476, 23, 32, 26, 5, -32 },
  { 4568, 23, 32, 26, 2, -32 },
  { 4660, 17, 42, 26, 7, -37 },
  { 4750, 12, 42, 26, 8, -37 },
  { 4813, 17, 42, 26, 4, -37 },
  { 4903, 19, 17, 26, 4, -32 },
  { 4944, 22, 3, 26, 0, 1 },
  { 4953, 7, 7, 26, 12, -35 },
  { 4960, 21, 25, 26, 3, -25 },
  { 5026, 20, 32, 26, 3, -32 },
  { 5106, 21, 25, 26, 3, -25 },
  { 5172, 22, 32, 26, 3, -32 },
  { 5260, 20, 25, 26, 3, -25 },
  { 5323, 29, 40, 26, -2, -32 },
  { 5468, 21, 33, 26, 3, -25 },
  { 5555, 20, 32, 26, 3, -32 },
  { 5635, 20, 34, 26, 2, -34 },
  { 5720, 22, 42, 26, 1, -34 },
  { 5836, 22, 32, 26, 3, -32 },
  { 5924, 17, 32, 26, 5, -32 },
  { 5992, 24, 25, 26, 1, -25 },
  { 6067, 20, 25, 26, 3, -25 },
  { 6130, 20, 25, 26, 3, -25 },
  { 6193, 22, 33, 26, 1, -25 },
  { 6284, 21, 33, 26, 3, -25 },
  { 6371, 21, 25, 26, 3, -25 },
  { 6437, 20, 25, 26, 3, -25 },
  { 6500, 20, 31, 26, 4, -31 },
  { 6578, 21, 24, 26, 3, -24 },
  { 6641, 20, 24, 26, 5, -24 },
  { 6701, 22, 24, 26, 4, -24 },
  { 6767, 24, 24, 26, 1, -24 },
  { 6839, 21, 32, 26, 3, -24 },
  { 6923, 21, 24, 26, 2, -24 },
  { 6986, 22, 42, 26, 4, -37 },
  { 7102, 9, 42, 26, 9, -37 },
  { 7150, 22, 42, 26, 1, -37 },
  { 7266, 21, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC44PT7B_H_
