#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC53PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x00,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF3, 0xE0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x03, 0x8E,
  0x03, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x70, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE7, 0x3E, 0x00, 0xF0, 0xE3, 0xE0, 0x3C,
  0x18, 0x3C, 0x07, 0x03, 0x03, 0x81, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0x81,
  0x80, 0x00, 0x78, 0x30, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xF1, 0xC0, 0x00,
  0x1F, 0xB8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0xFC, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x60, 0xF8, 0x00, 0x0C, 0x0F, 0x00, 0x01, 0x81,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x8F, 0x01, 0xC0, 0xF1, 0xE0,
  0x30, 0x1E, 0x3C, 0x06, 0x03, 0x87, 0x80, 0xC0, 0xF0, 0x78, 0x38, 0x3C,
  0x0F, 0x07, 0x0F, 0x80, 0xF8, 0xE3, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x0F, 0xFC,
  0x00, 0x0E, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0x38, 0x03,
  0x80, 0xE0, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x0E,
  0x01, 0xC3, 0x80, 0x00, 0xF0, 0x3C, 0x70, 0x00, 0x07, 0x87, 0x8F, 0x00,
  0x00, 0x7F, 0xF0, 0xE0, 0x00, 0x03, 0xFE, 0x1C, 0x00, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x87, 0xF8,
  0x00, 0x00, 0x71, 0xFF, 0xC0, 0x00, 0x0E, 0x3E, 0x3C, 0x00, 0x01, 0xC3,
  0x81, 0xE0, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x07, 0x87, 0x00, 0xE0, 0x00,
  0x70, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x1C,
  0x00, 0x38, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x38,
  0x00, 0x7F, 0xF0, 0x07, 0x00, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x80, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0xF3, 0xC1, 0xE0, 0x1E, 0x38, 0x0F, 0x01, 0xC7, 0x80, 0x78,
  0x38, 0x78, 0x07, 0x87, 0x87, 0x80, 0x3C, 0xF0, 0x70, 0x03, 0xCE, 0x07,
  0x00, 0x1F, 0xE0, 0x70, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xFC, 0x0F, 0x00, 0x3F, 0xC0,
  0xF0, 0x07, 0x9E, 0x0F, 0x80, 0xF8, 0xE0, 0x7F, 0xFE, 0x0F, 0x03, 0xFF,
  0xC0, 0x78, 0x1F, 0xF0, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x3D, 0xE7, 0x9E,
  0x79, 0xE7, 0xBE, 0xF3, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0x00, 0x00, 0x08,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x07, 0x00, 0xE7, 0xE0, 0x70, 0x7E, 0xFF, 0x86, 0x1F, 0xF3, 0xFE, 0x67,
  0xFC, 0x0F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x1F, 0x9F, 0xDF,
  0xEF, 0xF7, 0xFB, 0xF8, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3E,
  0x00, 0x7C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0x81, 0xE0, 0x70, 0x70, 0x7C,
  0x1E, 0x1E, 0x0F, 0xC3, 0xC3, 0xC1, 0xF0, 0x78, 0x78, 0x1E, 0x0F, 0x0F,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xCF, 0x00, 0x1F, 0x1C, 0x00, 0xF8, 0x38, 0x03, 0xE0, 0x70, 0x07,
  0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x20, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x1C,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0xFF, 0x80, 0x3D,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0E, 0xE0, 0x3E, 0x07, 0xC0, 0x0F, 0x83,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x82, 0x00, 0x03, 0x9F, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x79, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1C,
  0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0,
  0x00, 0x3C, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C,
  0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xC1, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x87, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFE, 0xF0, 0x1F, 0xFD, 0xE0,
  0x03, 0xE3, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0x80, 0x7E, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x0F, 0xE0, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x83, 0x80, 0x3F, 0xE7, 0x0F, 0x00, 0xFF,
  0xEE, 0x1E, 0x03, 0xE0, 0xF8, 0x38, 0x0F, 0x00, 0xF0, 0x70, 0x1E, 0x01,
  0xE0, 0xE0, 0x38, 0x03, 0xC1, 0xC0, 0xF0, 0x07, 0x87, 0x81, 0xE0, 0x0F,
  0x0F, 0x03, 0x80, 0x1C, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x70,
  0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x01, 0xC3, 0xC0, 0xF0, 0x07, 0x87,
  0x81, 0xE0, 0x0F, 0x0E, 0x03, 0x80, 0x1C, 0x1C, 0x07, 0x80, 0x78, 0x38,
  0x0F, 0x00, 0xF0, 0x70, 0x1F, 0x02, 0xE0, 0xE0, 0x1F, 0xFD, 0xC3, 0xC0,
  0x1F, 0xF3, 0x87, 0x80, 0x1F, 0x8E, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x3C,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x70,
  0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x9E, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x7F, 0xC0, 0x38, 0x00, 0xF8,
  0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x78, 0x0E, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x7C, 0x07, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0xF0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00,
  0x07, 0x81, 0xC0, 0x03, 0xE0, 0x38, 0x01, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x0E, 0x07, 0xFC, 0x03, 0x80, 0x1F, 0x01, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x3E, 0x07, 0x00, 0x1F, 0x01, 0xC0,
  0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0x0E, 0x07, 0xFF, 0xC7, 0x81, 0xFF,
  0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xC0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0x70,
  0x37, 0x00, 0x3B, 0x01, 0xB8, 0x01, 0xB8, 0x1C, 0xC0, 0x1D, 0xC0, 0xE6,
  0x00, 0xCE, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x81, 0xCE, 0x07,
  0x38, 0x0E, 0x70, 0x71, 0xC0, 0xF1, 0x83, 0x8E, 0x07, 0x8E, 0x38, 0x70,
  0x38, 0x71, 0xC7, 0x81, 0xC3, 0x8C, 0x3C, 0x0E, 0x1C, 0xE1, 0xE0, 0x70,
  0x66, 0x0E, 0x07, 0x83, 0x70, 0x70, 0x3C, 0x1F, 0x03, 0x81, 0xE0, 0xF8,
  0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0xE0, 0x7C,
  0x00, 0x1C, 0x0F, 0x80, 0x07, 0x81, 0xF8, 0x00, 0xF0, 0x3F, 0x00, 0x1E,
  0x0F, 0xE0, 0x03, 0x81, 0xDC, 0x00, 0x70, 0x3B, 0xC0, 0x0E, 0x07, 0x38,
  0x01, 0xC0, 0xE7, 0x00, 0x78, 0x1C, 0xE0, 0x0F, 0x07, 0x9C, 0x01, 0xC0,
  0xF1, 0xC0, 0x38, 0x1E, 0x38, 0x07, 0x03, 0x87, 0x00, 0xE0, 0x70, 0xE0,
  0x3C, 0x0E, 0x1E, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x78, 0x38, 0x1C, 0x0F,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x1E, 0x07, 0x01, 0xC3,
  0xC0, 0xE0, 0x38, 0x78, 0x3C, 0x07, 0x0E, 0x07, 0x80, 0xF1, 0xC0, 0xE0,
  0x0E, 0x38, 0x1C, 0x01, 0xCF, 0x03, 0x80, 0x39, 0xE0, 0x70, 0x07, 0x3C,
  0x1E, 0x00, 0x77, 0x03, 0xC0, 0x0E, 0xE0, 0x78, 0x01, 0xDC, 0x0E, 0x00,
  0x3B, 0x81, 0xC0, 0x07, 0xF0, 0x38, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x81,
  0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x78, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x38,
  0x03, 0xFC, 0x03, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3E, 0x07, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x38, 0x07, 0xF8, 0x03, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x07, 0x80, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x7E, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00,
  0x7C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x40, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xDE, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x38,
  0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1E, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x3C, 0xE0, 0x1F, 0x00, 0xF3, 0x80, 0x7C, 0x03, 0x9E, 0x01,
  0xF0, 0x0E, 0x78, 0x0F, 0xC0, 0x79, 0xE0, 0x3F, 0x01, 0xC7, 0x80, 0xDC,
  0x07, 0x1C, 0x03, 0x70, 0x1C, 0x70, 0x1D, 0xC0, 0xF1, 0xC0, 0x77, 0x03,
  0x87, 0x01, 0x9C, 0x0E, 0x1C, 0x0E, 0x60, 0x78, 0x70, 0x39, 0x81, 0xC1,
  0xC0, 0xC6, 0x07, 0x07, 0x03, 0x18, 0x1C, 0x1C, 0x1C, 0x60, 0xF0, 0x70,
  0x61, 0x83, 0x81, 0xC1, 0x86, 0x0E, 0x07, 0x0E, 0x18, 0x38, 0x1C, 0x38,
  0x61, 0xC0, 0x70, 0xC1, 0x87, 0x01, 0xC7, 0x06, 0x1C, 0x07, 0x1C, 0x18,
  0x70, 0x1C, 0x60, 0x63, 0x80, 0x71, 0x81, 0x8E, 0x01, 0xCE, 0x06, 0x38,
  0x07, 0x30, 0x19, 0xC0, 0x1C, 0xC0, 0x67, 0x00, 0x77, 0x01, 0x9C, 0x03,
  0xDC, 0x06, 0x70, 0x0E, 0x60, 0x1B, 0x80, 0x39, 0x80, 0xEE, 0x00, 0xEE,
  0x03, 0xB8, 0x03, 0xB0, 0x0F, 0xE0, 0x0E, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0xF8, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x03,
  0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x1C,
  0x78, 0x00, 0xF0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0x70, 0x1E, 0x01, 0xC0, 0xF0, 0x07, 0x83, 0x80, 0x0E, 0x1E,
  0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0xDE, 0x00, 0x07, 0xF0, 0x00,
  0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xE3, 0xC0, 0x7F, 0xF9, 0xC0, 0xFE, 0x3E, 0xE0, 0x78, 0x03, 0x70, 0x78,
  0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x0E, 0x1E,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0xF8, 0x3C, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x07, 0xFF, 0xEE, 0x01, 0xFF,
  0xE7, 0x00, 0x7F, 0xC3, 0x80, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xF0, 0x01, 0xC7, 0xFE, 0x01, 0xE7, 0xFF, 0x80, 0xF7, 0x8F,
  0xE0, 0x7F, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38,
  0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0E, 0xC0, 0x3E,
  0x07, 0x7F, 0xFE, 0x07, 0x9F, 0xFE, 0x03, 0xC7, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x0F, 0xFC, 0x78, 0x07, 0xFF,
  0x9C, 0x07, 0xF1, 0xF7, 0x01, 0xE0, 0x0D, 0xC0, 0xF0, 0x01, 0xF0, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x3E,
  0x07, 0x80, 0x1F, 0x81, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0x70, 0x07, 0xFF,
  0x9C, 0x00, 0xFF, 0x87, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xE3, 0xC0, 0x7F, 0xF9, 0xC0, 0x7E, 0x3E, 0xE0, 0x78,
  0x03, 0x70, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1C,
  0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3,
  0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07,
  0x87, 0x00, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x03,
  0x70, 0x3F, 0x07, 0xF8, 0x0F, 0xFF, 0xBC, 0x03, 0xFF, 0x1E, 0x00, 0x7E,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC7,
  0xFE, 0x01, 0xE7, 0xFF, 0x80, 0xF7, 0x87, 0xE0, 0x7F, 0x00, 0xF8, 0x3A,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00,
  0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xC3, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x01, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1F, 0x00,
  0xF0, 0x03, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x03, 0xC0,
  0x03, 0x80, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x18, 0x03, 0x00, 0xE7,
  0xF1, 0xFC, 0x0E, 0xFF, 0x3F, 0xE0, 0xF8, 0xFE, 0x1E, 0x0F, 0x07, 0xC1,
  0xE1, 0xE0, 0x38, 0x0E, 0x1E, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x0E, 0x1C,
  0x07, 0x80, 0xE1, 0xC0, 0x70, 0x1E, 0x1C, 0x07, 0x01, 0xE1, 0xC0, 0x70,
  0x1C, 0x3C, 0x07, 0x01, 0xC3, 0xC0, 0x70, 0x1C, 0x38, 0x0F, 0x01, 0xC3,
  0x80, 0xE0, 0x1C, 0x38, 0x0E, 0x03, 0xC3, 0x80, 0xE0, 0x3C, 0x78, 0x0E,
  0x03, 0x87, 0x80, 0xE0, 0x38, 0x70, 0x0E, 0x03, 0x87, 0x01, 0xC0, 0x38,
  0x70, 0x1C, 0x07, 0x87, 0x01, 0xC0, 0x78, 0xF0, 0x1C, 0x07, 0x0F, 0x01,
  0xC0, 0x70, 0xE0, 0x1C, 0x07, 0x0E, 0x03, 0xC0, 0x70, 0xE0, 0x38, 0x0F,
  0x0E, 0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x8F, 0xFC, 0x03, 0xCF,
  0xFF, 0x01, 0xEF, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x74, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x38, 0x00,
  0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xF1, 0xFC, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xE3, 0xFF, 0x00, 0x79, 0xFF, 0xE0, 0x1E, 0xF0, 0xFC,
  0x07, 0xF0, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03,
  0xB0, 0x0F, 0x81, 0xEF, 0xFF, 0xC0, 0x79, 0xFF, 0xE0, 0x1E, 0x3F, 0xE0,
  0x07, 0x81, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xE3, 0xC0, 0x7F, 0xF9, 0xC0, 0xFE, 0x3E, 0xE0, 0x78, 0x03,
  0x70, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3C, 0x00,
  0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78,
  0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x07, 0xFF, 0xEE,
  0x01, 0xFF, 0xE7, 0x00, 0x7F, 0xC3, 0x80, 0x02, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x03, 0x8F, 0xFC, 0x03, 0xCF, 0xFF, 0x01,
  0xEF, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x9F,
  0xE0, 0x7C, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80,
  0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1E,
  0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x80, 0x03,
  0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x1E, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x38,
  0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x1C,
  0x07, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x3B,
  0x80, 0xF8, 0x07, 0x70, 0x1F, 0x01, 0xEE, 0x03, 0x60, 0x39, 0xC0, 0xEC,
  0x07, 0x38, 0x1D, 0x81, 0xE7, 0x03, 0x30, 0x38, 0xE0, 0xE6, 0x07, 0x1C,
  0x1C, 0xC0, 0xE3, 0x83, 0x18, 0x38, 0x70, 0xE3, 0x07, 0x0E, 0x1C, 0x60,
  0xE1, 0xC3, 0x0C, 0x38, 0x38, 0xE1, 0x87, 0x07, 0x1C, 0x30, 0xE0, 0xE3,
  0x06, 0x38, 0x1C, 0xE0, 0xC7, 0x03, 0x9C, 0x18, 0xE0, 0x73, 0x03, 0x38,
  0x0E, 0xE0, 0x67, 0x01, 0xDC, 0x0C, 0xE0, 0x3B, 0x01, 0xB8, 0x07, 0xE0,
  0x37, 0x00, 0xFC, 0x06, 0xE0, 0x1F, 0x00, 0xD8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1E,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C,
  0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38,
  0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xB8, 0x7C,
  0x01, 0xF8, 0x3F, 0x07, 0x78, 0x3F, 0xFE, 0x78, 0x0F, 0xFC, 0x70, 0x03,
  0xF0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x8F,
  0xF0, 0x01, 0xCF, 0xFE, 0x00, 0xE7, 0x8F, 0x00, 0xF7, 0x83, 0xC0, 0x73,
  0x80, 0xF0, 0x39, 0xC0, 0x7C, 0x3D, 0xE0, 0x1F, 0xFC, 0xF0, 0x07, 0xFE,
  0x70, 0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 39, 32, 10, -39 },
  { 60, 17, 16, 32, 10, -39 },
  { 94, 31, 39, 32, 1, -39 },
  { 246, 27, 53, 32, 3, -46 },
  { 425, 36, 39, 32, -1, -39 },
  { 601, 28, 40, 32, 2, -39 },
  { 741, 6, 16, 32, 16, -39 },
  { 753, 21, 52, 32, 9, -45 },
  { 890, 21, 52, 32, 3, -45 },
  { 1027, 28, 27, 32, 3, -32 },
  { 1122, 25, 25, 32, 4, -30 },
  { 1201, 12, 16, 32, 6, -8 },
  { 1225, 17, 3, 32, 8, -19 },
  { 1232, 9, 9, 32, 10, -8 },
  { 1243, 31, 50, 32, 1, -44 },
  { 1437, 27, 40, 32, 3, -39 },
  { 1572, 23, 39, 32, 3, -39 },
  { 1685, 27, 39, 32, 3, -39 },
  { 1817, 26, 40, 32, 3, -39 },
  { 1947, 24, 39, 32, 4, -39 },
  { 2064, 25, 40, 32, 4, -39 },
  { 2189, 25, 40, 32, 3, -39 },
  { 2314, 25, 39, 32, 7, -39 },
  { 2436, 27, 40, 32, 3, -39 },
  { 2571, 24, 39, 32, 6, -39 },
  { 2688, 12, 31, 32, 10, -30 },
  { 2735, 16, 38, 32, 6, -30 },
  { 2811, 25, 27, 32, 5, -31 },
  { 2896, 25, 15, 32, 4, -25 },
  { 2943, 25, 27, 32, 3, -31 },
  { 3028, 21, 39, 32, 8, -39 },
  { 3131, 31, 48, 32, 1, -39 },
  { 3317, 25, 39, 32, 1, -39 },
  { 3439, 27, 39, 32, 3, -39 },
  { 3571, 26, 40, 32, 4, -39 },
  { 3701, 26, 39, 32, 3, -39 },
  { 3828, 27, 39, 32, 4, -39 },
  { 3960, 29, 39, 32, 3, -39 },
  { 4102, 26, 40, 32, 4, -39 },
  { 4232, 27, 39, 32, 3, -39 },
  { 4364, 26, 39, 32, 4, -39 },
  { 4491, 28, 40, 32, 2, -39 },
  { 4631, 29, 39, 32, 3, -39 },
  { 4773, 22, 39, 32, 4, -39 },
  { 4881, 29, 39, 32, 2, -39 },
  { 5023, 27, 39, 32, 3, -39 },
  { 5155, 25, 40, 32, 4, -39 },
  { 5280, 28, 39, 32, 3, -39 },
  { 5417, 25, 49, 32, 4, -39 },
  { 5571, 28, 39, 32, 3, -39 },
  { 5708, 27, 40, 32, 3, -39 },
  { 5843, 27, 39, 32, 6, -39 },
  { 5975, 26, 40, 32, 4, -39 },
  { 6105, 25, 39, 32, 7, -39 },
  { 6227, 30, 39, 32, 4, -39 },
  { 6374, 32, 39, 32, 0, -39 },
  { 6530, 27, 39, 32, 6, -39 },
  { 6662, 28, 39, 32, 2, -39 },
  { 6799, 20, 50, 32, 8, -44 },
  { 6924, 15, 50, 32, 9, -44 },
  { 7018, 20, 50, 32, 5, -44 },
  { 7143, 22, 21, 32, 5, -39 },
  { 7201, 26, 3, 32, 0, 1 },
  { 7211, 8, 8, 32, 15, -42 },
  { 7219, 25, 31, 32, 4, -30 },
  { 7316, 25, 40, 32, 3, -39 },
  { 7441, 24, 31, 32, 4, -30 },
  { 7534, 26, 40, 32, 4, -39 },
  { 7664, 24, 31, 32, 4, -30 },
  { 7757, 34, 49, 32, -2, -39 },
  { 7966, 25, 40, 32, 4, -30 },
  { 8091, 25, 39, 32, 3, -39 },
  { 8213, 25, 41, 32, 2, -41 },
  { 8342, 27, 51, 32, 1, -41 },
  { 8515, 28, 39, 32, 3, -39 },
  { 8652, 21, 39, 32, 6, -39 },
  { 8755, 28, 30, 32, 2, -30 },
  { 8860, 25, 30, 32, 3, -30 },
  { 8954, 24, 31, 32, 4, -30 },
  { 9047, 26, 40, 32, 2, -30 },
  { 9177, 25, 40, 32, 4, -30 },
  { 9302, 25, 30, 32, 4, -30 },
  { 9396, 25, 31, 32, 3, -30 },
  { 9493, 24, 37, 32, 5, -37 },
  { 9604, 25, 30, 32, 4, -29 },
  { 9698, 24, 29, 32, 6, -29 },
  { 9785, 27, 29, 32, 5, -29 },
  { 9883, 29, 29, 32, 1, -29 },
  { 9989, 24, 39, 32, 4, -29 },
  { 10106, 25, 29, 32, 3, -29 },
  { 10197, 26, 50, 32, 5, -44 },
  { 10360, 11, 50, 32, 11, -44 },
  { 10429, 26, 50, 32, 2, -44 },
  { 10592, 25, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC53PT7B_H_
