#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC59PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x9C, 0xFC, 0x00, 0xF8, 0x70, 0xF8, 0x07,
  0xC1, 0xC1, 0xE0, 0x1E, 0x07, 0x07, 0xC0, 0xF0, 0x18, 0x0F, 0x03, 0xC0,
  0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xF0, 0x78, 0x0E, 0x03, 0xC1, 0xE0, 0x38,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x7C, 0x1C, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x07, 0xE7, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0x8F, 0x80, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x01, 0xC0,
  0xF8, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xC0, 0x78, 0x78, 0x06, 0x01, 0xE1, 0xE0, 0x38, 0x07, 0x87,
  0x80, 0xE0, 0x3C, 0x1E, 0x03, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x81, 0xF0,
  0x38, 0x3E, 0x03, 0xE0, 0xE1, 0xF0, 0x0F, 0xE3, 0x1F, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFC,
  0x00, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C,
  0x03, 0x80, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x03, 0xC0,
  0x00, 0x70, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x03, 0x83, 0xC0, 0x00, 0x1C,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x81, 0xE1,
  0xC0, 0x00, 0x01, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00,
  0x00, 0x1F, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x80,
  0x00, 0x00, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x00,
  0x70, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x07, 0x00, 0x00, 0x78, 0x38, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x01, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x00, 0x38,
  0x07, 0x00, 0x78, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0x1C, 0x00,
  0x07, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x1E, 0x07, 0x80, 0x3C, 0x78, 0x0F,
  0x80, 0xF0, 0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x87, 0x80, 0x1F,
  0x1E, 0x0F, 0x00, 0x1E, 0x3C, 0x1E, 0x00, 0x3E, 0xF0, 0x3C, 0x00, 0x3F,
  0xC0, 0x78, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x0F, 0xF0,
  0x3E, 0x00, 0x3D, 0xE0, 0x3C, 0x01, 0xF1, 0xE0, 0x7E, 0x0F, 0xC3, 0xE0,
  0xFF, 0xFF, 0x03, 0xC0, 0xFF, 0xFC, 0x03, 0xC0, 0x7F, 0xE0, 0x07, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3E, 0x7C,
  0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x80, 0x1D, 0xF8, 0x0F,
  0x01, 0xFB, 0xFE, 0x1E, 0x1F, 0xFF, 0xFF, 0x18, 0xFF, 0xE3, 0xFF, 0x37,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x0F, 0xC7, 0xF9, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x78, 0x0E, 0x03, 0xC3, 0xC0, 0xF8, 0x1E, 0x1E,
  0x07, 0xE0, 0xF0, 0xF0, 0x7F, 0x07, 0x87, 0x81, 0xF8, 0x3C, 0x3C, 0x0F,
  0x81, 0xE3, 0xE0, 0x10, 0x1F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x81, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x8F, 0x00, 0x0F,
  0xC3, 0xC0, 0x0F, 0xC0, 0xF0, 0x03, 0xE0, 0x38, 0x00, 0xE0, 0x1E, 0x00,
  0x60, 0x07, 0x80, 0x10, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x01,
  0xE0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x1C, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE1, 0xFF, 0x00, 0x0F, 0x3F, 0xFE, 0x00, 0x7B, 0xFF, 0xF8,
  0x03, 0xFE, 0x0F, 0xE0, 0x1D, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x3F, 0xC0, 0x03, 0xCF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x78,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x01,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFB, 0xC0,
  0x03, 0xFC, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xC0, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x0C, 0x0E,
  0x0F, 0x00, 0x1F, 0xE3, 0x83, 0xC0, 0x1F, 0xFC, 0xE0, 0xE0, 0x0F, 0xFF,
  0xB8, 0x38, 0x07, 0xC0, 0x6E, 0x1E, 0x01, 0xE0, 0x0F, 0x87, 0x80, 0x70,
  0x03, 0xC1, 0xE0, 0x3C, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x3C, 0x1C, 0x03,
  0x80, 0x0F, 0x07, 0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0xF0, 0xF0,
  0x1E, 0x00, 0x3C, 0x3C, 0x07, 0x80, 0x0E, 0x0F, 0x01, 0xE0, 0x03, 0x83,
  0xC0, 0x78, 0x01, 0xE0, 0xE0, 0x1C, 0x00, 0x78, 0x38, 0x07, 0x00, 0x1E,
  0x1E, 0x03, 0xC0, 0x07, 0x87, 0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x1E, 0x00,
  0xF0, 0x78, 0x07, 0x80, 0x7C, 0x1C, 0x01, 0xFC, 0xF7, 0x07, 0x00, 0x3F,
  0xF9, 0xC1, 0xC0, 0x07, 0xFC, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x78, 0x07, 0xFC, 0x01, 0xC0, 0x01, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x1F,
  0x00, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0x80, 0x03, 0xF0, 0x1E,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xC0, 0xFF, 0xC0, 0x1C, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x1F,
  0x01, 0xE0, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFC, 0x3C, 0x07, 0xFF, 0xE1,
  0xE0, 0x3F, 0xFF, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x04,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07,
  0x70, 0x1E, 0xE0, 0x07, 0xF8, 0x0E, 0x70, 0x03, 0xBC, 0x07, 0x38, 0x03,
  0xDC, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80,
  0xE7, 0x80, 0xF1, 0xC0, 0xF3, 0xC0, 0x78, 0xE0, 0x71, 0xE0, 0x3C, 0x70,
  0x78, 0xE0, 0x1E, 0x38, 0x38, 0x70, 0x0F, 0x1E, 0x3C, 0x78, 0x07, 0x07,
  0x1C, 0x3C, 0x03, 0x83, 0x9E, 0x1E, 0x03, 0xC1, 0xCE, 0x0F, 0x01, 0xE0,
  0xEE, 0x07, 0x00, 0xF0, 0x77, 0x03, 0x80, 0x78, 0x1F, 0x03, 0xC0, 0x3C,
  0x0F, 0x81, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x38, 0x07, 0xE0,
  0x00, 0xF0, 0x0F, 0xC0, 0x01, 0xE0, 0x1F, 0x80, 0x03, 0xC0, 0x7F, 0x80,
  0x07, 0x80, 0xF7, 0x00, 0x0F, 0x01, 0xEE, 0x00, 0x1C, 0x03, 0xDC, 0x00,
  0x78, 0x07, 0x3C, 0x00, 0xF0, 0x0E, 0x78, 0x01, 0xE0, 0x3C, 0x70, 0x03,
  0xC0, 0x78, 0xE0, 0x07, 0x80, 0xF1, 0xE0, 0x0E, 0x01, 0xE3, 0xC0, 0x1C,
  0x03, 0xC3, 0x80, 0x78, 0x07, 0x07, 0x00, 0xF0, 0x1E, 0x0E, 0x01, 0xE0,
  0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x38, 0x0E, 0x01,
  0xE0, 0x70, 0x3C, 0x03, 0x80, 0xF0, 0x78, 0x07, 0x01, 0xE0, 0xF0, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x07, 0x07, 0x00, 0xF0,
  0x0F, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x03, 0x80, 0x1C, 0x78, 0x0F, 0x00,
  0x38, 0xF0, 0x1E, 0x00, 0x79, 0xE0, 0x3C, 0x00, 0xF3, 0x80, 0x78, 0x01,
  0xE7, 0x00, 0xF0, 0x01, 0xCE, 0x01, 0xC0, 0x03, 0xBC, 0x07, 0x80, 0x07,
  0xF8, 0x0F, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x0F,
  0xF8, 0x01, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x7F,
  0xC0, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x3F, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0x80,
  0x07, 0x80, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xBC, 0x01, 0xF0, 0x03, 0x9E, 0x00, 0xF8,
  0x03, 0xCF, 0x00, 0x6C, 0x01, 0xE7, 0x80, 0x76, 0x00, 0xE3, 0xC0, 0x3B,
  0x00, 0xF1, 0xE0, 0x1F, 0x80, 0x78, 0xE0, 0x0D, 0xC0, 0x3C, 0x70, 0x0E,
  0xE0, 0x1C, 0x38, 0x07, 0x70, 0x1E, 0x1C, 0x03, 0x38, 0x0F, 0x0E, 0x03,
  0x9C, 0x07, 0x07, 0x01, 0xCE, 0x03, 0x83, 0x80, 0xE7, 0x03, 0xC1, 0xC0,
  0xE3, 0x81, 0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0x70, 0x38, 0xE0, 0xF0, 0x38,
  0x18, 0x70, 0x78, 0x1C, 0x1C, 0x38, 0x38, 0x1E, 0x0E, 0x1C, 0x1C, 0x0F,
  0x06, 0x0E, 0x1E, 0x07, 0x87, 0x07, 0x0F, 0x03, 0xC3, 0x83, 0x87, 0x01,
  0xE1, 0xC1, 0xC3, 0x80, 0xF0, 0xC0, 0xE3, 0xC0, 0x78, 0xE0, 0x71, 0xC0,
  0x3C, 0x70, 0x30, 0xE0, 0x1E, 0x30, 0x18, 0x70, 0x0F, 0x38, 0x0C, 0x78,
  0x07, 0x9C, 0x06, 0x38, 0x03, 0xCC, 0x03, 0x1C, 0x01, 0xCE, 0x01, 0x9E,
  0x00, 0xE7, 0x00, 0xCF, 0x00, 0x73, 0x80, 0x67, 0x00, 0x39, 0x80, 0x33,
  0x80, 0x1D, 0xC0, 0x1B, 0xC0, 0x0E, 0xE0, 0x0D, 0xC0, 0x07, 0x60, 0x06,
  0xE0, 0x03, 0xF0, 0x07, 0x70, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x87, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0x8F, 0x00, 0xFF, 0xFC, 0xF0, 0x1F, 0xC7, 0xCE,
  0x03, 0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0,
  0x3C, 0x00, 0x6F, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xDE, 0x00, 0xFF,
  0xF9, 0xE0, 0x07, 0xFE, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xFC, 0x00,
  0x78, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x80, 0x7B, 0xE1, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0xE0, 0x01, 0xF0, 0x7F, 0x00,
  0x3E, 0x07, 0xB8, 0x0F, 0xC0, 0x7B, 0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0x00,
  0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x0F, 0x00,
  0x1F, 0xFE, 0x3C, 0x00, 0xFF, 0xFC, 0xF0, 0x07, 0xF1, 0xF3, 0x80, 0x3E,
  0x00, 0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x06, 0xF0, 0x0F, 0xC0, 0x7F, 0x80,
  0x1F, 0xFF, 0xDE, 0x00, 0x3F, 0xFE, 0x78, 0x00, 0x7F, 0xE1, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x3C, 0x07, 0xFF,
  0xE7, 0x81, 0xFC, 0x7C, 0xE0, 0x7C, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0x87,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x07, 0x78, 0x1F, 0xFF,
  0xCF, 0x01, 0xFF, 0xF1, 0xC0, 0x1F, 0xFC, 0x78, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x78,
  0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x80, 0x7B, 0xE1, 0xFC, 0x07, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x41, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x3E, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7C,
  0x00, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x78, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x7C, 0x01,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x80, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x81, 0xF0,
  0x0E, 0x7F, 0x8F, 0xF0, 0x1D, 0xFF, 0x3F, 0xF0, 0x7E, 0x1F, 0x63, 0xE0,
  0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x03, 0xC3, 0xC0, 0x78, 0x07, 0x87,
  0x80, 0xF0, 0x0E, 0x0E, 0x01, 0xE0, 0x1C, 0x3C, 0x03, 0xC0, 0x78, 0x78,
  0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x01, 0xE1, 0xE0, 0x1C, 0x03, 0xC3, 0xC0,
  0x78, 0x07, 0x87, 0x00, 0xF0, 0x0E, 0x0E, 0x01, 0xE0, 0x3C, 0x3C, 0x03,
  0x80, 0x78, 0x78, 0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x01, 0xE1, 0xE0, 0x1C,
  0x03, 0xC3, 0x80, 0x78, 0x07, 0x07, 0x00, 0xF0, 0x0E, 0x1E, 0x01, 0xC0,
  0x3C, 0x3C, 0x03, 0x80, 0x78, 0x78, 0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x01,
  0xE1, 0xC0, 0x3C, 0x03, 0x83, 0x80, 0x78, 0x07, 0x0F, 0x00, 0xF0, 0x1E,
  0x1E, 0x01, 0xC0, 0x3C, 0x3C, 0x03, 0x80, 0x78, 0x78, 0x07, 0x00, 0xF0,
  0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x41, 0xFC, 0x00, 0x78, 0x7F, 0xF0, 0x07,
  0x9F, 0xFF, 0x80, 0x7B, 0xE1, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0,
  0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0xFE, 0x00, 0x1E,
  0x1F, 0xFC, 0x00, 0xF3, 0xFF, 0xF0, 0x07, 0xBE, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0x7E, 0x00, 0x1F,
  0x03, 0xF8, 0x01, 0xF0, 0x1E, 0xE0, 0x3F, 0x00, 0xF7, 0xFF, 0xF0, 0x07,
  0x9F, 0xFF, 0x00, 0x38, 0x7F, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x8F, 0x00, 0xFF, 0xFC, 0xF0, 0x3F, 0xC7,
  0xDE, 0x03, 0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x6E, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xDE, 0x00,
  0xFF, 0xF9, 0xE0, 0x07, 0xFE, 0x1E, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x83, 0xF8,
  0x00, 0x71, 0xFF, 0xE0, 0x0F, 0x3F, 0xFF, 0x00, 0xF7, 0xC3, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0x7C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x80, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0xFF, 0x00,
  0xF8, 0x03, 0xBC, 0x03, 0xE0, 0x0E, 0xF0, 0x0D, 0x80, 0x7B, 0xC0, 0x76,
  0x01, 0xCF, 0x01, 0xD8, 0x07, 0x3C, 0x06, 0x60, 0x3C, 0xF0, 0x39, 0x80,
  0xE3, 0xC0, 0xE6, 0x03, 0x8F, 0x03, 0x18, 0x1E, 0x3C, 0x1C, 0x60, 0x70,
  0xF0, 0x71, 0x81, 0xC3, 0xC1, 0x86, 0x0F, 0x0F, 0x0E, 0x18, 0x38, 0x3C,
  0x38, 0x60, 0xE0, 0xF1, 0xC1, 0x87, 0x83, 0xC7, 0x07, 0x1C, 0x0F, 0x1C,
  0x1C, 0x70, 0x3C, 0xE0, 0x73, 0xC0, 0xF3, 0x81, 0xCE, 0x03, 0xCE, 0x07,
  0x38, 0x0F, 0x70, 0x1C, 0xE0, 0x3D, 0xC0, 0x77, 0x80, 0xE7, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x7E, 0x00,
  0xEC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x6F, 0x03, 0xF0, 0x0E, 0xF0, 0x1F, 0xFF, 0xCE, 0x00, 0xFF, 0xF9,
  0xE0, 0x07, 0xFE, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x70,
  0xFF, 0xC0, 0x0F, 0x1F, 0xFE, 0x00, 0xF3, 0xC1, 0xE0, 0x0F, 0x38, 0x0F,
  0x00, 0xF7, 0x80, 0xF8, 0x0E, 0x78, 0x07, 0xC1, 0xE7, 0x80, 0x3F, 0x7C,
  0x70, 0x01, 0xFF, 0xC7, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x3C, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 12, 43, 35, 12, -43 },
  { 66, 19, 18, 35, 11, -43 },
  { 109, 35, 43, 35, 1, -43 },
  { 298, 30, 59, 35, 3, -51 },
  { 520, 41, 43, 35, -2, -43 },
  { 741, 31, 45, 35, 2, -44 },
  { 916, 7, 18, 35, 17, -43 },
  { 932, 24, 57, 35, 10, -50 },
  { 1103, 23, 57, 35, 3, -50 },
  { 1267, 31, 30, 35, 3, -36 },
  { 1384, 28, 27, 35, 4, -33 },
  { 1479, 14, 18, 35, 6, -9 },
  { 1511, 20, 3, 35, 8, -21 },
  { 1519, 10, 10, 35, 11, -9 },
  { 1532, 33, 55, 35, 2, -49 },
  { 1759, 29, 45, 35, 4, -44 },
  { 1923, 26, 43, 35, 3, -43 },
  { 2063, 30, 44, 35, 3, -44 },
  { 2228, 30, 44, 35, 3, -43 },
  { 2393, 27, 43, 35, 4, -43 },
  { 2539, 29, 44, 35, 4, -43 },
  { 2699, 28, 44, 35, 3, -43 },
  { 2853, 28, 43, 35, 7, -43 },
  { 3004, 30, 45, 35, 3, -44 },
  { 3173, 28, 44, 35, 6, -44 },
  { 3327, 13, 34, 35, 11, -33 },
  { 3383, 18, 42, 35, 7, -33 },
  { 3478, 28, 31, 35, 5, -35 },
  { 3587, 28, 17, 35, 4, -28 },
  { 3647, 28, 31, 35, 3, -35 },
  { 3756, 23, 43, 35, 9, -43 },
  { 3880, 34, 55, 35, 1, -44 },
  { 4114, 28, 43, 35, 1, -43 },
  { 4265, 30, 43, 35, 3, -43 },
  { 4427, 29, 45, 35, 4, -44 },
  { 4591, 29, 43, 35, 3, -43 },
  { 4747, 31, 43, 35, 4, -43 },
  { 4914, 31, 43, 35, 4, -43 },
  { 5081, 29, 45, 35, 4, -44 },
  { 5245, 31, 43, 35, 3, -43 },
  { 5412, 29, 43, 35, 4, -43 },
  { 5568, 31, 44, 35, 2, -43 },
  { 5739, 33, 43, 35, 3, -43 },
  { 5917, 25, 43, 35, 4, -43 },
  { 6052, 33, 43, 35, 2, -43 },
  { 6230, 31, 43, 35, 3, -43 },
  { 6397, 29, 45, 35, 4, -44 },
  { 6561, 32, 43, 35, 3, -43 },
  { 6733, 29, 55, 35, 4, -44 },
  { 6933, 31, 43, 35, 3, -43 },
  { 7100, 30, 45, 35, 3, -44 },
  { 7269, 29, 43, 35, 7, -43 },
  { 7425, 30, 44, 35, 4, -43 },
  { 7590, 28, 43, 35, 8, -43 },
  { 7741, 33, 43, 35, 5, -43 },
  { 7919, 36, 43, 35, 0, -43 },
  { 8113, 30, 43, 35, 7, -43 },
  { 8275, 31, 43, 35, 3, -43 },
  { 8442, 23, 55, 35, 9, -49 },
  { 8601, 17, 55, 35, 10, -49 },
  { 8718, 23, 55, 35, 5, -49 },
  { 8877, 25, 23, 35, 6, -43 },
  { 8949, 29, 4, 35, 0, 1 },
  { 8964, 10, 8, 35, 16, -46 },
  { 8974, 28, 34, 35, 4, -33 },
  { 9093, 28, 44, 35, 3, -43 },
  { 9247, 28, 34, 35, 4, -33 },
  { 9366, 30, 44, 35, 4, -43 },
  { 9531, 27, 34, 35, 4, -33 },
  { 9646, 38, 54, 35, -2, -43 },
  { 9903, 27, 44, 35, 5, -33 },
  { 10052, 28, 43, 35, 3, -43 },
  { 10203, 27, 45, 35, 3, -45 },
  { 10355, 30, 56, 35, 1, -45 },
  { 10565, 30, 43, 35, 4, -43 },
  { 10727, 24, 43, 35, 6, -43 },
  { 10856, 31, 33, 35, 2, -33 },
  { 10984, 28, 33, 35, 3, -33 },
  { 11100, 27, 34, 35, 4, -33 },
  { 11215, 29, 44, 35, 2, -33 },
  { 11375, 28, 44, 35, 4, -33 },
  { 11529, 28, 33, 35, 5, -33 },
  { 11645, 27, 34, 35, 4, -33 },
  { 11760, 27, 41, 35, 6, -41 },
  { 11899, 28, 33, 35, 4, -32 },
  { 12015, 27, 32, 35, 7, -32 },
  { 12123, 30, 32, 35, 5, -32 },
  { 12243, 32, 32, 35, 1, -32 },
  { 12371, 28, 43, 35, 4, -32 },
  { 12522, 28, 32, 35, 3, -32 },
  { 12634, 29, 55, 35, 6, -49 },
  { 12834, 13, 55, 35, 12, -49 },
  { 12924, 29, 55, 35, 2, -49 },
  { 13124, 28, 11, 35, 4, -26 },
};

const GFXfont JetBrainsMono_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC59PT7B_H_
