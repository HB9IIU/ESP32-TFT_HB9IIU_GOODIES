#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC30PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3,
  0x08, 0x00, 0x00, 0x3C, 0xF3, 0x80, 0x61, 0xB0, 0xD8, 0x7C, 0x7E, 0x3E,
  0x1B, 0x0D, 0x86, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x60, 0xC0,
  0x30, 0x40, 0x30, 0x60, 0x18, 0x30, 0xFF, 0xFE, 0x7F, 0xFF, 0x06, 0x0C,
  0x02, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x83, 0x00, 0xC1, 0x83, 0xFF,
  0xF9, 0xFF, 0xFC, 0x30, 0x60, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x06,
  0x0C, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x3F, 0x81, 0xFF, 0x87, 0x33, 0x0C, 0x67, 0x30, 0x86, 0x61, 0x0C, 0xC2,
  0x01, 0xCC, 0x01, 0x98, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0x70,
  0x06, 0x70, 0x0C, 0x60, 0x18, 0xCC, 0x21, 0x98, 0x43, 0x30, 0x8E, 0x73,
  0x38, 0x7F, 0xE0, 0x7F, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x38, 0x7F, 0x01, 0x03, 0x18, 0x18, 0x30, 0x41, 0x81,
  0x86, 0x18, 0x0C, 0x31, 0x80, 0x61, 0x98, 0x03, 0x08, 0x80, 0x1F, 0xC8,
  0x00, 0x7C, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0xCF, 0xC0, 0x04, 0xC3, 0x00, 0x66, 0x18, 0x06, 0x30, 0xC0, 0x61, 0x06,
  0x06, 0x08, 0x20, 0x60, 0x43, 0x06, 0x03, 0xB8, 0x60, 0x0F, 0x00, 0x01,
  0xF0, 0x07, 0xF8, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x33, 0x83, 0x61,
  0x86, 0x61, 0xCC, 0x60, 0xCC, 0x60, 0x78, 0xC0, 0x70, 0xC0, 0x70, 0xC0,
  0x78, 0xE0, 0xD8, 0x7F, 0x8C, 0x7F, 0x0E, 0x6D, 0xFF, 0xB6, 0xC0, 0x00,
  0x30, 0x0F, 0x03, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0x00, 0x0C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x08, 0x00, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x04, 0x18, 0x3E, 0x23, 0xDF, 0x5F,
  0x07, 0xF0, 0x03, 0x00, 0x0F, 0x00, 0x33, 0x00, 0xC7, 0x03, 0x06, 0x0E,
  0x0E, 0x08, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x0E, 0x1C, 0x70, 0xE3, 0x87, 0x0C, 0x30,
  0x61, 0x80, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70,
  0x30, 0xC0, 0x73, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x60, 0x0C,
  0xC2, 0x19, 0x8E, 0x33, 0x1C, 0x66, 0x11, 0xCC, 0x03, 0x38, 0x06, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC3, 0x03, 0x87, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0xE0, 0x1F, 0x01, 0xD8, 0x38, 0xC3, 0x8C, 0x10, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x06, 0x1C, 0x07, 0x18, 0x03, 0x18,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x1F, 0xFE, 0x3F,
  0xF8, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0xC0, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC7, 0x03, 0x07, 0xBC,
  0x07, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x61, 0xC1, 0x8E, 0x06,
  0x30, 0x19, 0x80, 0x66, 0x01, 0xBF, 0xFC, 0xFF, 0xF0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x37, 0xF0, 0x7D,
  0xF0, 0xE0, 0x61, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x19, 0x80, 0x63, 0x00, 0xC3, 0x03, 0x07, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0x7F, 0xC3, 0xC7, 0x9C, 0x06, 0x60, 0x19, 0x80,
  0x7C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x18, 0x1C, 0x7F,
  0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x06, 0xC0, 0x33,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x30,
  0xC0, 0x61, 0x80, 0x66, 0x01, 0x8C, 0x03, 0x0C, 0x0C, 0x1C, 0x38, 0x1D,
  0xC0, 0x1F, 0x00, 0x7F, 0x01, 0x87, 0x06, 0x07, 0x18, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0xC7, 0x03, 0x87, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0xE3, 0x81, 0x8C, 0x07, 0x60, 0x0D, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1B, 0x80, 0x66, 0x03, 0x1E, 0x3C, 0x3F, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x18, 0xF3, 0xCF, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xCF, 0x3C, 0xF0, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x04,
  0x3F, 0xFD, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x20, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x0C, 0x00, 0x20, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x07, 0x83, 0xE0,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0x01, 0xFC, 0x03, 0xEF, 0x03, 0x80, 0xC3, 0x80, 0x61,
  0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x22, 0x60, 0xFD, 0x30, 0xE2,
  0x98, 0x60, 0xCC, 0x30, 0x66, 0x30, 0x33, 0x18, 0x19, 0x0C, 0x09, 0x86,
  0x0C, 0xC3, 0x06, 0x61, 0x83, 0x30, 0xE7, 0x98, 0x3E, 0xCC, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x04, 0xC0,
  0x33, 0x00, 0xCC, 0x06, 0x10, 0x18, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x60, 0x61, 0xFF, 0x8F, 0xFE, 0x30, 0x19, 0x80, 0x66, 0x00, 0x98, 0x03,
  0xC0, 0x0F, 0x00, 0x30, 0x1F, 0xF0, 0x3F, 0xF0, 0x60, 0x70, 0xC0, 0x61,
  0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x18, 0x60, 0xE0, 0xFF,
  0x83, 0xFF, 0x86, 0x03, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x19,
  0x80, 0x33, 0x00, 0xC6, 0x03, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0xF8, 0x30, 0x30, 0xC0, 0x71, 0x80, 0x66, 0x00, 0xCC, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x19, 0x80, 0x31, 0x80, 0xC3, 0x03, 0x87,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x60, 0xF0, 0xC0, 0x61,
  0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x33, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x19,
  0x80, 0x63, 0x01, 0xC6, 0x07, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xFF,
  0x1F, 0xFE, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x30, 0x30, 0xC0, 0x71, 0x80, 0x66,
  0x00, 0xCC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x0F,
  0xE6, 0x1F, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x31,
  0x80, 0xC3, 0x03, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xFF, 0xE3, 0xFF, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x30, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18,
  0x06, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xE0, 0x30, 0x60, 0x70,
  0x7F, 0xE0, 0x3F, 0x80, 0x18, 0x03, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C,
  0x18, 0x18, 0x30, 0x38, 0x30, 0x30, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xE0, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0E, 0x03, 0x8F, 0x03, 0x87, 0x81, 0x43, 0xC1, 0xE1, 0xA0, 0xB0, 0xD0,
  0xD8, 0x6C, 0x4C, 0x26, 0x64, 0x33, 0x26, 0x18, 0xB3, 0x0C, 0x51, 0x86,
  0x38, 0xC3, 0x00, 0x61, 0x80, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC0, 0x1C,
  0x06, 0x38, 0x0C, 0x70, 0x18, 0xB0, 0x31, 0x60, 0xC6, 0xC1, 0x8C, 0x83,
  0x19, 0x86, 0x33, 0x0C, 0x66, 0x18, 0x8C, 0x23, 0x08, 0xC6, 0x19, 0x8C,
  0x33, 0x18, 0x66, 0x30, 0x4C, 0x60, 0xD9, 0x81, 0xE3, 0x03, 0xC6, 0x07,
  0x8C, 0x07, 0x18, 0x0E, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x30, 0x30, 0xC0,
  0x61, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x19,
  0x80, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0,
  0x19, 0x80, 0x61, 0x80, 0xC3, 0x03, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xFC, 0x18, 0x0E, 0x18, 0x06, 0x18, 0x06, 0x30, 0x07, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x38, 0x7F, 0xF0, 0x7F,
  0x80, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x70,
  0x30, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0xE0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0xC0, 0x19, 0x80, 0x63, 0x80, 0xC3, 0x03, 0x07, 0xFE, 0x07, 0xF0,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x1F, 0xF0,
  0x3F, 0xF8, 0x60, 0x38, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x0C, 0x60, 0x38, 0xC3, 0xE3, 0xFF, 0x06, 0x18, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x8C,
  0x03, 0x18, 0x07, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x30, 0xC0, 0x73,
  0x00, 0x66, 0x00, 0xCC, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0xE7, 0x03, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00, 0xC6, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x63, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80,
  0xC3, 0x03, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xB0, 0x06, 0xC0, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x18, 0x60, 0x61, 0x83,
  0x06, 0x0C, 0x18, 0x60, 0x61, 0x81, 0x86, 0x02, 0x30, 0x0C, 0xC0, 0x36,
  0x00, 0xD8, 0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x60, 0xC1,
  0xB0, 0x60, 0xD8, 0x70, 0x4C, 0x28, 0x66, 0x14, 0x33, 0x1A, 0x19, 0x8D,
  0x08, 0xC4, 0x8C, 0x62, 0x46, 0x33, 0x23, 0x19, 0x13, 0x0C, 0x89, 0x84,
  0xC4, 0xC2, 0x42, 0x41, 0x21, 0x60, 0x90, 0xB0, 0x58, 0xD8, 0x68, 0x68,
  0x34, 0x3C, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x0C, 0x00, 0xC1,
  0x80, 0x60, 0x60, 0x38, 0x18, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x18,
  0xC0, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x0C, 0x18, 0x07,
  0x06, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x06, 0x38, 0x01, 0x80, 0xE0,
  0x07, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x18,
  0x30, 0x18, 0x60, 0x18, 0xC0, 0x0C, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x7F, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x70, 0x0F, 0xE1, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x7F, 0x00, 0x01, 0x80, 0x1E, 0x00, 0xF0, 0x0D, 0x80,
  0x64, 0x06, 0x30, 0x61, 0x83, 0x0C, 0x30, 0x33, 0x81, 0x98, 0x0D, 0x80,
  0x30, 0xFF, 0xFE, 0xC3, 0x0C, 0x61, 0x80, 0x03, 0xCC, 0x3F, 0xB1, 0xC3,
  0xCC, 0x07, 0x30, 0x1D, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80,
  0x66, 0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x80, 0xC6, 0x07, 0x1E, 0xEC, 0x3F,
  0x30, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC7, 0x83,
  0x7F, 0x0F, 0x0E, 0x38, 0x18, 0xC0, 0x73, 0x00, 0xD8, 0x06, 0x60, 0x19,
  0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x80, 0xCE, 0x03, 0x38, 0x18,
  0xD9, 0xE3, 0x7E, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xC3, 0x8E, 0x07, 0x30,
  0x0D, 0x80, 0x36, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x19, 0x80, 0xC6, 0x07, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x79, 0x83, 0xFB, 0x0E,
  0x1E, 0x30, 0x1C, 0x60, 0x39, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x30, 0x0C, 0xC0, 0x39, 0x80, 0x63, 0x80, 0xC3, 0x03, 0x87,
  0xBB, 0x07, 0xE6, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xC3, 0x8C, 0x06, 0x30,
  0x0D, 0x80, 0x36, 0x01, 0x98, 0x06, 0x7F, 0xF9, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0xC6, 0x06, 0x1E, 0x78, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xCC, 0x3F, 0xB1, 0xC3, 0xCC, 0x07, 0x30, 0x1D,
  0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E,
  0x60, 0x31, 0xC1, 0xC3, 0xFB, 0x07, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x01, 0xC1, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC7, 0x83, 0x7F, 0x0F, 0x0E, 0x38, 0x18, 0xC0, 0x73,
  0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x1B,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC0, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x10,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0xCC, 0x03, 0x18, 0x0E, 0x30, 0x38,
  0x60, 0xE0, 0xC1, 0x81, 0x86, 0x06, 0x18, 0x0F, 0xE0, 0x18, 0x60, 0x30,
  0xC0, 0x60, 0xC0, 0xC1, 0xC3, 0x01, 0x86, 0x03, 0x8C, 0x03, 0x18, 0x07,
  0x00, 0xFF, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xF0, 0xFF, 0x33, 0x0C,
  0x37, 0xBE, 0x38, 0xC7, 0x30, 0xC3, 0x30, 0xC2, 0x30, 0x86, 0x21, 0x86,
  0x61, 0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x84, 0x61, 0x0C, 0x41, 0x0C,
  0xC3, 0x0C, 0xC3, 0x0C, 0xC3, 0x0C, 0xC3, 0x0C, 0x31, 0xE0, 0xDF, 0xC3,
  0xC3, 0x8E, 0x06, 0x30, 0x1C, 0xC0, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19,
  0x80, 0x66, 0x01, 0x98, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C,
  0xC0, 0x30, 0x03, 0xC0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30, 0x19, 0x80,
  0x36, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x06, 0xC0,
  0x31, 0x80, 0xC6, 0x06, 0x1F, 0xF0, 0x3F, 0x80, 0x18, 0xF0, 0x37, 0xF0,
  0x78, 0x70, 0xE0, 0x61, 0x80, 0xE3, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x67, 0x01, 0x8E, 0x03, 0x1C, 0x0C,
  0x36, 0x78, 0x6F, 0xC0, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xCC, 0x3F, 0xB1, 0xC3, 0xCC, 0x07, 0x30, 0x1D, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x0C, 0xC0,
  0x33, 0x80, 0xC6, 0x07, 0x1E, 0xEC, 0x3F, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x19, 0xE0, 0x37, 0xF0, 0x70, 0x71, 0xC0,
  0x63, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x03, 0xE0, 0x3F, 0xE1, 0x81, 0x8C, 0x03, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1B,
  0x00, 0xEE, 0x03, 0x1E, 0x78, 0x3F, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x30, 0x0C, 0xC0, 0x33,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x76, 0x01, 0x98, 0x06, 0x60, 0x19,
  0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x1F, 0xF0,
  0x3F, 0x80, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x98, 0x06, 0x60, 0x31, 0x80,
  0xC6, 0x06, 0x0C, 0x18, 0x30, 0xC0, 0xC3, 0x03, 0x18, 0x0C, 0x60, 0x13,
  0x00, 0x6C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x83, 0x07, 0x06, 0x0E,
  0x0C, 0x14, 0x38, 0x68, 0x50, 0xD0, 0xA1, 0x23, 0x46, 0x44, 0x8C, 0x89,
  0x11, 0x32, 0x62, 0x44, 0xC4, 0x89, 0x0B, 0x1E, 0x14, 0x3C, 0x28, 0x70,
  0x70, 0xE0, 0xC1, 0xC0, 0x18, 0x03, 0x18, 0x06, 0x0C, 0x0C, 0x0C, 0x18,
  0x06, 0x38, 0x06, 0x30, 0x03, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x06, 0xC0, 0x0E, 0x60, 0x1C, 0x60, 0x18, 0x30, 0x30, 0x30, 0x60, 0x18,
  0xC0, 0x1C, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x19, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x60,
  0x71, 0xC3, 0xC3, 0xFB, 0x07, 0x8C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x03, 0xC1, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1E, 0x80, 0x1E, 0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xC3, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x0D,
  0x9C, 0x36, 0x38, 0xF0, 0x77, 0xC0, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 9, 9, 18, 6, -22 },
  { 29, 17, 22, 18, 1, -22 },
  { 76, 15, 30, 18, 2, -26 },
  { 133, 21, 22, 18, -1, -22 },
  { 191, 16, 22, 18, 1, -22 },
  { 235, 3, 9, 18, 9, -22 },
  { 239, 12, 29, 18, 5, -25 },
  { 283, 11, 29, 18, 2, -25 },
  { 323, 15, 15, 18, 2, -18 },
  { 352, 14, 14, 18, 2, -17 },
  { 377, 7, 10, 18, 3, -5 },
  { 386, 10, 2, 18, 4, -11 },
  { 389, 4, 4, 18, 6, -4 },
  { 391, 17, 28, 18, 1, -25 },
  { 451, 15, 22, 18, 2, -22 },
  { 493, 13, 22, 18, 2, -22 },
  { 529, 16, 22, 18, 1, -22 },
  { 573, 15, 22, 18, 2, -22 },
  { 615, 14, 22, 18, 2, -22 },
  { 654, 15, 22, 18, 2, -22 },
  { 696, 14, 22, 18, 2, -22 },
  { 735, 14, 22, 18, 4, -22 },
  { 774, 15, 22, 18, 2, -22 },
  { 816, 14, 22, 18, 3, -22 },
  { 855, 6, 17, 18, 6, -17 },
  { 868, 10, 22, 18, 3, -17 },
  { 896, 14, 16, 18, 3, -18 },
  { 924, 14, 8, 18, 2, -14 },
  { 938, 14, 16, 18, 2, -18 },
  { 966, 12, 22, 18, 5, -22 },
  { 999, 17, 27, 18, 1, -22 },
  { 1057, 14, 22, 18, 1, -22 },
  { 1096, 15, 22, 18, 2, -22 },
  { 1138, 15, 22, 18, 2, -22 },
  { 1180, 15, 22, 18, 2, -22 },
  { 1222, 16, 22, 18, 2, -22 },
  { 1266, 16, 22, 18, 2, -22 },
  { 1310, 15, 22, 18, 2, -22 },
  { 1352, 15, 22, 18, 2, -22 },
  { 1394, 15, 22, 18, 2, -22 },
  { 1436, 16, 22, 18, 1, -22 },
  { 1480, 16, 22, 18, 2, -22 },
  { 1524, 13, 22, 18, 2, -22 },
  { 1560, 17, 22, 18, 1, -22 },
  { 1607, 15, 22, 18, 2, -22 },
  { 1649, 15, 22, 18, 2, -22 },
  { 1691, 16, 22, 18, 2, -22 },
  { 1735, 15, 27, 18, 2, -22 },
  { 1786, 15, 22, 18, 2, -22 },
  { 1828, 15, 22, 18, 2, -22 },
  { 1870, 14, 22, 18, 4, -22 },
  { 1909, 15, 22, 18, 2, -22 },
  { 1951, 14, 22, 18, 4, -22 },
  { 1990, 17, 22, 18, 2, -22 },
  { 2037, 18, 22, 18, 0, -22 },
  { 2087, 16, 22, 18, 3, -22 },
  { 2131, 16, 22, 18, 1, -22 },
  { 2175, 11, 28, 18, 5, -25 },
  { 2214, 9, 28, 18, 5, -25 },
  { 2246, 11, 28, 18, 3, -25 },
  { 2285, 13, 12, 18, 3, -22 },
  { 2305, 15, 1, 18, 0, 1 },
  { 2307, 5, 5, 18, 8, -24 },
  { 2311, 14, 17, 18, 2, -17 },
  { 2341, 14, 22, 18, 2, -22 },
  { 2380, 14, 17, 18, 2, -17 },
  { 2410, 15, 22, 18, 2, -22 },
  { 2452, 14, 17, 18, 2, -17 },
  { 2482, 19, 27, 18, -1, -22 },
  { 2547, 14, 22, 18, 2, -17 },
  { 2586, 14, 22, 18, 2, -22 },
  { 2625, 14, 23, 18, 1, -23 },
  { 2666, 15, 28, 18, 1, -23 },
  { 2719, 15, 22, 18, 2, -22 },
  { 2761, 12, 22, 18, 3, -22 },
  { 2794, 16, 17, 18, 1, -17 },
  { 2828, 14, 17, 18, 2, -17 },
  { 2858, 14, 17, 18, 2, -17 },
  { 2888, 15, 22, 18, 1, -17 },
  { 2930, 14, 22, 18, 2, -17 },
  { 2969, 15, 17, 18, 2, -17 },
  { 3001, 14, 17, 18, 2, -17 },
  { 3031, 14, 21, 18, 3, -21 },
  { 3068, 14, 17, 18, 2, -17 },
  { 3098, 14, 17, 18, 3, -17 },
  { 3128, 15, 17, 18, 3, -17 },
  { 3160, 16, 17, 18, 1, -17 },
  { 3194, 14, 22, 18, 2, -17 },
  { 3233, 14, 17, 18, 2, -17 },
  { 3263, 15, 28, 18, 3, -25 },
  { 3316, 7, 28, 18, 6, -25 },
  { 3341, 15, 28, 18, 1, -25 },
  { 3394, 14, 5, 18, 2, -13 },
};

const GFXfont JetBrainsMono_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC30PT7B_H_
