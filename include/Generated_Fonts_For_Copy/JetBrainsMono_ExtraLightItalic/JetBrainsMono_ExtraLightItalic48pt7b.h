#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC48PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x00, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C,
  0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8,
  0x01, 0xFB, 0xFC, 0x03, 0xC7, 0x1E, 0x07, 0x87, 0x0E, 0x07, 0x06, 0x0F,
  0x0F, 0x06, 0x0F, 0x0E, 0x06, 0x0F, 0x0E, 0x06, 0x0F, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x8C, 0x00,
  0x07, 0xCC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1B, 0xF0, 0x00, 0x18, 0xF0, 0x00, 0x18, 0x78,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38,
  0xE0, 0x30, 0x38, 0xE0, 0x30, 0x38, 0xE0, 0x70, 0x78, 0xF0, 0x70, 0x70,
  0xF0, 0x60, 0xF0, 0x78, 0x61, 0xE0, 0x3F, 0x6F, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x0E, 0x03, 0xC7, 0x80, 0x1C,
  0x03, 0x83, 0x80, 0x18, 0x07, 0x01, 0x80, 0x38, 0x07, 0x01, 0x80, 0x70,
  0x06, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x83, 0x80,
  0x0E, 0x03, 0x87, 0x00, 0x0E, 0x03, 0x86, 0x00, 0x0E, 0x07, 0x0E, 0x00,
  0x0F, 0x07, 0x1C, 0x00, 0x07, 0xFE, 0x38, 0x00, 0x03, 0xFC, 0x70, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x0E, 0x3F, 0xE0,
  0x00, 0x1C, 0x7F, 0xE0, 0x00, 0x38, 0xF0, 0x70, 0x00, 0x30, 0xE0, 0x70,
  0x00, 0x71, 0xC0, 0x70, 0x00, 0xE1, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x70,
  0x03, 0x81, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x01, 0xE3, 0xC0,
  0x70, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0x70,
  0x0F, 0x1C, 0x1E, 0x03, 0x8E, 0x03, 0xC1, 0xC3, 0x80, 0x70, 0xF0, 0xE0,
  0x1E, 0x38, 0x38, 0x03, 0x9C, 0x1E, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0x81,
  0xC0, 0x07, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x7C, 0x07, 0x00, 0x3F,
  0x81, 0xC0, 0x1E, 0xE0, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0x87, 0x03, 0xFF,
  0xC0, 0xE0, 0x7F, 0xC0, 0x3C, 0x3C, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x73,
  0xCF, 0x3C, 0xE3, 0x80, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x38,
  0x06, 0xFC, 0x1C, 0x1F, 0xFF, 0x8E, 0x3F, 0xDF, 0xF6, 0x7F, 0x81, 0xFF,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x01,
  0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80,
  0x30, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3E, 0x1C,
  0x38, 0x3E, 0x1C, 0x38, 0x3E, 0x1C, 0x38, 0x1C, 0x1C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x3F, 0xBF, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0x70, 0x00, 0xF9, 0xC0, 0x0F, 0x87, 0x00, 0x7C,
  0x1C, 0x01, 0xC0, 0x70, 0x06, 0x03, 0xC0, 0x20, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x8F, 0xC0, 0x3E, 0x00, 0xF0, 0x1C,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x03, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x78, 0x07, 0xC0,
  0x3F, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x78,
  0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F, 0x80, 0x0E, 0x7F, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1D, 0x80, 0xF8, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x03, 0xC0, 0x3F, 0x9F, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x73, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xC3,
  0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xF0, 0x00, 0x71, 0xC0, 0x03,
  0xC7, 0x80, 0x1E, 0x1F, 0x00, 0xF0, 0x3F, 0x1F, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0x80, 0x00, 0xE7, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x38, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x07,
  0x00, 0x38, 0x07, 0x80, 0xF0, 0x03, 0xE1, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x07, 0x83, 0xE0, 0x1E,
  0x00, 0xF0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x78, 0x78, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x70, 0xF0, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x78, 0x03, 0xE0, 0x3F,
  0x9F, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF8, 0xFC, 0x0F, 0x00, 0xF8, 0x78, 0x00,
  0xE3, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x1E, 0x70, 0x00, 0x71, 0xE0, 0x03, 0xC7, 0xC0, 0x3E,
  0x0F, 0xC3, 0xF8, 0x1F, 0xFD, 0xC0, 0x3F, 0xCE, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x81, 0xF8, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0xFC, 0x1F, 0x87, 0xF8, 0xFE, 0x1F, 0xC1, 0xF0,
  0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x1F, 0xCE, 0x1C, 0x03, 0xFE, 0xE1, 0xC0, 0x78, 0x6E, 0x1C, 0x0F, 0x03,
  0xC1, 0xC0, 0xE0, 0x1C, 0x38, 0x1C, 0x01, 0xC3, 0x81, 0xC0, 0x1C, 0x38,
  0x1C, 0x01, 0xC3, 0x81, 0xC0, 0x1C, 0x38, 0x1C, 0x03, 0x83, 0x81, 0xC0,
  0x38, 0x70, 0x38, 0x03, 0x87, 0x03, 0x80, 0x38, 0x70, 0x38, 0x03, 0x87,
  0x03, 0x80, 0x38, 0x70, 0x38, 0x07, 0x87, 0x03, 0xC0, 0xF0, 0xE0, 0x3E,
  0x1B, 0x0E, 0x01, 0xFF, 0x70, 0xE0, 0x0F, 0xE7, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70,
  0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0xF8, 0x1C, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x3C, 0x07, 0xF0, 0x38, 0x00, 0xF8, 0x38, 0x00, 0x78, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xCF, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x78, 0x01,
  0xE0, 0x78, 0x07, 0x80, 0xFE, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x07,
  0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71,
  0xE0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0xCF, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xFF, 0xC7,
  0x03, 0xFF, 0x8E, 0x07, 0xFF, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xF0,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x78, 0x07,
  0x80, 0xFE, 0x7E, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x80,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x0F, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1E, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00,
  0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x3F, 0x3F, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x07, 0x00, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x06, 0xE0, 0x1D, 0x81, 0xB8, 0x07, 0x60,
  0x66, 0x03, 0xB8, 0x39, 0x80, 0xEE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C,
  0xE0, 0xE7, 0x0E, 0x70, 0x38, 0xC3, 0x9C, 0x0E, 0x31, 0xC7, 0x07, 0x0C,
  0x71, 0xC1, 0xC3, 0xB8, 0x70, 0x70, 0xEE, 0x1C, 0x1C, 0x1F, 0x0F, 0x07,
  0x07, 0x83, 0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x07, 0x06, 0xE0,
  0x07, 0x0E, 0xE0, 0x0E, 0x0E, 0xE0, 0x0E, 0x0E, 0xE0, 0x0E, 0x0E, 0x60,
  0x0E, 0x0E, 0x70, 0x0E, 0x0E, 0x70, 0x0E, 0x0E, 0x70, 0x1E, 0x1C, 0x30,
  0x1C, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x1C, 0x38,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x38, 0x1C,
  0x38, 0x38, 0x0C, 0x38, 0x38, 0x0E, 0x38, 0x38, 0x0E, 0x38, 0x78, 0x0E,
  0x70, 0x70, 0x0E, 0x70, 0x70, 0x07, 0x70, 0x70, 0x07, 0x70, 0x70, 0x07,
  0x70, 0x70, 0x07, 0x70, 0xF0, 0x03, 0x70, 0xE0, 0x03, 0xE0, 0xE0, 0x03,
  0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x07,
  0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x8E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0x80, 0x03,
  0xC7, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70,
  0x78, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xE0, 0x03, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x01, 0xE1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x7C, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1E, 0x07,
  0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x9F, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0xC0, 0x70, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0xF8, 0x1C, 0x03,
  0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x8F, 0xC0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0xE7, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78,
  0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x9F, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x1E, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xF0, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x38, 0x01,
  0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7,
  0x80, 0x01, 0xCE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x0F,
  0x01, 0xEE, 0x01, 0xE0, 0x39, 0xC0, 0x7C, 0x07, 0x38, 0x0D, 0x80, 0xE7,
  0x01, 0xF0, 0x38, 0xE0, 0x7E, 0x07, 0x1C, 0x0D, 0xC0, 0xE3, 0x81, 0xB8,
  0x1C, 0x70, 0x36, 0x07, 0x0E, 0x0E, 0xC0, 0xE1, 0xC1, 0x98, 0x1C, 0x30,
  0x33, 0x07, 0x06, 0x0E, 0x60, 0xE0, 0xC1, 0x8C, 0x1C, 0x18, 0x31, 0x83,
  0x87, 0x0E, 0x30, 0xE0, 0xE1, 0x86, 0x1C, 0x1C, 0x30, 0xC3, 0x83, 0x86,
  0x18, 0x60, 0x71, 0xC3, 0x1C, 0x0E, 0x30, 0x63, 0x81, 0xC6, 0x0C, 0x70,
  0x39, 0xC1, 0x8C, 0x07, 0x30, 0x33, 0x80, 0xE6, 0x06, 0x70, 0x1C, 0xC0,
  0xCC, 0x03, 0xB0, 0x1B, 0x80, 0x76, 0x03, 0x70, 0x0E, 0xC0, 0x6E, 0x01,
  0xF8, 0x0D, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00,
  0x78, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xF0, 0x00,
  0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x78, 0x00, 0x78, 0x38, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x1E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x01,
  0xE7, 0x00, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x07, 0x01, 0xC0,
  0xF0, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x00, 0xE3, 0x80, 0x0E,
  0x78, 0x00, 0xE7, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0F,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0x1C, 0x0F, 0xFF, 0x78, 0x3E, 0x07, 0xF0,
  0xF0, 0x07, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x3F, 0x1E, 0xE0,
  0x3F, 0xF9, 0xC0, 0x3F, 0xE3, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x80, 0x38, 0xFF, 0x80, 0xEF, 0xFF,
  0x03, 0xF0, 0x3E, 0x1F, 0x80, 0x78, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0, 0x03, 0xCE, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x3F, 0x00, 0xF0, 0xEF, 0x1F,
  0x83, 0x9F, 0xFC, 0x0E, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0F, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x01,
  0xE0, 0x7F, 0x7F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x3E,
  0x0E, 0x01, 0xFF, 0x8E, 0x03, 0xFF, 0xDE, 0x07, 0xC0, 0xFE, 0x0F, 0x00,
  0x7C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xF0, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x3F, 0x1E,
  0xE0, 0x1F, 0xFC, 0xE0, 0x0F, 0xF8, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDE, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x0E, 0x70, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x7E, 0x1F,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFC, 0x70, 0x7F, 0xFB, 0xC3, 0xE0, 0x7F, 0x1E, 0x00, 0xF8, 0x70,
  0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x70, 0x03, 0xE1, 0xE0, 0x1B, 0x83, 0xFF, 0xDE,
  0x07, 0xFE, 0x70, 0x0F, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x0F,
  0x80, 0x39, 0xFF, 0x80, 0xEF, 0xFF, 0x03, 0xF0, 0x3E, 0x1F, 0x00, 0x78,
  0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0xF3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x0F, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x02, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x87, 0x00, 0x07, 0x83, 0x80, 0x07, 0x81,
  0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0x70, 0x03, 0xC0,
  0x38, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x83, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x70, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1E, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x38,
  0x00, 0x1E, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x00, 0x3C, 0x1E, 0x03, 0x9F, 0x8F, 0xE0, 0xEF, 0xF7,
  0xF8, 0x3C, 0x1F, 0x0E, 0x0E, 0x07, 0x83, 0xC3, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x1C, 0x07, 0x03, 0x87, 0x01, 0x80, 0xE1,
  0xC0, 0xE0, 0x38, 0x70, 0x38, 0x0E, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81,
  0xC3, 0x80, 0xE0, 0x70, 0xE0, 0x38, 0x1C, 0x38, 0x0C, 0x07, 0x0E, 0x07,
  0x01, 0xC3, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x70, 0x1C, 0x0E, 0x1C,
  0x07, 0x03, 0x87, 0x01, 0x80, 0xE1, 0xC0, 0xE0, 0x38, 0x70, 0x38, 0x0E,
  0x1C, 0x0E, 0x07, 0x0F, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0x80, 0x39, 0xFF,
  0x80, 0xEF, 0xFF, 0x03, 0xF0, 0x3E, 0x1F, 0x00, 0x78, 0x7C, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xF3, 0xC0,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x8E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x3C, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x0F, 0x0E,
  0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01,
  0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0,
  0x01, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0F, 0x00,
  0xF0, 0x7E, 0x3F, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0x9F, 0xF8, 0x03, 0xBF, 0xFC, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x0E,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x3F, 0x00, 0xF0, 0x3B, 0xC7, 0xE0,
  0x39, 0xFF, 0xC0, 0x38, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x1C, 0x0F, 0xFF, 0x78, 0x3E, 0x07, 0xE0, 0xF0, 0x07, 0xC1,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3F, 0x1E, 0xE0, 0x3F, 0xF9, 0xC0,
  0x3F, 0xE3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x39, 0xFF, 0x80, 0xEF,
  0xFF, 0x07, 0xF0, 0x3E, 0x1D, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80, 0x03, 0xCE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xE0, 0x1F, 0x0F, 0x00, 0x3C, 0x78, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x1E,
  0x00, 0x78, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0xF0, 0x1F, 0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38,
  0x01, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x3C, 0x01, 0xC0,
  0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x3C, 0x03, 0xF0, 0x1E, 0x03, 0xB8, 0x0F, 0x01,
  0xDC, 0x0F, 0x80, 0xCE, 0x06, 0xC0, 0xE7, 0x03, 0x60, 0x73, 0x83, 0xB0,
  0x39, 0xC1, 0x98, 0x38, 0xE0, 0xCC, 0x1C, 0x70, 0xE6, 0x0E, 0x38, 0x63,
  0x0E, 0x1C, 0x31, 0x87, 0x0E, 0x38, 0xC3, 0x87, 0x18, 0x63, 0x83, 0x8C,
  0x31, 0xC1, 0xCE, 0x18, 0xE0, 0xE6, 0x0C, 0x60, 0x73, 0x06, 0x70, 0x3B,
  0x83, 0x38, 0x1D, 0x81, 0x98, 0x0E, 0xC0, 0xDC, 0x07, 0xE0, 0x6E, 0x03,
  0xE0, 0x36, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9E, 0x00, 0x1E,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x03, 0xCF, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0x78, 0x0F, 0xC0,
  0xFF, 0xF7, 0x03, 0xFF, 0x9C, 0x03, 0xF8, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0x00, 0x73, 0xFE, 0x01, 0xDE, 0x3C, 0x07, 0x70, 0x70,
  0x1F, 0x81, 0xE0, 0xEE, 0x03, 0xC3, 0xB8, 0x07, 0xFC, 0xE0, 0x0F, 0xE3,
  0x80, 0x0E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 35, 29, 9, -35 },
  { 50, 16, 14, 29, 9, -35 },
  { 78, 28, 35, 29, 1, -35 },
  { 201, 24, 49, 29, 3, -42 },
  { 348, 32, 35, 29, -1, -35 },
  { 488, 26, 36, 29, 1, -36 },
  { 605, 6, 14, 29, 14, -35 },
  { 616, 20, 47, 29, 8, -41 },
  { 734, 20, 47, 29, 2, -41 },
  { 852, 25, 24, 29, 3, -29 },
  { 927, 22, 22, 29, 4, -27 },
  { 988, 12, 15, 29, 5, -7 },
  { 1011, 16, 3, 29, 7, -17 },
  { 1017, 8, 7, 29, 9, -7 },
  { 1024, 28, 45, 29, 1, -40 },
  { 1182, 24, 36, 29, 3, -36 },
  { 1290, 22, 35, 29, 2, -35 },
  { 1387, 25, 36, 29, 2, -36 },
  { 1500, 24, 35, 29, 3, -35 },
  { 1605, 21, 35, 29, 4, -35 },
  { 1697, 24, 35, 29, 3, -35 },
  { 1802, 22, 35, 29, 3, -35 },
  { 1899, 23, 35, 29, 6, -35 },
  { 2000, 24, 36, 29, 3, -36 },
  { 2108, 22, 36, 29, 5, -36 },
  { 2207, 11, 27, 29, 9, -27 },
  { 2245, 15, 35, 29, 5, -27 },
  { 2311, 23, 24, 29, 4, -28 },
  { 2380, 22, 14, 29, 4, -23 },
  { 2419, 22, 24, 29, 3, -28 },
  { 2485, 19, 35, 29, 7, -35 },
  { 2569, 28, 45, 29, 1, -36 },
  { 2727, 23, 35, 29, 1, -35 },
  { 2828, 24, 35, 29, 3, -35 },
  { 2933, 23, 36, 29, 4, -36 },
  { 3037, 23, 35, 29, 3, -35 },
  { 3138, 25, 35, 29, 3, -35 },
  { 3248, 26, 35, 29, 3, -35 },
  { 3362, 23, 36, 29, 4, -36 },
  { 3466, 24, 35, 29, 3, -35 },
  { 3571, 24, 35, 29, 3, -35 },
  { 3676, 25, 35, 29, 2, -35 },
  { 3786, 26, 35, 29, 3, -35 },
  { 3900, 20, 35, 29, 4, -35 },
  { 3988, 26, 35, 29, 2, -35 },
  { 4102, 24, 35, 29, 3, -35 },
  { 4207, 23, 36, 29, 4, -36 },
  { 4311, 25, 35, 29, 3, -35 },
  { 4421, 24, 45, 29, 3, -36 },
  { 4556, 25, 35, 29, 3, -35 },
  { 4666, 25, 36, 29, 2, -36 },
  { 4779, 23, 35, 29, 6, -35 },
  { 4880, 24, 35, 29, 3, -35 },
  { 4985, 23, 35, 29, 6, -35 },
  { 5086, 27, 35, 29, 4, -35 },
  { 5205, 29, 35, 29, 0, -35 },
  { 5332, 24, 35, 29, 6, -35 },
  { 5437, 25, 35, 29, 2, -35 },
  { 5547, 19, 45, 29, 7, -40 },
  { 5654, 14, 45, 29, 8, -40 },
  { 5733, 19, 45, 29, 4, -40 },
  { 5840, 20, 19, 29, 5, -35 },
  { 5888, 24, 3, 29, 0, 1 },
  { 5897, 8, 7, 29, 13, -38 },
  { 5904, 23, 27, 29, 3, -27 },
  { 5982, 22, 35, 29, 3, -35 },
  { 6079, 22, 27, 29, 4, -27 },
  { 6154, 24, 35, 29, 3, -35 },
  { 6259, 21, 27, 29, 4, -27 },
  { 6330, 31, 44, 29, -2, -35 },
  { 6501, 22, 36, 29, 4, -27 },
  { 6600, 22, 35, 29, 3, -35 },
  { 6697, 22, 37, 29, 2, -37 },
  { 6799, 24, 46, 29, 1, -37 },
  { 6937, 25, 35, 29, 3, -35 },
  { 7047, 19, 35, 29, 5, -35 },
  { 7131, 26, 27, 29, 1, -27 },
  { 7219, 22, 27, 29, 3, -27 },
  { 7294, 21, 27, 29, 4, -27 },
  { 7365, 24, 36, 29, 1, -27 },
  { 7473, 23, 36, 29, 3, -27 },
  { 7577, 22, 27, 29, 4, -27 },
  { 7652, 22, 27, 29, 3, -27 },
  { 7727, 22, 34, 29, 5, -34 },
  { 7821, 23, 26, 29, 3, -26 },
  { 7896, 23, 26, 29, 5, -26 },
  { 7971, 25, 26, 29, 4, -26 },
  { 8053, 26, 26, 29, 1, -26 },
  { 8138, 22, 35, 29, 4, -26 },
  { 8235, 23, 26, 29, 3, -26 },
  { 8310, 23, 45, 29, 5, -40 },
  { 8440, 10, 45, 29, 10, -40 },
  { 8497, 23, 45, 29, 2, -40 },
  { 8627, 22, 10, 29, 4, -22 },
};

const GFXfont JetBrainsMono_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC48PT7B_H_
