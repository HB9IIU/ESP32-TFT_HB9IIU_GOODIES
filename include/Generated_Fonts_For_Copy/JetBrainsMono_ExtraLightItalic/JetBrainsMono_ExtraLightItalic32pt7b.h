#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC32PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1,
  0x83, 0x04, 0x08, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x1C, 0x00, 0x70, 0xDC,
  0x36, 0x1D, 0x87, 0x61, 0xD8, 0x66, 0x1B, 0x06, 0xC1, 0x80, 0x00, 0xC0,
  0xC0, 0x30, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0xC3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x30,
  0x30, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x81, 0x83, 0xFF, 0xFC, 0x18, 0x30,
  0x0C, 0x0C, 0x03, 0x06, 0x00, 0x81, 0x80, 0x60, 0x60, 0x18, 0x30, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0xF0,
  0x03, 0xFC, 0x0F, 0x7E, 0x0C, 0x47, 0x18, 0x47, 0x18, 0x43, 0x18, 0xC3,
  0x38, 0xC0, 0x18, 0xC0, 0x1C, 0x80, 0x1E, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0x9C, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0xC3, 0x0C,
  0xC3, 0x0C, 0xE3, 0x18, 0x63, 0x38, 0x7F, 0xF0, 0x3F, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x80, 0x04, 0x1F, 0x80, 0x60,
  0xE7, 0x03, 0x03, 0x0C, 0x0C, 0x08, 0x30, 0x60, 0x60, 0xC3, 0x01, 0x83,
  0x18, 0x06, 0x08, 0xC0, 0x18, 0x66, 0x00, 0x7F, 0xB0, 0x00, 0xF8, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x84, 0x00, 0x0C, 0xFC, 0x00,
  0x67, 0x38, 0x01, 0x18, 0x60, 0x0C, 0x41, 0x80, 0x63, 0x06, 0x03, 0x0C,
  0x18, 0x18, 0x30, 0x40, 0xC0, 0xC3, 0x06, 0x03, 0xFC, 0x30, 0x07, 0xC0,
  0x00, 0x70, 0x01, 0xFE, 0x01, 0xE7, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03,
  0xE0, 0x03, 0x98, 0x1B, 0x8E, 0x19, 0x83, 0x0C, 0xC1, 0xCC, 0x60, 0x6C,
  0x30, 0x3E, 0x38, 0x0E, 0x18, 0x07, 0x0C, 0x07, 0xC7, 0x07, 0x61, 0xFE,
  0x38, 0x7E, 0x0E, 0x77, 0x76, 0x66, 0x66, 0xC0, 0x00, 0x08, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x02, 0x0E, 0x0B, 0xC6,
  0x3C, 0xF9, 0x7F, 0x1F, 0xF8, 0x00, 0xC0, 0x00, 0xB0, 0x00, 0xD8, 0x00,
  0xC6, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0x70, 0x20, 0x20, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x1F, 0xFF,
  0xBF, 0xFF, 0x81, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x30, 0xC1,
  0x80, 0xFF, 0xFF, 0xF0, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0x1E,
  0x1C, 0x06, 0x18, 0x07, 0x38, 0x03, 0x30, 0x03, 0x30, 0x07, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x86, 0x73, 0xC6, 0x63, 0xC6, 0x61, 0x8E, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x18, 0xE0, 0x18,
  0x70, 0x70, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0xF0, 0x0F, 0xC0, 0x77, 0x07,
  0x98, 0x18, 0x60, 0x41, 0x82, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x07, 0xFC, 0x0F, 0x1E, 0x1C, 0x06, 0x18, 0x07, 0x30, 0x03, 0x30,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x18, 0xC0,
  0x18, 0xE0, 0x38, 0x60, 0x70, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x30, 0xC0, 0x63, 0x80, 0xCE, 0x01, 0x98,
  0x03, 0x30, 0x0E, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3B, 0xF8, 0x37,
  0xF8, 0x38, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0xE0, 0x18, 0x60, 0x38, 0x60, 0x30, 0x7F,
  0xE0, 0x1F, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x37, 0xE0, 0xFF, 0xE1,
  0xC0, 0xE7, 0x00, 0xCC, 0x01, 0xD8, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x77, 0x00, 0xC7, 0x03, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0xFE, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F,
  0x1E, 0x0C, 0x06, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x0E, 0x1C, 0x1C, 0x0E, 0x70, 0x03, 0xE0, 0x07, 0xE0, 0x1C, 0x70, 0x38,
  0x18, 0x70, 0x1C, 0x60, 0x0C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xE0,
  0x18, 0x60, 0x38, 0x7F, 0xF0, 0x3F, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x78,
  0xF1, 0xC0, 0x63, 0x00, 0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0xE7, 0x87, 0x87, 0xFE, 0x03, 0xDC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x0C, 0x7C, 0xF9, 0xF1, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0xF9, 0xE0, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x06, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x08, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xFC, 0x20,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x3F, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xC0, 0x78, 0x78, 0x38, 0x06, 0x0C, 0x01, 0xC6, 0x00, 0x31, 0x80,
  0x0C, 0xC0, 0x03, 0x30, 0x08, 0xCC, 0x1F, 0xB3, 0x0E, 0x29, 0x83, 0x06,
  0x61, 0x81, 0x98, 0x60, 0x66, 0x18, 0x19, 0x86, 0x06, 0x61, 0x83, 0x30,
  0xC0, 0xCC, 0x30, 0x33, 0x0E, 0x1C, 0xC1, 0xDF, 0x30, 0x7E, 0xCC, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x60, 0x06,
  0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30,
  0x18, 0x60, 0x70, 0x60, 0xC0, 0xC1, 0x81, 0x86, 0x03, 0x0F, 0xFE, 0x30,
  0x0C, 0x60, 0x19, 0xC0, 0x33, 0x00, 0x66, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0x80, 0x1F, 0xF8, 0x1F, 0xFE, 0x18, 0x0E, 0x18, 0x06, 0x18, 0x07, 0x18,
  0x06, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x1C, 0x3F, 0xF0, 0x3F,
  0xF8, 0x30, 0x1C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0xE0, 0x18, 0xC0, 0x78, 0xFF, 0xE0, 0xFF, 0xC0, 0x00,
  0xF0, 0x03, 0xFC, 0x07, 0x1E, 0x0C, 0x06, 0x18, 0x07, 0x18, 0x03, 0x38,
  0x03, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x60, 0x1C, 0x60, 0x18, 0x70, 0x30, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x18, 0x0E, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60,
  0x18, 0xE0, 0x30, 0xC0, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0x87, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF,
  0x8F, 0xFF, 0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xF0, 0x03, 0xFC, 0x07, 0x1E, 0x0C, 0x06, 0x18, 0x07, 0x18, 0x03, 0x38,
  0x03, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x31,
  0xFE, 0x71, 0xFE, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0x60, 0x18, 0x70, 0x30, 0x3F, 0xE0, 0x1F, 0xC0, 0x1C,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x38,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x3F, 0xFC, 0x3F, 0xFC, 0x30,
  0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60,
  0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x60, 0x0C, 0x70, 0x06, 0x38, 0x07, 0x0C,
  0x03, 0x07, 0x03, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x01, 0xC6, 0x00,
  0xC1, 0x80, 0x70, 0x60, 0x18, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x30,
  0xE0, 0x1C, 0x18, 0x06, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x83, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x07, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x03, 0xC2, 0x80, 0xE0, 0xA0, 0x68,
  0x6C, 0x1E, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0x91, 0x98, 0x64, 0x6E, 0x19,
  0xB3, 0x0E, 0x6C, 0xC3, 0x1E, 0x30, 0xC3, 0x8C, 0x30, 0xC3, 0x0C, 0x01,
  0xC3, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC0, 0x1E, 0x03, 0x1E,
  0x03, 0x1E, 0x03, 0x1E, 0x03, 0x1A, 0x06, 0x1B, 0x06, 0x3B, 0x06, 0x33,
  0x06, 0x31, 0x06, 0x31, 0x86, 0x31, 0x8E, 0x31, 0x8C, 0x31, 0x8C, 0x60,
  0x8C, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0x58, 0x60, 0x78, 0xC0,
  0x78, 0xC0, 0x78, 0xC0, 0x78, 0xC0, 0x38, 0x00, 0xF0, 0x03, 0xFC, 0x07,
  0x1E, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x70, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60,
  0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x86,
  0x01, 0xC3, 0x00, 0x61, 0x80, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x03, 0x0C, 0x07, 0x87, 0xFF, 0x03, 0xFF, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC,
  0x0F, 0x1E, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x07, 0x38, 0x07, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x0E, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x18,
  0x60, 0x18, 0x70, 0x30, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x1F, 0xFC, 0x0F, 0xFF,
  0x06, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60,
  0x06, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x07, 0x07, 0xFF, 0x03, 0xFC, 0x03,
  0x86, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x1C, 0x06, 0x0C, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xFC, 0x0F, 0x0E, 0x0C, 0x07, 0x18, 0x07, 0x18, 0x03, 0x18, 0x03, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xE0, 0x18, 0xE0, 0x38, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x06, 0x38, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0x70,
  0x70, 0x3F, 0xE0, 0x1F, 0xC0, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x30, 0x60,
  0x60, 0x70, 0x60, 0x30, 0xE0, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x31,
  0x80, 0x33, 0x00, 0x33, 0x00, 0x37, 0x00, 0x36, 0x00, 0x16, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x60, 0xE0, 0xD8, 0x38, 0x36, 0x0A, 0x0D, 0x82, 0x86,
  0x61, 0xA1, 0x98, 0x48, 0x66, 0x12, 0x19, 0x8D, 0x8C, 0x63, 0x63, 0x18,
  0x98, 0xC6, 0x26, 0x61, 0x99, 0x98, 0x64, 0x66, 0x19, 0x19, 0x86, 0xC6,
  0xC1, 0xB1, 0xB0, 0x68, 0x6C, 0x1E, 0x1A, 0x07, 0x87, 0x81, 0x41, 0xE0,
  0x50, 0x78, 0x1C, 0x1C, 0x0E, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x60, 0x0C,
  0x07, 0x01, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x18, 0x60, 0x01, 0x8E,
  0x00, 0x1C, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x03, 0x98, 0x00, 0x31, 0x80, 0x06,
  0x1C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x06, 0x07,
  0x00, 0x70, 0xE0, 0x03, 0x00, 0xC0, 0x07, 0xC0, 0x06, 0x60, 0x0C, 0x60,
  0x1C, 0x60, 0x18, 0x30, 0x30, 0x30, 0x70, 0x30, 0x60, 0x18, 0xC0, 0x19,
  0xC0, 0x19, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0F,
  0xF0, 0xFE, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x70,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07, 0xF0,
  0xFF, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x36, 0x00, 0xD8, 0x06, 0x60, 0x30, 0xC0, 0xC3, 0x06, 0x0C, 0x38,
  0x18, 0xC0, 0x66, 0x01, 0xB8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xE3, 0x0C,
  0x70, 0x03, 0xE6, 0x1F, 0xEC, 0x70, 0x78, 0xC0, 0x73, 0x00, 0xE6, 0x01,
  0xCC, 0x03, 0x38, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE6,
  0x01, 0x8C, 0x03, 0x18, 0x0E, 0x38, 0x3C, 0x3F, 0xD8, 0x7F, 0x70, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x3E, 0x0E, 0xFE,
  0x1A, 0x0E, 0x38, 0x0C, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x63, 0x00, 0xCE,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0x67, 0x01,
  0xCD, 0x03, 0x1B, 0xFC, 0x33, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x70,
  0x70, 0xC0, 0x73, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x38,
  0x18, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x03, 0xE6, 0x0F, 0xF6, 0x1C, 0x1E, 0x18, 0x0E, 0x30,
  0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0x70, 0x78, 0x3F,
  0xD8, 0x3F, 0xB8, 0x03, 0xF0, 0x1F, 0xF0, 0x70, 0x70, 0xC0, 0x63, 0x00,
  0xE6, 0x01, 0xCC, 0x03, 0x30, 0x06, 0x7F, 0xFC, 0xFF, 0xF9, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x06, 0x38, 0x18, 0x3F, 0xE0, 0x3F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xCC, 0x7F, 0xB3, 0x83, 0xCC,
  0x07, 0x60, 0x1D, 0x80, 0x76, 0x01, 0xB8, 0x06, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x81, 0xCF, 0x0F, 0x1F, 0xEC, 0x1E, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x07, 0x0F, 0xF8, 0x3F, 0x80,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x3E, 0x0E,
  0xFE, 0x1A, 0x0E, 0x38, 0x0C, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x63, 0x00,
  0xCE, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0x67,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x00, 0x00, 0x10, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x03, 0x18, 0x07, 0x38,
  0x0E, 0x30, 0x1C, 0x30, 0x38, 0x30, 0x70, 0x30, 0x60, 0x30, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x30, 0xE0, 0x30, 0xC0, 0x18, 0xC0, 0x1C, 0x7F, 0x07, 0xF8, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x1B, 0x8E, 0x0B,
  0xEF, 0x8E, 0x38, 0xE6, 0x1C, 0x33, 0x0C, 0x19, 0x86, 0x18, 0xC3, 0x0C,
  0x61, 0x86, 0x60, 0xC3, 0x30, 0x41, 0x98, 0x60, 0xCC, 0x30, 0xC6, 0x18,
  0x63, 0x0C, 0x33, 0x86, 0x19, 0x83, 0x0C, 0xC3, 0x06, 0x61, 0x87, 0x00,
  0x19, 0xF0, 0x77, 0xF0, 0xD0, 0x71, 0xC0, 0x63, 0x00, 0xE6, 0x01, 0xCC,
  0x03, 0x18, 0x06, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE6, 0x01,
  0x8C, 0x03, 0x38, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x70, 0x03, 0xF0,
  0x1F, 0xF0, 0x70, 0x70, 0xC0, 0x63, 0x00, 0xE6, 0x01, 0xCC, 0x03, 0x30,
  0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0xCC, 0x03,
  0x18, 0x0E, 0x38, 0x18, 0x3F, 0xE0, 0x3F, 0x80, 0x0C, 0xF8, 0x1D, 0xFC,
  0x1A, 0x0E, 0x1C, 0x06, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06,
  0x38, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x70, 0x1C, 0x68, 0x18, 0x6F, 0xF0, 0x67, 0xE0, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xE6, 0x1F, 0xEC,
  0x70, 0x78, 0xC0, 0x73, 0x00, 0xE6, 0x01, 0x8C, 0x03, 0x30, 0x06, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x03, 0x18, 0x0E,
  0x38, 0x3C, 0x7F, 0xD8, 0x7F, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x18, 0xF8, 0x1B, 0xFC, 0x1E, 0x0E, 0x1C,
  0x06, 0x18, 0x06, 0x38, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x70, 0x31, 0xC0,
  0x33, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xB0, 0x06, 0x70, 0x1C, 0x7F,
  0xF0, 0x7F, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x18, 0x06, 0x70,
  0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0xCC, 0x03, 0x38, 0x06,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x03, 0x18,
  0x0E, 0x38, 0x38, 0x3F, 0xE0, 0x3F, 0x80, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xB0, 0x06, 0xC0, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x60, 0xC1, 0x83,
  0x06, 0x18, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x0D, 0x80, 0x1C,
  0x00, 0x70, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3, 0x83, 0xC2, 0x86, 0xC6,
  0x86, 0xC6, 0x86, 0xC4, 0x8C, 0xCC, 0x8C, 0xCC, 0x8C, 0xC8, 0x98, 0xD8,
  0x98, 0xD8, 0x98, 0xD0, 0xB0, 0xF0, 0xB0, 0xF0, 0xB0, 0xE0, 0xA0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x18, 0x03, 0x8E, 0x01, 0x83, 0x01, 0x80, 0xC1, 0xC0,
  0x61, 0xC0, 0x19, 0xC0, 0x0C, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xD8, 0x00, 0xEC, 0x00, 0xE7, 0x00, 0x61, 0x80, 0x60, 0xE0, 0x60,
  0x30, 0x60, 0x1C, 0x70, 0x07, 0x00, 0x38, 0x06, 0x60, 0x0C, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0,
  0x19, 0x80, 0x73, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x1E, 0x16, 0x1F, 0xCC,
  0x0E, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x1F,
  0xF0, 0x3F, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x80, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xFF, 0xF9, 0xFF,
  0xF0, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x90, 0x03,
  0xE0, 0x00, 0x60, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x86,
  0x38, 0xC3, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0x63, 0x8C, 0x30,
  0xC3, 0x0C, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x09, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x3E, 0x07, 0x77, 0x06, 0x61, 0x86, 0x61,
  0xC6, 0x60, 0xFC, 0xC0, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 10, 9, 19, 6, -23 },
  { 34, 18, 23, 19, 1, -23 },
  { 86, 16, 32, 19, 2, -28 },
  { 150, 22, 24, 19, -1, -24 },
  { 216, 17, 24, 19, 1, -24 },
  { 267, 4, 9, 19, 9, -23 },
  { 272, 13, 31, 19, 5, -27 },
  { 323, 12, 31, 19, 2, -27 },
  { 370, 17, 17, 19, 2, -20 },
  { 407, 15, 15, 19, 2, -18 },
  { 436, 7, 10, 19, 4, -5 },
  { 445, 10, 2, 19, 5, -12 },
  { 448, 5, 5, 19, 6, -5 },
  { 452, 18, 31, 19, 1, -27 },
  { 522, 16, 24, 19, 2, -24 },
  { 570, 14, 23, 19, 2, -23 },
  { 611, 16, 24, 19, 2, -24 },
  { 659, 16, 23, 19, 2, -23 },
  { 705, 15, 23, 19, 2, -23 },
  { 749, 16, 23, 19, 2, -23 },
  { 795, 15, 23, 19, 2, -23 },
  { 839, 15, 23, 19, 4, -23 },
  { 883, 16, 24, 19, 2, -24 },
  { 931, 15, 24, 19, 3, -24 },
  { 976, 7, 18, 19, 6, -18 },
  { 992, 9, 23, 19, 4, -18 },
  { 1018, 15, 17, 19, 3, -19 },
  { 1050, 15, 9, 19, 2, -15 },
  { 1067, 15, 17, 19, 2, -19 },
  { 1099, 13, 23, 19, 5, -23 },
  { 1137, 18, 30, 19, 1, -24 },
  { 1205, 15, 23, 19, 1, -23 },
  { 1249, 16, 23, 19, 2, -23 },
  { 1295, 16, 24, 19, 2, -24 },
  { 1343, 16, 23, 19, 2, -23 },
  { 1389, 17, 23, 19, 2, -23 },
  { 1438, 17, 23, 19, 2, -23 },
  { 1487, 16, 24, 19, 2, -24 },
  { 1535, 16, 23, 19, 2, -23 },
  { 1581, 16, 23, 19, 2, -23 },
  { 1627, 17, 23, 19, 1, -23 },
  { 1676, 18, 23, 19, 2, -23 },
  { 1728, 14, 23, 19, 2, -23 },
  { 1769, 18, 23, 19, 1, -23 },
  { 1821, 16, 23, 19, 2, -23 },
  { 1867, 16, 24, 19, 2, -24 },
  { 1915, 17, 23, 19, 2, -23 },
  { 1964, 16, 30, 19, 2, -24 },
  { 2024, 17, 23, 19, 2, -23 },
  { 2073, 16, 24, 19, 2, -24 },
  { 2121, 16, 23, 19, 4, -23 },
  { 2167, 16, 23, 19, 2, -23 },
  { 2213, 16, 23, 19, 4, -23 },
  { 2259, 18, 23, 19, 2, -23 },
  { 2311, 20, 23, 19, 0, -23 },
  { 2369, 16, 23, 19, 4, -23 },
  { 2415, 17, 23, 19, 1, -23 },
  { 2464, 12, 31, 19, 5, -27 },
  { 2511, 8, 31, 19, 6, -27 },
  { 2542, 12, 31, 19, 3, -27 },
  { 2589, 14, 12, 19, 3, -23 },
  { 2610, 16, 2, 19, 0, 1 },
  { 2614, 5, 4, 19, 9, -25 },
  { 2617, 15, 18, 19, 2, -18 },
  { 2651, 15, 23, 19, 2, -23 },
  { 2695, 15, 18, 19, 2, -18 },
  { 2729, 16, 23, 19, 2, -23 },
  { 2775, 15, 18, 19, 2, -18 },
  { 2809, 21, 29, 19, -1, -23 },
  { 2886, 14, 24, 19, 3, -18 },
  { 2928, 15, 23, 19, 2, -23 },
  { 2972, 15, 25, 19, 1, -25 },
  { 3019, 16, 31, 19, 1, -25 },
  { 3081, 16, 23, 19, 2, -23 },
  { 3127, 13, 23, 19, 3, -23 },
  { 3165, 17, 18, 19, 1, -18 },
  { 3204, 15, 18, 19, 2, -18 },
  { 3238, 15, 18, 19, 2, -18 },
  { 3272, 16, 24, 19, 1, -18 },
  { 3320, 15, 24, 19, 2, -18 },
  { 3365, 16, 18, 19, 2, -18 },
  { 3401, 15, 18, 19, 2, -18 },
  { 3435, 15, 22, 19, 3, -22 },
  { 3477, 15, 18, 19, 2, -18 },
  { 3511, 14, 18, 19, 4, -18 },
  { 3543, 16, 18, 19, 3, -18 },
  { 3579, 17, 18, 19, 1, -18 },
  { 3618, 15, 24, 19, 2, -18 },
  { 3663, 15, 18, 19, 2, -18 },
  { 3697, 16, 31, 19, 3, -27 },
  { 3759, 6, 31, 19, 7, -27 },
  { 3783, 16, 31, 19, 1, -27 },
  { 3845, 16, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC32PT7B_H_
