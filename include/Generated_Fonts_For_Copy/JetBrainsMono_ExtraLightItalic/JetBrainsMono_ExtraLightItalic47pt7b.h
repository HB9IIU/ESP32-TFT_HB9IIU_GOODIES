#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC47PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0xE3, 0xF8, 0xFC, 0x1E, 0x00, 0x3C, 0x1E, 0x70, 0x3D,
  0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x1E, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x00, 0x00,
  0x07, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x06, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x06, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x06, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xF9,
  0x9F, 0x00, 0x70, 0xC3, 0xC0, 0x70, 0x61, 0xE0, 0x78, 0x30, 0x70, 0x38,
  0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03,
  0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xF0, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0x83,
  0xC0, 0x00, 0xC1, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x38, 0x70, 0x38,
  0x1C, 0x38, 0x1C, 0x1E, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x0F, 0x07, 0x83,
  0x07, 0x01, 0xE1, 0x8F, 0x00, 0xFE, 0xDF, 0x80, 0x3F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x0E, 0x01, 0xFF, 0x00, 0x1C,
  0x03, 0x83, 0x80, 0x18, 0x07, 0x03, 0x80, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x06, 0x03, 0x80, 0xE0, 0x06, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x83, 0x80,
  0x0E, 0x03, 0x87, 0x00, 0x0E, 0x03, 0x06, 0x00, 0x0E, 0x07, 0x0E, 0x00,
  0x0E, 0x07, 0x1C, 0x00, 0x0F, 0x1E, 0x38, 0x00, 0x07, 0xFC, 0x70, 0x00,
  0x03, 0xF8, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x02, 0x00, 0x00, 0x0E, 0x3F, 0xC0,
  0x00, 0x1C, 0x7F, 0xE0, 0x00, 0x38, 0xF0, 0xE0, 0x00, 0x30, 0xC0, 0x60,
  0x00, 0x61, 0xC0, 0x60, 0x00, 0xE1, 0xC0, 0x60, 0x01, 0xC1, 0xC0, 0x60,
  0x03, 0x81, 0x80, 0xE0, 0x07, 0x01, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0xE0,
  0x0C, 0x03, 0x80, 0xC0, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x01, 0xE3, 0x80,
  0x70, 0x01, 0xFF, 0x80, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0xE0, 0x1E,
  0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xEE, 0x00, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x70,
  0x1E, 0x38, 0x1E, 0x07, 0x0E, 0x03, 0xC3, 0x83, 0x80, 0x71, 0xC0, 0xE0,
  0x1E, 0x70, 0x78, 0x03, 0xB8, 0x1C, 0x00, 0xFC, 0x07, 0x00, 0x1F, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x01, 0xF0, 0x1C, 0x00, 0xFC, 0x07, 0x00, 0x7F,
  0x81, 0xE0, 0x3C, 0xE0, 0x7E, 0x7E, 0x1C, 0x0F, 0xFE, 0x07, 0x81, 0xFF,
  0x00, 0xE0, 0x7B, 0xDE, 0xF7, 0x3B, 0xDE, 0xF7, 0xB9, 0xCE, 0x70, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x40, 0x1C, 0x01, 0x78, 0x1C, 0x0F, 0xFE, 0x18, 0x7F, 0xFF, 0x99, 0xFF,
  0x1F, 0xDF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xEC, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8F, 0x00, 0x07, 0x87, 0x00,
  0x0F, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x01, 0xE0,
  0x10, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0x83, 0xE0, 0x7C, 0x03, 0xC0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C,
  0x0C, 0x0E, 0x38, 0x3C, 0x1C, 0x70, 0xF8, 0x38, 0xE1, 0xF0, 0xF3, 0xC1,
  0xE1, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x8F, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3E, 0x01, 0xE0,
  0x3F, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xF3, 0x80, 0x1F, 0x1C, 0x01, 0xE0,
  0xE0, 0x1E, 0x0E, 0x00, 0xC0, 0x70, 0x04, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00,
  0x38, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x88, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x20, 0x00, 0xE7,
  0xFC, 0x03, 0x9F, 0xFC, 0x07, 0x70, 0xFC, 0x0F, 0x80, 0x78, 0x1E, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x1E, 0x00, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x7C, 0x00, 0xF7, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x01,
  0xF0, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0xE1, 0xC0, 0x07,
  0x87, 0x80, 0x3C, 0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDC, 0x00, 0x0E, 0xF0,
  0x00, 0x3B, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x38, 0x03,
  0xC0, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xF0, 0x03, 0x80,
  0xE0, 0x0E, 0x00, 0xF0, 0x78, 0x00, 0xF3, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3C, 0x3E, 0x00, 0xF0, 0x1E, 0x03, 0x80,
  0x1E, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0xF3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x7F, 0x1F, 0x80, 0x7F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xE0, 0x7C, 0x1E, 0x00, 0xF0, 0x70, 0x01, 0xE3, 0x80, 0x03, 0x9E, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEF, 0x00, 0x07, 0x3C, 0x00, 0x3C, 0x70,
  0x00, 0xF1, 0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0xFF, 0xF0, 0x0F, 0xF3,
  0x80, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x07, 0xC0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x38, 0x07, 0xFB, 0x87, 0x01, 0xFF,
  0xF0, 0xE0, 0x78, 0x1E, 0x38, 0x0E, 0x03, 0xC7, 0x03, 0x80, 0x78, 0xE0,
  0x70, 0x0E, 0x1C, 0x0E, 0x01, 0xC3, 0x81, 0xC0, 0x38, 0x70, 0x70, 0x07,
  0x0E, 0x0E, 0x00, 0xE3, 0x81, 0xC0, 0x1C, 0x70, 0x38, 0x03, 0x0E, 0x07,
  0x00, 0xE1, 0xC0, 0xE0, 0x1C, 0x38, 0x1C, 0x03, 0x87, 0x03, 0x80, 0xF1,
  0xC0, 0x78, 0x3E, 0x38, 0x07, 0xFD, 0xC7, 0x00, 0x7F, 0x30, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0x60, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x07,
  0x00, 0xC0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x01, 0xE0, 0xF0, 0x01,
  0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83,
  0x80, 0x0E, 0x07, 0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0xE0, 0x07, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x3C,
  0x38, 0x01, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xF0, 0x3E, 0x07,
  0x80, 0x38, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x4E,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0F, 0x00,
  0x3C, 0x1E, 0x01, 0xE0, 0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x03,
  0xC0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C,
  0x1E, 0x00, 0x78, 0x38, 0x03, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x20, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xF0, 0x3E,
  0x07, 0x80, 0x38, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x03, 0xFF, 0x9C, 0x0F, 0xFE, 0x70, 0x3F, 0xF1, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03,
  0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0F,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x7F,
  0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x03,
  0xC1, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0F, 0x00,
  0x1E, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x0F, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xE0,
  0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x07, 0xC1, 0xB0, 0x03, 0xE0, 0x6C, 0x00, 0xD8, 0x1B,
  0x00, 0x7E, 0x06, 0xE0, 0x1B, 0x83, 0xB8, 0x0E, 0xE0, 0xEE, 0x03, 0x30,
  0x39, 0x81, 0xCC, 0x0E, 0x60, 0x67, 0x03, 0x98, 0x39, 0xC0, 0xE7, 0x0C,
  0x70, 0x31, 0xC7, 0x1C, 0x1C, 0x31, 0x87, 0x07, 0x0C, 0xE3, 0x81, 0xC3,
  0x30, 0xE0, 0x70, 0xFC, 0x38, 0x1C, 0x3E, 0x0E, 0x07, 0x07, 0x83, 0x83,
  0x81, 0xC0, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x0F, 0x07, 0xC0,
  0x0E, 0x07, 0xC0, 0x0E, 0x0E, 0xC0, 0x0E, 0x0E, 0xE0, 0x0E, 0x0E, 0xE0,
  0x0E, 0x0E, 0xE0, 0x0E, 0x0E, 0x60, 0x1C, 0x0E, 0x70, 0x1C, 0x1C, 0x70,
  0x1C, 0x1C, 0x70, 0x1C, 0x1C, 0x70, 0x1C, 0x1C, 0x30, 0x1C, 0x1C, 0x38,
  0x38, 0x1C, 0x38, 0x38, 0x3C, 0x38, 0x38, 0x38, 0x18, 0x38, 0x38, 0x1C,
  0x38, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x78, 0x38, 0x1C, 0x70, 0x38, 0x0C,
  0x70, 0x70, 0x0E, 0x70, 0x70, 0x0E, 0x70, 0x70, 0x0E, 0x70, 0x70, 0x06,
  0x70, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07,
  0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xF0, 0x3E, 0x07, 0x00, 0x78,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0xF3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x0F, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x38, 0x1E,
  0x01, 0xE0, 0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x00,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x38, 0x03,
  0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x3C, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x1E, 0x00, 0x70, 0x3E, 0x01, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0x00, 0x3E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C,
  0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70,
  0x03, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x1C, 0x00, 0xF0,
  0x1C, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0x78, 0x03, 0xC0,
  0x3F, 0x8F, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38,
  0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0x1F, 0x80,
  0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xDC,
  0x07, 0x80, 0x67, 0x01, 0xE0, 0x39, 0xC0, 0x78, 0x0E, 0x70, 0x3E, 0x03,
  0x9C, 0x0D, 0x81, 0xC7, 0x03, 0x60, 0x71, 0x81, 0xD8, 0x1C, 0x60, 0x66,
  0x07, 0x18, 0x19, 0x83, 0x86, 0x06, 0x60, 0xE1, 0x83, 0x18, 0x38, 0xE0,
  0xC6, 0x0C, 0x38, 0x31, 0x87, 0x0E, 0x1C, 0x61, 0xC3, 0x86, 0x18, 0x70,
  0xE1, 0x86, 0x18, 0x38, 0xE1, 0x8E, 0x0E, 0x30, 0x63, 0x83, 0x8C, 0x18,
  0xC0, 0xE3, 0x06, 0x70, 0x39, 0x81, 0x9C, 0x0E, 0x60, 0x67, 0x03, 0x98,
  0x19, 0x80, 0xEE, 0x0E, 0xE0, 0x3B, 0x03, 0xB8, 0x0E, 0xC0, 0xEC, 0x03,
  0xB0, 0x37, 0x00, 0xF8, 0x0D, 0xC0, 0x36, 0x03, 0x70, 0x0D, 0x80, 0xD8,
  0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x3C,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x87, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0x70, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0,
  0x1C, 0x38, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x00, 0xC1,
  0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x07, 0x70, 0x00, 0xFC,
  0x00, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0xE0, 0xE1, 0xC1, 0xC3, 0xC3, 0x80, 0x00, 0xFF, 0x1C, 0x07, 0xFE, 0x70,
  0x7F, 0x7D, 0xC1, 0xE0, 0x37, 0x0E, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00,
  0x38, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x0F, 0xC7, 0xB8,
  0x1F, 0xFD, 0xE0, 0x3F, 0xC7, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x3F, 0xC0, 0x39, 0xFF, 0x81, 0xFF, 0x3F,
  0x07, 0x60, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE3, 0xE0, 0x07, 0x0E, 0xC0, 0x3C, 0x3B, 0xC7, 0xE0, 0xE7, 0xFF,
  0x03, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00,
  0x0F, 0x70, 0x00, 0x7B, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x39, 0xC0, 0x03, 0xCE, 0x00, 0x1C, 0x78,
  0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0xE7, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0xFF, 0x1C, 0x01, 0xFF, 0x9C, 0x07, 0xF7, 0xDC, 0x07, 0x80,
  0xDC, 0x0E, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x3F, 0x1E,
  0xE0, 0x1F, 0xFD, 0xE0, 0x0F, 0xF1, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xF9, 0xF8, 0x1E, 0x01, 0xC1, 0xC0, 0x0F, 0x1E, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x1C, 0x78, 0x01, 0xE1, 0xC0, 0x1E, 0x0F, 0xC3, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x38, 0x1F, 0xF9, 0xC3, 0xFB, 0xEE, 0x1E, 0x03, 0x71, 0xC0, 0x0F,
  0x9E, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0x73,
  0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x3C, 0x00,
  0x78, 0xE0, 0x07, 0x87, 0x80, 0x7C, 0x3F, 0xBE, 0xE0, 0xFF, 0xE7, 0x01,
  0xFC, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x3F, 0xC0, 0x39, 0xFF, 0x81, 0xFF, 0x3F, 0x07,
  0x60, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00,
  0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x1E,
  0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xF0,
  0x1C, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x1C, 0x0F, 0x00,
  0x38, 0x1E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0xC0,
  0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0E, 0x7C, 0x3E,
  0x07, 0x7F, 0x3F, 0x83, 0xE3, 0xF1, 0xE1, 0xE0, 0xF0, 0x70, 0xE0, 0x70,
  0x38, 0x70, 0x38, 0x1C, 0x70, 0x18, 0x0E, 0x38, 0x0C, 0x07, 0x1C, 0x0E,
  0x07, 0x0E, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC3, 0x81, 0xC0, 0xE1, 0x80,
  0xE0, 0x71, 0xC0, 0x60, 0x38, 0xE0, 0x70, 0x18, 0x70, 0x38, 0x1C, 0x38,
  0x1C, 0x0E, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0x8E, 0x03, 0x01, 0xC7,
  0x01, 0x80, 0xE3, 0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x38,
  0x70, 0x38, 0x1C, 0x70, 0x18, 0x0E, 0x00, 0x0E, 0x3F, 0xC0, 0x39, 0xFF,
  0x81, 0xEF, 0x3F, 0x07, 0x60, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x1E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xFB, 0xF8, 0x1E, 0x03, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x79, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x78, 0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0xC7, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0x8F, 0xF0, 0x03, 0x9F, 0xF8, 0x07, 0xFC,
  0xFC, 0x07, 0x60, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x3B, 0x00,
  0xF0, 0x3B, 0xC7, 0xE0, 0x39, 0xFF, 0xC0, 0x38, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x1C, 0x0F, 0xFE, 0x70, 0x7F, 0x7D, 0xC3, 0xE0, 0x37, 0x0E, 0x00, 0x7C,
  0x78, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x2E, 0x0F, 0xC7, 0xB8, 0x1F, 0xFD, 0xE0, 0x3F, 0xC7, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x3F, 0xC0, 0x7B,
  0xFF, 0x81, 0xDF, 0x3F, 0x07, 0x60, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x7F, 0x3F, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x3C, 0x70, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0xC0, 0x03, 0x87, 0x80, 0x1E, 0x1F,
  0x83, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x3C, 0x00, 0x38,
  0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0,
  0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x03,
  0xC0, 0x7C, 0x0F, 0xC7, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x06, 0xE0, 0x6C, 0x0E, 0xE0,
  0x6C, 0x0E, 0xE0, 0x6C, 0x0C, 0xE0, 0xEC, 0x1C, 0xE0, 0xCC, 0x1C, 0xE0,
  0xCC, 0x18, 0xE1, 0x8C, 0x38, 0xE1, 0x8C, 0x38, 0xE1, 0x8C, 0x30, 0xE3,
  0x0C, 0x70, 0xE3, 0x0C, 0x70, 0xE3, 0x0C, 0x60, 0xE6, 0x0C, 0xE0, 0xE6,
  0x0C, 0xE0, 0xE6, 0x0C, 0xC0, 0xEC, 0x0C, 0xC0, 0xEC, 0x0D, 0xC0, 0xEC,
  0x0D, 0xC0, 0xF8, 0x0D, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0x38, 0x3C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x38, 0xE0, 0x01,
  0xCF, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x87, 0x80,
  0xDC, 0x3F, 0xFE, 0xE0, 0xFF, 0xE7, 0x01, 0xFC, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x0E,
  0x3F, 0xC0, 0x1C, 0xFF, 0xC0, 0x31, 0xC3, 0xC0, 0xE7, 0x03, 0x81, 0xCE,
  0x03, 0x83, 0x9C, 0x07, 0xFE, 0x38, 0x07, 0xF8, 0xE0, 0x03, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 34, 28, 9, -34 },
  { 44, 15, 14, 28, 9, -34 },
  { 71, 27, 34, 28, 1, -34 },
  { 186, 25, 48, 28, 2, -41 },
  { 336, 32, 35, 28, -1, -35 },
  { 476, 26, 35, 28, 1, -35 },
  { 590, 5, 14, 28, 14, -34 },
  { 599, 19, 46, 28, 8, -40 },
  { 709, 19, 46, 28, 2, -40 },
  { 819, 24, 24, 28, 3, -29 },
  { 891, 21, 22, 28, 4, -27 },
  { 949, 11, 15, 28, 5, -7 },
  { 970, 15, 3, 28, 7, -17 },
  { 976, 7, 7, 28, 9, -7 },
  { 983, 27, 44, 28, 1, -39 },
  { 1132, 23, 35, 28, 3, -35 },
  { 1233, 21, 34, 28, 2, -34 },
  { 1323, 24, 35, 28, 2, -35 },
  { 1428, 23, 34, 28, 3, -34 },
  { 1526, 22, 34, 28, 3, -34 },
  { 1620, 23, 34, 28, 3, -34 },
  { 1718, 22, 34, 28, 3, -34 },
  { 1812, 22, 34, 28, 6, -34 },
  { 1906, 23, 35, 28, 3, -35 },
  { 2007, 22, 35, 28, 5, -35 },
  { 2104, 11, 26, 28, 9, -26 },
  { 2140, 15, 34, 28, 5, -26 },
  { 2204, 22, 25, 28, 4, -28 },
  { 2273, 21, 13, 28, 4, -22 },
  { 2308, 22, 25, 28, 3, -28 },
  { 2377, 19, 34, 28, 7, -34 },
  { 2458, 27, 43, 28, 1, -35 },
  { 2604, 22, 34, 28, 1, -34 },
  { 2698, 23, 34, 28, 3, -34 },
  { 2796, 22, 35, 28, 4, -35 },
  { 2893, 23, 34, 28, 3, -34 },
  { 2991, 25, 34, 28, 3, -34 },
  { 3098, 25, 34, 28, 3, -34 },
  { 3205, 22, 35, 28, 4, -35 },
  { 3302, 24, 34, 28, 3, -34 },
  { 3404, 23, 34, 28, 3, -34 },
  { 3502, 25, 34, 28, 1, -34 },
  { 3609, 26, 34, 28, 3, -34 },
  { 3720, 20, 34, 28, 3, -34 },
  { 3805, 26, 34, 28, 2, -34 },
  { 3916, 24, 34, 28, 3, -34 },
  { 4018, 22, 35, 28, 4, -35 },
  { 4115, 25, 34, 28, 3, -34 },
  { 4222, 23, 43, 28, 3, -35 },
  { 4346, 24, 34, 28, 3, -34 },
  { 4448, 25, 35, 28, 2, -35 },
  { 4558, 23, 34, 28, 6, -34 },
  { 4656, 24, 34, 28, 3, -34 },
  { 4758, 23, 34, 28, 6, -34 },
  { 4856, 26, 34, 28, 4, -34 },
  { 4967, 29, 34, 28, 0, -34 },
  { 5091, 25, 34, 28, 5, -34 },
  { 5198, 25, 34, 28, 2, -34 },
  { 5305, 18, 44, 28, 7, -39 },
  { 5404, 13, 44, 28, 8, -39 },
  { 5476, 18, 44, 28, 4, -39 },
  { 5575, 19, 18, 28, 5, -34 },
  { 5618, 23, 3, 28, 0, 1 },
  { 5627, 7, 7, 28, 13, -37 },
  { 5634, 22, 26, 28, 3, -26 },
  { 5706, 22, 34, 28, 3, -34 },
  { 5800, 21, 26, 28, 4, -26 },
  { 5869, 24, 34, 28, 3, -34 },
  { 5971, 21, 26, 28, 4, -26 },
  { 6040, 31, 42, 28, -2, -34 },
  { 6203, 21, 34, 28, 4, -26 },
  { 6293, 22, 34, 28, 3, -34 },
  { 6387, 22, 36, 28, 2, -36 },
  { 6486, 24, 44, 28, 1, -36 },
  { 6618, 24, 34, 28, 3, -34 },
  { 6720, 19, 34, 28, 5, -34 },
  { 6801, 25, 26, 28, 1, -26 },
  { 6883, 22, 26, 28, 3, -26 },
  { 6955, 21, 26, 28, 4, -26 },
  { 7024, 24, 34, 28, 1, -26 },
  { 7126, 22, 34, 28, 3, -26 },
  { 7220, 22, 26, 28, 4, -26 },
  { 7292, 22, 26, 28, 3, -26 },
  { 7364, 21, 33, 28, 5, -33 },
  { 7451, 22, 26, 28, 3, -26 },
  { 7523, 22, 26, 28, 5, -26 },
  { 7595, 24, 26, 28, 4, -26 },
  { 7673, 26, 26, 28, 1, -26 },
  { 7758, 21, 34, 28, 4, -26 },
  { 7848, 22, 26, 28, 3, -26 },
  { 7920, 23, 44, 28, 5, -39 },
  { 8047, 10, 44, 28, 10, -39 },
  { 8102, 23, 44, 28, 2, -39 },
  { 8229, 23, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC47PT7B_H_
