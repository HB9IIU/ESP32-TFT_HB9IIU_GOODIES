#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC41PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x8F, 0x83, 0xC0, 0x78,
  0x3B, 0xC1, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xDC, 0x0E,
  0xE0, 0x67, 0x03, 0x38, 0x39, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x18,
  0x0E, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x70,
  0x18, 0x00, 0x60, 0x38, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0x60, 0x01, 0x80, 0xE0, 0x03, 0x80,
  0xC0, 0x03, 0x80, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x03,
  0x80, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x1C, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0C,
  0x00, 0x30, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xCD,
  0xF0, 0x3C, 0x63, 0x81, 0xC3, 0x0E, 0x1C, 0x18, 0x70, 0xE1, 0x83, 0x87,
  0x0C, 0x1C, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x78, 0xC0,
  0x01, 0xEC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x06, 0x78, 0x00, 0x31, 0xC0, 0x03, 0x07, 0x00, 0x18, 0x38,
  0x00, 0xC1, 0xC6, 0x06, 0x0E, 0x30, 0x30, 0x71, 0x81, 0x87, 0x0E, 0x18,
  0x38, 0x78, 0xC3, 0x81, 0xE6, 0x78, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x3F, 0xC0, 0x0E, 0x07,
  0x0E, 0x01, 0xC0, 0x60, 0x60, 0x38, 0x0E, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x60, 0x0C, 0x0E, 0x0C, 0x00, 0xC0, 0xE1, 0xC0, 0x0C, 0x0C, 0x38, 0x00,
  0xC0, 0xC7, 0x00, 0x0C, 0x1C, 0xE0, 0x00, 0xFF, 0x8C, 0x00, 0x07, 0xF1,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x10, 0x00, 0x01, 0x8F, 0xE0, 0x00, 0x31, 0xFF, 0x00, 0x06,
  0x38, 0x70, 0x00, 0xC3, 0x03, 0x00, 0x1C, 0x70, 0x30, 0x03, 0x86, 0x03,
  0x00, 0x70, 0x60, 0x70, 0x06, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x60, 0x18,
  0x06, 0x06, 0x03, 0x00, 0x70, 0xE0, 0x70, 0x07, 0xFC, 0x0E, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0x1C, 0x07, 0x38, 0x70, 0x18,
  0xE0, 0xE0, 0xE7, 0x01, 0xC7, 0x1C, 0x07, 0x38, 0x70, 0x0E, 0xC1, 0xC0,
  0x3F, 0x07, 0x00, 0x78, 0x18, 0x00, 0xC0, 0x60, 0x07, 0x81, 0x80, 0x3F,
  0x07, 0x01, 0xDC, 0x1E, 0x1E, 0x38, 0x3F, 0xF0, 0xE0, 0x7F, 0x01, 0xC0,
  0x7B, 0xDC, 0xE7, 0x39, 0xDE, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x02, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x06, 0x03, 0x80,
  0x9F, 0x0C, 0x1F, 0xFF, 0x33, 0xFC, 0x7E, 0xDF, 0x80, 0x7F, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x39, 0xC0, 0x01, 0xC3,
  0x80, 0x0F, 0x0E, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0,
  0x10, 0x02, 0x00, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x1C, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3B, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xC3, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xF1,
  0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x06,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x0F, 0x0E, 0x70, 0xF0,
  0xE7, 0x0F, 0x0C, 0x70, 0xF0, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x70, 0x70, 0x0F, 0x07, 0xC3, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0x98, 0x03,
  0xCE, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x20, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x00, 0xF0, 0x7C, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x86,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x01, 0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0x83, 0x80, 0x70,
  0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x01, 0xCE,
  0x00, 0x39, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x38, 0x01, 0x9F, 0xF0, 0x3B, 0xFF, 0x83, 0xE0, 0x78, 0x3C,
  0x03, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x83, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x77, 0xF0, 0x1F, 0xFF,
  0x07, 0xC0, 0xF0, 0xF0, 0x0F, 0x3C, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x06,
  0x70, 0x01, 0xCE, 0x00, 0x71, 0xE0, 0x1E, 0x1E, 0x0F, 0x81, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x00,
  0x0E, 0x60, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xF0, 0x7C, 0x0F, 0x00, 0xE0, 0x70, 0x03, 0x07, 0x00, 0x1C, 0x38, 0x00,
  0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x0E,
  0x03, 0x80, 0x3C, 0x78, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0,
  0x07, 0x8F, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00,
  0x0C, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1E, 0x00, 0xE0, 0x78, 0x1E, 0x01, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3E, 0x1F, 0x0F, 0x00, 0xE3, 0xC0,
  0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEC, 0x00,
  0x1D, 0x80, 0x03, 0xB0, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x9E, 0x01,
  0xE1, 0xE0, 0x78, 0x3F, 0xFF, 0x01, 0xFD, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x0F, 0xC7, 0xE7, 0xF1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x1F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xE0, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0x80,
  0xF0, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x86, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x1F, 0x39,
  0xC0, 0x7F, 0x73, 0x81, 0xE3, 0xE7, 0x07, 0x03, 0x8E, 0x0C, 0x07, 0x18,
  0x38, 0x0E, 0x30, 0x70, 0x1C, 0xE0, 0xE0, 0x39, 0xC1, 0xC0, 0x73, 0x83,
  0x00, 0xC7, 0x06, 0x01, 0x8C, 0x1C, 0x03, 0x18, 0x38, 0x0E, 0x30, 0x70,
  0x1C, 0xE0, 0xE0, 0x79, 0xC0, 0xFB, 0xE3, 0x81, 0xFE, 0xC7, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xB8, 0x00, 0x77, 0x00, 0x0C, 0xE0, 0x03, 0x9C, 0x00, 0x73,
  0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x03,
  0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x18, 0x07,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x00, 0x31, 0xC0, 0x07,
  0x38, 0x00, 0xE6, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0C,
  0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x18, 0x38, 0x00, 0xE1, 0xC0, 0x06,
  0x0E, 0x00, 0x30, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0,
  0x1C, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x18, 0x03, 0xC1,
  0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00,
  0x70, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C,
  0x01, 0xE0, 0xE0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0xC3, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x04, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x86, 0x00, 0x70, 0x70, 0x0F, 0x07, 0xC1, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0C, 0x03, 0xC0,
  0xE0, 0x0F, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0xC0,
  0xE1, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0xC3, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x07, 0xFE, 0x70, 0x7F, 0xC7, 0x07, 0xFC, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x60, 0x01, 0xC6, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x86, 0x00, 0x70, 0x70, 0x0F, 0x07, 0xC1, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0x00, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x18, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x30, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE0, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x80,
  0x78, 0x0F, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0xE0, 0x07,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x18, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x18, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x07,
  0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF8,
  0x06, 0xC3, 0x60, 0x3F, 0x0D, 0x80, 0xD8, 0x36, 0x07, 0x61, 0xD8, 0x19,
  0x87, 0x70, 0xEE, 0x1C, 0xC3, 0x38, 0x63, 0x1C, 0xE1, 0x8C, 0x63, 0x06,
  0x33, 0x8C, 0x38, 0xCC, 0x70, 0xE1, 0xB1, 0xC3, 0x87, 0x87, 0x0E, 0x1E,
  0x1C, 0x38, 0x70, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x00, 0x06, 0x00, 0x07, 0x80, 0x18, 0x3C, 0x00, 0xC1, 0xE0, 0x0E,
  0x0F, 0x80, 0x70, 0xFC, 0x03, 0x87, 0x60, 0x1C, 0x3B, 0x00, 0xC1, 0xD8,
  0x06, 0x0C, 0xE0, 0x70, 0x67, 0x03, 0x87, 0x18, 0x1C, 0x38, 0xC0, 0xE1,
  0xC7, 0x06, 0x0E, 0x38, 0x30, 0x60, 0xC3, 0x83, 0x06, 0x1C, 0x18, 0x30,
  0xE1, 0xC1, 0xC7, 0x0E, 0x0E, 0x30, 0x70, 0x31, 0x83, 0x81, 0x8C, 0x18,
  0x0E, 0xE0, 0xC0, 0x77, 0x0E, 0x01, 0xB8, 0x70, 0x0D, 0xC3, 0x80, 0x6C,
  0x1C, 0x03, 0xE0, 0xC0, 0x1F, 0x06, 0x00, 0x78, 0x70, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0x83, 0xC0, 0xF0, 0x0E, 0x0E, 0x00, 0xE1,
  0xC0, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x18, 0x60, 0x01, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x06, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x83, 0xE0, 0x3F, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0x80,
  0x1E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x30, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C,
  0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x7E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0x83, 0xC0, 0xF0, 0x0E, 0x0E,
  0x00, 0xE1, 0xC0, 0x06, 0x1C, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0x63,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E,
  0x30, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0xC6, 0x00, 0x1C, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x83, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0x80, 0x1E, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x07,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x00, 0xF0, 0x7C, 0x0F, 0x00, 0xE0, 0x70, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x1C,
  0x60, 0x01, 0xC3, 0x80, 0x0E, 0x1E, 0x00, 0xE0, 0x78, 0x1E, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30, 0xE0, 0x07,
  0x0C, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0x61, 0xC0, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x18, 0x70, 0x03, 0x86,
  0x00, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x0E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0x00,
  0x76, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x70, 0x30,
  0x07, 0x03, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0xC0, 0x38, 0x1C, 0x03,
  0x81, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x70, 0x01, 0x87, 0x00,
  0x18, 0x60, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x01, 0xDC, 0x00, 0x1D, 0xC0,
  0x01, 0xD8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x70, 0x1C, 0x0E, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x33, 0x81, 0xE0,
  0x67, 0x06, 0xC1, 0xCE, 0x0D, 0x83, 0x9C, 0x1B, 0x06, 0x38, 0x26, 0x0C,
  0x60, 0xCC, 0x38, 0xC1, 0x98, 0x71, 0x83, 0x30, 0xC3, 0x0C, 0x63, 0x86,
  0x18, 0x87, 0x0C, 0x31, 0x0C, 0x18, 0xC2, 0x18, 0x31, 0x84, 0x70, 0x63,
  0x08, 0xE0, 0xC4, 0x31, 0x81, 0x98, 0x63, 0x03, 0x30, 0xCE, 0x06, 0x61,
  0x98, 0x0D, 0x83, 0x30, 0x3B, 0x06, 0x60, 0x76, 0x0D, 0xC0, 0xE8, 0x1B,
  0x01, 0xF0, 0x36, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x0C, 0x60, 0x00, 0x07, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x0C,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0x98, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x18,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x38, 0x00, 0x19, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0xFE, 0x07,
  0xFC, 0x10, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x0C, 0x60,
  0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x06, 0x07, 0x03, 0x03, 0x01, 0xC3, 0x80,
  0xE3, 0x80, 0x31, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE1, 0xC1, 0xC0, 0x00, 0xF8, 0xE0, 0x7F,
  0xDC, 0x3F, 0x7B, 0x8F, 0x01, 0xF1, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00,
  0x71, 0x80, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00,
  0xC7, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03,
  0x9C, 0x00, 0xF3, 0x80, 0x1C, 0x38, 0x07, 0x87, 0x83, 0xF0, 0x7F, 0xEE,
  0x07, 0xF1, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE3, 0xF0, 0x0E,
  0xFF, 0x80, 0xDE, 0x7C, 0x1F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x80, 0x38, 0x78, 0x07, 0x07, 0xC0,
  0xF0, 0x67, 0xFE, 0x0E, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0x01, 0xE1, 0xC0, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x39, 0x80,
  0x06, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x9C, 0x00,
  0x71, 0x80, 0x1C, 0x38, 0x07, 0x87, 0xC1, 0xE0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x0F, 0x8E, 0x03, 0xFE, 0xE0,
  0xFD, 0xEE, 0x1E, 0x03, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x30, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0x87, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x83, 0xF0, 0x3F,
  0xF7, 0x01, 0xFC, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0xF8, 0x38,
  0x0F, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x77, 0xFF, 0xFD, 0xFF, 0xFF, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE6, 0x00, 0x71, 0xC0,
  0x3C, 0x78, 0x1E, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xE0,
  0x7F, 0xDC, 0x3F, 0x7B, 0x8F, 0x01, 0xF1, 0xC0, 0x1E, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0x80, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xC7, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x70,
  0x07, 0x8E, 0x01, 0xE1, 0xE0, 0x6C, 0x1F, 0xFB, 0x81, 0xFE, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE3, 0xF0, 0x0E, 0xFF, 0x80, 0xDE, 0x7C, 0x1F, 0x01,
  0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80,
  0x0E, 0x18, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x38,
  0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0F, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x06, 0x00, 0x70, 0x70,
  0x07, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x78, 0x07, 0x07, 0x80,
  0x30, 0x38, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x01,
  0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x0C, 0xF0, 0xF0, 0x37, 0xE7, 0xE1, 0xF3,
  0xB3, 0x87, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x60, 0x71, 0x81, 0x81,
  0x86, 0x06, 0x06, 0x18, 0x18, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x8E,
  0x0E, 0x0E, 0x30, 0x30, 0x30, 0xC0, 0xC0, 0xC3, 0x03, 0x03, 0x1C, 0x1C,
  0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC6, 0x06, 0x06, 0x18, 0x18, 0x18,
  0x60, 0x60, 0x63, 0x81, 0x83, 0x8E, 0x0E, 0x0E, 0x00, 0x0E, 0x3F, 0x00,
  0xEF, 0xF8, 0x0D, 0xE7, 0xC1, 0xF0, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE1, 0x80, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0xC3, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7D, 0xF8, 0x38, 0x0F, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xC0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xC6,
  0x00, 0x71, 0xC0, 0x38, 0x78, 0x1E, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0x1F, 0x80, 0x3B, 0xFE, 0x01, 0xBC, 0xF8, 0x1F, 0x01, 0xE0, 0xF0, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0x60,
  0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x30,
  0x60, 0x03, 0x83, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0F, 0x00,
  0x70, 0x78, 0x07, 0x03, 0xE0, 0x78, 0x19, 0xFF, 0x81, 0xC7, 0xF0, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0xFF, 0xDC, 0x3F,
  0x7B, 0x8F, 0x01, 0xF1, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xC7, 0x00,
  0x18, 0xC0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0xE3, 0x80, 0x1C, 0x38, 0x07, 0x87, 0x83, 0xF0, 0x7F, 0xEE, 0x07, 0xF1,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0C, 0x3E, 0x00, 0xCF, 0xF8, 0x1D,
  0xE7, 0xC1, 0xF0, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0x3F, 0x0E,
  0x00, 0xE1, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x98, 0x00, 0x73, 0x80,
  0x0E, 0x70, 0x03, 0x8F, 0x00, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1C, 0x00, 0xE3, 0x00,
  0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0x8E, 0x00,
  0x31, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x18, 0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03,
  0x9C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x83, 0xC0, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01,
  0xCE, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x0E,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x1C, 0x03, 0x03, 0x80, 0x70, 0xE0,
  0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x38, 0x00, 0x67, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x60,
  0x3E, 0x07, 0x01, 0xB0, 0x38, 0x1D, 0x81, 0x40, 0xEC, 0x1A, 0x06, 0x60,
  0xD0, 0x33, 0x04, 0xC3, 0x98, 0x66, 0x18, 0xC3, 0x30, 0xC6, 0x11, 0x8E,
  0x31, 0x8C, 0x61, 0x8C, 0x63, 0x0C, 0x43, 0x38, 0x66, 0x19, 0x83, 0x30,
  0xCC, 0x19, 0x06, 0xE0, 0xD8, 0x36, 0x06, 0xC1, 0xB0, 0x34, 0x0F, 0x81,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80,
  0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xEF, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0F,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xC0, 0x07,
  0x18, 0x00, 0xE3, 0x00, 0x1C, 0x70, 0x07, 0x0E, 0x01, 0x61, 0xE0, 0x7C,
  0x1F, 0xFB, 0x81, 0xFE, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x73, 0xFC, 0x06, 0x71, 0xE0, 0x66, 0x0E, 0x0E, 0x60,
  0x70, 0xEE, 0x03, 0xFC, 0xE0, 0x1F, 0x80, 0x00, 0x40,
};

const GFXglyph JetBrainsMono_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 30, 25, 8, -30 },
  { 35, 13, 12, 25, 8, -30 },
  { 55, 24, 30, 25, 1, -30 },
  { 145, 21, 42, 25, 2, -36 },
  { 256, 28, 30, 25, -1, -30 },
  { 361, 22, 30, 25, 1, -30 },
  { 444, 5, 12, 25, 12, -30 },
  { 452, 17, 40, 25, 7, -35 },
  { 537, 16, 40, 25, 2, -35 },
  { 617, 22, 21, 25, 2, -25 },
  { 675, 19, 19, 25, 3, -23 },
  { 721, 9, 13, 25, 5, -6 },
  { 736, 13, 3, 25, 6, -15 },
  { 741, 6, 6, 25, 8, -6 },
  { 746, 24, 39, 25, 1, -34 },
  { 863, 20, 30, 25, 3, -30 },
  { 938, 18, 30, 25, 2, -30 },
  { 1006, 21, 30, 25, 2, -30 },
  { 1085, 21, 30, 25, 2, -30 },
  { 1164, 19, 30, 25, 3, -30 },
  { 1236, 20, 30, 25, 3, -30 },
  { 1311, 19, 30, 25, 2, -30 },
  { 1383, 20, 30, 25, 5, -30 },
  { 1458, 21, 30, 25, 2, -30 },
  { 1537, 19, 30, 25, 4, -30 },
  { 1609, 9, 23, 25, 8, -23 },
  { 1635, 12, 30, 25, 5, -23 },
  { 1680, 19, 21, 25, 4, -24 },
  { 1730, 19, 12, 25, 3, -20 },
  { 1759, 20, 21, 25, 2, -24 },
  { 1812, 17, 30, 25, 6, -30 },
  { 1876, 23, 37, 25, 1, -30 },
  { 1983, 19, 30, 25, 1, -30 },
  { 2055, 21, 30, 25, 2, -30 },
  { 2134, 20, 30, 25, 3, -30 },
  { 2209, 21, 30, 25, 2, -30 },
  { 2288, 21, 30, 25, 3, -30 },
  { 2367, 21, 30, 25, 3, -30 },
  { 2446, 20, 30, 25, 3, -30 },
  { 2521, 21, 30, 25, 2, -30 },
  { 2600, 20, 30, 25, 3, -30 },
  { 2675, 22, 30, 25, 1, -30 },
  { 2758, 23, 30, 25, 2, -30 },
  { 2845, 17, 30, 25, 3, -30 },
  { 2909, 22, 30, 25, 2, -30 },
  { 2992, 21, 30, 25, 2, -30 },
  { 3071, 20, 30, 25, 3, -30 },
  { 3146, 22, 30, 25, 2, -30 },
  { 3229, 20, 37, 25, 3, -30 },
  { 3322, 22, 30, 25, 2, -30 },
  { 3405, 21, 30, 25, 2, -30 },
  { 3484, 20, 30, 25, 5, -30 },
  { 3559, 20, 30, 25, 3, -30 },
  { 3634, 20, 30, 25, 5, -30 },
  { 3709, 23, 30, 25, 3, -30 },
  { 3796, 25, 30, 25, 0, -30 },
  { 3890, 21, 30, 25, 5, -30 },
  { 3969, 21, 30, 25, 2, -30 },
  { 4048, 16, 39, 25, 6, -34 },
  { 4126, 12, 39, 25, 7, -34 },
  { 4185, 15, 39, 25, 4, -34 },
  { 4259, 17, 16, 25, 4, -30 },
  { 4293, 20, 2, 25, 0, 1 },
  { 4298, 7, 6, 25, 11, -32 },
  { 4304, 19, 23, 25, 3, -23 },
  { 4359, 20, 30, 25, 2, -30 },
  { 4434, 19, 23, 25, 3, -23 },
  { 4489, 20, 30, 25, 3, -30 },
  { 4564, 18, 23, 25, 3, -23 },
  { 4616, 26, 37, 25, -1, -30 },
  { 4737, 19, 30, 25, 3, -23 },
  { 4809, 20, 30, 25, 2, -30 },
  { 4884, 19, 32, 25, 2, -32 },
  { 4960, 20, 39, 25, 1, -32 },
  { 5058, 21, 30, 25, 3, -30 },
  { 5137, 17, 30, 25, 4, -30 },
  { 5201, 22, 23, 25, 1, -23 },
  { 5265, 20, 23, 25, 2, -23 },
  { 5323, 18, 23, 25, 3, -23 },
  { 5375, 21, 30, 25, 1, -23 },
  { 5454, 19, 30, 25, 3, -23 },
  { 5526, 20, 23, 25, 3, -23 },
  { 5584, 19, 23, 25, 3, -23 },
  { 5639, 19, 29, 25, 4, -29 },
  { 5708, 19, 23, 25, 3, -23 },
  { 5763, 19, 23, 25, 5, -23 },
  { 5818, 21, 23, 25, 4, -23 },
  { 5879, 22, 23, 25, 1, -23 },
  { 5943, 19, 30, 25, 3, -23 },
  { 6015, 20, 23, 25, 2, -23 },
  { 6073, 20, 39, 25, 4, -34 },
  { 6171, 9, 39, 25, 8, -34 },
  { 6215, 20, 39, 25, 1, -34 },
  { 6313, 20, 8, 25, 3, -18 },
};

const GFXfont JetBrainsMono_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC41PT7B_H_
