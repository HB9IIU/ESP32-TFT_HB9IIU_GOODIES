#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC15PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x92, 0x0B, 0x00, 0xDC, 0xA5, 0x29, 0x00, 0x08, 0x84,
  0x82, 0x47, 0xF1, 0x21, 0x10, 0x89, 0xFE, 0x44, 0x22, 0x12, 0x00, 0x08,
  0x10, 0x79, 0x54, 0xA9, 0x1C, 0x0C, 0x14, 0x26, 0x4C, 0xA7, 0x84, 0x08,
  0x00, 0x38, 0xD2, 0x24, 0x91, 0x28, 0x74, 0x02, 0x01, 0x70, 0x52, 0x29,
  0x12, 0x48, 0x70, 0x1E, 0x13, 0x20, 0x30, 0x10, 0x38, 0x49, 0x46, 0x44,
  0x46, 0x7B, 0x57, 0x80, 0x04, 0x62, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x81, 0x82, 0x00, 0x20, 0x40, 0x82, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x84, 0x31, 0x88, 0x00, 0x08, 0x08, 0xD3, 0x7C, 0x10, 0x28, 0xCC, 0x48,
  0x08, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x6B, 0x40, 0xF8, 0xF0, 0x01,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x06, 0x00, 0x3E, 0xC5, 0x0A, 0x14, 0x2B, 0x60, 0xC1, 0x85, 0x09,
  0xE0, 0x0C, 0xE4, 0x82, 0x08, 0x20, 0x84, 0x10, 0x4F, 0xC0, 0x3E, 0xC5,
  0x08, 0x10, 0x20, 0x82, 0x08, 0x21, 0x83, 0xF0, 0x3E, 0x04, 0x30, 0xC1,
  0x80, 0x81, 0x02, 0x85, 0x09, 0xE0, 0x06, 0x08, 0x20, 0x82, 0x0C, 0x51,
  0x42, 0xFC, 0x08, 0x10, 0x3E, 0x41, 0x02, 0x07, 0xC8, 0xC0, 0x82, 0x05,
  0x09, 0xE0, 0x04, 0x10, 0x41, 0x03, 0x88, 0xA0, 0xC1, 0x85, 0x09, 0xE0,
  0xFF, 0x06, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00, 0x1E, 0x45,
  0x0A, 0x12, 0x47, 0x11, 0x43, 0x85, 0x09, 0xE0, 0x7D, 0x8A, 0x14, 0x28,
  0x51, 0x9E, 0x08, 0x20, 0x43, 0x00, 0x6C, 0x00, 0x36, 0x33, 0x00, 0x00,
  0x64, 0xC8, 0x02, 0x0C, 0x63, 0x0C, 0x06, 0x03, 0x02, 0x7E, 0x00, 0x07,
  0xF0, 0x40, 0xC0, 0x60, 0x30, 0x63, 0x18, 0x40, 0x78, 0x10, 0x41, 0x0C,
  0xE4, 0x10, 0x01, 0x0C, 0x00, 0x0F, 0x18, 0x48, 0x28, 0x14, 0xFA, 0x49,
  0x24, 0xA2, 0x51, 0x47, 0xA0, 0x08, 0x04, 0x01, 0xC0, 0x04, 0x18, 0x28,
  0x91, 0x22, 0x48, 0x9F, 0x42, 0x87, 0x08, 0x3C, 0x85, 0x0A, 0x14, 0x4F,
  0x91, 0xC1, 0x83, 0x0B, 0xE0, 0x1E, 0x45, 0x0A, 0x04, 0x08, 0x10, 0x40,
  0x87, 0x09, 0xE0, 0x3C, 0x85, 0x0A, 0x14, 0x28, 0x50, 0xC2, 0x85, 0x1B,
  0xC0, 0x3F, 0x20, 0x40, 0x40, 0x42, 0x7C, 0x40, 0x40, 0x80, 0x80, 0xFC,
  0x3F, 0x40, 0x40, 0x40, 0x40, 0x7E, 0x40, 0x80, 0x80, 0x80, 0x80, 0x1E,
  0x45, 0x0A, 0x04, 0x08, 0x17, 0xC1, 0x85, 0x09, 0xE0, 0x23, 0x42, 0x42,
  0x42, 0x42, 0x7E, 0x42, 0x84, 0x84, 0x84, 0x84, 0x3E, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x23, 0xF0, 0x0F, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x42, 0x46, 0x7C, 0x21, 0x42, 0x46, 0x44, 0x48, 0x78, 0x48,
  0x88, 0x84, 0x84, 0x86, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x0F,
  0xC0, 0x63, 0x63, 0x66, 0x66, 0x5A, 0x92, 0x82, 0x82, 0x84, 0x84, 0x84,
  0x23, 0x62, 0x52, 0x52, 0x52, 0x52, 0x52, 0x8C, 0x8C, 0x8C, 0x8C, 0x1C,
  0x45, 0x0A, 0x14, 0x28, 0x50, 0xC2, 0x85, 0x09, 0xE0, 0x3E, 0x43, 0x41,
  0x41, 0x42, 0x7C, 0x40, 0x80, 0x80, 0x80, 0x80, 0x1C, 0x45, 0x0A, 0x14,
  0x28, 0x60, 0xC2, 0x85, 0x09, 0xE0, 0x40, 0x81, 0x80, 0x3E, 0x42, 0x41,
  0x42, 0x42, 0x7C, 0x48, 0x88, 0x88, 0x84, 0x84, 0x1E, 0x22, 0x42, 0x40,
  0x60, 0x18, 0x04, 0x02, 0x82, 0x84, 0x78, 0xFE, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x00, 0x23, 0x42, 0x42, 0x42, 0x42, 0x42, 0x42,
  0x84, 0x84, 0x84, 0x78, 0x83, 0x06, 0x14, 0x28, 0x89, 0x14, 0x28, 0x50,
  0xC1, 0x80, 0x49, 0xC4, 0xA6, 0x53, 0x29, 0xA5, 0x52, 0xA9, 0x54, 0xCC,
  0x66, 0x33, 0x00, 0x20, 0x88, 0x84, 0x82, 0x40, 0xC0, 0x40, 0x50, 0x28,
  0x22, 0x21, 0x30, 0xC0, 0x83, 0x09, 0x12, 0x45, 0x86, 0x08, 0x10, 0x20,
  0x41, 0x00, 0x7F, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80,
  0xFC, 0x3C, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x83, 0xC0,
  0x88, 0x88, 0x44, 0x44, 0x22, 0x22, 0x11, 0x3C, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x13, 0xC0, 0x10, 0xA2, 0x92, 0x8A, 0x10, 0xFE,
  0x8C, 0x3E, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x3E, 0x20, 0x81, 0x03, 0xE4,
  0x28, 0x50, 0xC2, 0x85, 0x0B, 0xE0, 0x3C, 0x85, 0x02, 0x08, 0x10, 0xA1,
  0x3C, 0x03, 0x02, 0x02, 0x3E, 0x42, 0x42, 0x42, 0x84, 0x84, 0x84, 0x7C,
  0x3C, 0x85, 0x0B, 0xF8, 0x10, 0x21, 0x3C, 0x03, 0xC1, 0x00, 0x40, 0x10,
  0x3F, 0x81, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x38,
  0x00, 0x3E, 0x85, 0x0A, 0x18, 0x50, 0x9F, 0x02, 0x04, 0x13, 0xC0, 0x20,
  0x81, 0x03, 0xE4, 0x28, 0x50, 0xC2, 0x85, 0x0A, 0x10, 0x08, 0x18, 0x00,
  0x07, 0x81, 0x02, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x02, 0x03, 0x00, 0x00,
  0x3E, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0xF0, 0x20,
  0x40, 0x41, 0x42, 0x44, 0x48, 0x70, 0x98, 0x88, 0x8C, 0x84, 0xE0, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x07, 0xC0, 0x3F, 0x49, 0x49, 0x49, 0x49,
  0x49, 0x4A, 0x92, 0x7C, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x42, 0x3C, 0x85,
  0x0A, 0x18, 0x50, 0xA1, 0x3C, 0x3E, 0x21, 0x21, 0x21, 0x42, 0x42, 0x42,
  0x7C, 0x40, 0x40, 0x80, 0x3E, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x3E, 0x04,
  0x08, 0x20, 0x5E, 0xC5, 0x0A, 0x04, 0x08, 0x20, 0x40, 0x3E, 0x85, 0x03,
  0xC0, 0x40, 0xA1, 0x3C, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x08, 0x10, 0x20,
  0x40, 0xF0, 0x42, 0x85, 0x0A, 0x18, 0x50, 0xA1, 0x3C, 0x87, 0x0A, 0x24,
  0x45, 0x0A, 0x18, 0x30, 0x99, 0x9A, 0x9A, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8,
  0x21, 0x12, 0x14, 0x08, 0x18, 0x34, 0x26, 0xC2, 0x42, 0x85, 0x0A, 0x28,
  0x50, 0x9F, 0x02, 0x04, 0x13, 0xC0, 0x7E, 0x08, 0x20, 0x82, 0x0C, 0x30,
  0x7E, 0x0E, 0x20, 0x40, 0x81, 0x02, 0x38, 0x18, 0x20, 0x40, 0x81, 0x02,
  0x03, 0x00, 0x24, 0x92, 0x92, 0x49, 0x49, 0x00, 0x18, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0xC0, 0x63, 0x26,
  0x38,
};

const GFXglyph JetBrainsMono_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 3, -11 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 7, 15, 9, 1, -13 },
  { 37, 10, 11, 9, 0, -11 },
  { 51, 8, 11, 9, 0, -11 },
  { 62, 2, 5, 9, 4, -11 },
  { 64, 6, 15, 9, 3, -13 },
  { 76, 6, 15, 9, 1, -13 },
  { 88, 8, 8, 9, 1, -9 },
  { 96, 7, 7, 9, 1, -8 },
  { 103, 3, 4, 9, 2, -2 },
  { 105, 5, 1, 9, 2, -5 },
  { 106, 2, 2, 9, 3, -2 },
  { 107, 9, 14, 9, 0, -12 },
  { 123, 7, 11, 9, 1, -11 },
  { 133, 6, 11, 9, 1, -11 },
  { 142, 7, 11, 9, 1, -11 },
  { 152, 7, 11, 9, 1, -11 },
  { 162, 7, 11, 9, 1, -11 },
  { 172, 7, 11, 9, 1, -11 },
  { 182, 7, 11, 9, 1, -11 },
  { 192, 7, 11, 9, 2, -11 },
  { 202, 7, 11, 9, 1, -11 },
  { 212, 7, 11, 9, 2, -11 },
  { 222, 3, 8, 9, 3, -8 },
  { 225, 4, 10, 9, 2, -8 },
  { 230, 7, 8, 9, 1, -9 },
  { 237, 7, 4, 9, 1, -7 },
  { 241, 7, 8, 9, 1, -9 },
  { 248, 6, 11, 9, 2, -11 },
  { 257, 9, 14, 9, 0, -11 },
  { 273, 7, 11, 9, 0, -11 },
  { 283, 7, 11, 9, 1, -11 },
  { 293, 7, 11, 9, 1, -11 },
  { 303, 7, 11, 9, 1, -11 },
  { 313, 8, 11, 9, 1, -11 },
  { 324, 8, 11, 9, 1, -11 },
  { 335, 7, 11, 9, 1, -11 },
  { 345, 8, 11, 9, 1, -11 },
  { 356, 7, 11, 9, 1, -11 },
  { 366, 8, 11, 9, 0, -11 },
  { 377, 8, 11, 9, 1, -11 },
  { 388, 6, 11, 9, 1, -11 },
  { 397, 8, 11, 9, 1, -11 },
  { 408, 8, 11, 9, 1, -11 },
  { 419, 7, 11, 9, 1, -11 },
  { 429, 8, 11, 9, 1, -11 },
  { 440, 7, 14, 9, 1, -11 },
  { 453, 8, 11, 9, 1, -11 },
  { 464, 8, 11, 9, 1, -11 },
  { 475, 7, 11, 9, 2, -11 },
  { 485, 8, 11, 9, 1, -11 },
  { 496, 7, 11, 9, 2, -11 },
  { 506, 9, 11, 9, 1, -11 },
  { 519, 9, 11, 9, 0, -11 },
  { 532, 7, 11, 9, 2, -11 },
  { 542, 8, 11, 9, 1, -11 },
  { 553, 6, 14, 9, 2, -12 },
  { 564, 4, 14, 9, 3, -12 },
  { 571, 6, 14, 9, 1, -12 },
  { 582, 6, 6, 9, 2, -11 },
  { 587, 7, 1, 9, 0, 0 },
  { 588, 3, 2, 9, 4, -12 },
  { 589, 7, 8, 9, 1, -8 },
  { 596, 7, 11, 9, 1, -11 },
  { 606, 7, 8, 9, 1, -8 },
  { 613, 8, 11, 9, 1, -11 },
  { 624, 7, 8, 9, 1, -8 },
  { 631, 10, 14, 9, -1, -11 },
  { 649, 7, 11, 9, 1, -8 },
  { 659, 7, 11, 9, 1, -11 },
  { 669, 7, 12, 9, 1, -12 },
  { 680, 8, 15, 9, 0, -12 },
  { 695, 8, 11, 9, 1, -11 },
  { 706, 6, 11, 9, 2, -11 },
  { 715, 8, 8, 9, 0, -8 },
  { 723, 7, 8, 9, 1, -8 },
  { 730, 7, 8, 9, 1, -8 },
  { 737, 8, 11, 9, 0, -8 },
  { 748, 7, 11, 9, 1, -8 },
  { 758, 7, 8, 9, 1, -8 },
  { 765, 7, 8, 9, 1, -8 },
  { 772, 7, 11, 9, 1, -11 },
  { 782, 7, 8, 9, 1, -8 },
  { 789, 7, 8, 9, 2, -8 },
  { 796, 8, 8, 9, 1, -8 },
  { 804, 8, 8, 9, 0, -8 },
  { 812, 7, 11, 9, 1, -8 },
  { 822, 7, 8, 9, 1, -8 },
  { 829, 7, 14, 9, 2, -12 },
  { 842, 3, 14, 9, 3, -12 },
  { 848, 8, 14, 9, 0, -12 },
  { 862, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC15PT7B_H_
