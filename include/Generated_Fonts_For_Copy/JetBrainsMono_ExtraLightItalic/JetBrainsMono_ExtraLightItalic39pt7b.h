#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC39PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x70, 0x77, 0x07, 0x70, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x06, 0x03,
  0x00, 0x1C, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x60, 0x31, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x06, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x1C,
  0x0E, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0x98, 0xE0, 0x61, 0x86, 0x0E, 0x18, 0x70, 0xC1,
  0x87, 0x0C, 0x18, 0x71, 0xC3, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x00, 0x0E,
  0x30, 0x00, 0x7B, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x06, 0xF8, 0x00, 0x63, 0x80, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x04, 0x1C,
  0x00, 0xC1, 0xCE, 0x0C, 0x1C, 0xE0, 0xC1, 0x86, 0x0C, 0x38, 0x70, 0xC7,
  0x07, 0x8C, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x20, 0x7F, 0x00, 0x38, 0x1E, 0x70, 0x06, 0x03, 0x06, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x18, 0x18, 0x18, 0x03, 0x03, 0x06, 0x00, 0x60, 0x61, 0xC0,
  0x0C, 0x0C, 0x70, 0x03, 0x83, 0x8C, 0x00, 0x30, 0x63, 0x00, 0x07, 0xF8,
  0xC0, 0x00, 0x7E, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0xF8, 0x00, 0x06, 0x3F, 0x80, 0x01, 0x8E,
  0x38, 0x00, 0x63, 0x03, 0x00, 0x1C, 0x60, 0x60, 0x07, 0x0C, 0x0C, 0x01,
  0xC3, 0x83, 0x80, 0x30, 0x60, 0x70, 0x0C, 0x0C, 0x0C, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x38, 0x70, 0x38, 0x03, 0xFC, 0x0E, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x07, 0x03, 0x80, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x7B, 0x80, 0x07, 0x1C, 0x07, 0x38, 0x70, 0x71, 0x81, 0xC3, 0x1C, 0x0E,
  0x38, 0xE0, 0x3B, 0x87, 0x01, 0xD8, 0x30, 0x07, 0x81, 0x80, 0x1C, 0x0C,
  0x01, 0xE0, 0xE0, 0x0F, 0x83, 0x81, 0xDC, 0x1C, 0x1C, 0x70, 0xFF, 0xC1,
  0x83, 0xFC, 0x0E, 0x00, 0x39, 0xDC, 0xE7, 0x39, 0xCE, 0x63, 0x38, 0x00,
  0x02, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x07, 0xE0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x01, 0x80, 0xC0, 0x4F, 0x8E, 0x1E, 0xFF, 0x27, 0xF8, 0xFD,
  0x7E, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0xDC, 0x00,
  0x1C, 0x70, 0x01, 0xE3, 0x80, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x01,
  0xC0, 0x20, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xE0,
  0xF0, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0x18, 0xF9, 0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xC0, 0x1C,
  0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE6, 0x00, 0x18,
  0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE3, 0xC3, 0x9C, 0x78, 0x73,
  0x8F, 0x0C, 0x60, 0xC1, 0x8C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x39, 0xC0, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1E,
  0x01, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x7B, 0x80, 0x71, 0x80, 0xF0, 0xC0, 0x60, 0x60, 0x20, 0x70,
  0x20, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x03, 0xF7, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0x80, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x60, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x70, 0x70, 0x0E,
  0x07, 0x81, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0C, 0x70, 0x03, 0x18, 0x00,
  0xCE, 0x00, 0x73, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x0F, 0x00, 0xEF,
  0xF8, 0x1F, 0xFF, 0x83, 0xC0, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x07,
  0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3B, 0xF8, 0x0D, 0xFF, 0x87,
  0x81, 0xE3, 0xC0, 0x3C, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x0E,
  0x70, 0x07, 0x0F, 0x07, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF6, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xF7, 0xC0, 0x78, 0x0E, 0x06, 0x00,
  0xE0, 0xE0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0,
  0x0C, 0x0E, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x8F, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0, 0x78, 0x38, 0x03, 0x83,
  0x00, 0x18, 0x70, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x38,
  0x60, 0x03, 0x87, 0x00, 0x70, 0x78, 0x1E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0xFD, 0xF0, 0x78, 0x0E, 0x38, 0x03,
  0x8C, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x03, 0x9C, 0x01, 0xC7, 0x80, 0xF0, 0xF9,
  0xF8, 0x3F, 0xEE, 0x03, 0xE7, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x1F, 0x1F, 0x8F, 0xC3, 0xC0, 0x00, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0x10, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x83, 0xFE, 0x07, 0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x1F, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x18, 0x38, 0x00, 0x70,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x80,
  0x79, 0xCE, 0x07, 0xF7, 0x38, 0x38, 0x78, 0xC0, 0xC0, 0xE3, 0x07, 0x03,
  0x8C, 0x18, 0x0E, 0x70, 0x60, 0x39, 0xC1, 0x80, 0xE7, 0x0E, 0x03, 0x18,
  0x38, 0x0C, 0x60, 0xE0, 0x31, 0x83, 0x01, 0xC6, 0x0C, 0x07, 0x38, 0x38,
  0x3C, 0xE0, 0xF1, 0xE3, 0x01, 0xFD, 0x8C, 0x03, 0xE0, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x37, 0x00, 0x1D, 0xC0,
  0x06, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06,
  0x0E, 0x03, 0x83, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x06, 0x01,
  0x83, 0x80, 0x60, 0xFF, 0xF8, 0x7F, 0xFE, 0x18, 0x01, 0x8E, 0x00, 0x73,
  0x80, 0x1C, 0xC0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0xE1,
  0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0x80, 0x38, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x38, 0x1F, 0x03, 0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01,
  0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00,
  0x38, 0x60, 0x07, 0x06, 0x03, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xBE, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x38,
  0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x0E, 0x01,
  0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x38, 0x0F, 0x07, 0x00, 0xF0, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00,
  0x18, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x0E, 0x0C, 0x1F, 0x81, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x08, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xBE, 0x07, 0x80,
  0xE0, 0xE0, 0x1C, 0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x13, 0x87, 0xFC, 0x70, 0xFF, 0x8E, 0x00, 0x31, 0x80, 0x0E,
  0x30, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38,
  0xE0, 0x06, 0x0E, 0x01, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x0C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x30, 0x01, 0x83,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x08, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x86,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0E, 0x00, 0x60, 0x70, 0x07,
  0x01, 0xE0, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x1C,
  0x18, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x1C,
  0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81,
  0xC0, 0x0C, 0x03, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x18,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x00, 0x78, 0x78, 0x06, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0x61,
  0xD8, 0x1B, 0x0C, 0xC1, 0x98, 0x66, 0x0D, 0xC3, 0x30, 0xCE, 0x19, 0x86,
  0x60, 0xC6, 0x63, 0x0E, 0x33, 0x18, 0x71, 0xB1, 0xC3, 0x8D, 0x8E, 0x18,
  0x78, 0x70, 0xC3, 0xC3, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x30, 0x00, 0xC3, 0x80,
  0x06, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE1,
  0x80, 0x06, 0x00, 0x07, 0x00, 0x30, 0xF8, 0x07, 0x0F, 0x80, 0x70, 0xD8,
  0x07, 0x0D, 0x80, 0x60, 0xDC, 0x06, 0x0C, 0xC0, 0x60, 0xCC, 0x0E, 0x1C,
  0xC0, 0xE1, 0xCC, 0x0E, 0x1C, 0xE0, 0xE1, 0x86, 0x0C, 0x18, 0x60, 0xC1,
  0x86, 0x0C, 0x38, 0x71, 0xC3, 0x83, 0x1C, 0x38, 0x31, 0xC3, 0x03, 0x18,
  0x30, 0x31, 0x83, 0x03, 0x98, 0x70, 0x1B, 0x87, 0x01, 0xB8, 0x70, 0x1B,
  0x86, 0x01, 0xF0, 0x60, 0x0F, 0x06, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xBE, 0x07, 0x81, 0xE0, 0xE0,
  0x1C, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00,
  0x38, 0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00,
  0x63, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x30, 0x01,
  0x8E, 0x00, 0x31, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E,
  0x0E, 0x01, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x86,
  0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0x80, 0x1C, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xBE, 0x07, 0x81, 0xE0, 0xE0, 0x1C,
  0x38, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03, 0x1C, 0x00, 0x63,
  0x80, 0x0C, 0x70, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x31, 0xC0, 0x06, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1E,
  0x01, 0xC1, 0xE0, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0x80, 0x78, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x03, 0xC1, 0x80, 0x3C,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0,
  0xC0, 0x0C, 0x07, 0x00, 0x60, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x38, 0x18, 0x00,
  0xE1, 0xC0, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xF7, 0xE0,
  0x70, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x07,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x18, 0x60, 0x03, 0x87, 0x00, 0x70, 0x7C, 0x0E, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x31, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0x70, 0x1C, 0x0F,
  0x07, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x39,
  0x80, 0x07, 0x30, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3,
  0x80, 0x30, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x38, 0x0E, 0x03,
  0x01, 0x80, 0x60, 0x70, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x38, 0x70, 0x07,
  0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x38, 0x1D, 0x81, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E,
  0x0E, 0x60, 0x58, 0x39, 0x83, 0x60, 0xC6, 0x0D, 0x83, 0x18, 0x36, 0x1C,
  0x61, 0x98, 0x61, 0x86, 0x61, 0x86, 0x19, 0x8E, 0x18, 0x46, 0x38, 0x63,
  0x18, 0xC1, 0x8C, 0x63, 0x06, 0x21, 0x9C, 0x19, 0x86, 0x60, 0xE6, 0x19,
  0x83, 0x98, 0x66, 0x0E, 0xC1, 0x38, 0x3B, 0x04, 0xC0, 0xEC, 0x13, 0x03,
  0xA0, 0x5C, 0x0D, 0x81, 0x60, 0x36, 0x05, 0x80, 0xD0, 0x16, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x00, 0xC0,
  0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x73,
  0x80, 0x00, 0x37, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xC7,
  0x00, 0x01, 0xC7, 0x00, 0x03, 0x83, 0x00, 0x03, 0x03, 0x80, 0x07, 0x01,
  0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00,
  0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0xFC, 0x00, 0x39,
  0x80, 0x07, 0x30, 0x01, 0xC7, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x03, 0x81,
  0xC0, 0x60, 0x18, 0x1C, 0x03, 0x07, 0x00, 0x70, 0xC0, 0x06, 0x38, 0x00,
  0xCE, 0x00, 0x1D, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x08, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x03, 0xFE, 0x0F, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0xFC,
  0x1F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0x98, 0x03, 0x98, 0x03,
  0x1C, 0x07, 0x1C, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x0E, 0x18, 0x06, 0x38,
  0x06, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE3, 0x87, 0x0C, 0x38, 0x70, 0x01, 0xF0, 0x01, 0xFF, 0x70, 0xF9, 0xDC,
  0x70, 0x1F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x01, 0xE1,
  0xE0, 0xD8, 0x3F, 0xEE, 0x07, 0xF3, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x0F, 0x00,
  0x67, 0xF8, 0x1D, 0xEF, 0x83, 0xE0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xE1,
  0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x38, 0x78, 0x07, 0x0D, 0x83, 0xC1, 0xBF, 0xF0, 0x73,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x0E, 0x18,
  0x03, 0x8E, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x06, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x87, 0x00, 0xE1, 0xE0, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x7C, 0x30, 0x3F, 0xEE, 0x0F,
  0x9D, 0xC3, 0x80, 0xF8, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x61, 0x80,
  0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x70, 0xE0, 0x1E, 0x0F, 0x06, 0xC0, 0xFF, 0xB8, 0x0F, 0xE7, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0x03, 0xE7, 0xC3, 0x80, 0xF1, 0x80, 0x39, 0xC0, 0x1C,
  0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0xB8, 0x01, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF6, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0x70,
  0x03, 0x18, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x01, 0xFF, 0x70, 0xF9, 0xDC, 0x70, 0x1F, 0x18, 0x03, 0x8E,
  0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00,
  0x39, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0xCE, 0x00, 0x71, 0x80, 0x1C,
  0x70, 0x0F, 0x1E, 0x05, 0x83, 0xFF, 0x60, 0x7F, 0x18, 0x02, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07,
  0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x0F, 0x80, 0x67,
  0xF8, 0x1D, 0xCF, 0x83, 0xE0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0x80,
  0x1C, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x70, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x21, 0x80, 0x0E, 0x1C, 0x00,
  0xE0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0xE0, 0x0C,
  0x0F, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0E, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC1,
  0xC0, 0x07, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0xE1, 0xE0, 0xEF, 0x9F, 0x87, 0x9F, 0x9C, 0x38, 0x78, 0x71, 0x81, 0x83,
  0x8C, 0x1C, 0x18, 0x60, 0xE0, 0xC7, 0x06, 0x06, 0x38, 0x30, 0x71, 0xC1,
  0x83, 0x8C, 0x0C, 0x1C, 0x60, 0x60, 0xC3, 0x07, 0x06, 0x38, 0x30, 0x31,
  0xC1, 0x81, 0x8E, 0x0C, 0x1C, 0x60, 0x60, 0xE3, 0x03, 0x07, 0x18, 0x38,
  0x30, 0xC1, 0xC1, 0x8E, 0x0C, 0x0C, 0x70, 0x60, 0xE0, 0x00, 0x3E, 0x01,
  0x9F, 0xE0, 0x77, 0x3E, 0x0F, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x86,
  0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x71, 0xC0,
  0x0E, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xF7, 0xC3, 0xC0, 0xF1, 0x80,
  0x39, 0xC0, 0x1C, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xEC, 0x00, 0x76, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x07, 0x1C, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x67, 0xF8, 0x0E, 0xF7, 0xC0, 0xF8, 0x1E, 0x0F,
  0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x3C, 0x03,
  0x83, 0x60, 0xF0, 0x37, 0xFE, 0x07, 0x3F, 0x80, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x70, 0xF9, 0xDC, 0x70, 0x1F, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x01, 0xE1, 0xE0, 0xD8, 0x7F,
  0xEE, 0x07, 0xF3, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x7F,
  0xC1, 0xFC, 0xF8, 0x68, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0x3F, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x38, 0x01,
  0xC6, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x03, 0x8C, 0x00, 0x71, 0xC0, 0x0C, 0x3C, 0x07, 0x83, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03,
  0x9C, 0x00, 0xE6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x1C, 0x07, 0x07, 0x83, 0xC0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x39, 0xC0,
  0x0C, 0x70, 0x07, 0x1C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x1C,
  0x0E, 0x06, 0x03, 0x83, 0x80, 0x60, 0xC0, 0x18, 0x70, 0x06, 0x18, 0x01,
  0xCE, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x3E, 0x0F, 0x07, 0xE0, 0xF0, 0x6E,
  0x0B, 0x06, 0xE1, 0xB0, 0xEE, 0x1B, 0x0C, 0xE1, 0x30, 0xCE, 0x33, 0x0C,
  0xE3, 0x31, 0x8E, 0x23, 0x18, 0xE6, 0x31, 0x8E, 0x63, 0x30, 0xE4, 0x33,
  0x0E, 0xC3, 0x30, 0x6C, 0x36, 0x06, 0x83, 0x60, 0x78, 0x36, 0x07, 0x83,
  0xE0, 0x70, 0x3C, 0x07, 0x03, 0xC0, 0x70, 0x3C, 0x00, 0x0E, 0x00, 0x78,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x38, 0x00, 0xE3,
  0x80, 0x07, 0x38, 0x00, 0x1D, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x38,
  0x00, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0xE0,
  0x07, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0xF1, 0xC0, 0x38, 0x78, 0x36, 0x0F, 0xF9, 0x81, 0xFC, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x3E, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x37, 0xF8, 0x0D, 0x87, 0x03, 0xE0,
  0xE1, 0xF8, 0x1C, 0xEE, 0x07, 0xFB, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 8, 28, 23, 8, -28 },
  { 29, 12, 11, 23, 8, -28 },
  { 46, 23, 28, 23, 1, -28 },
  { 127, 20, 39, 23, 2, -34 },
  { 225, 27, 29, 23, -1, -29 },
  { 323, 21, 29, 23, 1, -29 },
  { 400, 5, 11, 23, 11, -28 },
  { 407, 15, 38, 23, 7, -33 },
  { 479, 15, 38, 23, 2, -33 },
  { 551, 21, 20, 23, 2, -24 },
  { 604, 18, 18, 23, 3, -22 },
  { 645, 10, 12, 23, 4, -6 },
  { 660, 12, 2, 23, 6, -14 },
  { 663, 7, 6, 23, 7, -6 },
  { 669, 22, 36, 23, 1, -32 },
  { 768, 19, 29, 23, 3, -29 },
  { 837, 17, 28, 23, 2, -28 },
  { 897, 20, 29, 23, 2, -29 },
  { 970, 20, 28, 23, 2, -28 },
  { 1040, 18, 28, 23, 3, -28 },
  { 1103, 19, 28, 23, 3, -28 },
  { 1170, 18, 28, 23, 2, -28 },
  { 1233, 18, 28, 23, 5, -28 },
  { 1296, 20, 29, 23, 2, -29 },
  { 1369, 18, 29, 23, 4, -29 },
  { 1435, 9, 22, 23, 7, -22 },
  { 1460, 12, 28, 23, 4, -22 },
  { 1502, 18, 20, 23, 4, -23 },
  { 1547, 18, 12, 23, 3, -19 },
  { 1574, 19, 20, 23, 2, -23 },
  { 1622, 15, 28, 23, 6, -28 },
  { 1675, 22, 36, 23, 1, -29 },
  { 1774, 18, 28, 23, 1, -28 },
  { 1837, 20, 28, 23, 2, -28 },
  { 1907, 19, 29, 23, 3, -29 },
  { 1976, 19, 28, 23, 2, -28 },
  { 2043, 20, 28, 23, 3, -28 },
  { 2113, 21, 28, 23, 2, -28 },
  { 2187, 19, 29, 23, 3, -29 },
  { 2256, 20, 28, 23, 2, -28 },
  { 2326, 19, 29, 23, 3, -29 },
  { 2395, 21, 28, 23, 1, -28 },
  { 2469, 22, 29, 23, 2, -29 },
  { 2549, 16, 28, 23, 3, -28 },
  { 2605, 21, 28, 23, 2, -28 },
  { 2679, 20, 28, 23, 2, -28 },
  { 2749, 19, 29, 23, 3, -29 },
  { 2818, 21, 28, 23, 2, -28 },
  { 2892, 19, 36, 23, 3, -29 },
  { 2978, 21, 28, 23, 2, -28 },
  { 3052, 20, 29, 23, 2, -29 },
  { 3125, 19, 28, 23, 5, -28 },
  { 3192, 19, 28, 23, 3, -28 },
  { 3259, 19, 28, 23, 5, -28 },
  { 3326, 22, 28, 23, 3, -28 },
  { 3403, 24, 28, 23, 0, -28 },
  { 3487, 19, 28, 23, 5, -28 },
  { 3554, 20, 28, 23, 2, -28 },
  { 3624, 15, 36, 23, 6, -32 },
  { 3692, 11, 36, 23, 7, -32 },
  { 3742, 14, 36, 23, 4, -32 },
  { 3805, 16, 15, 23, 4, -28 },
  { 3835, 19, 2, 23, 0, 1 },
  { 3840, 6, 6, 23, 11, -31 },
  { 3845, 18, 22, 23, 3, -22 },
  { 3895, 19, 28, 23, 2, -28 },
  { 3962, 18, 22, 23, 3, -22 },
  { 4012, 19, 28, 23, 3, -28 },
  { 4079, 17, 22, 23, 3, -22 },
  { 4126, 25, 35, 23, -1, -28 },
  { 4236, 18, 29, 23, 3, -22 },
  { 4302, 19, 28, 23, 2, -28 },
  { 4369, 18, 30, 23, 2, -30 },
  { 4437, 19, 37, 23, 1, -30 },
  { 4525, 21, 28, 23, 2, -28 },
  { 4599, 16, 28, 23, 4, -28 },
  { 4655, 21, 22, 23, 1, -22 },
  { 4713, 19, 22, 23, 2, -22 },
  { 4766, 17, 22, 23, 3, -22 },
  { 4813, 20, 29, 23, 1, -22 },
  { 4886, 18, 29, 23, 3, -22 },
  { 4952, 18, 22, 23, 3, -22 },
  { 5002, 19, 22, 23, 2, -22 },
  { 5055, 18, 27, 23, 4, -27 },
  { 5116, 18, 21, 23, 3, -21 },
  { 5164, 18, 21, 23, 4, -21 },
  { 5212, 20, 21, 23, 3, -21 },
  { 5265, 21, 21, 23, 1, -21 },
  { 5321, 18, 28, 23, 3, -21 },
  { 5384, 19, 21, 23, 2, -21 },
  { 5434, 19, 36, 23, 4, -32 },
  { 5520, 8, 36, 23, 8, -32 },
  { 5556, 19, 36, 23, 1, -32 },
  { 5642, 18, 8, 23, 3, -18 },
};

const GFXfont JetBrainsMono_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC39PT7B_H_
