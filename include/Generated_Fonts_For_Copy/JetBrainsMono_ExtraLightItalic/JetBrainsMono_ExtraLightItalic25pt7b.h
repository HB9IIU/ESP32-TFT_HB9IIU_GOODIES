#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC25PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x08, 0x42, 0x00, 0x0C, 0xE7,
  0x00, 0x63, 0xE3, 0xC6, 0xC6, 0xC6, 0xC6, 0x86, 0x03, 0x0C, 0x08, 0x20,
  0x61, 0x81, 0x84, 0x04, 0x30, 0xFF, 0xF0, 0xC2, 0x02, 0x18, 0x18, 0x60,
  0x61, 0x01, 0x0C, 0x0C, 0x30, 0xFF, 0xF0, 0x86, 0x06, 0x18, 0x10, 0x40,
  0x43, 0x03, 0x08, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x7F,
  0x06, 0x58, 0x66, 0x62, 0x23, 0x11, 0x01, 0x88, 0x06, 0x40, 0x3A, 0x00,
  0xF8, 0x01, 0xF0, 0x09, 0x80, 0x46, 0x02, 0x32, 0x11, 0x91, 0x88, 0xCC,
  0xC7, 0x5C, 0x1F, 0xC0, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x00, 0x0F,
  0x81, 0x8C, 0x61, 0x84, 0x30, 0x82, 0x10, 0x81, 0x08, 0x80, 0x84, 0x80,
  0x66, 0xC0, 0x1C, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x4F, 0x00, 0x4C,
  0xC0, 0x64, 0x20, 0x66, 0x10, 0x63, 0x18, 0x61, 0x8C, 0x20, 0xCC, 0x60,
  0x3C, 0x00, 0x01, 0x00, 0x3F, 0x03, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x01, 0xE0, 0x19, 0x86, 0x86, 0x6C, 0x32, 0x60,
  0xF3, 0x03, 0x18, 0x18, 0xC1, 0xE7, 0x3B, 0x1F, 0x0C, 0x6D, 0xB5, 0xB0,
  0x00, 0xC0, 0x70, 0x70, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xE0, 0x18, 0x0C, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x00,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x10, 0xC1, 0xF3, 0x38, 0xFB, 0xD0, 0x78,
  0x01, 0x40, 0x0D, 0x80, 0x66, 0x03, 0x0C, 0x18, 0x38, 0x20, 0x80, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0xE3, 0x0C, 0x61, 0x8C, 0x30, 0xFF,
  0x6F, 0xFE, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x00, 0xFE, 0x18,
  0x63, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x44, 0x24, 0x66, 0xC6,
  0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xCE, 0x38, 0x7E,
  0x00, 0x01, 0xC0, 0xF8, 0x32, 0x0C, 0x42, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x7F,
  0xFF, 0xFC, 0x00, 0x80, 0x3F, 0x87, 0x0C, 0x30, 0x33, 0x01, 0x98, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xF8, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x20, 0x31, 0x01, 0x8C, 0x18, 0x71,
  0xC1, 0xF8, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03,
  0x00, 0xC3, 0x30, 0x6C, 0x0D, 0x81, 0x60, 0x2F, 0xFD, 0xFF, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x1F, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x67, 0x87, 0xFC, 0x70, 0x66, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0xC0, 0xCC, 0x08, 0xE3, 0x87, 0xE0, 0x00, 0xE0, 0x08, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xFC, 0x3C, 0xE3, 0x03, 0x60, 0x36,
  0x03, 0x40, 0x34, 0x03, 0x40, 0x66, 0x06, 0x71, 0xC1, 0xF0, 0x7F, 0xF4,
  0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x80, 0x3F, 0x83, 0x0C, 0x30, 0x31, 0x01, 0x88, 0x0C, 0x40,
  0xC3, 0x04, 0x0C, 0xC0, 0x38, 0x03, 0x70, 0x60, 0xC2, 0x06, 0x30, 0x19,
  0x00, 0x88, 0x0C, 0x60, 0x63, 0x8E, 0x0F, 0xE0, 0x02, 0x03, 0xF0, 0xC3,
  0x30, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0xD8, 0x19, 0xFE, 0x1E,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x3B,
  0xDE, 0x60, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x70, 0x0E, 0x3C, 0x78, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x80,
  0x00, 0x10, 0x03, 0x00, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x40, 0x7F, 0xF7, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x20, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x00, 0x3F, 0x10, 0xE0, 0x18, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x0C, 0x0E, 0x0F, 0x02, 0x00, 0x80, 0x60, 0x00, 0x00, 0x01, 0x80, 0xE0,
  0x38, 0x00, 0x00, 0x40, 0x07, 0xF0, 0x18, 0x30, 0x60, 0x21, 0x80, 0x62,
  0x00, 0xCC, 0x01, 0x98, 0x7A, 0x31, 0x8C, 0x42, 0x18, 0x8C, 0x33, 0x18,
  0x66, 0x30, 0xCC, 0x41, 0x98, 0x82, 0x21, 0x8C, 0x43, 0xE8, 0x83, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0,
  0x1E, 0x01, 0xE0, 0x16, 0x03, 0x60, 0x26, 0x06, 0x20, 0x62, 0x0C, 0x20,
  0xC2, 0x08, 0x31, 0xFF, 0x1F, 0xF3, 0x03, 0x30, 0x36, 0x03, 0x60, 0x1C,
  0x01, 0x1F, 0xE0, 0xC3, 0x86, 0x06, 0x20, 0x31, 0x01, 0x98, 0x08, 0xC0,
  0xC6, 0x0C, 0x3F, 0x81, 0x07, 0x08, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x80, 0x8C, 0x0C, 0x7F, 0xC7, 0xF8, 0x00, 0x01, 0x00, 0xFE, 0x18, 0x63,
  0x03, 0x20, 0x36, 0x03, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC0, 0xC6, 0x38, 0x3F, 0x00,
  0x1F, 0xE0, 0xC3, 0x86, 0x0C, 0x20, 0x31, 0x01, 0x98, 0x08, 0xC0, 0x46,
  0x06, 0x30, 0x31, 0x01, 0x88, 0x0C, 0xC0, 0x46, 0x02, 0x30, 0x31, 0x81,
  0x8C, 0x18, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xF9, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x04, 0x7F, 0xC3, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x3F, 0xF9, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x7F, 0xE3, 0xFF, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x00, 0x01, 0x00, 0xFE, 0x18, 0x63, 0x03,
  0x20, 0x36, 0x03, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x47, 0xE4, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xC6, 0x38, 0x3F, 0x00, 0x18,
  0x18, 0xC0, 0xC6, 0x06, 0x20, 0x31, 0x01, 0x18, 0x08, 0xC0, 0xC6, 0x06,
  0x3F, 0xF1, 0x01, 0x88, 0x0C, 0xC0, 0x46, 0x02, 0x30, 0x31, 0x81, 0x8C,
  0x0C, 0x40, 0x66, 0x02, 0x00, 0x3F, 0xF0, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0x8F, 0xF8, 0x01, 0xF8, 0x10, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18, 0x61, 0x81,
  0xF8, 0x00, 0x18, 0x0C, 0x60, 0x61, 0x81, 0x04, 0x0C, 0x10, 0x60, 0xC1,
  0x03, 0x0C, 0x0C, 0x60, 0x3F, 0x80, 0x86, 0x02, 0x18, 0x18, 0x20, 0x60,
  0xC1, 0x83, 0x06, 0x04, 0x18, 0x18, 0x40, 0x63, 0x00, 0xC0, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x1C, 0x70,
  0xE3, 0xC2, 0x8D, 0x1A, 0x34, 0x58, 0xD3, 0x62, 0x49, 0x89, 0xE4, 0x23,
  0x11, 0x8C, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x00, 0x84, 0x02, 0x30,
  0x08, 0xC0, 0x63, 0x01, 0x80, 0x1C, 0x08, 0xE0, 0xC5, 0x06, 0x28, 0x31,
  0x61, 0x9B, 0x08, 0xC8, 0x46, 0x46, 0x33, 0x31, 0x19, 0x88, 0xCC, 0xC2,
  0x46, 0x12, 0x30, 0xF1, 0x87, 0x88, 0x1C, 0x40, 0xE6, 0x06, 0x00, 0x01,
  0x00, 0xFC, 0x18, 0x63, 0x03, 0x20, 0x36, 0x03, 0x60, 0x26, 0x02, 0x60,
  0x66, 0x06, 0x40, 0x64, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x0C, 0xC0,
  0x86, 0x38, 0x3E, 0x00, 0x1F, 0xF0, 0x60, 0xE1, 0x81, 0x84, 0x03, 0x10,
  0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x30, 0xF0, 0xFF, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00,
  0x01, 0x00, 0xFC, 0x18, 0x63, 0x03, 0x20, 0x36, 0x03, 0x60, 0x36, 0x02,
  0x60, 0x24, 0x06, 0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0x4C, 0x0C,
  0xC0, 0x86, 0x38, 0x3E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x1F, 0xF0, 0xC1, 0xC6, 0x06, 0x20, 0x11, 0x00, 0x98, 0x0C, 0xC0, 0x66,
  0x06, 0x3F, 0xE1, 0xFE, 0x08, 0x60, 0xC3, 0x06, 0x08, 0x30, 0x61, 0x83,
  0x0C, 0x08, 0x40, 0x66, 0x03, 0x00, 0x00, 0x80, 0x3F, 0x83, 0x0C, 0x30,
  0x31, 0x01, 0x88, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xC0, 0x03, 0x00, 0x19, 0x00, 0xC8, 0x04, 0x60, 0x63, 0x8E, 0x0F,
  0xE0, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x33, 0x03, 0x30, 0x32, 0x03, 0x20, 0x36,
  0x02, 0x60, 0x26, 0x06, 0x60, 0x64, 0x06, 0x40, 0x6C, 0x04, 0xC0, 0x4C,
  0x0C, 0xC0, 0xCC, 0x18, 0x63, 0x83, 0xE0, 0xC0, 0x34, 0x03, 0x40, 0x64,
  0x06, 0x40, 0x46, 0x0C, 0x60, 0x86, 0x18, 0x61, 0x86, 0x30, 0x63, 0x02,
  0x20, 0x26, 0x02, 0x40, 0x2C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x43, 0x0D,
  0x0C, 0x24, 0x30, 0xB1, 0x46, 0xC5, 0x1B, 0x14, 0x4C, 0xD1, 0x32, 0x4C,
  0xC9, 0x33, 0x64, 0x8D, 0x16, 0x34, 0x58, 0xD1, 0x43, 0x85, 0x0E, 0x1C,
  0x28, 0x70, 0xE1, 0x83, 0x06, 0x00, 0x18, 0x06, 0x18, 0x18, 0x30, 0x60,
  0x30, 0xC0, 0x63, 0x00, 0x4C, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0B, 0x00, 0x36, 0x00, 0xC4, 0x03, 0x0C, 0x04, 0x08, 0x18, 0x18,
  0x60, 0x31, 0x80, 0x30, 0xC0, 0x3E, 0x01, 0x90, 0x18, 0xC1, 0x86, 0x0C,
  0x10, 0xC0, 0xC4, 0x06, 0x60, 0x16, 0x00, 0xE0, 0x07, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0xF1, 0xF8, 0xC0, 0x81, 0x83, 0x06, 0x04,
  0x08, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30,
  0x20, 0x60, 0xC1, 0x81, 0x0F, 0xC3, 0xF0, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x0F, 0xC3, 0xF0, 0x06, 0x03,
  0xC0, 0xB0, 0x64, 0x11, 0x8C, 0x66, 0x09, 0x82, 0xC0, 0xE0, 0x30, 0xFF,
  0xF0, 0xC4, 0x63, 0x0F, 0x33, 0xDA, 0x30, 0x66, 0x06, 0x60, 0x64, 0x06,
  0x40, 0x6C, 0x04, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x1C, 0x63, 0xC7, 0xE8,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x13, 0xC3, 0x6E, 0x38, 0x33, 0x03,
  0x30, 0x32, 0x03, 0x20, 0x36, 0x02, 0x60, 0x26, 0x06, 0x60, 0x66, 0x04,
  0x51, 0xCD, 0xF8, 0x0F, 0x83, 0xF8, 0xC1, 0xB0, 0x36, 0x06, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x0B, 0x03, 0x60, 0x66, 0x38, 0x7E, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0x33, 0xDA, 0x30, 0x66, 0x06, 0x60,
  0x64, 0x06, 0x40, 0x6C, 0x04, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x1C, 0x63,
  0xC7, 0xE8, 0x0F, 0x83, 0xB8, 0xC1, 0xB0, 0x36, 0x06, 0x80, 0xDF, 0xFF,
  0xFE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x66, 0x38, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x1F, 0xFE,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0x33, 0xDA, 0x30,
  0x66, 0x06, 0x60, 0x64, 0x06, 0x40, 0x6C, 0x04, 0xC0, 0xCC, 0x0C, 0xC1,
  0xC7, 0x7C, 0x3C, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x03, 0x87, 0xF0, 0xF8,
  0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x13, 0xC3, 0x6E, 0x38, 0x33,
  0x03, 0x30, 0x32, 0x03, 0x20, 0x36, 0x02, 0x60, 0x26, 0x06, 0x60, 0x66,
  0x06, 0x40, 0x6C, 0x04, 0x01, 0xC0, 0x1C, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x01,
  0xC0, 0x04, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x81, 0xF8, 0x1E, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x32, 0x06, 0x60, 0xE6, 0x0C,
  0x61, 0x86, 0x30, 0x7E, 0x07, 0xE0, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x18,
  0x80, 0xC8, 0x0C, 0xFC, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xC7, 0xF0, 0x2E, 0x71, 0x9C, 0xC8, 0xC6, 0xC6, 0x36, 0x31, 0xB1, 0x09,
  0x08, 0x48, 0x42, 0x42, 0x36, 0x31, 0xB1, 0x8D, 0x8C, 0x4C, 0x42, 0x42,
  0x30, 0x13, 0xC3, 0x6E, 0x38, 0x33, 0x03, 0x30, 0x32, 0x03, 0x20, 0x36,
  0x02, 0x60, 0x26, 0x06, 0x60, 0x66, 0x06, 0x40, 0x6C, 0x04, 0x0F, 0x83,
  0xB8, 0xC1, 0xB0, 0x36, 0x06, 0x80, 0xD0, 0x1E, 0x02, 0xC0, 0x58, 0x1B,
  0x03, 0x60, 0x46, 0x38, 0x7C, 0x00, 0x13, 0xC3, 0x6E, 0x38, 0x33, 0x03,
  0x30, 0x32, 0x03, 0x20, 0x36, 0x02, 0x60, 0x26, 0x06, 0x60, 0x66, 0x04,
  0x51, 0xC5, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x0F,
  0x33, 0xDA, 0x30, 0x66, 0x06, 0x60, 0x64, 0x06, 0x40, 0x6C, 0x04, 0xC0,
  0x4C, 0x0C, 0xC0, 0xCC, 0x1C, 0x63, 0xC7, 0xC8, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x37, 0xC3, 0xDE, 0x30, 0x62, 0x03, 0x60, 0x26,
  0x02, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x0F, 0xC7, 0xBC, 0x81, 0xB0, 0x06, 0x00, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0xC0, 0x08, 0x01, 0x60, 0x6E, 0x18, 0xFE, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xC0, 0xFC,
  0x20, 0x36, 0x02, 0x60, 0x26, 0x06, 0x60, 0x64, 0x06, 0x40, 0x6C, 0x04,
  0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x18, 0x63, 0x83, 0xE0, 0xC0, 0x78, 0x0F,
  0x03, 0x60, 0x64, 0x18, 0x83, 0x18, 0x43, 0x18, 0x62, 0x04, 0xC0, 0x90,
  0x16, 0x03, 0x80, 0x70, 0x00, 0xC2, 0x1E, 0x30, 0xF1, 0x85, 0x8C, 0x6C,
  0xA3, 0x65, 0x13, 0x2D, 0x9A, 0x6C, 0xD3, 0x46, 0x9A, 0x38, 0xF1, 0xC7,
  0x0E, 0x38, 0x61, 0xC0, 0x30, 0x18, 0xC1, 0x86, 0x18, 0x18, 0x80, 0xCC,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0D, 0x00, 0xCC, 0x04, 0x20, 0x61, 0x86,
  0x04, 0x60, 0x30, 0x60, 0x2C, 0x05, 0x81, 0xB0, 0x34, 0x06, 0x80, 0xD0,
  0x16, 0x02, 0xC0, 0xD8, 0x1B, 0x07, 0x3B, 0xE3, 0xC8, 0x01, 0x00, 0x60,
  0x0C, 0x03, 0x1F, 0xE3, 0xC0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x70, 0x1F, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xC0, 0xF8, 0x00, 0xC0,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0F, 0x00, 0x30, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C,
  0x30, 0x82, 0x18, 0x61, 0x86, 0x10, 0x41, 0x0C, 0x30, 0x1C, 0x01, 0xF0,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x02, 0x00, 0x3F, 0x03, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF8, 0x0C, 0x00, 0x78, 0x34, 0xC2,
  0xC6, 0x2C, 0x3E, 0x80, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 8, 7, 15, 5, -18 },
  { 20, 14, 18, 15, 1, -18 },
  { 52, 13, 26, 15, 1, -22 },
  { 95, 17, 18, 15, -1, -18 },
  { 134, 13, 19, 15, 1, -19 },
  { 165, 3, 7, 15, 7, -18 },
  { 168, 10, 24, 15, 4, -21 },
  { 198, 10, 24, 15, 1, -21 },
  { 228, 14, 13, 15, 1, -15 },
  { 251, 12, 12, 15, 2, -14 },
  { 269, 6, 8, 15, 3, -4 },
  { 275, 8, 1, 15, 4, -9 },
  { 276, 4, 4, 15, 5, -4 },
  { 278, 14, 24, 15, 1, -21 },
  { 320, 12, 19, 15, 2, -19 },
  { 349, 11, 18, 15, 1, -18 },
  { 374, 13, 19, 15, 1, -19 },
  { 405, 13, 18, 15, 1, -18 },
  { 435, 11, 18, 15, 2, -18 },
  { 460, 12, 18, 15, 2, -18 },
  { 487, 12, 18, 15, 1, -18 },
  { 514, 12, 18, 15, 3, -18 },
  { 541, 13, 19, 15, 1, -19 },
  { 572, 11, 19, 15, 3, -19 },
  { 599, 5, 14, 15, 5, -14 },
  { 608, 7, 18, 15, 3, -14 },
  { 624, 12, 13, 15, 2, -15 },
  { 644, 12, 7, 15, 2, -12 },
  { 655, 12, 13, 15, 1, -15 },
  { 675, 10, 18, 15, 4, -18 },
  { 698, 15, 23, 15, 0, -19 },
  { 742, 12, 18, 15, 0, -18 },
  { 769, 13, 18, 15, 1, -18 },
  { 799, 12, 19, 15, 2, -19 },
  { 828, 13, 18, 15, 1, -18 },
  { 858, 13, 18, 15, 2, -18 },
  { 888, 13, 18, 15, 2, -18 },
  { 918, 12, 19, 15, 2, -19 },
  { 947, 13, 18, 15, 1, -18 },
  { 977, 12, 18, 15, 2, -18 },
  { 1004, 13, 18, 15, 1, -18 },
  { 1034, 14, 18, 15, 1, -18 },
  { 1066, 10, 18, 15, 2, -18 },
  { 1089, 14, 18, 15, 1, -18 },
  { 1121, 13, 18, 15, 1, -18 },
  { 1151, 12, 19, 15, 2, -19 },
  { 1180, 14, 18, 15, 1, -18 },
  { 1212, 12, 24, 15, 2, -19 },
  { 1248, 13, 18, 15, 1, -18 },
  { 1278, 13, 19, 15, 1, -19 },
  { 1309, 12, 18, 15, 3, -18 },
  { 1336, 12, 18, 15, 2, -18 },
  { 1363, 12, 18, 15, 3, -18 },
  { 1390, 14, 18, 15, 2, -18 },
  { 1422, 15, 18, 15, 0, -18 },
  { 1456, 13, 18, 15, 3, -18 },
  { 1486, 13, 18, 15, 1, -18 },
  { 1516, 9, 24, 15, 4, -21 },
  { 1543, 7, 24, 15, 4, -21 },
  { 1564, 10, 24, 15, 2, -21 },
  { 1594, 10, 10, 15, 3, -18 },
  { 1607, 12, 1, 15, 0, 1 },
  { 1609, 4, 4, 15, 7, -20 },
  { 1611, 12, 14, 15, 2, -14 },
  { 1632, 12, 18, 15, 1, -18 },
  { 1659, 11, 14, 15, 2, -14 },
  { 1679, 12, 18, 15, 2, -18 },
  { 1706, 11, 14, 15, 2, -14 },
  { 1726, 16, 23, 15, -1, -18 },
  { 1772, 12, 19, 15, 2, -14 },
  { 1801, 12, 18, 15, 1, -18 },
  { 1828, 12, 19, 15, 1, -19 },
  { 1857, 13, 24, 15, 0, -19 },
  { 1896, 12, 18, 15, 2, -18 },
  { 1923, 10, 18, 15, 3, -18 },
  { 1946, 13, 14, 15, 1, -14 },
  { 1969, 12, 14, 15, 1, -14 },
  { 1990, 11, 14, 15, 2, -14 },
  { 2010, 12, 19, 15, 1, -14 },
  { 2039, 12, 19, 15, 2, -14 },
  { 2068, 12, 14, 15, 2, -14 },
  { 2089, 11, 14, 15, 2, -14 },
  { 2109, 12, 18, 15, 2, -18 },
  { 2136, 12, 14, 15, 2, -14 },
  { 2157, 11, 14, 15, 3, -14 },
  { 2177, 13, 14, 15, 2, -14 },
  { 2200, 13, 14, 15, 1, -14 },
  { 2223, 11, 19, 15, 2, -14 },
  { 2250, 12, 14, 15, 1, -14 },
  { 2271, 12, 24, 15, 3, -21 },
  { 2307, 6, 24, 15, 5, -21 },
  { 2325, 12, 24, 15, 1, -21 },
  { 2361, 12, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_ExtraLightItalic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC25PT7B_H_
