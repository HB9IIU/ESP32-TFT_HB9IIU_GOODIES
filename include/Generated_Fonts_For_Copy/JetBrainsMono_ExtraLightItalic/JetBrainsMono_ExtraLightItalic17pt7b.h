#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC17PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x22, 0x22, 0x00, 0x6E, 0x4D, 0x24, 0xB2, 0x88, 0x04,
  0x42, 0x20, 0x88, 0xFF, 0x11, 0x04, 0x41, 0x10, 0x88, 0xFF, 0x89, 0x84,
  0x41, 0x10, 0x04, 0x02, 0x01, 0x03, 0xE2, 0x53, 0x49, 0xA0, 0x50, 0x1C,
  0x07, 0x02, 0xC2, 0x69, 0x26, 0x91, 0xF0, 0x20, 0x10, 0x00, 0x10, 0x25,
  0x89, 0x13, 0x22, 0x44, 0x90, 0xF4, 0x01, 0x00, 0x48, 0x16, 0x82, 0x88,
  0x92, 0x22, 0x48, 0x70, 0x06, 0x06, 0xC1, 0x18, 0x40, 0x10, 0x04, 0x03,
  0x85, 0x32, 0x45, 0x10, 0xC4, 0x21, 0x14, 0x79, 0x80, 0xFA, 0x80, 0x06,
  0x30, 0xC1, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x0C, 0x08, 0x18,
  0x08, 0x30, 0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40,
  0x82, 0x18, 0x60, 0x0C, 0x04, 0x22, 0x2F, 0xE0, 0x81, 0xE0, 0x90, 0x8C,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x10, 0x10, 0x32, 0x64, 0xC8, 0xFC,
  0xFC, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0x0C, 0x1D, 0x88,
  0x48, 0x24, 0x12, 0x09, 0x64, 0x92, 0xC1, 0x41, 0xA0, 0x98, 0xC7, 0xC0,
  0x0C, 0x69, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x27, 0xF0, 0x0C,
  0x19, 0x88, 0x48, 0x20, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x0F, 0xE0, 0x3F, 0x02, 0x04, 0x08, 0x1C, 0x02, 0x02, 0x02, 0x02, 0x82,
  0xC6, 0x78, 0x03, 0x04, 0x0C, 0x08, 0x10, 0x21, 0x42, 0x42, 0xFE, 0x02,
  0x02, 0x06, 0x3F, 0x20, 0x20, 0x60, 0x5E, 0x63, 0x01, 0x03, 0x02, 0x82,
  0xC6, 0x7C, 0x06, 0x0C, 0x08, 0x10, 0x2C, 0x76, 0x43, 0x81, 0x81, 0x82,
  0xC6, 0x7C, 0xFF, 0xC3, 0x82, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x60, 0x40, 0x0C, 0x13, 0x21, 0x61, 0x21, 0x22, 0x1C, 0x26, 0x42, 0x83,
  0x82, 0xC2, 0x7C, 0x18, 0x66, 0x42, 0x83, 0x82, 0x82, 0xC6, 0x7C, 0x08,
  0x18, 0x10, 0x20, 0x40, 0x27, 0x70, 0x00, 0x00, 0xEE, 0x11, 0xCE, 0x00,
  0x00, 0x06, 0x23, 0x11, 0x88, 0x00, 0x01, 0x06, 0x38, 0xE0, 0x80, 0xE0,
  0x30, 0x0C, 0x04, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x40, 0x30, 0x0C, 0x06,
  0x01, 0x0E, 0x38, 0xE0, 0x80, 0x78, 0x10, 0x41, 0x0C, 0x66, 0x10, 0x40,
  0x0C, 0x30, 0x07, 0x06, 0x61, 0x04, 0x81, 0x20, 0x51, 0xF4, 0xCD, 0x22,
  0x48, 0x92, 0x24, 0x8B, 0x3E, 0xC0, 0x10, 0x06, 0x00, 0xF0, 0x06, 0x06,
  0x0A, 0x0A, 0x19, 0x11, 0x11, 0x21, 0x3F, 0x61, 0x41, 0xC1, 0x3F, 0x10,
  0x88, 0x48, 0x24, 0x33, 0xE1, 0x08, 0x82, 0x41, 0x61, 0x21, 0x9F, 0x80,
  0x04, 0x0D, 0x88, 0x4C, 0x24, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0xB0,
  0x88, 0xC7, 0xC0, 0x3E, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42,
  0xC2, 0x84, 0xF8, 0x3F, 0x90, 0x08, 0x04, 0x04, 0x03, 0xF9, 0x00, 0x80,
  0x40, 0x20, 0x30, 0x1F, 0xC0, 0x3F, 0x90, 0x08, 0x0C, 0x04, 0x03, 0xF9,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x00, 0x04, 0x0D, 0x88, 0x4C, 0x24,
  0x02, 0x01, 0x00, 0x9E, 0x41, 0x61, 0xB0, 0x88, 0xC7, 0xC0, 0x21, 0x90,
  0x88, 0x48, 0x24, 0x13, 0xF9, 0x0C, 0x84, 0x42, 0x61, 0x20, 0x90, 0x40,
  0x3F, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0xFE,
  0x0F, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x82, 0x84, 0x78,
  0x21, 0x90, 0x88, 0x88, 0x44, 0x43, 0xC1, 0x10, 0x88, 0x44, 0x63, 0x20,
  0x90, 0x60, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x07,
  0xF0, 0x21, 0xA9, 0x54, 0xAA, 0xA5, 0x52, 0xC9, 0x25, 0x82, 0x83, 0x41,
  0x20, 0x90, 0x40, 0x31, 0x98, 0x9C, 0x4A, 0x24, 0x92, 0x49, 0x24, 0x94,
  0x4A, 0x43, 0x21, 0x90, 0xC0, 0x0C, 0x13, 0x21, 0x61, 0x41, 0x41, 0x41,
  0x41, 0x43, 0xC2, 0xC2, 0x46, 0x7C, 0x3F, 0x10, 0xC8, 0x28, 0x14, 0x12,
  0x19, 0xF0, 0x80, 0x40, 0x60, 0x20, 0x10, 0x00, 0x0C, 0x13, 0x21, 0x61,
  0x41, 0x41, 0x41, 0x41, 0x43, 0xC2, 0x82, 0x46, 0x7C, 0x08, 0x04, 0x04,
  0x3F, 0x10, 0xC8, 0x28, 0x34, 0x12, 0x31, 0xE0, 0x88, 0x44, 0x62, 0x20,
  0x90, 0x40, 0x04, 0x1D, 0x88, 0x4C, 0x26, 0x01, 0x00, 0x70, 0x0C, 0x03,
  0x01, 0xA0, 0x98, 0x47, 0xC0, 0xFF, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x21, 0x90, 0x98, 0x48, 0x24, 0x12, 0x09,
  0x0C, 0x84, 0x42, 0x61, 0x11, 0x8F, 0x80, 0x81, 0xC3, 0x42, 0x42, 0x44,
  0x44, 0x48, 0x48, 0x58, 0x50, 0x50, 0x20, 0x4C, 0x53, 0x24, 0xC9, 0x52,
  0x55, 0x15, 0x45, 0x52, 0x94, 0xA6, 0x29, 0x8C, 0x63, 0x10, 0x30, 0xC4,
  0x21, 0x90, 0x2C, 0x0A, 0x01, 0x00, 0xC0, 0x68, 0x12, 0x08, 0xC4, 0x13,
  0x06, 0x81, 0xA1, 0x10, 0x88, 0x82, 0x81, 0x40, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x3F, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x20, 0x1F, 0xC0, 0x3C, 0x82, 0x08, 0x61, 0x04, 0x10, 0x41,
  0x0C, 0x20, 0x82, 0x08, 0x3C, 0x84, 0x10, 0x84, 0x21, 0x84, 0x21, 0x08,
  0x21, 0x08, 0x43, 0x3C, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x61, 0x04,
  0x10, 0x41, 0x3C, 0x18, 0x30, 0x93, 0x24, 0x50, 0x40, 0xFF, 0x90, 0x08,
  0x37, 0x63, 0x41, 0x43, 0x42, 0xC2, 0xC2, 0x46, 0x7A, 0x20, 0x20, 0x24,
  0x5E, 0x61, 0x41, 0x41, 0x42, 0x42, 0xC2, 0xC6, 0xBC, 0x08, 0x3E, 0x61,
  0x41, 0x40, 0x40, 0xC0, 0xC2, 0x46, 0x7C, 0x01, 0x80, 0x82, 0x46, 0xE6,
  0x32, 0x09, 0x0C, 0x84, 0xC2, 0x61, 0x11, 0x8F, 0x40, 0x08, 0x36, 0x61,
  0x41, 0x41, 0x7E, 0xC0, 0xC0, 0x46, 0x7C, 0x03, 0xE0, 0x40, 0x08, 0x01,
  0x11, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x3C, 0x00, 0x08, 0x37, 0x63, 0x41, 0x43, 0x42, 0x42, 0x46,
  0x7A, 0x02, 0x02, 0x04, 0x78, 0x20, 0x20, 0x24, 0x5E, 0x61, 0x41, 0x43,
  0x42, 0x42, 0xC2, 0x82, 0x82, 0x0E, 0x04, 0x00, 0x00, 0x3C, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0xFF, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xF0,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x31, 0xF0,
  0x20, 0x10, 0x08, 0x2C, 0x24, 0x22, 0x21, 0x30, 0xF0, 0x4C, 0x62, 0x21,
  0x90, 0x40, 0xF0, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x81,
  0xF0, 0x12, 0x36, 0x92, 0x49, 0x28, 0x94, 0x4A, 0x45, 0x22, 0x92, 0x49,
  0x00, 0x24, 0x5E, 0x61, 0x41, 0x43, 0x42, 0x42, 0xC2, 0x82, 0x82, 0x08,
  0x36, 0x61, 0x41, 0x41, 0x42, 0xC2, 0xC2, 0x46, 0x7C, 0x24, 0x5E, 0x61,
  0x41, 0x41, 0x42, 0x42, 0xC2, 0xC6, 0xBC, 0x80, 0x80, 0x80, 0x08, 0x37,
  0x63, 0x41, 0x43, 0x42, 0xC2, 0xC2, 0x46, 0x7A, 0x02, 0x04, 0x04, 0x04,
  0x3B, 0x61, 0x41, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x0C, 0x37, 0x41,
  0x40, 0x60, 0x1E, 0x02, 0x02, 0xC2, 0x7C, 0x10, 0x20, 0x47, 0xF2, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x81, 0xE0, 0x61, 0x41, 0x41, 0x43, 0x42, 0x42,
  0xC2, 0x46, 0x7C, 0x83, 0x82, 0xC4, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20,
  0x88, 0xC4, 0x65, 0x52, 0xAA, 0x55, 0x32, 0x99, 0x8C, 0x44, 0x00, 0x30,
  0xC4, 0x40, 0xA0, 0x30, 0x0C, 0x07, 0x03, 0x20, 0x8C, 0xC1, 0x00, 0x61,
  0x41, 0x41, 0x43, 0x42, 0xC2, 0x46, 0x7A, 0x02, 0x06, 0x04, 0x78, 0x7F,
  0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0, 0xFE, 0x07, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x08, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x30, 0x1C,
  0x11, 0x13, 0x22, 0x22, 0x22, 0x44, 0x44, 0x4C, 0x38, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x0F, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0xC0,
  0x31, 0x59, 0x89, 0x86,
};

const GFXglyph JetBrainsMono_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 17, 10, 1, -15 },
  { 46, 11, 13, 10, 0, -13 },
  { 64, 10, 13, 10, 0, -13 },
  { 81, 2, 5, 10, 5, -12 },
  { 83, 7, 16, 10, 3, -14 },
  { 97, 7, 16, 10, 1, -14 },
  { 111, 9, 8, 10, 1, -10 },
  { 120, 8, 8, 10, 1, -10 },
  { 128, 4, 6, 10, 2, -3 },
  { 131, 6, 1, 10, 2, -6 },
  { 132, 3, 2, 10, 3, -2 },
  { 133, 10, 16, 10, 0, -14 },
  { 153, 9, 13, 10, 1, -13 },
  { 168, 7, 12, 10, 1, -12 },
  { 179, 9, 13, 10, 1, -13 },
  { 194, 8, 12, 10, 1, -12 },
  { 206, 8, 12, 10, 1, -12 },
  { 218, 8, 12, 10, 1, -12 },
  { 230, 8, 12, 10, 1, -12 },
  { 242, 8, 12, 10, 2, -12 },
  { 254, 8, 13, 10, 1, -13 },
  { 267, 8, 13, 10, 2, -13 },
  { 280, 4, 10, 10, 3, -10 },
  { 285, 5, 13, 10, 2, -10 },
  { 294, 8, 9, 10, 2, -10 },
  { 303, 8, 5, 10, 1, -8 },
  { 308, 8, 9, 10, 1, -10 },
  { 317, 6, 12, 10, 3, -12 },
  { 326, 10, 16, 10, 0, -13 },
  { 346, 8, 12, 10, 0, -12 },
  { 358, 9, 12, 10, 1, -12 },
  { 372, 9, 13, 10, 1, -13 },
  { 387, 8, 12, 10, 1, -12 },
  { 399, 9, 12, 10, 1, -12 },
  { 413, 9, 12, 10, 1, -12 },
  { 427, 9, 13, 10, 1, -13 },
  { 442, 9, 12, 10, 1, -12 },
  { 456, 8, 12, 10, 1, -12 },
  { 468, 8, 12, 10, 1, -12 },
  { 480, 9, 12, 10, 1, -12 },
  { 494, 7, 12, 10, 1, -12 },
  { 505, 9, 12, 10, 1, -12 },
  { 519, 9, 12, 10, 1, -12 },
  { 533, 8, 13, 10, 1, -13 },
  { 546, 9, 12, 10, 1, -12 },
  { 560, 8, 16, 10, 1, -13 },
  { 576, 9, 12, 10, 1, -12 },
  { 590, 9, 13, 10, 1, -13 },
  { 605, 8, 12, 10, 2, -12 },
  { 617, 9, 12, 10, 1, -12 },
  { 631, 8, 12, 10, 2, -12 },
  { 643, 10, 12, 10, 1, -12 },
  { 658, 10, 12, 10, 0, -12 },
  { 673, 9, 12, 10, 2, -12 },
  { 687, 9, 12, 10, 1, -12 },
  { 701, 6, 16, 10, 3, -14 },
  { 713, 5, 16, 10, 3, -14 },
  { 723, 6, 16, 10, 2, -14 },
  { 735, 7, 6, 10, 2, -12 },
  { 741, 8, 1, 10, 0, 0 },
  { 742, 2, 2, 10, 5, -13 },
  { 743, 8, 10, 10, 1, -10 },
  { 753, 8, 12, 10, 1, -12 },
  { 765, 8, 10, 10, 1, -10 },
  { 775, 9, 12, 10, 1, -12 },
  { 789, 8, 10, 10, 1, -10 },
  { 799, 11, 15, 10, -1, -12 },
  { 820, 8, 13, 10, 1, -10 },
  { 833, 8, 12, 10, 1, -12 },
  { 845, 8, 13, 10, 1, -13 },
  { 858, 9, 16, 10, 0, -13 },
  { 876, 9, 12, 10, 1, -12 },
  { 890, 7, 12, 10, 2, -12 },
  { 901, 9, 10, 10, 1, -10 },
  { 913, 8, 10, 10, 1, -10 },
  { 923, 8, 10, 10, 1, -10 },
  { 933, 8, 13, 10, 1, -10 },
  { 946, 8, 13, 10, 1, -10 },
  { 959, 8, 10, 10, 1, -10 },
  { 969, 8, 10, 10, 1, -10 },
  { 979, 7, 12, 10, 2, -12 },
  { 990, 8, 9, 10, 1, -9 },
  { 999, 8, 9, 10, 2, -9 },
  { 1008, 9, 9, 10, 1, -9 },
  { 1019, 10, 9, 10, 0, -9 },
  { 1031, 8, 12, 10, 1, -9 },
  { 1043, 8, 9, 10, 1, -9 },
  { 1052, 8, 16, 10, 2, -14 },
  { 1068, 4, 16, 10, 3, -14 },
  { 1076, 8, 16, 10, 1, -14 },
  { 1092, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC17PT7B_H_
