#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC67PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00,
  0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x8F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFD, 0xFE, 0x00, 0x1F, 0x87, 0x0F, 0xC0, 0x0F, 0xC1, 0xC1, 0xF0, 0x03,
  0xE0, 0x70, 0x3E, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x3E, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x0E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x3E, 0x07,
  0x00, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x7F,
  0xBC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x00, 0x70, 0xFE,
  0x00, 0x00, 0x1C, 0x1F, 0x80, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x01, 0xC0,
  0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x3C, 0x3E, 0x00, 0xE0, 0x1F, 0x0F, 0x80,
  0x38, 0x07, 0xC3, 0xE0, 0x0E, 0x01, 0xE0, 0xF8, 0x07, 0x80, 0x78, 0x3E,
  0x01, 0xC0, 0x3E, 0x0F, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x1C, 0x07, 0xC0,
  0x7E, 0x07, 0x07, 0xE0, 0x0F, 0xC1, 0xC3, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x3C,
  0x00, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC1, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x78, 0x00, 0x00,
  0x1F, 0x8F, 0xC3, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0x78, 0x7C, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x0F, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x38, 0x01, 0xE0,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x78,
  0x00, 0x0F, 0x87, 0xE0, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF1,
  0xF0, 0x1F, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x80,
  0x78, 0x3E, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x3C, 0x00,
  0x3E, 0x1E, 0x03, 0xC0, 0x03, 0xE3, 0xE0, 0x3C, 0x00, 0x1F, 0x7C, 0x07,
  0xC0, 0x01, 0xF7, 0x80, 0x7C, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x07,
  0xC0, 0x03, 0xEF, 0x80, 0x7C, 0x00, 0x7C, 0x7C, 0x07, 0xE0, 0x1F, 0x87,
  0xC0, 0x3F, 0xCF, 0xF0, 0x3E, 0x03, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x7C, 0xF9, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0xFB, 0xF7, 0xEF, 0x9F,
  0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x01, 0x3E, 0x00,
  0x78, 0x01, 0xE7, 0xF8, 0x0F, 0x01, 0xFD, 0xFF, 0xC1, 0xC1, 0xFF, 0xFF,
  0xFE, 0x38, 0xFF, 0xF8, 0xFF, 0xE6, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0x03, 0xF8,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0x03, 0xF8, 0x1E, 0x07,
  0x80, 0xFE, 0x07, 0x81, 0xE0, 0x3F, 0x83, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x3E, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x9E,
  0x00, 0x01, 0xF8, 0x78, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xFC, 0x07, 0x80,
  0x07, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x70, 0x03, 0xC0, 0x01,
  0x00, 0x0F, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x1F,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x83, 0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0x80, 0x0F, 0x3F, 0xFF, 0xC0,
  0x0F, 0x7F, 0xFF, 0xE0, 0x0F, 0x78, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x7D, 0xFF,
  0xFC, 0x00, 0xF7, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x3E, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x7E, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0xF8, 0x00, 0xFF, 0xFB, 0xE0, 0x00, 0x3F, 0x87,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x40, 0x78,
  0x1E, 0x00, 0x0F, 0xF8, 0xF0, 0x3C, 0x00, 0x7F, 0xF9, 0xE0, 0xF8, 0x01,
  0xFF, 0xFB, 0xC1, 0xF0, 0x07, 0xE0, 0x77, 0x03, 0xC0, 0x1F, 0x80, 0x7E,
  0x07, 0x80, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x1E, 0x01,
  0xF0, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x07,
  0xC1, 0xE0, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x07, 0x80,
  0x7C, 0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x7C, 0x00,
  0x3C, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x1F, 0x81, 0xE0, 0x07, 0xF0,
  0xFF, 0x03, 0xC0, 0x07, 0xFF, 0xDE, 0x07, 0x80, 0x0F, 0xFF, 0x3C, 0x0F,
  0x00, 0x07, 0xF8, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xFE,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x78, 0x00,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0,
  0x0F, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xF0,
  0x0F, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x7F, 0xFF, 0x07, 0xC0, 0x3F, 0xFF, 0x83, 0xC0, 0x3F, 0xFF, 0xC1,
  0xE0, 0x1F, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xDC, 0x00, 0x07, 0xF0,
  0x1D, 0xC0, 0x00, 0xFF, 0x01, 0xDC, 0x00, 0x0F, 0xF0, 0x1D, 0xE0, 0x01,
  0xEE, 0x01, 0xDE, 0x00, 0x1E, 0xE0, 0x3D, 0xE0, 0x03, 0xDE, 0x03, 0xCE,
  0x00, 0x3D, 0xE0, 0x3C, 0xE0, 0x07, 0x9E, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0x70, 0x1E,
  0x3C, 0x07, 0x87, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x3C, 0x3C, 0x07, 0x87,
  0x83, 0x87, 0xC0, 0x78, 0x78, 0x78, 0x7C, 0x07, 0x83, 0x87, 0x07, 0x80,
  0xF8, 0x38, 0xF0, 0x78, 0x0F, 0x83, 0x8E, 0x07, 0x80, 0xF0, 0x3D, 0xE0,
  0x78, 0x0F, 0x03, 0xDC, 0x0F, 0x80, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0x01,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x00, 0xF0,
  0x1F, 0xC0, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x07,
  0xC0, 0x7F, 0x80, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x78, 0x0F, 0xF8, 0x00,
  0x1E, 0x03, 0xCE, 0x00, 0x07, 0x80, 0xF3, 0xC0, 0x03, 0xE0, 0x3C, 0xF0,
  0x00, 0xF8, 0x0F, 0x3C, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0x0F, 0x00, 0xF1,
  0xE0, 0x03, 0xC0, 0x7C, 0x78, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x7C, 0x07,
  0x87, 0x80, 0x1F, 0x01, 0xE0, 0xE0, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0,
  0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x83, 0xC0, 0x1E, 0x03, 0xE0, 0xF0, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x0E, 0x03, 0xC0, 0x7C, 0x03,
  0xC0, 0xF0, 0x1E, 0x00, 0xF0, 0x7C, 0x07, 0x80, 0x3C, 0x1F, 0x01, 0xE0,
  0x0F, 0x07, 0x80, 0x78, 0x01, 0xE1, 0xE0, 0x3E, 0x00, 0x78, 0x78, 0x0F,
  0x80, 0x1E, 0x1E, 0x03, 0xC0, 0x07, 0x8F, 0x80, 0xF0, 0x00, 0xF3, 0xE0,
  0x3C, 0x00, 0x3C, 0xF0, 0x0F, 0x00, 0x0F, 0x3C, 0x03, 0xC0, 0x03, 0xCF,
  0x01, 0xF0, 0x00, 0xF3, 0xC0, 0x7C, 0x00, 0x1E, 0xF0, 0x1E, 0x00, 0x07,
  0xBC, 0x07, 0x80, 0x01, 0xEE, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x78, 0x00,
  0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xC0,
  0x00, 0x3F, 0x80, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x1E, 0x00, 0x01, 0xFC, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0x7C, 0xF0, 0x01, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0xC0, 0x07,
  0x8F, 0x00, 0x3F, 0x00, 0x1E, 0x3C, 0x00, 0xFC, 0x00, 0xF8, 0xF0, 0x03,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0xC0, 0x0F, 0x0F, 0x00, 0x77, 0x00, 0x3C,
  0x3C, 0x01, 0xDC, 0x01, 0xE0, 0xF0, 0x07, 0x70, 0x07, 0x83, 0xC0, 0x3D,
  0xC0, 0x1E, 0x0F, 0x00, 0xE7, 0x00, 0xF8, 0x3C, 0x03, 0x9C, 0x03, 0xC0,
  0xF0, 0x1E, 0x70, 0x0F, 0x03, 0xC0, 0x71, 0xC0, 0x3C, 0x1E, 0x01, 0xC7,
  0x01, 0xE0, 0x78, 0x07, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x70, 0x1E, 0x07,
  0x80, 0xE1, 0xC0, 0x78, 0x1E, 0x03, 0x87, 0x03, 0xC0, 0x78, 0x1E, 0x1C,
  0x0F, 0x01, 0xE0, 0x70, 0x70, 0x3C, 0x07, 0x81, 0xC1, 0xC0, 0xE0, 0x1E,
  0x07, 0x07, 0x07, 0x80, 0x78, 0x38, 0x1C, 0x1E, 0x01, 0xE0, 0xE0, 0x70,
  0x78, 0x07, 0x83, 0x81, 0xC3, 0xC0, 0x1E, 0x1C, 0x07, 0x0F, 0x00, 0x78,
  0x70, 0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0x70, 0xF0, 0x07, 0x8F, 0x01, 0xC7,
  0x80, 0x1E, 0x38, 0x07, 0x1E, 0x00, 0x78, 0xE0, 0x1C, 0x78, 0x01, 0xE3,
  0x80, 0x71, 0xC0, 0x07, 0x9C, 0x01, 0xCF, 0x00, 0x1E, 0x70, 0x0F, 0x3C,
  0x00, 0x79, 0xC0, 0x38, 0xF0, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0x07, 0x38,
  0x03, 0x9E, 0x00, 0x1C, 0xE0, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x03, 0xDC, 0x00, 0xEF, 0x00, 0x0F, 0x70, 0x03, 0xBC, 0x00, 0x3D, 0xC0,
  0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x40, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x3C, 0x01, 0xFF, 0xF8, 0x78, 0x07, 0xFF, 0xF9,
  0xF0, 0x1F, 0xE1, 0xFB, 0xE0, 0x7E, 0x00, 0x77, 0xC1, 0xF8, 0x00, 0x7F,
  0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x77, 0x80, 0xFF, 0x07, 0xCF,
  0x00, 0xFF, 0xFF, 0x3E, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xE0, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x40, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0x78, 0xFF, 0xFC, 0x01,
  0xF3, 0xFF, 0xFC, 0x03, 0xEF, 0x83, 0xFC, 0x07, 0xBC, 0x01, 0xFC, 0x0F,
  0x60, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x3E, 0x07, 0xB8, 0x01, 0xF8, 0x1F,
  0x7C, 0x0F, 0xE0, 0x3E, 0x7F, 0xFF, 0x80, 0x7C, 0x7F, 0xFE, 0x00, 0xF0,
  0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x17,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0x03, 0xC0, 0x01, 0xFF, 0xC1, 0xE0, 0x03, 0xFF, 0xF0,
  0xF0, 0x03, 0xFF, 0xFC, 0xF8, 0x03, 0xFC, 0x3F, 0x7C, 0x03, 0xF0, 0x03,
  0xBE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xBC, 0x01, 0xFE, 0x0F, 0x9E,
  0x00, 0x7F, 0xFF, 0x9F, 0x00, 0x1F, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF1, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0xFF, 0xF8,
  0x78, 0x07, 0xFF, 0xF9, 0xF0, 0x1F, 0xE1, 0xFB, 0xE0, 0x7E, 0x00, 0x77,
  0xC1, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC,
  0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFD, 0xE0, 0x0F, 0xFF, 0xF3, 0xC0, 0x0F, 0xFF, 0x87,
  0x80, 0x0F, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x40, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0x78, 0xFF, 0xFC, 0x01, 0xF3, 0xFF,
  0xFC, 0x03, 0xEF, 0x83, 0xFC, 0x07, 0xBC, 0x01, 0xFC, 0x0F, 0x60, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x04, 0x00, 0x3C, 0xFF, 0x07,
  0xF8, 0x03, 0xDF, 0xF8, 0xFF, 0xC0, 0x7B, 0xFF, 0x9F, 0xFC, 0x07, 0xB0,
  0xFD, 0x87, 0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x78, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0x1E, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x07, 0xC1, 0xE0, 0x0F, 0x00,
  0x7C, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x0F, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x38, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x07,
  0x83, 0xFF, 0x80, 0x0F, 0x1F, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0x80, 0x7D,
  0xF0, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0x81, 0xEC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x3C,
  0x7F, 0xFE, 0x00, 0x3E, 0x7F, 0xFF, 0x80, 0x1F, 0x7E, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xF8, 0x07, 0xB0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0x70, 0x03, 0xF0, 0x0F, 0xBE,
  0x07, 0xF0, 0x07, 0xCF, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xF0, 0x01, 0xE0,
  0xFF, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x3C, 0x01, 0xFF, 0xF8, 0x78, 0x07, 0xFF, 0xF9, 0xF0, 0x1F, 0xE1, 0xFB,
  0xE0, 0x7E, 0x00, 0x77, 0xC1, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x77, 0x80, 0xFF, 0x07, 0xCF, 0x00, 0xFF, 0xFF, 0x3E,
  0x00, 0xFF, 0xFC, 0x7C, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xC1, 0xFF, 0xC0, 0x03, 0xC7, 0xFF, 0xE0, 0x03, 0xCF, 0xFF, 0xF8, 0x07,
  0xDF, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x07, 0xB0, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0x80, 0x1E,
  0xF0, 0x07, 0xE0, 0x07, 0xBC, 0x01, 0xF8, 0x03, 0xCF, 0x00, 0x7E, 0x00,
  0xF3, 0xC0, 0x3B, 0x80, 0x3C, 0xF0, 0x0E, 0xE0, 0x0E, 0x3C, 0x03, 0xB8,
  0x07, 0x8F, 0x01, 0xCE, 0x01, 0xE3, 0xC0, 0x71, 0x80, 0x70, 0xF0, 0x1C,
  0x60, 0x3C, 0x3C, 0x0E, 0x18, 0x0F, 0x0F, 0x03, 0x86, 0x03, 0x83, 0xC0,
  0xE1, 0x81, 0xE0, 0xF0, 0x70, 0x60, 0x78, 0x3C, 0x1C, 0x1C, 0x1C, 0x0F,
  0x0F, 0x07, 0x0F, 0x03, 0xC3, 0x81, 0xC3, 0xC0, 0xF0, 0xE0, 0x70, 0xE0,
  0x3C, 0x78, 0x1C, 0x78, 0x0F, 0x1C, 0x07, 0x1E, 0x03, 0xC7, 0x01, 0xC7,
  0x80, 0xF3, 0xC0, 0x73, 0xC0, 0x3C, 0xE0, 0x1C, 0xF0, 0x0F, 0x38, 0x07,
  0x3C, 0x03, 0xDE, 0x01, 0xDE, 0x00, 0xF7, 0x00, 0x77, 0x80, 0x3D, 0xC0,
  0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFE,
  0x07, 0xE0, 0x0F, 0x78, 0x07, 0xFC, 0xFC, 0xF0, 0x0F, 0xFF, 0xF1, 0xE0,
  0x07, 0xFF, 0xC7, 0xC0, 0x07, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x0F, 0xFC, 0x00,
  0x1F, 0x1F, 0xFF, 0x00, 0x1E, 0x3F, 0xFF, 0x00, 0x1E, 0x3E, 0x0F, 0x80,
  0x1E, 0x7C, 0x07, 0xC0, 0x1E, 0x78, 0x03, 0xE0, 0x1E, 0x78, 0x03, 0xE0,
  0x3C, 0x78, 0x01, 0xF0, 0x7C, 0xF8, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0xFF,
  0xF0, 0xF0, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 15, 49, 40, 13, -49 },
  { 93, 21, 20, 40, 13, -49 },
  { 146, 38, 49, 40, 2, -49 },
  { 379, 34, 67, 40, 4, -58 },
  { 664, 46, 49, 40, -2, -49 },
  { 946, 36, 51, 40, 2, -50 },
  { 1176, 7, 20, 40, 20, -49 },
  { 1194, 28, 65, 40, 11, -57 },
  { 1422, 27, 65, 40, 3, -57 },
  { 1642, 35, 34, 40, 4, -41 },
  { 1791, 31, 31, 40, 5, -38 },
  { 1912, 16, 21, 40, 7, -10 },
  { 1954, 22, 4, 40, 10, -24 },
  { 1965, 11, 11, 40, 12, -10 },
  { 1981, 38, 63, 40, 2, -56 },
  { 2281, 34, 51, 40, 4, -50 },
  { 2498, 30, 49, 40, 3, -49 },
  { 2682, 35, 50, 40, 3, -50 },
  { 2901, 33, 50, 40, 4, -49 },
  { 3108, 30, 49, 40, 5, -49 },
  { 3292, 32, 50, 40, 5, -49 },
  { 3492, 31, 50, 40, 4, -49 },
  { 3686, 32, 49, 40, 8, -49 },
  { 3882, 33, 51, 40, 4, -50 },
  { 4093, 31, 50, 40, 7, -50 },
  { 4287, 16, 39, 40, 12, -38 },
  { 4365, 20, 49, 40, 8, -38 },
  { 4488, 32, 34, 40, 6, -39 },
  { 4624, 31, 20, 40, 5, -32 },
  { 4702, 31, 34, 40, 4, -39 },
  { 4834, 27, 49, 40, 10, -49 },
  { 5000, 39, 62, 40, 1, -50 },
  { 5303, 32, 49, 40, 1, -49 },
  { 5499, 34, 49, 40, 4, -49 },
  { 5708, 33, 51, 40, 5, -50 },
  { 5919, 33, 49, 40, 4, -49 },
  { 6122, 34, 49, 40, 5, -49 },
  { 6331, 36, 49, 40, 4, -49 },
  { 6552, 33, 51, 40, 5, -50 },
  { 6763, 34, 49, 40, 4, -49 },
  { 6972, 32, 49, 40, 5, -49 },
  { 7168, 35, 50, 40, 2, -49 },
  { 7387, 37, 49, 40, 4, -49 },
  { 7614, 28, 49, 40, 5, -49 },
  { 7786, 36, 49, 40, 3, -49 },
  { 8007, 34, 49, 40, 4, -49 },
  { 8216, 32, 51, 40, 5, -50 },
  { 8420, 36, 49, 40, 4, -49 },
  { 8641, 32, 62, 40, 5, -50 },
  { 8889, 35, 49, 40, 4, -49 },
  { 9104, 35, 51, 40, 3, -50 },
  { 9328, 33, 49, 40, 8, -49 },
  { 9531, 33, 50, 40, 5, -49 },
  { 9738, 32, 49, 40, 9, -49 },
  { 9934, 38, 49, 40, 5, -49 },
  { 10167, 41, 49, 40, 0, -49 },
  { 10419, 34, 49, 40, 8, -49 },
  { 10628, 35, 49, 40, 3, -49 },
  { 10843, 26, 63, 40, 10, -56 },
  { 11048, 18, 63, 40, 12, -56 },
  { 11190, 26, 63, 40, 6, -56 },
  { 11395, 28, 26, 40, 7, -49 },
  { 11486, 33, 4, 40, 0, 2 },
  { 11503, 11, 10, 40, 18, -53 },
  { 11517, 31, 39, 40, 5, -38 },
  { 11669, 31, 50, 40, 4, -49 },
  { 11863, 31, 39, 40, 5, -38 },
  { 12015, 33, 50, 40, 5, -49 },
  { 12222, 30, 39, 40, 5, -38 },
  { 12369, 43, 61, 40, -2, -49 },
  { 12697, 31, 50, 40, 5, -38 },
  { 12891, 31, 49, 40, 4, -49 },
  { 13081, 31, 52, 40, 3, -52 },
  { 13283, 34, 64, 40, 1, -52 },
  { 13555, 35, 49, 40, 4, -49 },
  { 13770, 27, 49, 40, 7, -49 },
  { 13936, 36, 38, 40, 2, -38 },
  { 14107, 31, 38, 40, 4, -38 },
  { 14255, 30, 39, 40, 5, -38 },
  { 14402, 33, 50, 40, 2, -38 },
  { 14609, 31, 50, 40, 5, -38 },
  { 14803, 32, 38, 40, 5, -38 },
  { 14955, 31, 39, 40, 4, -38 },
  { 15107, 30, 47, 40, 7, -47 },
  { 15284, 31, 38, 40, 5, -37 },
  { 15432, 30, 37, 40, 8, -37 },
  { 15571, 34, 37, 40, 6, -37 },
  { 15729, 36, 37, 40, 2, -37 },
  { 15896, 31, 49, 40, 5, -37 },
  { 16086, 32, 37, 40, 4, -37 },
  { 16234, 33, 63, 40, 7, -56 },
  { 16494, 14, 63, 40, 14, -56 },
  { 16605, 33, 63, 40, 2, -56 },
  { 16865, 32, 13, 40, 5, -30 },
};

const GFXfont JetBrainsMono_ExtraLightItalic67pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic67pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC67PT7B_H_
