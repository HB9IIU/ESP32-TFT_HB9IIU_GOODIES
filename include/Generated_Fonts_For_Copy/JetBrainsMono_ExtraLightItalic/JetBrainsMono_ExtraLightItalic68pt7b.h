#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC68PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x1F,
  0x00, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F,
  0x8F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xC7, 0x9F,
  0xC0, 0x07, 0xC1, 0xC1, 0xF8, 0x03, 0xE0, 0x70, 0x3E, 0x01, 0xF0, 0x1C,
  0x07, 0xC0, 0x7C, 0x07, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xC0, 0x38, 0x07, 0xC0, 0xF0, 0x0E, 0x01, 0xF0, 0x3C,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0xC1, 0xC0, 0x00,
  0x03, 0xF8, 0x70, 0x00, 0x00, 0x7F, 0x1C, 0x00, 0x00, 0x0F, 0xF7, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x38, 0xFE, 0x00, 0x00, 0x1E, 0x1F, 0x80, 0x00,
  0x07, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x7C, 0x00, 0x00, 0x70, 0x1F, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0x38, 0x03, 0xC3, 0xE0, 0x0E, 0x00,
  0xF0, 0xF8, 0x03, 0x80, 0x7C, 0x3E, 0x00, 0xE0, 0x1F, 0x0F, 0x80, 0x78,
  0x07, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x01, 0xF0, 0x1F, 0x81,
  0xC0, 0xF8, 0x03, 0xF8, 0x70, 0xFE, 0x00, 0x7F, 0xDF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0,
  0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x80, 0x78,
  0x3C, 0x00, 0x00, 0x1F, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x87, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x3F, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x03,
  0x80, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF1, 0xF0, 0x1F, 0x00,
  0x3E, 0x1E, 0x00, 0xF8, 0x03, 0xC1, 0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0x7C, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x3C, 0x00, 0x3E, 0x1F, 0x03,
  0xC0, 0x01, 0xF3, 0xE0, 0x3C, 0x00, 0x1F, 0x3C, 0x07, 0xC0, 0x00, 0xFF,
  0x80, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x03, 0xF7,
  0xC0, 0x7C, 0x00, 0x7E, 0x7C, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x3F, 0x8F,
  0xF8, 0x3E, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0x00,
  0x7F, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xBF, 0x00, 0x78, 0x03,
  0xF7, 0xFC, 0x0F, 0x03, 0xFF, 0xFF, 0xE1, 0xC1, 0xFF, 0xCF, 0xFF, 0x38,
  0xFF, 0xF0, 0x7F, 0xF7, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x07, 0xF9, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0x8F, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x38, 0x03, 0xC1, 0xF0,
  0x1F, 0x00, 0xF0, 0x7C, 0x0F, 0xE0, 0x7C, 0x1F, 0x03, 0xF8, 0x1F, 0x07,
  0x80, 0xFE, 0x07, 0xC1, 0xE0, 0x3F, 0x81, 0xF0, 0x78, 0x07, 0xC0, 0x78,
  0x3E, 0x00, 0xE0, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x3F, 0xBE,
  0x00, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xC3, 0xE0, 0x01, 0xFC, 0x0F, 0x00,
  0x0F, 0xE0, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x03,
  0x00, 0x1F, 0x00, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xD0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE1, 0xFF, 0xE0, 0x01, 0xF3,
  0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xFE, 0x00, 0x7B, 0xF8, 0xFF, 0x80, 0x3D,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x01,
  0xF7, 0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xF0, 0x07, 0xDF, 0xBF, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xEF, 0x80, 0x03,
  0xFF, 0x8F, 0x00, 0x00, 0x18, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xFC,
  0x3E, 0x07, 0x80, 0x07, 0xFF, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0xBC, 0x0F,
  0x80, 0x1F, 0xFF, 0xBC, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0x00, 0x3C,
  0x00, 0xFC, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0x7C,
  0x0F, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0x00,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x00,
  0xF8, 0x1E, 0x00, 0xF0, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x1E,
  0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x3E, 0x01, 0xE0,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x01, 0xF0,
  0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0xE0, 0x78, 0x01, 0xF0, 0x0D,
  0xE0, 0x78, 0x01, 0xFE, 0x7D, 0xE0, 0x78, 0x00, 0xFF, 0xF9, 0xC0, 0x78,
  0x00, 0x7F, 0xF1, 0xC0, 0x78, 0x00, 0x3F, 0xC3, 0xC0, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x1E, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0xFC, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x07,
  0xF0, 0x07, 0x80, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x7E, 0x01, 0xE0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01,
  0xF8, 0x07, 0x80, 0x01, 0xF8, 0x03, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x0F, 0x80, 0x7F,
  0xFF, 0x87, 0xC0, 0x3F, 0xFF, 0x83, 0xE0, 0x1F, 0xFF, 0xC1, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x40, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xF7, 0x00, 0xEF, 0x00, 0x07, 0xF8, 0x07,
  0x78, 0x00, 0x7B, 0xC0, 0x39, 0xC0, 0x03, 0xDE, 0x03, 0xCE, 0x00, 0x3C,
  0xF0, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x0F, 0x1E, 0x01, 0xE3, 0x80, 0x78, 0xF0,
  0x1F, 0x1E, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x87, 0x83,
  0xC3, 0xC0, 0x3C, 0x1C, 0x1E, 0x1E, 0x01, 0xE0, 0xE1, 0xE0, 0xF0, 0x0F,
  0x07, 0x0F, 0x0F, 0x80, 0x78, 0x3C, 0xF0, 0x7C, 0x07, 0xC1, 0xE7, 0x83,
  0xE0, 0x3E, 0x0F, 0x78, 0x1E, 0x01, 0xE0, 0x3B, 0xC0, 0xF0, 0x0F, 0x01,
  0xDC, 0x07, 0x80, 0x78, 0x0F, 0xE0, 0x3C, 0x03, 0xC0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x00, 0x3C, 0x03, 0xFC, 0x00,
  0x07, 0x80, 0x7F, 0x80, 0x01, 0xF0, 0x0F, 0xF0, 0x00, 0x3E, 0x01, 0xEF,
  0x00, 0x07, 0x80, 0x7D, 0xE0, 0x00, 0xF0, 0x0F, 0x3C, 0x00, 0x1E, 0x01,
  0xE7, 0x80, 0x03, 0xC0, 0x3C, 0x78, 0x00, 0xF8, 0x07, 0x8F, 0x00, 0x1F,
  0x00, 0xF1, 0xE0, 0x03, 0xE0, 0x3E, 0x3C, 0x00, 0x78, 0x07, 0xC7, 0x80,
  0x0F, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x03, 0xC1,
  0xE0, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x78, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0x78,
  0x1E, 0x01, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x00, 0x78, 0x7C, 0x03,
  0xC0, 0x0F, 0x0F, 0x80, 0xF8, 0x01, 0xE1, 0xE0, 0x1F, 0x00, 0x1E, 0x3C,
  0x03, 0xC0, 0x03, 0xC7, 0x80, 0x78, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x0F,
  0x3E, 0x01, 0xE0, 0x00, 0xF7, 0xC0, 0x7C, 0x00, 0x1E, 0xF0, 0x0F, 0x80,
  0x03, 0xDE, 0x01, 0xE0, 0x00, 0x7B, 0xC0, 0x3C, 0x00, 0x0F, 0xF8, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x03, 0xF8,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x07,
  0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xFC,
  0x01, 0xE0, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x17, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3C, 0xF0, 0x01, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0xE0, 0x03,
  0xCF, 0x00, 0x1F, 0x80, 0x1F, 0x3C, 0x00, 0x7E, 0x00, 0x78, 0xF0, 0x03,
  0xB8, 0x01, 0xE3, 0xC0, 0x0E, 0xE0, 0x0F, 0x8F, 0x00, 0x3B, 0x80, 0x3C,
  0x3C, 0x01, 0xEE, 0x00, 0xF0, 0xF0, 0x07, 0x38, 0x03, 0xC3, 0xC0, 0x1C,
  0xE0, 0x1F, 0x0F, 0x00, 0xF3, 0x80, 0x78, 0x3C, 0x03, 0x8E, 0x01, 0xE0,
  0xF0, 0x0E, 0x38, 0x07, 0x83, 0xC0, 0x39, 0xE0, 0x3C, 0x0F, 0x01, 0xC7,
  0x80, 0xF0, 0x3C, 0x07, 0x1C, 0x03, 0xC0, 0xF0, 0x1C, 0x70, 0x0F, 0x07,
  0xC0, 0xF1, 0xC0, 0x78, 0x1E, 0x03, 0x87, 0x01, 0xE0, 0x78, 0x0E, 0x1C,
  0x07, 0x81, 0xE0, 0x38, 0x70, 0x3C, 0x07, 0x81, 0xC1, 0xC0, 0xF0, 0x1E,
  0x07, 0x07, 0x03, 0xC0, 0x78, 0x1C, 0x1C, 0x0F, 0x01, 0xE0, 0xF0, 0x70,
  0x78, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0x1E, 0x0E, 0x07, 0x07, 0x80, 0x78,
  0x78, 0x1C, 0x1C, 0x01, 0xE1, 0xC0, 0x70, 0xF0, 0x07, 0x87, 0x01, 0xC3,
  0xC0, 0x1E, 0x1C, 0x07, 0x0F, 0x00, 0x78, 0xE0, 0x1C, 0x78, 0x01, 0xE3,
  0x80, 0x71, 0xE0, 0x07, 0x8E, 0x01, 0xC7, 0x80, 0x1E, 0x78, 0x07, 0x1E,
  0x00, 0x79, 0xC0, 0x1C, 0xF0, 0x01, 0xE7, 0x00, 0x73, 0xC0, 0x07, 0x9C,
  0x01, 0xCF, 0x00, 0x1E, 0xE0, 0x07, 0x38, 0x00, 0x7B, 0x80, 0x1D, 0xE0,
  0x01, 0xCE, 0x00, 0x77, 0x80, 0x07, 0x70, 0x01, 0xDE, 0x00, 0x1D, 0xC0,
  0x07, 0xF0, 0x00, 0xF7, 0x00, 0x1F, 0xC0, 0x03, 0xDC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00,
  0x3C, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0x1E, 0x00, 0xFF, 0xFF, 0x9E,
  0x01, 0xFC, 0x07, 0xDE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xC0, 0x00, 0xFE,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3B, 0xE0,
  0x3F, 0xC1, 0xFB, 0xC0, 0x1F, 0xFF, 0xF3, 0xC0, 0x0F, 0xFF, 0xC3, 0xC0,
  0x07, 0xFF, 0x87, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x80,
  0x03, 0xC3, 0xFF, 0xE0, 0x03, 0xC7, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xF8,
  0x07, 0xDE, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x07, 0xB0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x03, 0xE0, 0x7B, 0x00, 0x07, 0xC0, 0x7B, 0x80, 0x1F, 0xC0,
  0x7B, 0xF0, 0x7F, 0x80, 0xF9, 0xFF, 0xFF, 0x00, 0xF8, 0xFF, 0xFC, 0x00,
  0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x1F, 0x00,
  0x07, 0xFF, 0x87, 0xC0, 0x07, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xFE, 0x78,
  0x01, 0xFC, 0x07, 0xDE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x0F,
  0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x0E, 0xF8, 0x03, 0xFC, 0x1F, 0xBC, 0x00,
  0x7F, 0xFF, 0xCF, 0x00, 0x0F, 0xFF, 0xC3, 0xC0, 0x01, 0xFF, 0xE1, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0x0F, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x17, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0x1E, 0x00, 0xFF, 0xFF, 0x9E, 0x01, 0xFC,
  0x07, 0xDE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x0D, 0xE0, 0x3F, 0x80, 0x3D, 0xE0, 0x1F, 0xFB,
  0xFB, 0xE0, 0x0F, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xE3, 0xE0, 0x01, 0xFF,
  0x83, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x7F, 0x80, 0x03, 0xC3, 0xFF, 0xE0, 0x03, 0xC7,
  0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xF8, 0x07, 0xDE, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0xFC, 0x07, 0xB0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0xFC, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x01, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x3C, 0xFF, 0x87, 0xFC, 0x03, 0xDF, 0xF8, 0xFF, 0xE0,
  0x7B, 0xFF, 0xDF, 0xFE, 0x07, 0xA0, 0x7D, 0x83, 0xE0, 0x7C, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0x1F, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0xF0, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x3C, 0x1F, 0x00,
  0x78, 0x03, 0xC1, 0xF0, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x70, 0x03, 0xC1,
  0xE0, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x00,
  0x78, 0x3E, 0x00, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x83,
  0xC0, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xC3, 0xFF, 0xE0, 0x03, 0xC7, 0xFF,
  0xF0, 0x07, 0xCF, 0xFF, 0xF8, 0x07, 0xDE, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0xFC, 0x07, 0xB0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x17, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x3F,
  0xFE, 0x00, 0x0F, 0x1F, 0xFF, 0xC0, 0x07, 0xCF, 0xFF, 0xF8, 0x01, 0xF7,
  0x80, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x1E, 0xC0, 0x01,
  0xF0, 0x07, 0xB8, 0x01, 0xFC, 0x01, 0xEF, 0xC1, 0xFE, 0x00, 0xF9, 0xFF,
  0xFF, 0x00, 0x3E, 0x3F, 0xFF, 0x00, 0x0F, 0x87, 0xFF, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x7F,
  0xFF, 0x1E, 0x00, 0xFF, 0xFF, 0x9E, 0x01, 0xFC, 0x07, 0xDE, 0x03, 0xF0,
  0x01, 0xFE, 0x07, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x3B, 0xE0, 0x3F, 0xC1, 0xFB, 0xC0, 0x1F, 0xFF,
  0xF3, 0xC0, 0x0F, 0xFF, 0xC3, 0xC0, 0x07, 0xFF, 0x87, 0xC0, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x20,
  0x7F, 0x80, 0x03, 0xC3, 0xFF, 0xE0, 0x03, 0xC7, 0xFF, 0xF8, 0x03, 0xCF,
  0xFF, 0xFC, 0x03, 0xDE, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x7B, 0xC0, 0x0F, 0xC0, 0x0F, 0x78, 0x01, 0xF8,
  0x03, 0xCF, 0x00, 0x77, 0x00, 0x79, 0xE0, 0x0E, 0xE0, 0x0F, 0x3C, 0x01,
  0xDC, 0x01, 0xC7, 0x80, 0x73, 0x80, 0x78, 0xF0, 0x0E, 0x70, 0x0F, 0x1E,
  0x01, 0xCE, 0x01, 0xE3, 0xC0, 0x71, 0xC0, 0x78, 0x78, 0x0E, 0x38, 0x0F,
  0x0F, 0x01, 0xC7, 0x01, 0xE1, 0xE0, 0x70, 0xE0, 0x78, 0x3C, 0x0E, 0x1C,
  0x0F, 0x07, 0x81, 0xC3, 0x81, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x1E, 0x0E,
  0x0E, 0x0F, 0x03, 0xC1, 0xC1, 0xC1, 0xE0, 0x78, 0x70, 0x38, 0x78, 0x0F,
  0x0E, 0x07, 0x0F, 0x01, 0xE1, 0xC0, 0xE1, 0xE0, 0x3C, 0x70, 0x1C, 0x78,
  0x07, 0x8E, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x71, 0xE0, 0x1E, 0x70, 0x0E,
  0x78, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0x79, 0xC0, 0x39, 0xE0, 0x0F, 0x70,
  0x07, 0x38, 0x01, 0xEE, 0x00, 0xEF, 0x00, 0x3D, 0xC0, 0x1D, 0xE0, 0x07,
  0xF0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0D, 0xE0, 0x3E, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x3B,
  0xE0, 0x1F, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0xE3, 0xC0, 0x07, 0xFF, 0xC3,
  0xC0, 0x01, 0xFF, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x10,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x0F, 0x1F, 0xFF, 0x00, 0x0F,
  0x3F, 0x1F, 0x80, 0x0F, 0x3C, 0x0F, 0xC0, 0x1F, 0x7C, 0x07, 0xC0, 0x1E,
  0x78, 0x03, 0xE0, 0x1E, 0x78, 0x01, 0xF0, 0x3E, 0x78, 0x01, 0xF8, 0x7C,
  0xF8, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 15, 50, 41, 13, -50 },
  { 95, 22, 21, 41, 13, -50 },
  { 153, 39, 50, 41, 2, -50 },
  { 397, 34, 69, 41, 4, -59 },
  { 691, 46, 50, 41, -2, -50 },
  { 979, 36, 51, 41, 2, -50 },
  { 1209, 8, 21, 41, 20, -50 },
  { 1230, 27, 66, 41, 12, -57 },
  { 1453, 27, 66, 41, 3, -57 },
  { 1676, 35, 34, 41, 4, -41 },
  { 1825, 32, 31, 41, 5, -38 },
  { 1949, 17, 21, 41, 7, -10 },
  { 1994, 22, 4, 41, 10, -24 },
  { 2005, 11, 11, 41, 13, -10 },
  { 2021, 39, 63, 41, 2, -56 },
  { 2329, 34, 51, 41, 4, -50 },
  { 2546, 30, 50, 41, 4, -50 },
  { 2734, 35, 50, 41, 3, -50 },
  { 2953, 34, 51, 41, 4, -50 },
  { 3170, 31, 50, 41, 5, -50 },
  { 3364, 33, 51, 41, 5, -50 },
  { 3575, 32, 51, 41, 4, -50 },
  { 3779, 33, 50, 41, 8, -50 },
  { 3986, 34, 51, 41, 4, -50 },
  { 4203, 32, 50, 41, 7, -50 },
  { 4403, 15, 39, 41, 13, -38 },
  { 4477, 20, 49, 41, 8, -38 },
  { 4600, 32, 35, 41, 6, -40 },
  { 4740, 32, 19, 41, 5, -32 },
  { 4816, 32, 35, 41, 4, -40 },
  { 4956, 26, 50, 41, 11, -50 },
  { 5119, 40, 62, 41, 1, -50 },
  { 5429, 33, 50, 41, 1, -50 },
  { 5636, 34, 50, 41, 4, -50 },
  { 5849, 33, 51, 41, 5, -50 },
  { 6060, 33, 50, 41, 4, -50 },
  { 6267, 35, 50, 41, 5, -50 },
  { 6486, 37, 50, 41, 4, -50 },
  { 6718, 33, 51, 41, 5, -50 },
  { 6929, 35, 50, 41, 4, -50 },
  { 7148, 33, 50, 41, 5, -50 },
  { 7355, 36, 51, 41, 2, -50 },
  { 7585, 37, 50, 41, 4, -50 },
  { 7817, 29, 50, 41, 5, -50 },
  { 7999, 37, 50, 41, 3, -50 },
  { 8231, 35, 50, 41, 4, -50 },
  { 8450, 33, 51, 41, 5, -50 },
  { 8661, 36, 50, 41, 4, -50 },
  { 8886, 33, 62, 41, 5, -50 },
  { 9142, 35, 50, 41, 4, -50 },
  { 9361, 35, 51, 41, 4, -50 },
  { 9585, 34, 50, 41, 8, -50 },
  { 9798, 34, 51, 41, 5, -50 },
  { 10015, 33, 50, 41, 9, -50 },
  { 10222, 38, 50, 41, 5, -50 },
  { 10460, 42, 50, 41, 0, -50 },
  { 10723, 35, 50, 41, 8, -50 },
  { 10942, 36, 50, 41, 3, -50 },
  { 11167, 26, 63, 41, 10, -56 },
  { 11372, 19, 63, 41, 12, -56 },
  { 11522, 26, 63, 41, 6, -56 },
  { 11727, 28, 27, 41, 7, -50 },
  { 11822, 33, 4, 41, 0, 2 },
  { 11839, 11, 9, 41, 19, -53 },
  { 11852, 32, 39, 41, 5, -38 },
  { 12008, 32, 51, 41, 4, -50 },
  { 12212, 31, 39, 41, 5, -38 },
  { 12364, 34, 51, 41, 5, -50 },
  { 12581, 31, 39, 41, 5, -38 },
  { 12733, 44, 62, 41, -2, -50 },
  { 13074, 32, 50, 41, 5, -38 },
  { 13274, 32, 50, 41, 4, -50 },
  { 13474, 31, 52, 41, 3, -52 },
  { 13676, 35, 64, 41, 1, -52 },
  { 13956, 35, 50, 41, 4, -50 },
  { 14175, 28, 50, 41, 7, -50 },
  { 14350, 36, 38, 41, 2, -38 },
  { 14521, 32, 38, 41, 4, -38 },
  { 14673, 31, 39, 41, 5, -38 },
  { 14825, 34, 50, 41, 2, -38 },
  { 15038, 32, 50, 41, 5, -38 },
  { 15238, 32, 38, 41, 5, -38 },
  { 15390, 32, 39, 41, 4, -38 },
  { 15546, 31, 48, 41, 7, -48 },
  { 15732, 32, 38, 41, 5, -37 },
  { 15884, 31, 37, 41, 8, -37 },
  { 16028, 35, 37, 41, 6, -37 },
  { 16190, 36, 37, 41, 2, -37 },
  { 16357, 32, 49, 41, 5, -37 },
  { 16553, 32, 37, 41, 4, -37 },
  { 16701, 33, 63, 41, 7, -56 },
  { 16961, 15, 63, 41, 14, -56 },
  { 17080, 34, 63, 41, 2, -56 },
  { 17348, 32, 14, 41, 5, -31 },
};

const GFXfont JetBrainsMono_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC68PT7B_H_
