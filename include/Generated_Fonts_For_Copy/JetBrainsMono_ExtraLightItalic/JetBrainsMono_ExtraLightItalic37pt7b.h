#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC37PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x78, 0xF8, 0x78, 0x78, 0x77, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE7,
  0x0E, 0x60, 0xE6, 0x0E, 0xE0, 0xCE, 0x0C, 0xE0, 0xC0, 0x00, 0x30, 0x38,
  0x03, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xE0, 0x0E, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x00, 0x38, 0x18, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0,
  0xC0, 0x60, 0x06, 0x07, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x18, 0x1C,
  0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x30,
  0x18, 0x01, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x07, 0x00,
  0x70, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x3C, 0x9E, 0x0E, 0x31, 0xC1, 0x86, 0x1C, 0x30, 0xC3, 0x8E, 0x18,
  0x71, 0xC3, 0x00, 0x38, 0x40, 0x07, 0x08, 0x00, 0x73, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x04, 0xF0, 0x01, 0x8E,
  0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x9C, 0x18, 0x73, 0x82, 0x0C,
  0x70, 0xC3, 0x87, 0x18, 0x60, 0xF3, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x01, 0xF0, 0x01, 0x83, 0xFC, 0x01, 0x81, 0x87, 0x01, 0x81, 0x81, 0x81,
  0x80, 0xC0, 0xC1, 0x80, 0x60, 0xC1, 0xC0, 0x30, 0x61, 0xC0, 0x38, 0x30,
  0xC0, 0x1C, 0x18, 0xC0, 0x06, 0x18, 0xC0, 0x03, 0xFC, 0xC0, 0x00, 0xF8,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x63, 0xE0, 0x00, 0x67, 0xF8, 0x00, 0x63, 0x0E, 0x00, 0x63, 0x03, 0x00,
  0x71, 0x81, 0x80, 0x30, 0xC0, 0xC0, 0x30, 0x60, 0xC0, 0x30, 0x30, 0x60,
  0x30, 0x18, 0x30, 0x30, 0x0C, 0x38, 0x38, 0x07, 0xF8, 0x38, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0x83, 0x80, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xCC, 0x01,
  0x38, 0xE0, 0x63, 0x07, 0x0E, 0x70, 0x71, 0xC7, 0x03, 0x98, 0x60, 0x1B,
  0x86, 0x01, 0xF0, 0x60, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1F, 0x0E, 0x03,
  0xB0, 0x70, 0x73, 0x87, 0xFE, 0x18, 0x3F, 0x81, 0xC0, 0x77, 0x77, 0x6E,
  0xEE, 0xEC, 0xC0, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x18, 0x1F,
  0xE3, 0x1F, 0x7E, 0x6F, 0xE3, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x3B, 0x00, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0xF0, 0xE0, 0x1C, 0x1C, 0x0F,
  0x01, 0xC0, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE0,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7B, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07, 0x00, 0xE0, 0xC0, 0x0C,
  0x38, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x18,
  0xE0, 0x07, 0x1C, 0x20, 0xE3, 0x0F, 0x1C, 0x61, 0xE3, 0x0C, 0x38, 0x63,
  0x80, 0x0C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x30, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x78, 0x1C, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xFC, 0x03,
  0x9C, 0x0F, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x10, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x1C, 0x0F, 0x07, 0x00, 0xE1, 0xC0, 0x0C, 0x30,
  0x01, 0xC6, 0x00, 0x39, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x83, 0x80,
  0x70, 0x78, 0x3C, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0xE0,
  0x70, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x38,
  0x03, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x3C, 0x03, 0x3F, 0xC0, 0xDD, 0xF8, 0x3C, 0x0E,
  0x0E, 0x01, 0xC7, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x80,
  0x70, 0xF0, 0x38, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0xF0,
  0xE0, 0x38, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x19, 0x80, 0x1C, 0xE0, 0x1C, 0x78,
  0x1C, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x6E, 0x00, 0x76, 0x00, 0x33, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1C, 0x0F, 0x07,
  0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x0E, 0x0C,
  0x01, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x03, 0xCE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x01, 0xCF, 0x00, 0xF0, 0x70, 0x38, 0x07, 0x06, 0x00, 0x61, 0xC0,
  0x0C, 0x30, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x80,
  0x70, 0x78, 0x1E, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0x03, 0xC7, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0xE3, 0x80, 0xF1, 0xFF, 0xB0, 0x3F, 0xB0, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1F, 0x1F, 0x3F, 0x1F,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xFC, 0xFC, 0xF8, 0xF8, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0x80, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x0F, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0x01, 0xF0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0xE0, 0x3C, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00,
  0xE3, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x79, 0xCC, 0x0F, 0xEC, 0x60,
  0xE0, 0xE3, 0x06, 0x07, 0x18, 0x30, 0x39, 0xC3, 0x81, 0xCE, 0x18, 0x0E,
  0x60, 0xC0, 0x63, 0x06, 0x03, 0x18, 0x30, 0x18, 0xC1, 0x80, 0xCE, 0x1C,
  0x0E, 0x70, 0xE0, 0x73, 0x83, 0x87, 0x18, 0x1F, 0xD8, 0xC0, 0x7C, 0xC6,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03,
  0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0xC0,
  0x70, 0xE0, 0x30, 0x70, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x0E, 0x03,
  0x07, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x63, 0x80, 0x39, 0x80, 0x1C, 0xC0,
  0x0E, 0xE0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x60, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x30, 0x1E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01,
  0x87, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0E,
  0x0C, 0x07, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x0E, 0x03, 0xC1, 0x80, 0x38,
  0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x70, 0x60, 0x3C, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x70, 0x0E,
  0x1C, 0x01, 0x86, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x04,
  0xE0, 0x06, 0x30, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0x70, 0x38, 0x1F,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xE0, 0xF8, 0x30,
  0x0E, 0x0C, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x01,
  0xC6, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00, 0x63,
  0x80, 0x38, 0xC0, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x31, 0xC0,
  0x0C, 0x70, 0x07, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x78,
  0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x83, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0,
  0x78, 0x70, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x0F, 0xF1, 0x83, 0xFC, 0x60, 0x03, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x06, 0x30, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x70,
  0x70, 0x38, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x61, 0xC0, 0x1C,
  0x38, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x87, 0x00, 0x30,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x00, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x18,
  0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x07, 0x07, 0x00,
  0xE0, 0x78, 0x1C, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x78,
  0x70, 0x03, 0x83, 0x80, 0x38, 0x18, 0x03, 0x80, 0xC0, 0x1C, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xC0, 0x60, 0x06,
  0x07, 0x00, 0x30, 0x70, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xE0, 0xE0,
  0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0x80, 0xC0, 0x0C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xC0,
  0x60, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x00, 0xF0, 0xE0, 0x1E, 0x1B, 0x01, 0xE1, 0xB0, 0x3E, 0x1B, 0x03, 0x61,
  0xB0, 0x76, 0x1B, 0x06, 0xE1, 0x98, 0xEE, 0x39, 0x8C, 0xC3, 0x99, 0xCC,
  0x39, 0x98, 0xC3, 0x1B, 0x9C, 0x30, 0xB1, 0xC3, 0x0E, 0x1C, 0x30, 0xE1,
  0x87, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00,
  0x38, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x00, 0x0F, 0x00, 0x61, 0xE0, 0x1C,
  0x3C, 0x03, 0x87, 0x80, 0x70, 0xD8, 0x0C, 0x1B, 0x01, 0x87, 0x60, 0x30,
  0xEC, 0x06, 0x19, 0xC1, 0xC3, 0x18, 0x38, 0x63, 0x06, 0x0C, 0x60, 0xC3,
  0x8C, 0x18, 0x70, 0xC3, 0x0E, 0x18, 0xE1, 0x83, 0x1C, 0x30, 0x63, 0x06,
  0x0E, 0x61, 0xC0, 0xCC, 0x38, 0x19, 0x87, 0x03, 0x30, 0xC0, 0x7E, 0x18,
  0x07, 0xC3, 0x00, 0xF0, 0x60, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xC3, 0x80, 0x71, 0x80, 0x18, 0xC0,
  0x0C, 0xE0, 0x06, 0x70, 0x03, 0x30, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xEE,
  0x00, 0x67, 0x00, 0x33, 0x80, 0x19, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x07,
  0x70, 0x03, 0x38, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0xE6, 0x00, 0x73, 0x80,
  0x31, 0xC0, 0x38, 0x70, 0x38, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0E, 0x03, 0xE0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x18,
  0x00, 0xE1, 0x80, 0x1C, 0x38, 0x03, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xF0,
  0x78, 0x70, 0x0E, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x63, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x70,
  0x70, 0x38, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x38, 0x0F, 0x06, 0x00, 0x70, 0xC0, 0x0E, 0x18,
  0x00, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0x60,
  0x07, 0x0C, 0x01, 0xC3, 0x80, 0x78, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0x81,
  0x80, 0x30, 0x30, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x18, 0x18, 0x03, 0x83, 0x00, 0x70, 0x60, 0x06, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1C, 0x0F, 0x07,
  0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x01, 0xC3, 0x80,
  0x30, 0x78, 0x1E, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFA, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x07, 0x18,
  0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00,
  0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x71,
  0x80, 0x1C, 0x60, 0x07, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x70, 0x70, 0x38, 0x1F, 0xFC,
  0x01, 0xFC, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0C,
  0xE0, 0x07, 0x18, 0x01, 0x86, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x1C, 0x18,
  0x07, 0x06, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x1C, 0x1C, 0x07, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00,
  0x33, 0x80, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x70, 0x3B, 0x03, 0x81, 0x98, 0x14, 0x0C,
  0xC1, 0xE0, 0xE6, 0x0F, 0x06, 0x30, 0x58, 0x31, 0x86, 0xC1, 0x8C, 0x36,
  0x1C, 0x61, 0xB0, 0xC3, 0x09, 0x86, 0x18, 0xCC, 0x71, 0xC6, 0x63, 0x0E,
  0x23, 0x18, 0x73, 0x18, 0xC3, 0x98, 0xCE, 0x1C, 0xC6, 0x60, 0xC4, 0x33,
  0x06, 0x61, 0x98, 0x33, 0x0D, 0x81, 0x90, 0x6C, 0x0D, 0x83, 0x60, 0x6C,
  0x1F, 0x03, 0x40, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x2C, 0x07, 0x81, 0xC0,
  0x38, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x06, 0x00, 0x38, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x18, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x70, 0x00,
  0x61, 0xC0, 0x00, 0xE3, 0x00, 0x00, 0xCE, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xCE, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x70, 0x30, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x38, 0x01, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xEC,
  0x00, 0x19, 0xC0, 0x07, 0x38, 0x01, 0xC3, 0x00, 0x30, 0x70, 0x0E, 0x0E,
  0x03, 0x80, 0xC0, 0x60, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x30, 0xC0, 0x07,
  0x38, 0x00, 0xE6, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0xC0, 0x1D, 0x80,
  0x33, 0x00, 0xE7, 0x01, 0x86, 0x07, 0x0C, 0x1C, 0x18, 0x30, 0x38, 0xE0,
  0x31, 0x80, 0x67, 0x00, 0xFC, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xC3, 0x06, 0x1C, 0x01, 0xC0, 0x03, 0xFD, 0xC3, 0xEF, 0xE3, 0x81,
  0xF3, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x0C, 0xE0, 0x0E, 0x60, 0x07, 0x30,
  0x03, 0x98, 0x01, 0x8C, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x33, 0x80, 0x39,
  0x80, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x1C, 0x0B, 0x0F, 0xFD, 0x83, 0xF9,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC3, 0x80, 0x77, 0xF8, 0x1F, 0xDF, 0x06, 0x80, 0xE1,
  0xC0, 0x38, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38, 0xC0,
  0x0E, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x38, 0x78, 0x1C, 0x3B, 0xFE, 0x0E,
  0x7F, 0x00, 0x00, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0x80, 0xE3, 0x80,
  0x31, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x19, 0x80, 0x1C,
  0xE0, 0x0E, 0x70, 0x0E, 0x1C, 0x0E, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x1C, 0x18, 0x1F, 0xEE, 0x0F, 0xBF, 0x87, 0x03, 0xE3, 0x80, 0x70,
  0xC0, 0x1C, 0x70, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0x60,
  0x06, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x70, 0x70, 0x2C, 0x1F, 0xFB, 0x03, 0xF9, 0xC0,
  0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xBE, 0x1C, 0x07, 0x38, 0x07, 0x30, 0x03,
  0x70, 0x03, 0x70, 0x03, 0x60, 0x07, 0x7F, 0xFF, 0x7F, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x0E, 0xE0, 0x1C,
  0x70, 0x38, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xFD, 0xC3, 0xEF, 0xE3, 0x81, 0xF3, 0x80, 0x71, 0x80,
  0x39, 0xC0, 0x0C, 0xE0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x98, 0x01, 0x8C,
  0x00, 0xCE, 0x00, 0x67, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0x70, 0x3E,
  0x3F, 0xF6, 0x0F, 0xF3, 0x00, 0xC1, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC3, 0x80, 0x77, 0xF8, 0x1F, 0xDF, 0x06, 0x80, 0xE1, 0xC0,
  0x38, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x38, 0xC0, 0x0E,
  0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x70, 0x07, 0x1C,
  0x01, 0xC6, 0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x60, 0x1C, 0x0C, 0x07,
  0x01, 0x81, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xC1, 0xC0, 0x38, 0x18, 0x07, 0x03, 0x80, 0xE0, 0x30,
  0x18, 0x07, 0x03, 0x00, 0x60, 0x60, 0x0E, 0x0C, 0x00, 0xC3, 0x80, 0x1C,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xC1, 0xC1, 0xBF, 0x7E, 0x1A, 0x74, 0xE1,
  0xC3, 0x86, 0x18, 0x30, 0x61, 0x83, 0x06, 0x38, 0x30, 0x63, 0x83, 0x06,
  0x30, 0x70, 0xE3, 0x06, 0x0E, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x70, 0x60,
  0xC7, 0x06, 0x0C, 0x60, 0xE0, 0xC6, 0x0C, 0x1C, 0x60, 0xC1, 0xC6, 0x0C,
  0x18, 0xE0, 0xC1, 0x8E, 0x0C, 0x18, 0xC1, 0xC1, 0x80, 0x00, 0x38, 0x07,
  0x7F, 0x81, 0xFD, 0xF0, 0x68, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0x63, 0x80,
  0x18, 0xE0, 0x06, 0x38, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0C,
  0x30, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x18,
  0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07,
  0xFC, 0x0F, 0xBE, 0x1C, 0x07, 0x38, 0x07, 0x30, 0x03, 0x70, 0x03, 0x70,
  0x03, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x0E, 0xC0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x70, 0x38, 0x7F,
  0xF0, 0x1F, 0xC0, 0x00, 0x1C, 0x01, 0xDF, 0xE0, 0x3F, 0xBE, 0x06, 0x80,
  0xE0, 0xE0, 0x1C, 0x18, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x01,
  0xC3, 0x00, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xF0, 0x38,
  0x3B, 0xFE, 0x07, 0x3F, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xFD, 0xC3, 0xEF, 0xE3, 0x81, 0xF3, 0x80, 0x71, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xCE,
  0x00, 0x67, 0x00, 0x33, 0x80, 0x39, 0x80, 0x1C, 0xE0, 0x0C, 0x70, 0x0E,
  0x1C, 0x0B, 0x0F, 0xFD, 0x83, 0xF9, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x0C, 0xFF, 0x06, 0xE7, 0xC3, 0xC0, 0xF3, 0xC0, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x60, 0x07, 0x30, 0x03, 0x98, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC0,
  0xFC, 0xF8, 0x70, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x11, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0xE0, 0x07, 0x18, 0x01, 0xC7,
  0x00, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x07, 0xFF, 0xFD, 0xFF, 0xFE,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x38, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x63,
  0x00, 0x33, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x0E, 0x60, 0x07, 0x30, 0x03,
  0x98, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x18, 0xE0, 0x1C, 0x38, 0x1C, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xE0, 0x03,
  0xB0, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x61, 0xC0,
  0x70, 0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x1C, 0x07, 0x0C, 0x01,
  0x8E, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x78, 0x1C, 0x1F, 0x07, 0x83,
  0x60, 0xF0, 0x6C, 0x16, 0x1D, 0x86, 0xC3, 0x30, 0xD8, 0x66, 0x13, 0x1C,
  0xC6, 0x63, 0x18, 0xCC, 0x63, 0x11, 0x8C, 0x66, 0x33, 0x0C, 0xC2, 0x61,
  0x90, 0x4C, 0x36, 0x0B, 0x06, 0xC1, 0x60, 0xD0, 0x2C, 0x1E, 0x07, 0x03,
  0xC0, 0xE0, 0x70, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x30, 0x38, 0x03, 0x87, 0x00, 0x18, 0xE0, 0x01, 0xDC, 0x00, 0x0D,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0x98, 0x00, 0x71, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xE0, 0x1C, 0x06, 0x03,
  0x80, 0x70, 0x70, 0x03, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x98, 0x01, 0xCC,
  0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x80, 0x39, 0xC0, 0x1C, 0xC0, 0x0E,
  0x60, 0x06, 0x30, 0x03, 0x38, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x78, 0xE0, 0x78, 0x7F, 0xEC, 0x1F, 0xE6, 0x01, 0x87, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0x06, 0x06,
  0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x03, 0xC0, 0x00, 0xFC,
  0x00, 0x5F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x00, 0x0C, 0x01, 0x9F, 0x80, 0xDD, 0xE0, 0x6C, 0x38, 0x3C,
  0x0C, 0x3E, 0x07, 0xFB, 0x01, 0xF8, 0x00, 0x10,
};

const GFXglyph JetBrainsMono_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 27, 22, 7, -27 },
  { 28, 12, 11, 22, 7, -27 },
  { 45, 21, 27, 22, 1, -27 },
  { 116, 19, 37, 22, 2, -32 },
  { 204, 25, 27, 22, -1, -27 },
  { 289, 20, 27, 22, 1, -27 },
  { 357, 4, 11, 22, 11, -27 },
  { 363, 15, 36, 22, 6, -31 },
  { 431, 15, 36, 22, 2, -31 },
  { 499, 19, 19, 22, 2, -23 },
  { 545, 17, 17, 22, 3, -21 },
  { 582, 9, 12, 22, 4, -6 },
  { 596, 13, 2, 22, 5, -13 },
  { 600, 6, 5, 22, 7, -5 },
  { 604, 21, 35, 22, 1, -31 },
  { 696, 19, 27, 22, 2, -27 },
  { 761, 16, 27, 22, 2, -27 },
  { 815, 19, 27, 22, 2, -27 },
  { 880, 19, 27, 22, 2, -27 },
  { 945, 17, 27, 22, 3, -27 },
  { 1003, 18, 27, 22, 3, -27 },
  { 1064, 17, 27, 22, 2, -27 },
  { 1122, 17, 27, 22, 5, -27 },
  { 1180, 19, 27, 22, 2, -27 },
  { 1245, 17, 27, 22, 4, -27 },
  { 1303, 8, 21, 22, 7, -21 },
  { 1324, 11, 27, 22, 4, -21 },
  { 1362, 18, 19, 22, 3, -22 },
  { 1405, 17, 11, 22, 3, -18 },
  { 1429, 17, 19, 22, 2, -22 },
  { 1470, 14, 27, 22, 6, -27 },
  { 1518, 21, 34, 22, 1, -27 },
  { 1608, 17, 27, 22, 1, -27 },
  { 1666, 19, 27, 22, 2, -27 },
  { 1731, 18, 27, 22, 3, -27 },
  { 1792, 18, 27, 22, 2, -27 },
  { 1853, 19, 27, 22, 3, -27 },
  { 1918, 20, 27, 22, 2, -27 },
  { 1986, 18, 27, 22, 3, -27 },
  { 2047, 19, 27, 22, 2, -27 },
  { 2112, 18, 27, 22, 3, -27 },
  { 2173, 20, 27, 22, 1, -27 },
  { 2241, 21, 27, 22, 2, -27 },
  { 2312, 15, 27, 22, 3, -27 },
  { 2363, 20, 27, 22, 2, -27 },
  { 2431, 19, 27, 22, 2, -27 },
  { 2496, 17, 27, 22, 3, -27 },
  { 2554, 20, 27, 22, 2, -27 },
  { 2622, 18, 34, 22, 3, -27 },
  { 2699, 19, 27, 22, 2, -27 },
  { 2764, 19, 27, 22, 2, -27 },
  { 2829, 19, 27, 22, 4, -27 },
  { 2894, 18, 27, 22, 3, -27 },
  { 2955, 18, 27, 22, 5, -27 },
  { 3016, 21, 27, 22, 3, -27 },
  { 3087, 23, 27, 22, 0, -27 },
  { 3165, 19, 27, 22, 4, -27 },
  { 3230, 19, 27, 22, 2, -27 },
  { 3295, 14, 35, 22, 6, -31 },
  { 3357, 11, 35, 22, 6, -31 },
  { 3406, 15, 35, 22, 3, -31 },
  { 3472, 15, 14, 22, 4, -27 },
  { 3499, 18, 2, 22, 0, 1 },
  { 3504, 6, 5, 22, 10, -29 },
  { 3508, 17, 21, 22, 3, -21 },
  { 3553, 18, 27, 22, 2, -27 },
  { 3614, 17, 21, 22, 3, -21 },
  { 3659, 18, 27, 22, 3, -27 },
  { 3720, 16, 21, 22, 3, -21 },
  { 3762, 24, 34, 22, -1, -27 },
  { 3864, 17, 28, 22, 3, -21 },
  { 3924, 18, 27, 22, 2, -27 },
  { 3985, 17, 28, 22, 2, -28 },
  { 4045, 18, 35, 22, 1, -28 },
  { 4124, 19, 27, 22, 2, -27 },
  { 4189, 15, 27, 22, 4, -27 },
  { 4240, 20, 21, 22, 1, -21 },
  { 4293, 18, 21, 22, 2, -21 },
  { 4341, 16, 21, 22, 3, -21 },
  { 4383, 19, 28, 22, 1, -21 },
  { 4450, 17, 28, 22, 3, -21 },
  { 4510, 17, 21, 22, 3, -21 },
  { 4555, 18, 21, 22, 2, -21 },
  { 4603, 17, 26, 22, 4, -26 },
  { 4659, 17, 20, 22, 3, -20 },
  { 4702, 17, 20, 22, 4, -20 },
  { 4745, 19, 20, 22, 3, -20 },
  { 4793, 20, 20, 22, 1, -20 },
  { 4843, 17, 27, 22, 3, -20 },
  { 4901, 18, 20, 22, 2, -20 },
  { 4946, 18, 35, 22, 4, -31 },
  { 5025, 8, 35, 22, 8, -31 },
  { 5060, 18, 35, 22, 1, -31 },
  { 5139, 17, 8, 22, 3, -17 },
};

const GFXfont JetBrainsMono_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC37PT7B_H_
