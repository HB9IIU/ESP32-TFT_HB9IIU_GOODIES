#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC57PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFC, 0xCF, 0xC0, 0x0F, 0x8E, 0x1F,
  0x00, 0xF0, 0x70, 0x78, 0x0F, 0x03, 0x83, 0xC0, 0x78, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x3C, 0x06, 0x03, 0xC1, 0xE0, 0x70, 0x1E, 0x0F, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0xF8, 0x30, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x1F, 0x9C, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x07, 0x1F,
  0x80, 0x00, 0x38, 0x7C, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x60, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x0E, 0x01,
  0xC0, 0x78, 0x70, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0x1C, 0x1E, 0x03, 0x01,
  0xE0, 0xF0, 0x18, 0x1F, 0x07, 0xC1, 0xC0, 0xF0, 0x3E, 0x0E, 0x1F, 0x00,
  0xFC, 0x73, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1C, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0x80, 0x78,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x07, 0x80,
  0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x07, 0x03, 0xC0,
  0x01, 0xC0, 0x1C, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x0E, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0xE0, 0x00,
  0x07, 0xFF, 0xC7, 0x80, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x00, 0x0F, 0xE1,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x03, 0xC3, 0xFE, 0x00, 0x00, 0x0E, 0x1F, 0xFC, 0x00,
  0x00, 0x70, 0xF0, 0xF8, 0x00, 0x03, 0x87, 0x81, 0xE0, 0x00, 0x1C, 0x1C,
  0x03, 0x80, 0x00, 0xF0, 0xE0, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x07, 0x00, 0xE0,
  0x1E, 0x00, 0x38, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0xF1, 0xE0, 0xF0, 0x03, 0xCF, 0x01, 0xE0, 0x1E, 0x3C, 0x07,
  0x80, 0xF0, 0xE0, 0x0F, 0x03, 0x87, 0x80, 0x3E, 0x1E, 0x1E, 0x00, 0x78,
  0xF0, 0x78, 0x00, 0xF7, 0x81, 0xE0, 0x03, 0xDE, 0x07, 0x80, 0x07, 0xF0,
  0x1C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0xE0, 0x3C, 0x00, 0x3F, 0xC0, 0xF0, 0x01, 0xFF, 0x03, 0xE0,
  0x0F, 0x9E, 0x07, 0xC0, 0xFC, 0x7C, 0x1F, 0xFF, 0xC0, 0xF0, 0x3F, 0xFE,
  0x01, 0xE0, 0x7F, 0xE0, 0x07, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x3C, 0xF3,
  0xDF, 0x7D, 0xF7, 0x9E, 0x7B, 0xEF, 0xBC, 0xF3, 0xCF, 0x38, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x67, 0xE0, 0x38, 0x0F, 0xDF, 0xF0,
  0xE1, 0xFF, 0xFF, 0xE3, 0x1F, 0xFC, 0x7F, 0xED, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7,
  0xF8, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE1, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x0F,
  0x03, 0xC3, 0xC1, 0xF8, 0x3C, 0x3C, 0x1F, 0x83, 0xC3, 0xC1, 0xF8, 0x3C,
  0x38, 0x1F, 0x83, 0xC7, 0x80, 0xF0, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x03, 0xF3, 0xC0, 0x03, 0xE1, 0xE0,
  0x07, 0xE0, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x03,
  0xE0, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x78, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x7C, 0x00, 0x1C, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0x80,
  0x0F, 0x3F, 0xFC, 0x00, 0xEF, 0xFF, 0xE0, 0x1E, 0xF0, 0x3F, 0x01, 0xFC,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0xFF, 0x80,
  0x0F, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x1C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7C,
  0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0x1F, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x83, 0xFC,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFE, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xC0,
  0x18, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x20, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x18, 0x1C, 0x1C, 0x00, 0x7F, 0xCE, 0x0E,
  0x00, 0xFF, 0xE7, 0x07, 0x00, 0xFE, 0x7B, 0x87, 0x80, 0x78, 0x07, 0xC3,
  0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x01, 0xE0, 0xE0, 0x1C, 0x00, 0x70,
  0x70, 0x1E, 0x00, 0x78, 0x38, 0x0F, 0x00, 0x3C, 0x3C, 0x07, 0x80, 0x1E,
  0x1E, 0x03, 0x80, 0x0E, 0x0F, 0x01, 0xC0, 0x07, 0x07, 0x80, 0xE0, 0x03,
  0x83, 0x80, 0xF0, 0x03, 0xC1, 0xC0, 0x78, 0x01, 0xE0, 0xE0, 0x3C, 0x00,
  0xF0, 0xF0, 0x1E, 0x00, 0x78, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x80,
  0x3C, 0x1C, 0x03, 0xC0, 0x3E, 0x0E, 0x00, 0xF8, 0x77, 0x07, 0x00, 0x7F,
  0xF3, 0x87, 0x80, 0x1F, 0xF3, 0xC3, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x78,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3C, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0xFC, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x3F, 0x01, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE1,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x87,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0,
  0x3F, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xC0, 0x0F, 0xC0,
  0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x03, 0x80,
  0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x0F, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x20, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x7F,
  0xFC, 0x3C, 0x07, 0xFF, 0xC3, 0xC0, 0x7F, 0xFC, 0x3C, 0x0F, 0xFF, 0xC3,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0,
  0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1C, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38,
  0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x06,
  0xE0, 0x01, 0xF8, 0x1D, 0xC0, 0x03, 0xF0, 0x3B, 0x80, 0x0E, 0xE0, 0x77,
  0x00, 0x1D, 0xC0, 0xEE, 0x00, 0x77, 0x01, 0xDC, 0x00, 0xEE, 0x03, 0x9C,
  0x03, 0x9C, 0x07, 0x38, 0x07, 0x38, 0x1E, 0x70, 0x1C, 0xF0, 0x3C, 0xE0,
  0x79, 0xE0, 0x71, 0xC0, 0xE3, 0xC0, 0xE1, 0xC3, 0xC7, 0x01, 0xC3, 0x87,
  0x0E, 0x03, 0x87, 0x1E, 0x3C, 0x0F, 0x0E, 0x38, 0x78, 0x1E, 0x1C, 0x70,
  0xF0, 0x3C, 0x1D, 0xC1, 0xE0, 0x78, 0x3B, 0x83, 0x80, 0xE0, 0x7E, 0x07,
  0x01, 0xC0, 0xFC, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x38, 0x0F, 0x80, 0x01, 0xC0, 0x7C, 0x00, 0x1E, 0x07, 0xF0, 0x00,
  0xF0, 0x3F, 0x80, 0x07, 0x81, 0xFC, 0x00, 0x3C, 0x0E, 0xE0, 0x01, 0xE0,
  0x77, 0x80, 0x0E, 0x03, 0xBC, 0x00, 0x70, 0x3C, 0xE0, 0x07, 0x81, 0xE7,
  0x00, 0x3C, 0x0F, 0x38, 0x01, 0xE0, 0x79, 0xE0, 0x0F, 0x03, 0x87, 0x00,
  0x70, 0x1C, 0x38, 0x03, 0x80, 0xE1, 0xC0, 0x3C, 0x0F, 0x0F, 0x01, 0xE0,
  0x78, 0x78, 0x0F, 0x03, 0xC1, 0xC0, 0x78, 0x1E, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x0E, 0x0F, 0x03, 0xC0, 0x70,
  0x78, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0x1E, 0x1E, 0x07, 0x00, 0xF0, 0xE0,
  0x38, 0x03, 0x87, 0x03, 0xC0, 0x1C, 0x78, 0x1E, 0x00, 0xE3, 0xC0, 0xF0,
  0x07, 0x9E, 0x07, 0x80, 0x1C, 0xF0, 0x38, 0x00, 0xE7, 0x01, 0xC0, 0x07,
  0x38, 0x1E, 0x00, 0x3D, 0xC0, 0xF0, 0x01, 0xEE, 0x07, 0x80, 0x07, 0xF0,
  0x3C, 0x00, 0x3F, 0x81, 0xE0, 0x01, 0xF8, 0x0E, 0x00, 0x0F, 0xC0, 0x70,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x3F, 0x01, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3F, 0x00, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC1, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C,
  0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x3F, 0x01,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x37, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0,
  0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x38, 0x01, 0xE0, 0x07, 0x38, 0x03,
  0xE0, 0x0F, 0x38, 0x03, 0xE0, 0x0F, 0x38, 0x03, 0xE0, 0x0E, 0x38, 0x03,
  0x60, 0x1E, 0x38, 0x07, 0x60, 0x1E, 0x38, 0x07, 0x60, 0x1C, 0x38, 0x06,
  0x60, 0x1C, 0x38, 0x0E, 0x60, 0x3C, 0x38, 0x0E, 0x60, 0x3C, 0x38, 0x0C,
  0x60, 0x38, 0x38, 0x0C, 0x60, 0x38, 0x38, 0x1C, 0xE0, 0x78, 0x78, 0x1C,
  0xE0, 0x70, 0x78, 0x18, 0xE0, 0x70, 0x78, 0x38, 0xE0, 0xF0, 0x78, 0x38,
  0xE0, 0xF0, 0x78, 0x30, 0xE0, 0xE0, 0x78, 0x70, 0xE0, 0xE0, 0x78, 0x70,
  0xE1, 0xE0, 0x78, 0x70, 0xE1, 0xC0, 0x78, 0x60, 0xE1, 0xC0, 0x78, 0xE0,
  0xE1, 0xC0, 0x70, 0xE0, 0xE3, 0xC0, 0x70, 0xC0, 0xE3, 0x80, 0x71, 0xC0,
  0xE3, 0x80, 0x71, 0xC0, 0xE7, 0x80, 0x71, 0x80, 0xE7, 0x00, 0x71, 0x80,
  0xE7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x73, 0x80, 0xEF, 0x00, 0x73, 0x00,
  0xCE, 0x00, 0x77, 0x00, 0xCE, 0x00, 0x77, 0x00, 0xCE, 0x00, 0x76, 0x00,
  0xDE, 0x00, 0x7E, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0xDC, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x20, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x70, 0x01, 0xC0,
  0x70, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x0F, 0x00,
  0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xFE, 0x3C, 0x07, 0xFF, 0xE7, 0x81, 0xFC, 0x3E, 0xE0, 0x7C,
  0x01, 0xFC, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0xC1, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x7F, 0x03, 0xE0, 0x1D, 0xC0, 0x7F,
  0xFF, 0x78, 0x07, 0xFF, 0xCF, 0x00, 0x3F, 0xE1, 0xE0, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x07, 0xE0, 0x03, 0xC7, 0xFF, 0x00, 0x79, 0xFF, 0xF0, 0x0F, 0x78, 0x7F,
  0x01, 0xDC, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xFC, 0x00, 0x78, 0x1F, 0xE0, 0x3F,
  0x03, 0xDF, 0xFF, 0xC0, 0x71, 0xFF, 0xE0, 0x1E, 0x1F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x81, 0xE0, 0x07, 0xFF,
  0x1E, 0x01, 0xFF, 0xF9, 0xE0, 0x3F, 0x87, 0xDC, 0x07, 0xC0, 0x1F, 0xC0,
  0x78, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x1E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0x01, 0xDC, 0x03,
  0xFF, 0xFB, 0xC0, 0x1F, 0xFF, 0x3C, 0x00, 0x7F, 0xC3, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xE1, 0xFC, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x3C, 0x07, 0xFF,
  0xE7, 0x81, 0xFC, 0x3E, 0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0x83,
  0xC0, 0x01, 0xF0, 0x70, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x3F, 0x78, 0x0F, 0xFF,
  0xCF, 0x00, 0x7F, 0xE1, 0xC0, 0x03, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x07, 0xE0, 0x03, 0xC7, 0xFF, 0x00, 0x79, 0xFF, 0xF0, 0x0F, 0x78, 0x7F,
  0x01, 0xDC, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0,
  0x0E, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x70, 0x0F,
  0x80, 0x07, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C,
  0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0x03, 0xE0, 0x1C, 0xFE, 0x3F, 0xC0, 0xF7, 0xFC, 0xFF, 0x83,
  0xF1, 0xF6, 0x3E, 0x0E, 0x83, 0xD0, 0x78, 0x3C, 0x07, 0x80, 0xE0, 0xE0,
  0x1C, 0x03, 0x83, 0x80, 0x70, 0x0E, 0x1E, 0x01, 0xC0, 0x38, 0x78, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1C, 0x03, 0x80,
  0x78, 0x70, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x07, 0x0F, 0x00, 0xE0, 0x3C,
  0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC3, 0x80, 0x70, 0x0F, 0x0E,
  0x01, 0xC0, 0x38, 0x38, 0x07, 0x00, 0xE1, 0xE0, 0x1C, 0x03, 0x87, 0x80,
  0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0x78, 0x70, 0x0E, 0x01, 0xE1, 0xC0, 0x38,
  0x07, 0x87, 0x00, 0xE0, 0x1C, 0x3C, 0x03, 0x80, 0x70, 0xF0, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x38, 0x07, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0xF1, 0xFF, 0xC0, 0x1E, 0x7F, 0xFC, 0x03, 0xDE,
  0x1F, 0xC0, 0x77, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xF3,
  0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x38,
  0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3C, 0x7F, 0xF0, 0x03, 0xCF, 0xFF, 0x80, 0x3D,
  0xE1, 0xFC, 0x03, 0xB8, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xF0,
  0x01, 0xE0, 0x3F, 0xC0, 0x7E, 0x03, 0xDF, 0xFF, 0xC0, 0x38, 0xFF, 0xF0,
  0x07, 0x87, 0xFE, 0x00, 0x78, 0x04, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x3C, 0x07, 0xFF,
  0xE7, 0x01, 0xFC, 0x3E, 0xE0, 0x7C, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0x83,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x7F, 0x03, 0xE0, 0x1D, 0xC0, 0x7F, 0xFF, 0x78, 0x07, 0xFF, 0xCF, 0x00,
  0x3F, 0xE1, 0xE0, 0x00, 0x40, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xF1, 0xFF, 0xC0, 0x1E, 0x7F, 0xFC, 0x03,
  0xDE, 0x1F, 0xC0, 0x77, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F,
  0xF1, 0xFE, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x08, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xEE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7F,
  0x00, 0x78, 0x03, 0xF8, 0x03, 0xC0, 0x1D, 0xC0, 0x3E, 0x00, 0xEE, 0x01,
  0xF0, 0x0F, 0x70, 0x0D, 0xC0, 0x73, 0x80, 0xEE, 0x03, 0x9C, 0x07, 0x70,
  0x3C, 0xE0, 0x33, 0x81, 0xC7, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0xE0, 0xF1,
  0xC0, 0xC7, 0x07, 0x0E, 0x0E, 0x38, 0x38, 0x70, 0x71, 0xC3, 0xC3, 0x83,
  0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE0, 0xE1, 0xC3, 0x8F, 0x07, 0x0C, 0x1C,
  0x70, 0x38, 0xE0, 0xE3, 0x81, 0xC7, 0x07, 0x3C, 0x0E, 0x30, 0x39, 0xC0,
  0x73, 0x81, 0xCE, 0x03, 0x9C, 0x0E, 0xF0, 0x1C, 0xC0, 0x77, 0x00, 0xEE,
  0x03, 0xB8, 0x07, 0x70, 0x1D, 0xC0, 0x3B, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x3E,
  0x01, 0xDE, 0x07, 0xFF, 0xF3, 0xC0, 0x7F, 0xFC, 0x70, 0x03, 0xFF, 0x1E,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x1C, 0x7F, 0xE0, 0x03,
  0x9F, 0xFE, 0x00, 0xF3, 0xC3, 0xE0, 0x1E, 0xF0, 0x3E, 0x03, 0xDE, 0x03,
  0xC0, 0x73, 0x80, 0x3C, 0x1E, 0x70, 0x07, 0xFF, 0x9E, 0x00, 0x7F, 0xE3,
  0xC0, 0x03, 0xF8, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 12, 42, 34, 11, -42 },
  { 64, 18, 17, 34, 11, -42 },
  { 103, 33, 42, 34, 1, -42 },
  { 277, 29, 58, 34, 3, -50 },
  { 488, 38, 42, 34, -1, -42 },
  { 688, 30, 43, 34, 2, -42 },
  { 850, 6, 17, 34, 17, -42 },
  { 863, 23, 55, 34, 10, -48 },
  { 1022, 23, 55, 34, 3, -48 },
  { 1181, 30, 29, 34, 3, -35 },
  { 1290, 27, 26, 34, 4, -32 },
  { 1378, 14, 18, 34, 6, -9 },
  { 1410, 19, 4, 34, 8, -21 },
  { 1420, 10, 9, 34, 10, -8 },
  { 1432, 33, 53, 34, 1, -47 },
  { 1651, 28, 43, 34, 4, -42 },
  { 1802, 25, 42, 34, 3, -42 },
  { 1934, 29, 42, 34, 3, -42 },
  { 2087, 29, 43, 34, 3, -42 },
  { 2243, 26, 42, 34, 4, -42 },
  { 2380, 28, 43, 34, 4, -42 },
  { 2531, 27, 43, 34, 3, -42 },
  { 2677, 27, 42, 34, 7, -42 },
  { 2819, 29, 43, 34, 3, -42 },
  { 2975, 26, 42, 34, 6, -42 },
  { 3112, 14, 33, 34, 10, -32 },
  { 3170, 18, 41, 34, 6, -32 },
  { 3263, 27, 29, 34, 5, -33 },
  { 3361, 27, 16, 34, 4, -27 },
  { 3415, 27, 29, 34, 3, -33 },
  { 3513, 22, 42, 34, 9, -42 },
  { 3629, 33, 52, 34, 1, -42 },
  { 3844, 27, 42, 34, 1, -42 },
  { 3986, 29, 42, 34, 3, -42 },
  { 4139, 28, 43, 34, 4, -42 },
  { 4290, 28, 42, 34, 3, -42 },
  { 4437, 29, 42, 34, 4, -42 },
  { 4590, 30, 42, 34, 4, -42 },
  { 4748, 28, 43, 34, 4, -42 },
  { 4899, 29, 42, 34, 3, -42 },
  { 5052, 28, 42, 34, 4, -42 },
  { 5199, 30, 43, 34, 2, -42 },
  { 5361, 32, 42, 34, 3, -42 },
  { 5529, 24, 42, 34, 4, -42 },
  { 5655, 31, 42, 34, 2, -42 },
  { 5818, 29, 42, 34, 3, -42 },
  { 5971, 28, 43, 34, 4, -42 },
  { 6122, 31, 42, 34, 3, -42 },
  { 6285, 28, 52, 34, 4, -42 },
  { 6467, 30, 42, 34, 3, -42 },
  { 6625, 29, 43, 34, 3, -42 },
  { 6781, 28, 42, 34, 7, -42 },
  { 6928, 29, 43, 34, 4, -42 },
  { 7084, 27, 42, 34, 8, -42 },
  { 7226, 32, 42, 34, 4, -42 },
  { 7394, 35, 42, 34, 0, -42 },
  { 7578, 29, 42, 34, 7, -42 },
  { 7731, 30, 42, 34, 3, -42 },
  { 7889, 21, 53, 34, 9, -47 },
  { 8029, 16, 53, 34, 10, -47 },
  { 8135, 22, 53, 34, 5, -47 },
  { 8281, 24, 23, 34, 6, -42 },
  { 8350, 28, 4, 34, 0, 1 },
  { 8364, 9, 8, 34, 16, -45 },
  { 8373, 27, 33, 34, 4, -32 },
  { 8485, 27, 43, 34, 3, -42 },
  { 8631, 27, 33, 34, 4, -32 },
  { 8743, 28, 43, 34, 4, -42 },
  { 8894, 26, 33, 34, 4, -32 },
  { 9002, 37, 52, 34, -2, -42 },
  { 9243, 27, 42, 34, 4, -32 },
  { 9385, 27, 42, 34, 3, -42 },
  { 9527, 26, 44, 34, 3, -44 },
  { 9670, 29, 54, 34, 1, -44 },
  { 9866, 29, 42, 34, 4, -42 },
  { 10019, 23, 42, 34, 6, -42 },
  { 10140, 30, 32, 34, 2, -32 },
  { 10260, 27, 32, 34, 3, -32 },
  { 10368, 26, 33, 34, 4, -32 },
  { 10476, 28, 42, 34, 2, -32 },
  { 10623, 27, 42, 34, 4, -32 },
  { 10765, 27, 32, 34, 4, -32 },
  { 10873, 26, 33, 34, 4, -32 },
  { 10981, 26, 40, 34, 6, -40 },
  { 11111, 27, 32, 34, 4, -31 },
  { 11219, 27, 31, 34, 6, -31 },
  { 11324, 29, 31, 34, 5, -31 },
  { 11437, 31, 31, 34, 1, -31 },
  { 11558, 27, 41, 34, 4, -31 },
  { 11697, 27, 31, 34, 3, -31 },
  { 11802, 28, 53, 34, 6, -47 },
  { 11988, 12, 53, 34, 12, -47 },
  { 12068, 28, 53, 34, 2, -47 },
  { 12254, 27, 11, 34, 4, -26 },
};

const GFXfont JetBrainsMono_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC57PT7B_H_
