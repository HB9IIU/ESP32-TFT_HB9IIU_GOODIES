#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC61PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x83, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7C, 0x38, 0xFC, 0x00, 0xF8, 0x38, 0x7C, 0x01, 0xF0, 0x38, 0x3E,
  0x01, 0xE0, 0x70, 0x3E, 0x03, 0xE0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x01, 0xF8, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0x8F, 0xC0, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x03, 0x83, 0xE0,
  0x00, 0x03, 0x81, 0xF0, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0,
  0x78, 0x07, 0x00, 0xF0, 0x78, 0x07, 0x01, 0xE0, 0x78, 0x07, 0x01, 0xE0,
  0x78, 0x07, 0x03, 0xE0, 0x7C, 0x0E, 0x03, 0xC0, 0x7C, 0x0E, 0x07, 0xC0,
  0x3F, 0x0E, 0x1F, 0x80, 0x1F, 0xCE, 0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x70,
  0x01, 0xF9, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x70,
  0x00, 0x3C, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0x03,
  0xC0, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x70,
  0x00, 0x00, 0x7F, 0xFC, 0x38, 0x00, 0x00, 0x1F, 0xFE, 0x1E, 0x00, 0x00,
  0x03, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x87, 0xFF, 0x80, 0x00,
  0x03, 0xC3, 0xE1, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x3C, 0x00, 0x00, 0x70,
  0x70, 0x07, 0x00, 0x00, 0x3C, 0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x70, 0x00, 0x0F, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x07, 0x00,
  0x03, 0xC0, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC1, 0xF0,
  0x01, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x1E, 0x07, 0xC0, 0x1F,
  0x1F, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x0F, 0x07, 0x80, 0x3E, 0x0F,
  0x03, 0xC0, 0x0F, 0x07, 0x83, 0xE0, 0x07, 0xC7, 0x81, 0xE0, 0x01, 0xE7,
  0x80, 0xF0, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0x3C, 0x00, 0x0F,
  0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01,
  0xF8, 0x07, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x01, 0xFF, 0x01, 0xF0, 0x01,
  0xF7, 0x80, 0x7C, 0x01, 0xF1, 0xE0, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3C, 0x07, 0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x07, 0x80, 0x1D, 0xF0, 0x0F, 0x00, 0xFF, 0xFC,
  0x1C, 0x0F, 0xFF, 0xFE, 0x38, 0xFF, 0xE7, 0xFE, 0x73, 0xFF, 0x03, 0xFF,
  0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0x80, 0x01, 0xC0,
  0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x0F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFE, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0xE0, 0x3E, 0x1E, 0x07, 0xC0,
  0xF0, 0xF8, 0x3F, 0x03, 0xC3, 0xC0, 0xFE, 0x0F, 0x0F, 0x03, 0xF0, 0x3C,
  0x3C, 0x07, 0xC0, 0xF0, 0xF0, 0x0E, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFD, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x87, 0x80, 0x07,
  0xE0, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0E, 0x00, 0xF0,
  0x01, 0x80, 0x1E, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x87, 0xFC, 0x00, 0x3C, 0x7F, 0xFC, 0x00, 0xF3, 0xFF, 0xF8, 0x03,
  0xDF, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xFC, 0x00,
  0x3D, 0xFF, 0xF0, 0x07, 0xBF, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFE, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x78, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xEF, 0x00, 0x7F, 0xFE, 0xF0, 0x00, 0xFF, 0xCF, 0x00,
  0x00, 0x60, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x0C, 0x0F, 0x0F, 0x00, 0x1F, 0xF1, 0xC1, 0xE0, 0x07, 0xFF, 0x38,
  0x3C, 0x01, 0xFF, 0xF7, 0x07, 0x80, 0x7C, 0x06, 0xE0, 0xE0, 0x0F, 0x00,
  0x7C, 0x3C, 0x03, 0xC0, 0x0F, 0x87, 0x80, 0x78, 0x01, 0xE0, 0xF0, 0x0E,
  0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x78, 0x00, 0xF0, 0x70,
  0x0F, 0x00, 0x1E, 0x0E, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x3C, 0x00, 0x78,
  0x78, 0x07, 0x00, 0x0E, 0x0F, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x3C, 0x00,
  0x78, 0x3C, 0x07, 0x80, 0x0F, 0x07, 0x00, 0xF0, 0x01, 0xE1, 0xE0, 0x1E,
  0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x03, 0xE0, 0xF0,
  0x0F, 0x80, 0xDC, 0x1E, 0x00, 0xFF, 0xFB, 0x83, 0x80, 0x1F, 0xFE, 0xF0,
  0x70, 0x01, 0xFF, 0x9E, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x07,
  0xF0, 0x0F, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0x80,
  0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x47, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1F,
  0xE0, 0x0F, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x80,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0x80,
  0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFC, 0x3C, 0x07,
  0xFF, 0xE3, 0xC0, 0x3F, 0xFF, 0x1E, 0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x01,
  0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x07, 0xE0, 0x3B, 0x80, 0x07, 0x70, 0x1D, 0xC0, 0x03, 0xB8, 0x0E, 0xE0,
  0x03, 0xBC, 0x07, 0x70, 0x01, 0xDE, 0x07, 0xBC, 0x01, 0xCE, 0x03, 0xCE,
  0x00, 0xE7, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xE3, 0x80, 0x73, 0xC0, 0x71,
  0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x78, 0xF0, 0x3C, 0x38, 0x38, 0x78, 0x1E,
  0x1C, 0x3C, 0x38, 0x0F, 0x0E, 0x1C, 0x3C, 0x07, 0x87, 0x0E, 0x1E, 0x03,
  0xC3, 0x8E, 0x0F, 0x01, 0xC0, 0xE7, 0x07, 0x81, 0xE0, 0x77, 0x03, 0xC0,
  0xF0, 0x3B, 0x83, 0xC0, 0x78, 0x1F, 0x81, 0xE0, 0x3C, 0x0F, 0xC0, 0xF0,
  0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x3C, 0x0F,
  0xC0, 0x00, 0x70, 0x1F, 0xC0, 0x01, 0xE0, 0x3F, 0x80, 0x03, 0xC0, 0x77,
  0x00, 0x07, 0x80, 0xEE, 0x00, 0x0F, 0x03, 0xDE, 0x00, 0x1E, 0x07, 0xBC,
  0x00, 0x3C, 0x0F, 0x78, 0x00, 0xF0, 0x1E, 0x70, 0x01, 0xE0, 0x3C, 0xE0,
  0x03, 0xC0, 0x79, 0xE0, 0x07, 0x80, 0xE3, 0xC0, 0x0F, 0x03, 0xC3, 0x80,
  0x1E, 0x07, 0x87, 0x00, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0x1E, 0x1E, 0x01,
  0xE0, 0x3C, 0x3C, 0x03, 0xC0, 0x70, 0x38, 0x07, 0x81, 0xE0, 0x70, 0x0F,
  0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0xF0,
  0x1E, 0x03, 0x81, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x0F, 0x07, 0x81,
  0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0x1C, 0x3C, 0x07, 0x80, 0x38, 0x78, 0x0F,
  0x00, 0x78, 0xF0, 0x1E, 0x00, 0xF1, 0xE0, 0x38, 0x00, 0xE3, 0xC0, 0xF0,
  0x01, 0xC7, 0x81, 0xE0, 0x03, 0xCE, 0x03, 0xC0, 0x07, 0xBC, 0x07, 0x80,
  0x0F, 0x78, 0x0F, 0x00, 0x0E, 0xF0, 0x1C, 0x00, 0x1F, 0xE0, 0x78, 0x00,
  0x3F, 0xC0, 0xF0, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x00,
  0xFC, 0x07, 0x80, 0x01, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F,
  0x80, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x03, 0xFC, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x6F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x3F, 0x80, 0x78,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7E,
  0x03, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x03,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xDE, 0x00, 0x7C, 0x00, 0xF7, 0x80, 0x1F, 0x00, 0x39, 0xE0,
  0x07, 0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x9E, 0x00, 0xFC, 0x01, 0xE7,
  0x80, 0x37, 0x00, 0xF1, 0xE0, 0x1D, 0xC0, 0x3C, 0x78, 0x07, 0x70, 0x0F,
  0x1E, 0x01, 0xDC, 0x03, 0x87, 0x80, 0xE7, 0x01, 0xE1, 0xE0, 0x39, 0xC0,
  0x78, 0x78, 0x0E, 0x70, 0x1E, 0x1E, 0x03, 0x1C, 0x07, 0x07, 0x81, 0xC7,
  0x03, 0xC1, 0xE0, 0x71, 0xC0, 0xF0, 0x70, 0x1C, 0x70, 0x38, 0x1C, 0x0E,
  0x1C, 0x0E, 0x07, 0x03, 0x87, 0x07, 0x81, 0xC0, 0xE1, 0xC1, 0xE0, 0x70,
  0x30, 0x60, 0x70, 0x1C, 0x1C, 0x18, 0x3C, 0x07, 0x07, 0x06, 0x0F, 0x01,
  0xC1, 0x81, 0x83, 0x80, 0x70, 0xE0, 0x60, 0xE0, 0x3C, 0x38, 0x18, 0x78,
  0x0F, 0x0E, 0x06, 0x1E, 0x03, 0xC7, 0x01, 0x87, 0x00, 0xF1, 0xC0, 0x61,
  0xC0, 0x3C, 0x70, 0x38, 0xF0, 0x0F, 0x18, 0x0E, 0x38, 0x03, 0xCE, 0x03,
  0x8E, 0x00, 0xF3, 0x80, 0xE7, 0x80, 0x3C, 0xC0, 0x39, 0xE0, 0x0F, 0x70,
  0x0E, 0x70, 0x03, 0xDC, 0x03, 0x9C, 0x00, 0xF7, 0x00, 0xEF, 0x00, 0x39,
  0x80, 0x3B, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x03, 0xB8, 0x03, 0xB8, 0x00,
  0xEC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x0E, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0xF0, 0x78, 0x03, 0xFF, 0xE3, 0xC0, 0x3F, 0xFF, 0x9E, 0x03,
  0xF8, 0x7D, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xF8, 0x1E, 0x00,
  0x0F, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0x80, 0xFE, 0x03, 0xBC, 0x03, 0xFF, 0xFD, 0xE0, 0x0F, 0xFF, 0x8F, 0x00,
  0x3F, 0xF8, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3F,
  0xC0, 0x07, 0x8F, 0xFF, 0x00, 0x79, 0xFF, 0xF8, 0x0F, 0x3E, 0x3F, 0xC0,
  0xF7, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F,
  0xC0, 0x01, 0xF0, 0xF6, 0x00, 0x3E, 0x0F, 0x78, 0x0F, 0xC0, 0xF3, 0xFF,
  0xF8, 0x0F, 0x3F, 0xFF, 0x00, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x01, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0x83, 0xC0, 0x07, 0xFF, 0xC7, 0x80, 0x1F, 0xFF, 0xCF, 0x00, 0x7F, 0x0F,
  0xBE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x07,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xDE, 0x00, 0x7F, 0xFF,
  0xBC, 0x00, 0x7F, 0xFC, 0x78, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0xF0, 0x07, 0xFF, 0x8F, 0x01, 0xFF, 0xFC, 0xF0, 0x3F, 0x87, 0xDF,
  0x07, 0xE0, 0x0F, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x03, 0xF0, 0x1E, 0xF0,
  0x3F, 0xFF, 0xCF, 0x01, 0xFF, 0xF9, 0xE0, 0x07, 0xFE, 0x1E, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x3F, 0xC0, 0x07, 0x8F, 0xFF, 0x00, 0x79, 0xFF,
  0xF8, 0x0F, 0x3C, 0x1F, 0xC0, 0xF7, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0x8F, 0x81, 0xF8, 0x07, 0xBF,
  0xE3, 0xFC, 0x07, 0x7F, 0xE7, 0xFE, 0x07, 0x63, 0xEE, 0x3E, 0x0F, 0x81,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0x0E, 0x0F, 0x00, 0xE0, 0x1E, 0x0E, 0x00,
  0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01,
  0xE0, 0x1E, 0x1E, 0x01, 0xC0, 0x1C, 0x1E, 0x01, 0xC0, 0x3C, 0x1C, 0x01,
  0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x03,
  0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0x80, 0x38, 0x38, 0x03,
  0x80, 0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07,
  0x80, 0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x00, 0xF0, 0x70, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x00, 0xE0, 0x07, 0x83,
  0xFC, 0x00, 0x78, 0xFF, 0xF0, 0x07, 0x9F, 0xFF, 0x80, 0xF3, 0xC1, 0xFC,
  0x0F, 0x70, 0x07, 0xE0, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF8,
  0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0x00,
  0x07, 0x8F, 0xFF, 0x00, 0x1E, 0x7F, 0xFE, 0x00, 0xF3, 0xE1, 0xFC, 0x03,
  0xDC, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF6, 0x00, 0x3E,
  0x03, 0xDE, 0x03, 0xF0, 0x0F, 0x3F, 0xFF, 0x80, 0x3C, 0xFF, 0xFC, 0x00,
  0xF0, 0xFF, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x78, 0x03, 0xFF, 0xE3, 0xC0, 0x3F, 0xFF, 0x9E, 0x03, 0xF8, 0x7D, 0xE0,
  0x3F, 0x00, 0x7F, 0x03, 0xE0, 0x01, 0xF8, 0x1E, 0x00, 0x0F, 0xC1, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x80, 0xFE, 0x03,
  0xBC, 0x03, 0xFF, 0xF9, 0xE0, 0x0F, 0xFF, 0x8F, 0x00, 0x3F, 0xF0, 0x78,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x3C, 0x7F, 0xF8,
  0x01, 0xE7, 0xFF, 0xE0, 0x0E, 0x7C, 0x3F, 0x80, 0xF7, 0x00, 0x7E, 0x07,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x07,
  0xE0, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E,
  0x03, 0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x0E, 0xF0, 0x07, 0xC0,
  0x1E, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x1C, 0xF0, 0x0F, 0xC0,
  0x3C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x1D, 0xC0, 0x38, 0xF0, 0x1D, 0xC0,
  0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x38, 0xC0, 0x70, 0xF0, 0x38, 0xC0,
  0xF0, 0xF0, 0x38, 0xC0, 0xF0, 0xF0, 0x70, 0xC0, 0xE0, 0xF0, 0x70, 0xC1,
  0xE0, 0xF0, 0x70, 0xC1, 0xE0, 0xF0, 0xE0, 0xC1, 0xC0, 0xF0, 0xE0, 0xC3,
  0xC0, 0xF0, 0xE0, 0xC3, 0xC0, 0xF1, 0xC0, 0xC3, 0x80, 0xF1, 0xC0, 0xC3,
  0x80, 0xF1, 0xC0, 0xC7, 0x80, 0xF3, 0x80, 0xC7, 0x00, 0xF3, 0x80, 0xC7,
  0x00, 0xF3, 0x80, 0xCF, 0x00, 0xF7, 0x00, 0xCE, 0x00, 0xF7, 0x00, 0xCE,
  0x00, 0x77, 0x00, 0xDE, 0x00, 0x7E, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0xDC,
  0x00, 0x7E, 0x00, 0xDC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x3D, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x6F,
  0x03, 0xF0, 0x1D, 0xE0, 0x3F, 0xFF, 0xDE, 0x01, 0xFF, 0xF1, 0xE0, 0x07,
  0xFE, 0x1E, 0x00, 0x04, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x71, 0xFF, 0x80, 0x0F, 0x3F, 0xFC,
  0x00, 0xF7, 0xC3, 0xE0, 0x0F, 0x78, 0x1F, 0x00, 0xF7, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x81, 0xEF, 0x00, 0x7C, 0x3E, 0xF0, 0x03, 0xFF, 0xCF, 0x00,
  0x1F, 0xF8, 0xE0, 0x00, 0xFF, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 13, 45, 37, 12, -45 },
  { 75, 19, 19, 37, 12, -45 },
  { 121, 36, 45, 37, 1, -45 },
  { 324, 32, 62, 37, 3, -53 },
  { 572, 42, 45, 37, -2, -45 },
  { 809, 33, 46, 37, 2, -45 },
  { 999, 7, 19, 37, 18, -45 },
  { 1016, 25, 60, 37, 10, -52 },
  { 1204, 24, 60, 37, 3, -52 },
  { 1384, 31, 31, 37, 4, -37 },
  { 1505, 28, 28, 37, 5, -34 },
  { 1603, 14, 19, 37, 7, -9 },
  { 1637, 20, 4, 37, 9, -22 },
  { 1647, 10, 10, 37, 11, -9 },
  { 1660, 35, 58, 37, 2, -51 },
  { 1914, 30, 46, 37, 4, -45 },
  { 2087, 27, 45, 37, 3, -45 },
  { 2239, 31, 45, 37, 3, -45 },
  { 2414, 30, 46, 37, 4, -45 },
  { 2587, 27, 44, 37, 5, -44 },
  { 2736, 30, 46, 37, 4, -45 },
  { 2909, 28, 46, 37, 4, -45 },
  { 3070, 30, 45, 37, 7, -45 },
  { 3239, 31, 46, 37, 3, -45 },
  { 3418, 29, 45, 37, 6, -45 },
  { 3582, 14, 35, 37, 11, -34 },
  { 3644, 19, 44, 37, 7, -34 },
  { 3749, 28, 31, 37, 6, -36 },
  { 3858, 28, 18, 37, 5, -29 },
  { 3921, 29, 31, 37, 3, -36 },
  { 4034, 24, 45, 37, 10, -45 },
  { 4169, 35, 56, 37, 1, -45 },
  { 4414, 29, 45, 37, 1, -45 },
  { 4578, 30, 45, 37, 4, -45 },
  { 4747, 29, 46, 37, 5, -45 },
  { 4914, 30, 45, 37, 4, -45 },
  { 5083, 32, 45, 37, 4, -45 },
  { 5263, 32, 45, 37, 4, -45 },
  { 5443, 29, 46, 37, 5, -45 },
  { 5610, 31, 45, 37, 4, -45 },
  { 5785, 30, 45, 37, 4, -45 },
  { 5954, 32, 46, 37, 2, -45 },
  { 6138, 33, 45, 37, 4, -45 },
  { 6324, 25, 45, 37, 5, -45 },
  { 6465, 33, 45, 37, 3, -45 },
  { 6651, 31, 45, 37, 4, -45 },
  { 6826, 29, 46, 37, 5, -45 },
  { 6993, 32, 45, 37, 4, -45 },
  { 7173, 30, 56, 37, 4, -45 },
  { 7383, 31, 45, 37, 4, -45 },
  { 7558, 32, 46, 37, 3, -45 },
  { 7742, 30, 45, 37, 7, -45 },
  { 7911, 31, 46, 37, 4, -45 },
  { 8090, 29, 45, 37, 8, -45 },
  { 8254, 34, 45, 37, 5, -45 },
  { 8446, 37, 45, 37, 0, -45 },
  { 8655, 31, 45, 37, 7, -45 },
  { 8830, 32, 45, 37, 3, -45 },
  { 9010, 24, 58, 37, 9, -51 },
  { 9184, 17, 58, 37, 11, -51 },
  { 9308, 23, 58, 37, 6, -51 },
  { 9475, 26, 24, 37, 6, -45 },
  { 9553, 30, 3, 37, 0, 2 },
  { 9565, 9, 9, 37, 17, -48 },
  { 9576, 29, 35, 37, 4, -34 },
  { 9703, 28, 46, 37, 4, -45 },
  { 9864, 28, 35, 37, 5, -34 },
  { 9987, 31, 46, 37, 4, -45 },
  { 10166, 27, 35, 37, 5, -34 },
  { 10285, 39, 56, 37, -2, -45 },
  { 10558, 28, 45, 37, 5, -34 },
  { 10716, 28, 45, 37, 4, -45 },
  { 10874, 28, 47, 37, 3, -47 },
  { 11039, 31, 58, 37, 1, -47 },
  { 11264, 31, 45, 37, 4, -45 },
  { 11439, 24, 45, 37, 7, -45 },
  { 11574, 32, 34, 37, 2, -34 },
  { 11710, 28, 34, 37, 4, -34 },
  { 11829, 27, 35, 37, 5, -34 },
  { 11948, 30, 45, 37, 2, -34 },
  { 12117, 29, 45, 37, 4, -34 },
  { 12281, 29, 34, 37, 5, -34 },
  { 12405, 28, 35, 37, 4, -34 },
  { 12528, 28, 43, 37, 6, -43 },
  { 12679, 29, 35, 37, 4, -34 },
  { 12806, 28, 34, 37, 7, -34 },
  { 12925, 32, 34, 37, 5, -34 },
  { 13061, 33, 34, 37, 1, -34 },
  { 13202, 28, 45, 37, 5, -34 },
  { 13360, 30, 34, 37, 3, -34 },
  { 13488, 30, 58, 37, 6, -51 },
  { 13706, 13, 58, 37, 13, -51 },
  { 13801, 30, 58, 37, 2, -51 },
  { 14019, 28, 11, 37, 5, -27 },
};

const GFXfont JetBrainsMono_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC61PT7B_H_
