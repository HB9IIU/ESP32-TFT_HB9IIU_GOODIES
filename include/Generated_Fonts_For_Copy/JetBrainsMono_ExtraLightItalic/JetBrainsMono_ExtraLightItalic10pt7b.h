#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC10PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xB6, 0x80, 0x34, 0xA7, 0xD2, 0xF9, 0x49, 0x00, 0x21,
  0x1F, 0x5E, 0x18, 0xDA, 0xE2, 0x00, 0x77, 0x31, 0xC0, 0xC3, 0x4A, 0xA6,
  0x00, 0x39, 0x02, 0x19, 0x9A, 0x46, 0x80, 0xE0, 0x34, 0x88, 0x88, 0x88,
  0x40, 0x64, 0x92, 0x4A, 0x80, 0x25, 0x5C, 0xC9, 0x00, 0x22, 0xF4, 0x40,
  0x5A, 0xF0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x80, 0x74, 0x63,
  0x69, 0x4B, 0x80, 0x6A, 0x22, 0x22, 0xF0, 0x39, 0x10, 0x82, 0x11, 0x8F,
  0x80, 0x79, 0x18, 0x21, 0x4B, 0x80, 0x12, 0x49, 0x97, 0x10, 0x7C, 0x3D,
  0x21, 0x4B, 0x80, 0x34, 0x69, 0x99, 0xE0, 0xFC, 0x84, 0x42, 0x21, 0x00,
  0x74, 0x54, 0xC9, 0x4B, 0x80, 0x74, 0x63, 0xA2, 0x11, 0x00, 0x50, 0x20,
  0x24, 0x04, 0xA4, 0x0B, 0xA0, 0x83, 0x00, 0xF0, 0xF0, 0x86, 0x12, 0xC0,
  0xE1, 0x2C, 0x80, 0x80, 0x3D, 0x15, 0xE9, 0xA6, 0xA9, 0x20, 0x60, 0x11,
  0x4A, 0x97, 0xA6, 0x20, 0xF4, 0x65, 0xE9, 0x4B, 0x80, 0x74, 0x61, 0x08,
  0x4B, 0x80, 0xF4, 0x65, 0x29, 0x4B, 0x80, 0x7C, 0x21, 0xE8, 0x43, 0xC0,
  0xFC, 0x21, 0xE8, 0x42, 0x00, 0x74, 0x61, 0x69, 0x4B, 0x80, 0x8C, 0x65,
  0xE9, 0x4A, 0x40, 0x79, 0x08, 0x44, 0x23, 0xC0, 0x1C, 0x20, 0x82, 0x0A,
  0x27, 0x00, 0x8C, 0xA9, 0xCA, 0x4A, 0x40, 0x48, 0x88, 0x88, 0xF0, 0x65,
  0xB7, 0x56, 0x4A, 0x28, 0x80, 0x4E, 0x75, 0x6B, 0x5A, 0x40, 0x74, 0x65,
  0x29, 0x4B, 0x80, 0xFC, 0x63, 0xE8, 0x42, 0x00, 0x74, 0x65, 0x29, 0x4B,
  0x84, 0x20, 0xFC, 0x63, 0xEA, 0x4A, 0x40, 0x7C, 0x60, 0xC1, 0x4B, 0x80,
  0xF9, 0x08, 0x44, 0x21, 0x00, 0x8C, 0x65, 0x29, 0x4B, 0x80, 0x8C, 0x64,
  0xA6, 0x31, 0x00, 0xAD, 0x7B, 0xD9, 0x5A, 0x80, 0x64, 0xA3, 0x04, 0x31,
  0x28, 0x80, 0x8A, 0x94, 0xC4, 0x21, 0x00, 0x3C, 0x21, 0x08, 0x21, 0x0F,
  0x80, 0x6A, 0x49, 0x24, 0xC0, 0x92, 0x44, 0x92, 0x20, 0x71, 0x22, 0x22,
  0x22, 0xE0, 0x25, 0x59, 0xF8, 0xC0, 0x79, 0x99, 0x9F, 0x8A, 0xD9, 0x99,
  0xE0, 0x69, 0x88, 0x9E, 0x0B, 0x65, 0x29, 0x4B, 0xC0, 0x69, 0x9E, 0x9E,
  0x1C, 0x47, 0xC8, 0x20, 0x82, 0x08, 0xC0, 0x79, 0x99, 0x97, 0x1E, 0x8E,
  0x99, 0x99, 0x90, 0x10, 0x0C, 0xA1, 0x08, 0x9F, 0x08, 0x0E, 0x10, 0x88,
  0x42, 0x17, 0x00, 0x84, 0x65, 0x4E, 0x52, 0x40, 0xE4, 0x44, 0x44, 0x70,
  0x69, 0x55, 0x6A, 0xAA, 0xA0, 0xE9, 0x99, 0x99, 0x69, 0x99, 0x9E, 0x53,
  0x52, 0x94, 0xFA, 0x10, 0x79, 0x99, 0x9F, 0x12, 0xA6, 0xA3, 0x08, 0x40,
  0x69, 0x87, 0x1E, 0x27, 0xD0, 0x84, 0x21, 0xC0, 0x99, 0x99, 0x9E, 0x8C,
  0xA5, 0x46, 0x20, 0xAD, 0x7B, 0xEB, 0x50, 0x44, 0xA3, 0x0C, 0x53, 0x20,
  0x99, 0x99, 0x97, 0x1E, 0xF1, 0x24, 0x8F, 0x19, 0x08, 0x4C, 0x10, 0x88,
  0x30, 0x55, 0x6A, 0x80, 0x30, 0x84, 0x41, 0x90, 0x84, 0xC0, 0xF0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 7, 7, 6, 0, -7 },
  { 25, 6, 7, 6, 0, -7 },
  { 31, 1, 3, 6, 3, -7 },
  { 32, 4, 9, 6, 2, -8 },
  { 37, 3, 9, 6, 1, -8 },
  { 41, 5, 5, 6, 1, -6 },
  { 45, 4, 5, 6, 1, -6 },
  { 48, 2, 4, 6, 1, -2 },
  { 49, 4, 1, 6, 1, -4 },
  { 50, 1, 1, 6, 2, -1 },
  { 51, 6, 9, 6, 0, -8 },
  { 58, 5, 7, 6, 1, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 6, 7, 6, 0, -7 },
  { 73, 5, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 5, 7, 6, 1, -7 },
  { 87, 4, 7, 6, 1, -7 },
  { 91, 5, 7, 6, 1, -7 },
  { 96, 5, 7, 6, 1, -7 },
  { 101, 5, 7, 6, 1, -7 },
  { 106, 2, 6, 6, 2, -6 },
  { 108, 3, 8, 6, 1, -6 },
  { 111, 5, 5, 6, 1, -6 },
  { 115, 4, 3, 6, 1, -5 },
  { 117, 4, 5, 6, 1, -6 },
  { 120, 4, 7, 6, 2, -7 },
  { 124, 6, 9, 6, 0, -7 },
  { 131, 5, 7, 6, 0, -7 },
  { 136, 5, 7, 6, 1, -7 },
  { 141, 5, 7, 6, 1, -7 },
  { 146, 5, 7, 6, 1, -7 },
  { 151, 5, 7, 6, 1, -7 },
  { 156, 5, 7, 6, 1, -7 },
  { 161, 5, 7, 6, 1, -7 },
  { 166, 5, 7, 6, 1, -7 },
  { 171, 5, 7, 6, 1, -7 },
  { 176, 6, 7, 6, 0, -7 },
  { 182, 5, 7, 6, 1, -7 },
  { 187, 4, 7, 6, 1, -7 },
  { 191, 6, 7, 6, 0, -7 },
  { 197, 5, 7, 6, 1, -7 },
  { 202, 5, 7, 6, 1, -7 },
  { 207, 5, 7, 6, 1, -7 },
  { 212, 5, 9, 6, 1, -7 },
  { 218, 5, 7, 6, 1, -7 },
  { 223, 5, 7, 6, 1, -7 },
  { 228, 5, 7, 6, 1, -7 },
  { 233, 5, 7, 6, 1, -7 },
  { 238, 5, 7, 6, 1, -7 },
  { 243, 5, 7, 6, 1, -7 },
  { 248, 6, 7, 6, 0, -7 },
  { 254, 5, 7, 6, 1, -7 },
  { 259, 6, 7, 6, 0, -7 },
  { 265, 3, 9, 6, 2, -8 },
  { 269, 3, 9, 6, 2, -8 },
  { 273, 4, 9, 6, 1, -8 },
  { 278, 4, 4, 6, 1, -7 },
  { 280, 5, 1, 6, 0, 0 },
  { 281, 1, 2, 6, 3, -8 },
  { 282, 4, 6, 6, 1, -6 },
  { 285, 4, 7, 6, 1, -7 },
  { 289, 4, 6, 6, 1, -6 },
  { 292, 5, 7, 6, 1, -7 },
  { 297, 4, 6, 6, 1, -6 },
  { 300, 6, 9, 6, 0, -7 },
  { 307, 4, 8, 6, 1, -6 },
  { 311, 4, 7, 6, 1, -7 },
  { 315, 5, 8, 6, 0, -8 },
  { 320, 5, 10, 6, 0, -8 },
  { 327, 5, 7, 6, 1, -7 },
  { 332, 4, 7, 6, 1, -7 },
  { 336, 6, 6, 6, 0, -6 },
  { 341, 4, 6, 6, 1, -6 },
  { 344, 4, 6, 6, 1, -6 },
  { 347, 5, 8, 6, 0, -6 },
  { 352, 4, 8, 6, 1, -6 },
  { 356, 5, 6, 6, 1, -6 },
  { 360, 4, 6, 6, 1, -6 },
  { 363, 5, 7, 6, 1, -7 },
  { 368, 4, 6, 6, 1, -6 },
  { 371, 5, 6, 6, 1, -6 },
  { 375, 5, 6, 6, 1, -6 },
  { 379, 6, 6, 6, 0, -6 },
  { 384, 4, 8, 6, 1, -6 },
  { 388, 4, 6, 6, 1, -6 },
  { 391, 5, 9, 6, 1, -8 },
  { 397, 2, 9, 6, 2, -8 },
  { 400, 5, 9, 6, 0, -8 },
  { 406, 4, 1, 6, 1, -4 },
};

const GFXfont JetBrainsMono_ExtraLightItalic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC10PT7B_H_
