#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC27PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC0,
  0x00, 0x01, 0xCF, 0x1C, 0x61, 0xB1, 0xD8, 0xCC, 0x66, 0x32, 0x1B, 0x0D,
  0x84, 0x01, 0x86, 0x02, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x20, 0x80, 0xC3,
  0x0F, 0xFF, 0x86, 0x08, 0x0C, 0x30, 0x10, 0x60, 0x60, 0x80, 0xC3, 0x01,
  0x06, 0x1F, 0xFF, 0x0C, 0x30, 0x10, 0x60, 0x60, 0x80, 0xC3, 0x01, 0x06,
  0x06, 0x18, 0x00, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x7C, 0x07, 0xF8,
  0x32, 0x71, 0x88, 0xC6, 0x23, 0x18, 0x80, 0x62, 0x01, 0x98, 0x07, 0x60,
  0x0F, 0x80, 0x0F, 0x80, 0x17, 0x00, 0x4C, 0x03, 0x18, 0x0C, 0x66, 0x21,
  0x98, 0x8C, 0x62, 0x30, 0xEB, 0x81, 0xF8, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x07, 0x80, 0x61, 0xF8, 0x18, 0x61, 0x06, 0x0C, 0x21,
  0x81, 0x84, 0x60, 0x21, 0x88, 0x04, 0x32, 0x00, 0xCC, 0xC0, 0x0F, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x4F, 0x00, 0x13, 0xF0, 0x04, 0xC2,
  0x01, 0x98, 0x40, 0x62, 0x18, 0x18, 0x43, 0x06, 0x08, 0x60, 0x81, 0x98,
  0x60, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xC3, 0x86, 0x06, 0x18, 0x18,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x07, 0x70, 0xD8, 0xC2,
  0x41, 0x9B, 0x06, 0xCC, 0x0E, 0x30, 0x38, 0xC0, 0xE3, 0x06, 0xCE, 0x73,
  0x1F, 0x86, 0x6D, 0xFD, 0xB6, 0x00, 0x60, 0x38, 0x0E, 0x07, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0xE0, 0x78, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xE3, 0x3F, 0xEB, 0xE1, 0xFC, 0x01, 0x80, 0x0D, 0x00, 0x66, 0x03, 0x18,
  0x18, 0x30, 0x60, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x7F, 0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x1C, 0x63, 0x8C, 0x71, 0x86, 0x30, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x7F, 0x86, 0x0E, 0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x13, 0x39, 0x99, 0xCC, 0x84, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0C,
  0xC0, 0x66, 0x06, 0x1C, 0xF0, 0x7E, 0x00, 0x00, 0xE0, 0x1E, 0x07, 0x40,
  0xC4, 0x18, 0xC1, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x7F, 0xFF,
  0xFF, 0x03, 0xF0, 0x1F, 0xE0, 0xC1, 0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xFF, 0x3F, 0xFC,
  0x1F, 0xF8, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x07, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x98, 0x0C, 0xC0, 0x66, 0x06, 0x3C, 0xE0, 0x7E, 0x00, 0x00, 0x30, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x83,
  0x30, 0x36, 0x02, 0xC0, 0x6C, 0x06, 0xFF, 0xEF, 0xFE, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x1F, 0xF8, 0xFF, 0xC4, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0xF8, 0x2F, 0xE3, 0x83, 0x18, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0xC0, 0x66, 0x06, 0x1C, 0xE0, 0x7E, 0x00,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x37, 0xC3, 0xDE, 0x70, 0x76, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02,
  0xC0, 0x6C, 0x0C, 0x73, 0xC3, 0xF0, 0x7F, 0xFB, 0xFF, 0xD8, 0x06, 0xC0,
  0x6C, 0x03, 0x60, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x86, 0x0E, 0x60, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0xC6, 0x0C, 0x1C, 0xC0, 0x7C, 0x03, 0xE0, 0x61, 0x86, 0x06,
  0x60, 0x13, 0x00, 0xD8, 0x04, 0xC0, 0x66, 0x07, 0x1C, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xFE, 0x30, 0x76, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x6C, 0x06, 0x71, 0xC3, 0xEC, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0xF3, 0xCF, 0x00, 0x07, 0x0F, 0x0F, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x10,
  0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF,
  0xFC, 0x40, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x3E, 0x07,
  0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x70,
  0xF8, 0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x06, 0x06, 0x0C, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x10, 0x03, 0x30, 0x7B, 0x30, 0xCF, 0x31, 0x86, 0x31, 0x86,
  0x21, 0x06, 0x21, 0x06, 0x63, 0x06, 0x63, 0x06, 0x63, 0x04, 0x63, 0x0C,
  0x41, 0xF4, 0x40, 0x48, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x60, 0x1B,
  0x00, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x30, 0x81, 0x04, 0x18, 0x20,
  0x81, 0x8F, 0xFC, 0x60, 0x66, 0x03, 0x30, 0x19, 0x00, 0xD8, 0x07, 0xC0,
  0x10, 0x1F, 0x80, 0xFF, 0x8C, 0x0C, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0,
  0x44, 0x06, 0x60, 0x63, 0xFE, 0x1F, 0xF8, 0xC0, 0xC6, 0x03, 0x20, 0x1B,
  0x00, 0xD8, 0x06, 0xC0, 0x66, 0x07, 0x3F, 0xF1, 0xFE, 0x00, 0x03, 0xE0,
  0x7F, 0x86, 0x0E, 0x60, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x58, 0x04,
  0xC0, 0x67, 0x06, 0x1C, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xFF, 0x0C, 0x1C,
  0x60, 0x63, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x02, 0x60, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0x66, 0x03, 0x20, 0x13, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x0E,
  0x3F, 0xE1, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x11, 0xFF, 0x87, 0xFE, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0xFF, 0xC7, 0xFF, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x03, 0xE0, 0x7F, 0x86, 0x0E, 0x60, 0x33, 0x01, 0x98, 0x0C,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xFC, 0xC7, 0xE4, 0x03, 0x60,
  0x1B, 0x00, 0xD8, 0x04, 0xC0, 0x67, 0x06, 0x1C, 0xF0, 0x7E, 0x00, 0x18,
  0x08, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x44, 0x06,
  0x60, 0x33, 0xFF, 0x9F, 0xFC, 0xC0, 0x66, 0x02, 0x20, 0x33, 0x01, 0x98,
  0x0C, 0xC0, 0x66, 0x03, 0x30, 0x11, 0x01, 0x80, 0x1F, 0xF8, 0xFF, 0xC0,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x81,
  0x87, 0x3C, 0x0F, 0xC0, 0x18, 0x0C, 0x40, 0x33, 0x01, 0x8C, 0x0C, 0x30,
  0x30, 0xC1, 0x83, 0x0C, 0x08, 0x30, 0x61, 0x81, 0xFC, 0x07, 0xF0, 0x18,
  0x60, 0x61, 0x81, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x01, 0x8C,
  0x06, 0x20, 0x1C, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x38, 0x1C, 0x50,
  0x70, 0xA0, 0xA1, 0x43, 0x46, 0xC5, 0x8D, 0x9B, 0x19, 0x26, 0x32, 0xCC,
  0x65, 0x10, 0x8E, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x08, 0x40, 0x10, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x80, 0x18, 0x09, 0xC0,
  0xCF, 0x06, 0x78, 0x33, 0xC1, 0x9A, 0x0C, 0x90, 0x44, 0xC2, 0x66, 0x33,
  0x11, 0x98, 0x8C, 0xC6, 0x64, 0x32, 0x21, 0x93, 0x05, 0x98, 0x2C, 0xC1,
  0xE6, 0x0F, 0x30, 0x39, 0x01, 0x80, 0x03, 0xC0, 0x7F, 0x86, 0x0C, 0x60,
  0x33, 0x01, 0x98, 0x0C, 0x80, 0x6C, 0x02, 0x60, 0x33, 0x01, 0x98, 0x0C,
  0xC0, 0x64, 0x03, 0x60, 0x13, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x1C,
  0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7F, 0xC3, 0x01, 0x8C, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x00, 0xC8, 0x06, 0x60, 0x19, 0x81, 0xC7, 0xFE, 0x1F, 0xC0,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x07, 0xE0, 0x7F, 0x86, 0x0C, 0x60, 0x33, 0x01, 0x90, 0x0C,
  0x80, 0x6C, 0x02, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x03, 0x60,
  0x13, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x1C, 0xE0, 0x7E, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0xC0, 0x7F, 0xC3, 0x03,
  0x8C, 0x06, 0x30, 0x08, 0xC0, 0x23, 0x01, 0x88, 0x06, 0x60, 0x31, 0x83,
  0x87, 0xFC, 0x18, 0xC0, 0x61, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x30, 0xC0,
  0xC3, 0x03, 0x0C, 0x06, 0x20, 0x18, 0x03, 0xF0, 0x1F, 0xE0, 0xC1, 0xC6,
  0x03, 0x18, 0x0C, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x98, 0x06, 0x60, 0x31,
  0x80, 0xC7, 0x8E, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01,
  0x98, 0x0C, 0x80, 0x44, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66,
  0x03, 0x20, 0x13, 0x01, 0x98, 0x0C, 0xC0, 0x67, 0x06, 0x1C, 0xE0, 0x7E,
  0x00, 0x80, 0x1E, 0x01, 0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x60, 0x63, 0x03,
  0x18, 0x10, 0xC1, 0x82, 0x0C, 0x10, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x01,
  0x90, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x41, 0x86,
  0x83, 0x0D, 0x0E, 0x1A, 0x14, 0x24, 0x28, 0xC8, 0xD1, 0x91, 0x22, 0x22,
  0x44, 0x44, 0x99, 0x99, 0x33, 0x22, 0x46, 0x45, 0x8D, 0x8B, 0x1A, 0x36,
  0x34, 0x68, 0x68, 0xF0, 0xF1, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x00,
  0x0C, 0x03, 0x86, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x80, 0x61, 0x80, 0x18,
  0xC0, 0x0C, 0xC0, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x26, 0x00, 0x33, 0x00, 0x30, 0x80, 0x30, 0x60, 0x18, 0x30,
  0x18, 0x0C, 0x18, 0x06, 0x1C, 0x01, 0x80, 0xC0, 0x0D, 0x00, 0x66, 0x01,
  0x98, 0x0C, 0x20, 0x60, 0xC1, 0x83, 0x0C, 0x04, 0x60, 0x19, 0x80, 0x6C,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xC3, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0xF8, 0xFE,
  0x00, 0xC1, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x81,
  0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x0F,
  0xE0, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x83, 0xF0, 0xFE, 0x00, 0x03, 0x00,
  0xE0, 0x1E, 0x06, 0xC0, 0x88, 0x31, 0x0C, 0x31, 0x86, 0x60, 0x48, 0x0F,
  0x01, 0x80, 0xFF, 0xF8, 0xE1, 0x0C, 0x30, 0x0F, 0x98, 0xFE, 0x8C, 0x0C,
  0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xC8, 0x04, 0xC0, 0x66, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x0E, 0x39, 0xB0, 0xFB, 0x00, 0x18, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x7C, 0x2E, 0xE3, 0x03, 0x70, 0x36, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x34, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x6E, 0x0C, 0xF1,
  0x89, 0xF0, 0x0F, 0xC1, 0xFE, 0x30, 0x32, 0x03, 0x60, 0x36, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x06, 0xE0, 0xC7, 0x3C, 0x3F,
  0x00, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x87, 0xCC, 0x7F,
  0x46, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x02, 0x60, 0x33,
  0x01, 0x98, 0x0C, 0xC0, 0x66, 0x07, 0x1C, 0xD8, 0x7D, 0x80, 0x0F, 0xC1,
  0xCE, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x60, 0x37, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x06, 0xC0, 0xC7, 0x1C, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x3F, 0xFC, 0x10, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x98, 0xFE, 0x8C, 0x0C, 0x40,
  0x66, 0x03, 0x30, 0x19, 0x80, 0xC8, 0x04, 0x40, 0x66, 0x03, 0x30, 0x18,
  0xC1, 0xC7, 0xF6, 0x1F, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x1F,
  0xE0, 0xFC, 0x00, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x7C,
  0x3E, 0xE3, 0x03, 0x70, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x34, 0x02,
  0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x68, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x7F, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x73, 0x03, 0x08, 0x1C, 0x60, 0x61, 0x83, 0x06,
  0x18, 0x1F, 0xC0, 0x7E, 0x01, 0x8C, 0x04, 0x38, 0x30, 0x60, 0xC0, 0xC3,
  0x03, 0x0C, 0x06, 0x30, 0x18, 0xFE, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x7F, 0x8F, 0xF0, 0x37, 0x38, 0xEF,
  0x73, 0x18, 0xC8, 0x63, 0x61, 0x0D, 0x84, 0x36, 0x30, 0x98, 0xC6, 0x63,
  0x19, 0x0C, 0x64, 0x21, 0xB0, 0x86, 0xC2, 0x13, 0x18, 0x4C, 0x63, 0x00,
  0x37, 0xC3, 0xEE, 0x30, 0x37, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0x80, 0xC0, 0x0F,
  0xC1, 0xFE, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03, 0x60, 0x34, 0x03, 0xC0,
  0x2C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xC7, 0x38, 0x3F, 0x00, 0x1B, 0xE0,
  0xFB, 0x86, 0x06, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x20,
  0x13, 0x01, 0x98, 0x0C, 0xC0, 0x67, 0x06, 0x3C, 0x71, 0x3E, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0F, 0x98, 0xFE, 0x8C, 0x1C,
  0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xC8, 0x04, 0xC0, 0x66, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x0E, 0x39, 0xA0, 0xF9, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x33, 0xE1, 0xF7, 0x8E, 0x0C, 0x60, 0x33, 0x01,
  0x90, 0x09, 0x80, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x0F, 0xE1, 0xCF, 0x30, 0x36, 0x03, 0x60,
  0x06, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0xE0, 0x06, 0x00, 0x6C, 0x06, 0xC0,
  0x6E, 0x1C, 0x7F, 0x80, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x01, 0xFC, 0x1F, 0x80, 0x30, 0x19, 0x00,
  0x88, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x40, 0x26,
  0x03, 0x30, 0x19, 0x80, 0xCE, 0x0C, 0x39, 0xC0, 0xFC, 0x00, 0xC0, 0x3C,
  0x03, 0xC0, 0x64, 0x06, 0x60, 0xC6, 0x0C, 0x61, 0x86, 0x18, 0x21, 0x02,
  0x30, 0x32, 0x03, 0x60, 0x34, 0x03, 0xC0, 0x18, 0x00, 0xC3, 0x0F, 0x0C,
  0x3C, 0x30, 0xB1, 0x46, 0xC5, 0x1B, 0x14, 0x4C, 0x91, 0x32, 0x4C, 0xC9,
  0x23, 0x44, 0x8D, 0x16, 0x3C, 0x50, 0xE1, 0x43, 0x87, 0x0E, 0x18, 0x00,
  0x30, 0x0C, 0x60, 0x60, 0x83, 0x03, 0x18, 0x04, 0x60, 0x1B, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x80, 0x36, 0x01, 0x8C, 0x06, 0x30, 0x30, 0x61, 0x81,
  0x8C, 0x03, 0x00, 0x30, 0x19, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30,
  0x19, 0x80, 0x88, 0x04, 0xC0, 0x66, 0x03, 0x30, 0x18, 0xC1, 0xC7, 0xF6,
  0x1F, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x1F, 0xE1, 0xFC, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0xF8, 0x0E, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x81, 0xFC, 0x0F, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xF0, 0x07, 0x80, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31,
  0x8C, 0x42, 0x31, 0x8C, 0x63, 0x11, 0x8C, 0x63, 0x18, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0xF0, 0x1F, 0x81, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x1F,
  0x00, 0xF0, 0x00, 0x3C, 0x1B, 0x70, 0xF1, 0x85, 0x87, 0xEC, 0x1E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 20, 16, 5, -20 },
  { 16, 9, 8, 16, 5, -20 },
  { 25, 15, 20, 16, 1, -20 },
  { 63, 14, 27, 16, 1, -23 },
  { 111, 19, 20, 16, -1, -20 },
  { 159, 14, 20, 16, 1, -20 },
  { 194, 3, 8, 16, 8, -20 },
  { 197, 11, 26, 16, 5, -23 },
  { 233, 11, 26, 16, 1, -23 },
  { 269, 14, 13, 16, 2, -16 },
  { 292, 13, 12, 16, 2, -15 },
  { 312, 6, 8, 16, 3, -4 },
  { 318, 9, 2, 16, 4, -10 },
  { 321, 4, 4, 16, 5, -4 },
  { 323, 15, 25, 16, 1, -22 },
  { 370, 13, 20, 16, 2, -20 },
  { 403, 12, 20, 16, 1, -20 },
  { 433, 14, 20, 16, 1, -20 },
  { 468, 13, 20, 16, 2, -20 },
  { 501, 12, 20, 16, 2, -20 },
  { 531, 13, 20, 16, 2, -20 },
  { 564, 12, 20, 16, 2, -20 },
  { 594, 13, 20, 16, 3, -20 },
  { 627, 13, 20, 16, 2, -20 },
  { 660, 12, 20, 16, 3, -20 },
  { 690, 6, 15, 16, 5, -15 },
  { 702, 8, 19, 16, 3, -15 },
  { 721, 13, 14, 16, 2, -16 },
  { 744, 13, 8, 16, 2, -13 },
  { 757, 12, 14, 16, 2, -16 },
  { 778, 11, 20, 16, 4, -20 },
  { 806, 16, 25, 16, 0, -20 },
  { 856, 13, 20, 16, 0, -20 },
  { 889, 13, 20, 16, 2, -20 },
  { 922, 13, 20, 16, 2, -20 },
  { 955, 13, 20, 16, 2, -20 },
  { 988, 14, 20, 16, 2, -20 },
  { 1023, 14, 20, 16, 2, -20 },
  { 1058, 13, 20, 16, 2, -20 },
  { 1091, 13, 20, 16, 2, -20 },
  { 1124, 13, 20, 16, 2, -20 },
  { 1157, 14, 20, 16, 1, -20 },
  { 1192, 14, 20, 16, 2, -20 },
  { 1227, 11, 20, 16, 2, -20 },
  { 1255, 15, 20, 16, 1, -20 },
  { 1293, 13, 20, 16, 2, -20 },
  { 1326, 13, 20, 16, 2, -20 },
  { 1359, 14, 20, 16, 2, -20 },
  { 1394, 13, 25, 16, 2, -20 },
  { 1435, 14, 20, 16, 2, -20 },
  { 1470, 14, 20, 16, 1, -20 },
  { 1505, 14, 20, 16, 3, -20 },
  { 1540, 13, 20, 16, 2, -20 },
  { 1573, 13, 20, 16, 4, -20 },
  { 1606, 15, 20, 16, 2, -20 },
  { 1644, 17, 20, 16, 0, -20 },
  { 1687, 14, 20, 16, 3, -20 },
  { 1722, 14, 20, 16, 1, -20 },
  { 1757, 10, 25, 16, 4, -22 },
  { 1789, 7, 25, 16, 5, -22 },
  { 1811, 11, 25, 16, 2, -22 },
  { 1846, 11, 11, 16, 3, -20 },
  { 1862, 13, 1, 16, 0, 1 },
  { 1864, 5, 4, 16, 7, -21 },
  { 1867, 13, 15, 16, 2, -15 },
  { 1892, 12, 20, 16, 2, -20 },
  { 1922, 12, 15, 16, 2, -15 },
  { 1945, 13, 20, 16, 2, -20 },
  { 1978, 12, 15, 16, 2, -15 },
  { 2001, 18, 25, 16, -1, -20 },
  { 2058, 13, 20, 16, 2, -15 },
  { 2091, 12, 20, 16, 2, -20 },
  { 2121, 13, 21, 16, 1, -21 },
  { 2156, 14, 26, 16, 0, -21 },
  { 2202, 14, 20, 16, 2, -20 },
  { 2237, 11, 20, 16, 3, -20 },
  { 2265, 14, 15, 16, 1, -15 },
  { 2292, 12, 15, 16, 2, -15 },
  { 2315, 12, 15, 16, 2, -15 },
  { 2338, 13, 20, 16, 1, -15 },
  { 2371, 13, 20, 16, 2, -15 },
  { 2404, 13, 15, 16, 2, -15 },
  { 2429, 12, 15, 16, 2, -15 },
  { 2452, 12, 19, 16, 3, -19 },
  { 2481, 13, 15, 16, 2, -15 },
  { 2506, 12, 15, 16, 3, -15 },
  { 2529, 14, 15, 16, 2, -15 },
  { 2556, 14, 15, 16, 1, -15 },
  { 2583, 13, 20, 16, 2, -15 },
  { 2616, 13, 15, 16, 1, -15 },
  { 2641, 13, 25, 16, 3, -22 },
  { 2682, 5, 25, 16, 6, -22 },
  { 2698, 13, 25, 16, 1, -22 },
  { 2739, 13, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC27PT7B_H_
