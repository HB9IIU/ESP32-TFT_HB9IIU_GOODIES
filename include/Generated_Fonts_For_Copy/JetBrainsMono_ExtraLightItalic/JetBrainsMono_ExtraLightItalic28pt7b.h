#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC28PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC2, 0x08, 0x20, 0x84,
  0x00, 0x03, 0x8E, 0x38, 0x71, 0xB0, 0xD8, 0x6C, 0x36, 0x33, 0x19, 0x0D,
  0x86, 0x01, 0x86, 0x01, 0x06, 0x03, 0x04, 0x03, 0x0C, 0x02, 0x0C, 0x3F,
  0xFF, 0x3F, 0xFF, 0x0C, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x18, 0x30, 0x18,
  0x20, 0x10, 0x60, 0xFF, 0xFC, 0x30, 0x40, 0x20, 0xC0, 0x60, 0xC0, 0x61,
  0x80, 0x41, 0x80, 0xC1, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x07,
  0x00, 0x7F, 0x81, 0xCB, 0x83, 0x33, 0x0C, 0x63, 0x18, 0x86, 0x31, 0x00,
  0x62, 0x00, 0xE4, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x9C, 0x01,
  0x18, 0x02, 0x30, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x46, 0x0E, 0xB8,
  0x0F, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0xF8, 0x0C, 0x31, 0x83, 0x0C, 0x30, 0xC1, 0x84, 0x30, 0x30, 0x8C,
  0x04, 0x11, 0x00, 0xC6, 0x40, 0x1F, 0x98, 0x01, 0xC6, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x19, 0xF0, 0x02, 0x67, 0x00, 0x88, 0x60, 0x33, 0x0C,
  0x0C, 0x61, 0x83, 0x0C, 0x20, 0xC1, 0x8C, 0x10, 0x33, 0x8C, 0x03, 0xE0,
  0x01, 0xE0, 0x0F, 0xE0, 0x38, 0xE0, 0x60, 0xC1, 0x81, 0x83, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x18, 0x36, 0x38,
  0xCC, 0x33, 0x10, 0x3C, 0x60, 0x78, 0xC0, 0x61, 0x81, 0xE3, 0x06, 0xC7,
  0xB8, 0xC7, 0xE1, 0xC0, 0x6D, 0xB7, 0xB6, 0x00, 0x20, 0x1C, 0x0F, 0x03,
  0x80, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x38, 0x01, 0x00, 0x08, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x07,
  0x80, 0x60, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0xC3,
  0x07, 0xCC, 0xF7, 0xEF, 0x01, 0xE0, 0x05, 0x00, 0x36, 0x01, 0x98, 0x0C,
  0x30, 0x60, 0xE1, 0x81, 0x00, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x1E, 0x38, 0xE1, 0xC3, 0x0C, 0x18, 0x60, 0xFF, 0xFF,
  0xC0, 0x77, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0xC1,
  0xC3, 0x8E, 0x06, 0x30, 0x0C, 0xC0, 0x32, 0x01, 0x98, 0x06, 0x60, 0x19,
  0x8C, 0x66, 0x71, 0x98, 0xC6, 0x40, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x0C,
  0xC0, 0x33, 0x01, 0x8E, 0x0E, 0x1E, 0xF0, 0x3F, 0x00, 0x01, 0xE0, 0x1F,
  0x03, 0x98, 0x38, 0xC1, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x0F, 0xF0, 0x38, 0x70,
  0xC0, 0x61, 0x80, 0x66, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xE0,
  0x07, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x30, 0x18, 0xC0, 0x63, 0x03, 0x07, 0x3C, 0x0F, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x30,
  0xC1, 0x8C, 0x0C, 0xC0, 0x64, 0x03, 0x60, 0x1B, 0xFF, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0xFC, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0D, 0xF8, 0x2C, 0x71, 0xC0, 0xC6,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x30, 0x0C, 0xC0, 0x63,
  0x83, 0x87, 0xBC, 0x0F, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x37, 0xE1, 0xC3, 0x98, 0x0C, 0xC0,
  0x6C, 0x01, 0x60, 0x0B, 0x00, 0xD8, 0x06, 0xC0, 0x67, 0x03, 0x1E, 0xF0,
  0x7E, 0x00, 0x7F, 0xFD, 0x80, 0x36, 0x01, 0x98, 0x0C, 0xC0, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xC3, 0x86, 0x06, 0x30, 0x08, 0xC0, 0x63,
  0x01, 0x8C, 0x0C, 0x18, 0x70, 0x3F, 0x00, 0x78, 0x07, 0x70, 0x30, 0x61,
  0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x1E, 0xF0,
  0x3F, 0x80, 0x03, 0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x02, 0xC0, 0x36, 0x01, 0x98, 0x18, 0xFF, 0xC3, 0xEC, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x0C, 0x78, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0F, 0x3E, 0x78, 0x03, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x41, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x10, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xDF, 0xFE, 0x20, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x40,
  0x00, 0x3F, 0x80, 0x38, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xC3, 0xF0, 0x78, 0x08, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xC1, 0xC1,
  0x80, 0x60, 0xC0, 0x10, 0xC0, 0x08, 0x60, 0x04, 0x20, 0x22, 0x30, 0xFD,
  0x18, 0x61, 0x8C, 0x60, 0xC6, 0x30, 0x62, 0x18, 0x31, 0x0C, 0x11, 0x84,
  0x18, 0xC6, 0x0C, 0x63, 0x06, 0x30, 0xC7, 0x18, 0x7D, 0x88, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x04, 0x40,
  0x31, 0x00, 0xC4, 0x06, 0x18, 0x18, 0x60, 0x41, 0x83, 0x06, 0x0C, 0x18,
  0x7F, 0xE1, 0x81, 0x8C, 0x02, 0x30, 0x08, 0x80, 0x36, 0x00, 0xF8, 0x03,
  0x1F, 0xF0, 0x40, 0xE3, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01,
  0x88, 0x0C, 0x60, 0xE1, 0xFF, 0x06, 0x0E, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x03, 0x8F, 0xFC, 0x3F, 0xC0, 0x01,
  0xC0, 0x1F, 0xC1, 0xC3, 0x86, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x06, 0x1E, 0xF0, 0x3F, 0x80,
  0x1F, 0xE0, 0x83, 0x8C, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x64,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x00,
  0xD8, 0x0C, 0xC0, 0x66, 0x06, 0x3F, 0xE1, 0xFC, 0x00, 0x1F, 0xFC, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xF0, 0xFF, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x1F, 0xC1, 0xC3, 0x86, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0xFE, 0x63, 0xF9, 0x80, 0xC4, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x06, 0x1E, 0xF0, 0x3F, 0x80, 0x18,
  0x0C, 0x40, 0x33, 0x00, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x88,
  0x06, 0x60, 0x19, 0xFF, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC4,
  0x03, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x18, 0x1F, 0xFC,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFE, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x30,
  0x0C, 0x60, 0x18, 0xC0, 0x30, 0xC0, 0xC1, 0xEF, 0x01, 0xFC, 0x00, 0x18,
  0x0E, 0x20, 0x18, 0xC0, 0x61, 0x81, 0xC3, 0x03, 0x06, 0x0C, 0x0C, 0x38,
  0x18, 0x60, 0x61, 0x80, 0xFF, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x0C, 0x0C,
  0x18, 0x10, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x00, 0xC6, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x1C, 0x0E, 0x38, 0x14, 0x50,
  0x78, 0xB0, 0xB1, 0x63, 0x66, 0x44, 0x8C, 0x99, 0x19, 0x26, 0x33, 0xCC,
  0x67, 0x18, 0x86, 0x31, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0x80, 0x33, 0x00, 0x46, 0x01, 0x80, 0x1C, 0x0C, 0x70,
  0x33, 0xC0, 0xCD, 0x02, 0x34, 0x18, 0xD8, 0x63, 0x61, 0x89, 0x86, 0x62,
  0x19, 0x8C, 0x46, 0x33, 0x18, 0xCC, 0x61, 0x31, 0x04, 0xCC, 0x1B, 0x30,
  0x68, 0xC1, 0xA3, 0x03, 0x8C, 0x0E, 0x30, 0x38, 0x01, 0xC0, 0x3F, 0x87,
  0x0E, 0x30, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0x06, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x00, 0xD8, 0x06, 0xC0, 0x26,
  0x03, 0x18, 0x38, 0xF7, 0x83, 0xF0, 0x00, 0x1F, 0xF8, 0x20, 0x78, 0xC0,
  0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x10, 0x06, 0x60, 0x18,
  0xC1, 0xE1, 0xFF, 0x83, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x3F,
  0xC1, 0xC3, 0x86, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x88, 0x06, 0x60,
  0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x30,
  0x0C, 0xC0, 0x33, 0x01, 0x8E, 0x0E, 0x1E, 0xF0, 0x3F, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0xF0, 0x40, 0xE3, 0x01,
  0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x06, 0x60, 0x39, 0xFF,
  0xC7, 0xFC, 0x18, 0x60, 0x61, 0x81, 0x82, 0x04, 0x0C, 0x30, 0x30, 0xC0,
  0x63, 0x01, 0x8C, 0x06, 0x30, 0x1C, 0x00, 0xE0, 0x0F, 0xF0, 0x38, 0x70,
  0x60, 0x61, 0x80, 0x63, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0xC1, 0xEF, 0x01, 0xFC, 0x00, 0xFF, 0xFC,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0C, 0x40,
  0x33, 0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x88, 0x06, 0x60,
  0x19, 0x80, 0x46, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x30,
  0x08, 0xC0, 0x61, 0x83, 0x87, 0xBC, 0x0F, 0xC0, 0xC0, 0x1E, 0x01, 0xB0,
  0x0D, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x03, 0x08, 0x18, 0x61, 0x83, 0x0C,
  0x18, 0x40, 0xC6, 0x06, 0x30, 0x33, 0x01, 0x98, 0x0D, 0x80, 0x2C, 0x01,
  0x40, 0x0E, 0x00, 0x70, 0x00, 0x61, 0xC3, 0x61, 0x82, 0x61, 0x86, 0x43,
  0x86, 0x42, 0x84, 0x42, 0x84, 0x46, 0x8C, 0x44, 0x8C, 0x44, 0x88, 0x4C,
  0x98, 0x48, 0x98, 0xC8, 0x98, 0xC8, 0x90, 0xD8, 0xB0, 0xD0, 0xB0, 0xD0,
  0xA0, 0xF0, 0xA0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0x0C, 0x03, 0x83,
  0x01, 0x81, 0x81, 0x80, 0xC1, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x04, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x31, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x18, 0x18, 0x0C, 0x18,
  0x03, 0x1C, 0x01, 0x80, 0xC0, 0x0E, 0xC0, 0x31, 0x80, 0x61, 0x01, 0x83,
  0x06, 0x06, 0x0C, 0x04, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x16, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xE1, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x7E, 0x1F, 0xC0, 0xC0, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x03, 0x0F, 0xC4,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0xFC, 0x3F, 0x00, 0x03, 0x80, 0x78, 0x06, 0x80,
  0xCC, 0x08, 0xC1, 0x8C, 0x30, 0x43, 0x06, 0x60, 0x6C, 0x07, 0xFF, 0xFC,
  0xC6, 0x63, 0x03, 0x80, 0x7E, 0xC6, 0x1E, 0x60, 0x76, 0x03, 0xB0, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x70,
  0x71, 0xCF, 0x87, 0xCC, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x18,
  0x1B, 0xF0, 0xE1, 0xC6, 0x06, 0x70, 0x1B, 0x00, 0x98, 0x0C, 0xC0, 0x66,
  0x03, 0x30, 0x19, 0x00, 0xD8, 0x04, 0xC0, 0x67, 0x07, 0x3C, 0x71, 0xBF,
  0x00, 0x03, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x76, 0x01, 0xB0, 0x0D, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x6C, 0x06, 0x30, 0x31,
  0xEF, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x03, 0x98,
  0x3F, 0x61, 0x87, 0x8C, 0x0E, 0x60, 0x39, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x00, 0xCC, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x83, 0x87, 0x3E,
  0x0F, 0x98, 0x03, 0x80, 0x7F, 0x06, 0x0C, 0x60, 0x66, 0x01, 0x30, 0x09,
  0x80, 0xCF, 0xFE, 0x7F, 0xF2, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x06, 0x30,
  0x31, 0xC7, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0x00, 0x7E, 0xC6, 0x1E, 0x60, 0x76, 0x03, 0xB0, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x0C, 0xC0, 0xC6, 0x0E, 0x3F, 0xF0,
  0x79, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0xFF, 0x07, 0xF0, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x18, 0x1B, 0xF0, 0xE0, 0xC6,
  0x06, 0x70, 0x13, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x00,
  0xD8, 0x04, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xC0, 0x00, 0x40, 0x07,
  0x80, 0x38, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0xFF, 0x03, 0xF8, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x04, 0xC0, 0x63, 0x03,
  0x8C, 0x1C, 0x20, 0x61, 0x83, 0x06, 0x18, 0x1F, 0xC0, 0x7F, 0x01, 0x8C,
  0x04, 0x18, 0x30, 0x70, 0xC0, 0xC3, 0x03, 0x8C, 0x06, 0x30, 0x1C, 0xFE,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x07, 0x00,
  0x7F, 0x87, 0xF0, 0x03, 0x18, 0x7F, 0x78, 0xC7, 0x31, 0x8C, 0x22, 0x18,
  0x4C, 0x31, 0x98, 0x63, 0x30, 0x86, 0x61, 0x0C, 0xC6, 0x19, 0x0C, 0x22,
  0x18, 0xCC, 0x31, 0x98, 0x43, 0x30, 0x86, 0x63, 0x0C, 0x01, 0x81, 0xBF,
  0x0E, 0x0C, 0x60, 0x67, 0x01, 0x30, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x01, 0x90, 0x0D, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0x03,
  0x80, 0x7F, 0x06, 0x1C, 0x60, 0x66, 0x01, 0x30, 0x09, 0x80, 0xCC, 0x06,
  0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x30, 0x71, 0xCF, 0x07,
  0xE0, 0x00, 0xC0, 0x6F, 0xC1, 0xC1, 0x86, 0x06, 0x38, 0x0C, 0xC0, 0x23,
  0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x62, 0x01, 0x98, 0x04, 0x60, 0x31,
  0xC1, 0xC7, 0x8E, 0x1B, 0xF0, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x7E, 0xC6, 0x1E, 0x60, 0x76, 0x03, 0xB0, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x32, 0x01, 0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x70,
  0x71, 0xCF, 0x87, 0xCC, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x01, 0xC1, 0xBF, 0x8F, 0x0E, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0,
  0x6C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x0C, 0x60, 0x32, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x6C, 0x03,
  0x60, 0x33, 0xC7, 0x8F, 0xF0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x30, 0x19, 0x80, 0xC8, 0x06, 0xC0, 0x36, 0x01, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x40, 0x36, 0x01, 0xB0, 0x09, 0x80, 0xC6, 0x0E, 0x3D,
  0xE0, 0xFC, 0x00, 0xC0, 0x1A, 0x01, 0x90, 0x0C, 0xC0, 0xC6, 0x06, 0x30,
  0x61, 0x83, 0x04, 0x30, 0x31, 0x81, 0x98, 0x0C, 0xC0, 0x6C, 0x01, 0x60,
  0x0E, 0x00, 0x70, 0x00, 0xC3, 0x87, 0x87, 0x0B, 0x0E, 0x36, 0x3C, 0x6C,
  0x58, 0x98, 0xB3, 0x33, 0x66, 0x64, 0xC8, 0x49, 0xB0, 0xB3, 0x61, 0x46,
  0x82, 0x8F, 0x07, 0x1E, 0x0C, 0x18, 0x18, 0x30, 0x00, 0x38, 0x0E, 0x30,
  0x30, 0x30, 0xC0, 0x63, 0x80, 0x66, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x19, 0x80, 0x73, 0x00, 0xC3, 0x03, 0x06, 0x0C, 0x06, 0x30,
  0x0E, 0x00, 0x30, 0x19, 0x00, 0xD8, 0x06, 0xC0, 0x26, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x40, 0x36, 0x03, 0x38, 0x18, 0xC1, 0xC7, 0xF6, 0x0F,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x00, 0x7C, 0x03, 0x80, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFC, 0x03, 0xF0,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x0C, 0x31,
  0x86, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86,
  0x18, 0x63, 0x0C, 0x30, 0xC3, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x08, 0x0B, 0xF0, 0xD9, 0x87, 0x86, 0x3C, 0x1F,
  0x60, 0x70,
};

const GFXglyph JetBrainsMono_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 6, 20, 17, 6, -20 },
  { 16, 9, 8, 17, 5, -20 },
  { 25, 16, 20, 17, 1, -20 },
  { 65, 15, 28, 17, 1, -24 },
  { 118, 19, 21, 17, -1, -21 },
  { 168, 15, 21, 17, 1, -21 },
  { 208, 3, 8, 17, 8, -20 },
  { 211, 11, 28, 17, 5, -24 },
  { 250, 12, 28, 17, 1, -24 },
  { 292, 14, 14, 17, 2, -17 },
  { 317, 13, 13, 17, 2, -16 },
  { 339, 7, 8, 17, 3, -4 },
  { 346, 9, 2, 17, 4, -10 },
  { 349, 5, 4, 17, 5, -4 },
  { 352, 16, 26, 17, 1, -23 },
  { 404, 14, 21, 17, 2, -21 },
  { 441, 13, 20, 17, 1, -20 },
  { 474, 15, 21, 17, 1, -21 },
  { 514, 14, 20, 17, 2, -20 },
  { 549, 13, 20, 17, 2, -20 },
  { 582, 14, 20, 17, 2, -20 },
  { 617, 13, 20, 17, 2, -20 },
  { 650, 14, 20, 17, 3, -20 },
  { 685, 14, 21, 17, 2, -21 },
  { 722, 13, 21, 17, 3, -21 },
  { 757, 7, 16, 17, 5, -16 },
  { 771, 9, 20, 17, 3, -16 },
  { 794, 13, 14, 17, 3, -16 },
  { 817, 13, 8, 17, 2, -13 },
  { 830, 13, 14, 17, 2, -16 },
  { 853, 11, 20, 17, 4, -20 },
  { 881, 17, 26, 17, 0, -21 },
  { 937, 14, 20, 17, 0, -20 },
  { 972, 14, 20, 17, 2, -20 },
  { 1007, 14, 21, 17, 2, -21 },
  { 1044, 13, 20, 17, 2, -20 },
  { 1077, 14, 20, 17, 2, -20 },
  { 1112, 15, 20, 17, 2, -20 },
  { 1150, 14, 21, 17, 2, -21 },
  { 1187, 14, 20, 17, 2, -20 },
  { 1222, 14, 20, 17, 2, -20 },
  { 1257, 15, 20, 17, 1, -20 },
  { 1295, 15, 20, 17, 2, -20 },
  { 1333, 12, 20, 17, 2, -20 },
  { 1363, 15, 20, 17, 1, -20 },
  { 1401, 14, 20, 17, 2, -20 },
  { 1436, 13, 21, 17, 2, -21 },
  { 1471, 15, 20, 17, 2, -20 },
  { 1509, 14, 26, 17, 2, -21 },
  { 1555, 14, 20, 17, 2, -20 },
  { 1590, 15, 21, 17, 1, -21 },
  { 1630, 14, 20, 17, 3, -20 },
  { 1665, 14, 20, 17, 2, -20 },
  { 1700, 13, 20, 17, 4, -20 },
  { 1733, 16, 20, 17, 2, -20 },
  { 1773, 17, 20, 17, 0, -20 },
  { 1816, 15, 20, 17, 3, -20 },
  { 1854, 15, 20, 17, 1, -20 },
  { 1892, 11, 26, 17, 4, -23 },
  { 1928, 8, 26, 17, 5, -23 },
  { 1954, 10, 26, 17, 3, -23 },
  { 1987, 12, 10, 17, 3, -20 },
  { 2002, 14, 1, 17, 0, 1 },
  { 2004, 4, 4, 17, 8, -22 },
  { 2006, 13, 16, 17, 2, -16 },
  { 2032, 13, 20, 17, 2, -20 },
  { 2065, 13, 16, 17, 2, -16 },
  { 2091, 14, 20, 17, 2, -20 },
  { 2126, 13, 16, 17, 2, -16 },
  { 2152, 18, 25, 17, -1, -20 },
  { 2209, 13, 21, 17, 2, -16 },
  { 2244, 13, 20, 17, 2, -20 },
  { 2277, 13, 22, 17, 1, -22 },
  { 2313, 15, 27, 17, 0, -22 },
  { 2364, 14, 20, 17, 2, -20 },
  { 2399, 11, 20, 17, 3, -20 },
  { 2427, 15, 16, 17, 1, -16 },
  { 2457, 13, 16, 17, 2, -16 },
  { 2483, 13, 16, 17, 2, -16 },
  { 2509, 14, 21, 17, 1, -16 },
  { 2546, 13, 21, 17, 2, -16 },
  { 2581, 13, 16, 17, 2, -16 },
  { 2607, 13, 16, 17, 2, -16 },
  { 2633, 13, 20, 17, 3, -20 },
  { 2666, 13, 15, 17, 2, -15 },
  { 2691, 13, 15, 17, 3, -15 },
  { 2716, 15, 15, 17, 2, -15 },
  { 2745, 15, 15, 17, 1, -15 },
  { 2774, 13, 20, 17, 2, -15 },
  { 2807, 13, 15, 17, 2, -15 },
  { 2832, 14, 26, 17, 3, -23 },
  { 2878, 6, 26, 17, 6, -23 },
  { 2898, 14, 26, 17, 1, -23 },
  { 2944, 13, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC28PT7B_H_
