#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC43PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x0F, 0x87, 0xC3, 0xC0,
  0x38, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x01, 0x80, 0x07, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x30,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x18, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x80, 0x07, 0x01,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xC0,
  0x30, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x30, 0x0C, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xC6,
  0x78, 0x0E, 0x18, 0xF0, 0x70, 0xC1, 0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x1C,
  0x38, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0F, 0x1C, 0x00, 0x1C,
  0x60, 0x00, 0x7D, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0C, 0xF8, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0xC0,
  0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x71, 0xC1, 0x81, 0xC7, 0x06,
  0x06, 0x1C, 0x18, 0x38, 0x70, 0x61, 0xE1, 0xE1, 0x8F, 0x03, 0xE6, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x08, 0x0F, 0xE0, 0x01, 0x80, 0xFF, 0x80, 0x1C, 0x0E, 0x0E,
  0x01, 0xC0, 0x60, 0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x0C,
  0x01, 0xC0, 0xC0, 0xC0, 0x0C, 0x06, 0x0C, 0x00, 0x60, 0x30, 0xE0, 0x03,
  0x03, 0x8E, 0x00, 0x1C, 0x18, 0xE0, 0x00, 0xFF, 0xCE, 0x00, 0x03, 0xFC,
  0x60, 0x00, 0x07, 0x86, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x71, 0xFE, 0x00,
  0x03, 0x1C, 0x38, 0x00, 0x31, 0xC0, 0xC0, 0x03, 0x8C, 0x06, 0x00, 0x38,
  0x60, 0x30, 0x03, 0x83, 0x01, 0x80, 0x38, 0x38, 0x1C, 0x01, 0x81, 0xC0,
  0xE0, 0x18, 0x0E, 0x06, 0x01, 0x80, 0x70, 0x70, 0x1C, 0x03, 0xC7, 0x81,
  0xC0, 0x0F, 0xF8, 0x1C, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x70, 0x00, 0x78, 0x70, 0x1C, 0xE0,
  0xF0, 0x71, 0xC0, 0xE1, 0xC3, 0x01, 0xE3, 0x8E, 0x01, 0xCE, 0x1C, 0x01,
  0xF8, 0x38, 0x03, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x1F,
  0x03, 0x80, 0x7F, 0x07, 0x01, 0xEE, 0x0F, 0x0F, 0x8E, 0x0F, 0xFC, 0x1C,
  0x0F, 0xF0, 0x1C, 0x7B, 0x9C, 0xEF, 0x7B, 0xDC, 0xE7, 0x39, 0x8C, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x08, 0x06, 0x01, 0x3E, 0x0C, 0x1F,
  0xFF, 0x18, 0xFE, 0x7F, 0xA7, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x07,
  0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0x80,
  0x38, 0x01, 0x00, 0x20, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3C,
  0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE1, 0xC1, 0xCE,
  0x1F, 0x0E, 0x70, 0xF8, 0x73, 0x83, 0xC7, 0x1C, 0x08, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xE0, 0x07, 0x07, 0x80, 0x70,
  0x3F, 0x1F, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xF3, 0x80, 0x3C, 0x70, 0x1E, 0x0E, 0x03, 0x81,
  0xC0, 0x40, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x01,
  0xC1, 0xE0, 0x1E, 0x07, 0xC3, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x0C, 0x78, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x39,
  0xFE, 0x01, 0xFF, 0xFC, 0x0D, 0x81, 0xE0, 0xF8, 0x07, 0x87, 0x80, 0x1C,
  0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0xC1, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x7E,
  0x01, 0xDF, 0xF8, 0x1F, 0x87, 0xC3, 0xC0, 0x3C, 0x38, 0x01, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xF0, 0x03, 0x87,
  0x00, 0x70, 0x7C, 0x1E, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x80, 0xE0, 0x0F, 0x0F, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x3E, 0x00, 0xF0, 0x3C,
  0x07, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x70, 0x78, 0x03, 0xC0, 0xF8, 0x3E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x1E, 0x1E, 0x00,
  0xE1, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x01, 0xE7, 0x80, 0x3C, 0x3C, 0x07, 0xC3, 0xFF, 0xF8, 0x1F, 0xF7, 0x00,
  0x3C, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x83, 0xF1, 0xFC,
  0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC1, 0xF0, 0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x08,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x7C, 0xE1,
  0x80, 0xFF, 0x71, 0xC0, 0xF9, 0xF8, 0xE0, 0x70, 0x3C, 0x70, 0x70, 0x1C,
  0x38, 0x38, 0x0E, 0x1C, 0x1C, 0x07, 0x0C, 0x0C, 0x03, 0x8E, 0x06, 0x01,
  0xC7, 0x07, 0x00, 0xE3, 0x83, 0x80, 0x61, 0xC1, 0xC0, 0x30, 0xE0, 0xE0,
  0x38, 0x60, 0x70, 0x1C, 0x30, 0x38, 0x0E, 0x38, 0x1C, 0x0F, 0x1C, 0x0F,
  0xFB, 0x8E, 0x03, 0xF9, 0x87, 0x00, 0x30, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0D, 0x80, 0x01,
  0xD8, 0x00, 0x1D, 0x80, 0x01, 0x98, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0,
  0x1C, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x60, 0x0E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1C, 0x00,
  0x61, 0xC0, 0x06, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0x80, 0xFC, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x06, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x30, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x0F, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x38, 0x07, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1C, 0x60, 0x01,
  0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x80, 0x70, 0x1E,
  0x0F, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0x81, 0xF8, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x03,
  0x87, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x3C, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x70, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x3F, 0xF1, 0x81, 0xFF,
  0x1C, 0x1F, 0xF8, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x07, 0x07, 0x80, 0x70, 0x1E, 0x0F, 0x80, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x06, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x0C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81,
  0xC0, 0x07, 0x03, 0xC0, 0x1C, 0x03, 0xE0, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0x70, 0x03, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x78, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x80, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x78, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x60, 0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x1E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x6C, 0x03, 0xF0, 0xDC, 0x06, 0xC1, 0xB8, 0x1D,
  0x83, 0x30, 0x33, 0x06, 0x60, 0xEE, 0x1C, 0xC1, 0x9C, 0x39, 0xC7, 0x38,
  0x73, 0x8C, 0x60, 0xE3, 0x38, 0xC1, 0x86, 0x63, 0x83, 0x0D, 0xC7, 0x0E,
  0x1B, 0x0E, 0x1C, 0x3E, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x00, 0x60, 0xE0,
  0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x0E, 0x0F, 0x80, 0x38, 0x1F, 0x00, 0x70, 0x36, 0x00,
  0xE0, 0x6C, 0x01, 0xC0, 0xDC, 0x03, 0x83, 0xB8, 0x06, 0x07, 0x30, 0x1C,
  0x0E, 0x60, 0x38, 0x1C, 0xC0, 0x70, 0x31, 0xC0, 0xE0, 0x63, 0x81, 0xC1,
  0xC3, 0x03, 0x03, 0x86, 0x06, 0x07, 0x0E, 0x1C, 0x0E, 0x1C, 0x38, 0x1C,
  0x18, 0x70, 0x30, 0x30, 0xE0, 0xE0, 0x71, 0xC1, 0xC0, 0xE3, 0x03, 0x81,
  0xCE, 0x07, 0x01, 0x9C, 0x0E, 0x03, 0x38, 0x18, 0x07, 0x70, 0x30, 0x0E,
  0xE0, 0xE0, 0x0D, 0x81, 0xC0, 0x1B, 0x03, 0x80, 0x3E, 0x07, 0x00, 0x7C,
  0x0E, 0x00, 0xF8, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x38, 0x38,
  0x00, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01,
  0xC7, 0x00, 0x0E, 0x18, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x1E,
  0x0F, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xE0, 0x0F, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x30, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x03, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x3E,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x70, 0x07, 0x07, 0x00,
  0x38, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x86,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x0C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0C, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x70, 0x3E, 0x0F, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xE0, 0x1F, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x86, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x07, 0x83, 0x80, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xE0, 0xE0, 0x03, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x0F, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x3C, 0x1C, 0x00,
  0x70, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x78, 0x78, 0x03, 0xC0, 0xF8, 0x3E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x78,
  0x1E, 0x01, 0xC0, 0x3C, 0x1E, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x87, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x30, 0x38, 0x03, 0x03, 0x80, 0x38, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00,
  0x39, 0xC0, 0x01, 0xB8, 0x00, 0x1B, 0x80, 0x01, 0xB0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x1E, 0x03, 0x70, 0x1E, 0x07,
  0x70, 0x1E, 0x07, 0x70, 0x36, 0x06, 0x70, 0x36, 0x0E, 0x70, 0x36, 0x0E,
  0x70, 0x64, 0x0E, 0x70, 0x64, 0x0C, 0x70, 0x6C, 0x1C, 0x70, 0xCC, 0x1C,
  0x70, 0xCC, 0x18, 0x70, 0xCC, 0x18, 0x70, 0xCC, 0x38, 0x71, 0x8C, 0x38,
  0x71, 0x8C, 0x30, 0x61, 0x8C, 0x70, 0x63, 0x0C, 0x70, 0x63, 0x0C, 0x60,
  0x63, 0x0C, 0x60, 0x63, 0x0C, 0xE0, 0x66, 0x0C, 0xE0, 0x66, 0x0C, 0xC0,
  0x66, 0x0C, 0xC0, 0x6C, 0x0D, 0xC0, 0x6C, 0x0D, 0x80, 0x6C, 0x0D, 0x80,
  0x68, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x06,
  0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3D, 0x80,
  0x00, 0xE7, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x00,
  0xC0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xB8, 0x00,
  0xCE, 0x00, 0x71, 0x80, 0x38, 0x60, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC0,
  0xC0, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0x63, 0x80, 0x1F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0xE1,
  0xC1, 0xC1, 0xC3, 0xC0, 0x00, 0xFC, 0x70, 0x3F, 0xE7, 0x07, 0xEF, 0x70,
  0xE0, 0x1F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00,
  0x1C, 0x60, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x87, 0xC1, 0xF8, 0x3F,
  0xFB, 0x81, 0xFE, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC3, 0xF0,
  0x1C, 0xFF, 0x81, 0xDE, 0xFC, 0x1F, 0x01, 0xE1, 0xE0, 0x0E, 0x3C, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x38, 0xF0, 0x03, 0x8F,
  0x80, 0x70, 0xFC, 0x1E, 0x0E, 0xFF, 0xC0, 0xC7, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF0, 0x1E, 0x1E, 0x00, 0xE1, 0xC0,
  0x0E, 0x38, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38,
  0x78, 0x07, 0x03, 0xC1, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x3F, 0x1C, 0x03, 0xFE, 0x70, 0x1F,
  0xBD, 0xC0, 0xE0, 0x1F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x18, 0x00, 0x70, 0xE0, 0x03, 0xC1, 0x80, 0x0E, 0x07, 0x00, 0x78,
  0x1C, 0x03, 0xE0, 0x7C, 0x1F, 0x80, 0xFF, 0xEE, 0x01, 0xFE, 0x38, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xCF, 0xC0, 0xE0, 0x1E, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x01, 0xC7,
  0x00, 0x38, 0x70, 0x07, 0x03, 0xC1, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x70, 0x3F, 0xF7, 0x07, 0xEF, 0x70, 0xF0, 0x1F, 0x1C, 0x00,
  0xF1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x78, 0x05, 0x83,
  0xC1, 0xF8, 0x1F, 0xFB, 0x80, 0xFE, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC7, 0xF0, 0x1C, 0xFF, 0x81, 0xDE, 0x7C, 0x1F, 0x01, 0xE1,
  0xE0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00,
  0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xC0,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x0F, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x0E,
  0x07, 0x00, 0x70, 0x18, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0xF0, 0x0E,
  0x07, 0x80, 0x38, 0x3C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x0E, 0xF8, 0x78, 0x1B, 0xFB, 0xF8, 0x34, 0x74, 0x78, 0x70,
  0xF0, 0x71, 0xC0, 0xC0, 0xE3, 0x81, 0x81, 0xC7, 0x03, 0x03, 0x0E, 0x0E,
  0x06, 0x18, 0x1C, 0x1C, 0x30, 0x38, 0x38, 0xE0, 0x60, 0x71, 0xC0, 0xC0,
  0xE3, 0x81, 0x81, 0xC7, 0x07, 0x03, 0x0C, 0x0E, 0x06, 0x18, 0x1C, 0x1C,
  0x70, 0x30, 0x38, 0xE0, 0x60, 0x71, 0xC0, 0xC0, 0xE3, 0x83, 0x81, 0x87,
  0x07, 0x03, 0x0C, 0x0E, 0x0E, 0x18, 0x1C, 0x1C, 0x70, 0x30, 0x38, 0x1C,
  0x7F, 0x01, 0xCF, 0xF8, 0x1D, 0xE7, 0xC1, 0xF0, 0x1E, 0x1E, 0x00, 0xE3,
  0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8C, 0x00, 0x38, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xEF, 0xC0, 0xF0, 0x1E, 0x1C, 0x00, 0xE1,
  0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01,
  0xC7, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00,
  0x38, 0x70, 0x07, 0x03, 0xC1, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0x1F, 0xC0, 0x1C, 0xFF, 0x80, 0x77, 0xBF, 0x01, 0xF0, 0x1E, 0x07, 0x80,
  0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x3E, 0x01, 0xC0, 0xFC, 0x1E, 0x03,
  0xBF, 0xF0, 0x0C, 0x7F, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFC, 0x70, 0x3F, 0xE7, 0x07, 0xEF, 0x70, 0xF0,
  0x1F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x60, 0x01, 0xCE, 0x00, 0x3C,
  0xE0, 0x03, 0x87, 0x00, 0x78, 0x70, 0x0F, 0x87, 0xC1, 0xB8, 0x3F, 0xF3,
  0x81, 0xFE, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x0E,
  0x3F, 0x80, 0x77, 0xFE, 0x03, 0xF9, 0xF8, 0x1A, 0x01, 0xE1, 0xE0, 0x07,
  0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0,
  0x03, 0x8E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xC7, 0xE1, 0xE0, 0x0E,
  0x1C, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xF0, 0x03, 0x87, 0x80, 0xF0, 0x7F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x63, 0x80,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6,
  0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x78, 0x78, 0x0F, 0x03, 0xC1, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x1C, 0x60, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x70, 0x70, 0x07, 0x03, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x38,
  0x1C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x01, 0x87, 0x00, 0x18, 0x70, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x0D, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0x6C, 0x07,
  0x01, 0xB0, 0x3C, 0x0E, 0xC0, 0xF0, 0x33, 0x02, 0xC0, 0xCC, 0x1B, 0x07,
  0x30, 0x6C, 0x18, 0xC1, 0x30, 0x63, 0x0C, 0xC3, 0x8C, 0x33, 0x0C, 0x31,
  0x84, 0x30, 0xC6, 0x11, 0xC3, 0x18, 0x46, 0x0C, 0xC1, 0x18, 0x33, 0x04,
  0xE0, 0xCC, 0x13, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xF0, 0x36, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x3C,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x70, 0x00, 0x71, 0xC0, 0x00, 0x77,
  0x80, 0x00, 0xEE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00,
  0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x38, 0x00, 0x63, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x03, 0xC7, 0x00, 0x78, 0x78, 0x0F, 0x83, 0xC1, 0xB8, 0x3F, 0xFB,
  0x80, 0xFE, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x39, 0xFE, 0x01, 0x9E, 0x38, 0x0C,
  0xE0, 0xE0, 0xE6, 0x07, 0x87, 0x30, 0x1E, 0x73, 0x80, 0x7F, 0x1C, 0x01,
  0xF0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 9, 31, 26, 9, -31 },
  { 36, 14, 13, 26, 8, -31 },
  { 59, 25, 31, 26, 1, -31 },
  { 156, 22, 43, 26, 2, -37 },
  { 275, 29, 32, 26, -1, -32 },
  { 391, 23, 32, 26, 1, -32 },
  { 483, 5, 13, 26, 13, -31 },
  { 492, 18, 41, 26, 7, -36 },
  { 585, 17, 41, 26, 2, -36 },
  { 673, 23, 22, 26, 2, -26 },
  { 737, 20, 20, 26, 3, -24 },
  { 787, 10, 14, 26, 5, -7 },
  { 805, 14, 2, 26, 6, -15 },
  { 809, 7, 6, 26, 8, -6 },
  { 815, 25, 41, 26, 1, -36 },
  { 944, 21, 32, 26, 3, -32 },
  { 1028, 19, 31, 26, 2, -31 },
  { 1102, 22, 32, 26, 2, -32 },
  { 1190, 21, 31, 26, 3, -31 },
  { 1272, 20, 31, 26, 3, -31 },
  { 1350, 21, 31, 26, 3, -31 },
  { 1432, 20, 31, 26, 3, -31 },
  { 1510, 21, 31, 26, 5, -31 },
  { 1592, 22, 32, 26, 2, -32 },
  { 1680, 20, 32, 26, 4, -32 },
  { 1760, 10, 24, 26, 8, -24 },
  { 1790, 13, 31, 26, 5, -24 },
  { 1841, 20, 22, 26, 4, -25 },
  { 1896, 20, 12, 26, 3, -20 },
  { 1926, 21, 22, 26, 2, -25 },
  { 1984, 17, 31, 26, 7, -31 },
  { 2050, 25, 40, 26, 1, -32 },
  { 2175, 20, 31, 26, 1, -31 },
  { 2253, 21, 31, 26, 3, -31 },
  { 2335, 21, 32, 26, 3, -32 },
  { 2419, 21, 31, 26, 3, -31 },
  { 2501, 22, 31, 26, 3, -31 },
  { 2587, 23, 31, 26, 3, -31 },
  { 2677, 21, 32, 26, 3, -32 },
  { 2761, 21, 31, 26, 3, -31 },
  { 2843, 21, 31, 26, 3, -31 },
  { 2925, 23, 31, 26, 1, -31 },
  { 3015, 23, 31, 26, 3, -31 },
  { 3105, 18, 31, 26, 3, -31 },
  { 3175, 23, 31, 26, 2, -31 },
  { 3265, 23, 31, 26, 2, -31 },
  { 3355, 21, 32, 26, 3, -32 },
  { 3439, 22, 31, 26, 3, -31 },
  { 3525, 21, 40, 26, 3, -32 },
  { 3630, 22, 31, 26, 3, -31 },
  { 3716, 22, 32, 26, 2, -32 },
  { 3804, 21, 31, 26, 5, -31 },
  { 3886, 22, 31, 26, 3, -31 },
  { 3972, 20, 31, 26, 6, -31 },
  { 4050, 24, 31, 26, 3, -31 },
  { 4143, 26, 31, 26, 0, -31 },
  { 4244, 22, 31, 26, 5, -31 },
  { 4330, 23, 31, 26, 2, -31 },
  { 4420, 16, 41, 26, 7, -36 },
  { 4502, 12, 41, 26, 7, -36 },
  { 4564, 16, 41, 26, 4, -36 },
  { 4646, 18, 16, 26, 4, -31 },
  { 4682, 21, 3, 26, 0, 1 },
  { 4690, 7, 6, 26, 12, -34 },
  { 4696, 20, 24, 26, 3, -24 },
  { 4756, 20, 31, 26, 3, -31 },
  { 4834, 20, 24, 26, 3, -24 },
  { 4894, 22, 31, 26, 3, -31 },
  { 4980, 20, 24, 26, 3, -24 },
  { 5040, 27, 39, 26, -1, -31 },
  { 5172, 20, 32, 26, 3, -24 },
  { 5252, 20, 31, 26, 3, -31 },
  { 5330, 20, 33, 26, 2, -33 },
  { 5413, 22, 41, 26, 1, -33 },
  { 5526, 22, 31, 26, 3, -31 },
  { 5612, 17, 31, 26, 5, -31 },
  { 5678, 23, 24, 26, 1, -24 },
  { 5747, 20, 24, 26, 3, -24 },
  { 5807, 20, 24, 26, 3, -24 },
  { 5867, 22, 32, 26, 1, -24 },
  { 5955, 20, 32, 26, 3, -24 },
  { 6035, 21, 24, 26, 3, -24 },
  { 6098, 20, 24, 26, 3, -24 },
  { 6158, 20, 30, 26, 4, -30 },
  { 6233, 20, 24, 26, 3, -24 },
  { 6293, 20, 24, 26, 5, -24 },
  { 6353, 22, 24, 26, 4, -24 },
  { 6419, 23, 24, 26, 1, -24 },
  { 6488, 20, 32, 26, 3, -24 },
  { 6568, 21, 24, 26, 2, -24 },
  { 6631, 22, 41, 26, 4, -36 },
  { 6744, 9, 41, 26, 9, -36 },
  { 6791, 22, 41, 26, 1, -36 },
  { 6904, 21, 8, 26, 3, -19 },
};

const GFXfont JetBrainsMono_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC43PT7B_H_
