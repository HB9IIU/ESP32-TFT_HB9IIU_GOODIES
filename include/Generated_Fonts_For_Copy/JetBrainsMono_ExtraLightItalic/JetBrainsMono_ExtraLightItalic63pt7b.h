#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC63PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7,
  0x80, 0x78, 0x70, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xF9, 0xDF, 0xC0, 0x03, 0xF0, 0xE3, 0xF0, 0x03,
  0xE0, 0xE0, 0xF8, 0x01, 0xE0, 0x70, 0x3E, 0x01, 0xE0, 0x38, 0x1F, 0x00,
  0xF0, 0x1C, 0x07, 0x80, 0xF8, 0x0E, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x01, 0xF0, 0x38, 0x00,
  0x00, 0x7C, 0x38, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x0F, 0xEE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x77,
  0xF8, 0x00, 0x00, 0x38, 0xFE, 0x00, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x0E,
  0x0F, 0x80, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x0F, 0x00,
  0x70, 0x0F, 0x07, 0x80, 0x38, 0x0F, 0x83, 0xC0, 0x38, 0x07, 0x81, 0xE0,
  0x1C, 0x03, 0xC0, 0xF8, 0x0E, 0x03, 0xE0, 0x7C, 0x07, 0x03, 0xE0, 0x1F,
  0x03, 0x83, 0xE0, 0x0F, 0xC1, 0xC3, 0xF0, 0x03, 0xF9, 0xEF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x00, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xE1, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x0E,
  0x00, 0x00, 0x07, 0xFF, 0xC3, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x01, 0xE1,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0x87, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x3C, 0x01, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x38, 0x00, 0x03,
  0xC0, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC1, 0xF0, 0x01, 0xE1,
  0xE0, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xF0, 0x3E,
  0x0F, 0x00, 0x3E, 0x0F, 0x03, 0xC0, 0x0F, 0x87, 0x80, 0xF0, 0x01, 0xF3,
  0xE0, 0x7C, 0x00, 0x3C, 0xF0, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0x80, 0x01,
  0xFC, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x1E, 0x00, 0x3E, 0x78, 0x07, 0xC0, 0x1F, 0x0F, 0x01,
  0xFC, 0x1F, 0x83, 0xE0, 0x3F, 0xFF, 0xC0, 0x78, 0x07, 0xFF, 0xE0, 0x1F,
  0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0x70, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x30, 0x00, 0xF0, 0x01, 0x9F, 0x00, 0x70, 0x07, 0xDF,
  0xF0, 0x38, 0x1F, 0xEF, 0xFE, 0x1C, 0x3F, 0xFB, 0xFF, 0x8C, 0x7F, 0xF0,
  0x3F, 0xF6, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xF0, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xE0, 0x10, 0x07, 0xC3, 0xC0, 0xFC, 0x0F, 0x87, 0x81, 0xF8, 0x1E,
  0x1F, 0x07, 0xF0, 0x3C, 0x3E, 0x07, 0xE0, 0x78, 0x78, 0x0F, 0xC0, 0xF0,
  0xF0, 0x0F, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xCF, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0xC1, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x01, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x30, 0x01, 0xE0, 0x02, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x10, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x83, 0xFE, 0x00, 0x0F, 0x1F, 0xFF, 0x00, 0x1E, 0xFF, 0xFF, 0x00,
  0x7B, 0xFF, 0xFF, 0x00, 0xF7, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x20,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x7F, 0x00, 0x07, 0xDF,
  0xFE, 0x00, 0x7D, 0xFF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0x80, 0x3F,
  0x83, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBC, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3D, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x81, 0xFF, 0xBF,
  0xF8, 0x07, 0xFF, 0xF7, 0x80, 0x1F, 0xFF, 0x78, 0x00, 0x3F, 0xC7, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x06, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x80,
  0xF0, 0x78, 0x00, 0x7F, 0xC7, 0x83, 0xC0, 0x07, 0xFF, 0x38, 0x1E, 0x00,
  0x7F, 0xFD, 0xC0, 0xF0, 0x07, 0xC0, 0x6E, 0x07, 0x80, 0x7C, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x3C, 0x00, 0x7C, 0x1E, 0x01, 0xE0,
  0x03, 0xE0, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x3C, 0x00, 0x3C, 0x0E, 0x01, 0xE0, 0x01,
  0xE0, 0xF0, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x1E, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x78, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0x07, 0x81, 0xE0, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x06, 0xE0, 0x78,
  0x03, 0xFF, 0xEF, 0x03, 0xC0, 0x0F, 0xFF, 0x78, 0x1E, 0x00, 0x3F, 0xE3,
  0xC0, 0xF0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x1F, 0x80,
  0x78, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x03,
  0xFF, 0xF0, 0xF0, 0x0F, 0xFF, 0xC3, 0xC0, 0x7F, 0xFF, 0x1F, 0x01, 0xFF,
  0xFC, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x3B, 0x80, 0xEF, 0x00, 0x1E, 0xE0, 0x39, 0xC0, 0x07,
  0x78, 0x0E, 0x70, 0x03, 0xDE, 0x03, 0x9C, 0x00, 0xE7, 0x81, 0xE7, 0x00,
  0x79, 0xC0, 0x79, 0xE0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x8E,
  0x03, 0x8F, 0x01, 0xE3, 0x81, 0xE3, 0xC0, 0x78, 0xE0, 0x70, 0xF0, 0x3C,
  0x3C, 0x3C, 0x38, 0x0F, 0x0F, 0x0E, 0x1E, 0x03, 0xC1, 0xC7, 0x87, 0x80,
  0xF0, 0x71, 0xC1, 0xE0, 0x3C, 0x1C, 0xF0, 0x78, 0x0F, 0x07, 0x38, 0x1E,
  0x03, 0xC1, 0xFE, 0x0F, 0x81, 0xE0, 0x3F, 0x03, 0xC0, 0x78, 0x0F, 0xC0,
  0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1F, 0x03,
  0xF8, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x1E, 0x03,
  0xFC, 0x00, 0x1E, 0x03, 0xDC, 0x00, 0x1E, 0x03, 0x9C, 0x00, 0x1E, 0x07,
  0x9E, 0x00, 0x3C, 0x07, 0x9E, 0x00, 0x3C, 0x07, 0x9E, 0x00, 0x3C, 0x07,
  0x8E, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x3C, 0x0F,
  0x8F, 0x00, 0x78, 0x0F, 0x07, 0x00, 0x78, 0x0F, 0x07, 0x00, 0x78, 0x0F,
  0x07, 0x80, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x0F,
  0x03, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xC0, 0xF0, 0x1E,
  0x01, 0xE0, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x3C, 0x01, 0xE1, 0xE0, 0x3C,
  0x00, 0xE1, 0xE0, 0x3C, 0x00, 0xF1, 0xE0, 0x3C, 0x00, 0xF1, 0xE0, 0x3C,
  0x00, 0xF1, 0xE0, 0x7C, 0x00, 0x73, 0xC0, 0x78, 0x00, 0x73, 0xC0, 0x78,
  0x00, 0x7B, 0xC0, 0x78, 0x00, 0x7B, 0xC0, 0x78, 0x00, 0x7B, 0xC0, 0x78,
  0x00, 0x3B, 0xC0, 0x78, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x3F, 0x80, 0xF0,
  0x00, 0x3F, 0x80, 0xF0, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x0F, 0xE0,
  0x1E, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xE7, 0x00, 0x1F, 0x00, 0x3C, 0xE0,
  0x07, 0xE0, 0x07, 0x9C, 0x00, 0xFC, 0x01, 0xE7, 0x80, 0x1F, 0x80, 0x3C,
  0xF0, 0x07, 0x70, 0x07, 0x9E, 0x00, 0xEE, 0x00, 0xE3, 0xC0, 0x1D, 0xC0,
  0x3C, 0x78, 0x03, 0xB8, 0x07, 0x8F, 0x00, 0xE7, 0x00, 0xF1, 0xE0, 0x1C,
  0xE0, 0x3C, 0x3C, 0x03, 0x9C, 0x07, 0x87, 0x80, 0xE3, 0x80, 0xF0, 0xF0,
  0x1C, 0x70, 0x1C, 0x1E, 0x03, 0x8C, 0x07, 0x83, 0xC0, 0x61, 0x80, 0xF0,
  0x78, 0x1C, 0x30, 0x1E, 0x0F, 0x03, 0x86, 0x03, 0x81, 0xE0, 0x70, 0xC0,
  0xF0, 0x3C, 0x1C, 0x18, 0x1E, 0x07, 0x83, 0x87, 0x03, 0x80, 0xF0, 0x70,
  0xE0, 0xF0, 0x1E, 0x1C, 0x1C, 0x1E, 0x03, 0x83, 0x83, 0x83, 0xC0, 0x70,
  0x70, 0x70, 0x70, 0x0E, 0x0E, 0x0E, 0x1E, 0x01, 0xC3, 0x81, 0xC3, 0xC0,
  0x38, 0x70, 0x38, 0x70, 0x07, 0x0E, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0xE3,
  0xC0, 0x3C, 0x70, 0x1C, 0x78, 0x07, 0x8E, 0x03, 0x8E, 0x00, 0xF1, 0x80,
  0x73, 0xC0, 0x1E, 0x70, 0x0E, 0x78, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0x79,
  0xC0, 0x39, 0xC0, 0x0F, 0x70, 0x07, 0x78, 0x01, 0xEE, 0x00, 0xEF, 0x00,
  0x3D, 0xC0, 0x1D, 0xC0, 0x07, 0xB0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07,
  0xC0, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0x03, 0xE0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0xFF, 0xF0, 0xF0,
  0x0F, 0xFF, 0xF3, 0xC0, 0x7F, 0x87, 0xDF, 0x03, 0xF0, 0x07, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8,
  0x07, 0xE0, 0x3D, 0xE0, 0x1F, 0xFF, 0xE7, 0x80, 0x3F, 0xFF, 0x1E, 0x00,
  0x3F, 0xF0, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x07, 0xFC, 0x00, 0x78, 0xFF, 0xF8, 0x03, 0xCF, 0xFF, 0xE0, 0x1E, 0xF8,
  0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x0F, 0x60, 0x01, 0xF0, 0x7E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07,
  0xF8, 0x01, 0xF8, 0x3D, 0xF0, 0x3F, 0x81, 0xE7, 0xFF, 0xF8, 0x0F, 0x1F,
  0xFF, 0x00, 0x78, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8,
  0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x3F, 0xFC,
  0x3C, 0x00, 0xFF, 0xFF, 0x3C, 0x01, 0xFE, 0x1F, 0x7C, 0x03, 0xF0, 0x07,
  0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0xF7,
  0x80, 0x1F, 0xFF, 0xE7, 0x80, 0x0F, 0xFF, 0xC7, 0x80, 0x03, 0xFF, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x78, 0x03, 0xFF, 0xE3, 0xC0,
  0x7F, 0xFF, 0x9E, 0x07, 0xF8, 0x7D, 0xF0, 0x7E, 0x00, 0xFF, 0x03, 0xE0,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0xEF, 0x03, 0xF8, 0x1E,
  0xF8, 0x0F, 0xFF, 0xF7, 0x80, 0x3F, 0xFE, 0x3C, 0x00, 0xFF, 0xE1, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0xFC, 0x00, 0x78,
  0xFF, 0xF8, 0x03, 0xCF, 0xFF, 0xE0, 0x1E, 0xF8, 0x7F, 0x80, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C,
  0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x07, 0x8F, 0xC0, 0xFC, 0x03, 0xCF, 0xF0, 0xFF,
  0x01, 0xEF, 0xFC, 0xFF, 0xC0, 0xFC, 0x3E, 0xC3, 0xE0, 0x74, 0x0F, 0x40,
  0xF8, 0x3C, 0x07, 0xC0, 0x3C, 0x3E, 0x01, 0xE0, 0x1E, 0x1E, 0x00, 0xE0,
  0x0F, 0x0F, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x00, 0xF0, 0xF0, 0x07,
  0x00, 0x78, 0x78, 0x03, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x07, 0x87, 0x80,
  0x38, 0x03, 0xC3, 0xC0, 0x1C, 0x01, 0xE1, 0xE0, 0x1E, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC0, 0x3C, 0x3C,
  0x01, 0xC0, 0x1E, 0x1E, 0x00, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x07, 0x87,
  0x80, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x01, 0xE1,
  0xE0, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x00, 0x78, 0x78, 0x03, 0x80, 0x3C,
  0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x83, 0xFE, 0x00, 0x3C, 0x7F, 0xFC,
  0x01, 0xE7, 0xFF, 0xF0, 0x0F, 0x7C, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xF8, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xC3, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0x80, 0x03, 0xC7,
  0xFF, 0xC0, 0x07, 0x9F, 0xFF, 0xC0, 0x0F, 0x7C, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x1E, 0xF8, 0x1F, 0xC0, 0x3C, 0xFF,
  0xFF, 0x00, 0x78, 0xFF, 0xFC, 0x00, 0xF0, 0xFF, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0xFF, 0xF0,
  0xF0, 0x0F, 0xFF, 0xF7, 0xC0, 0x7F, 0x87, 0xDF, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x3D, 0xE0, 0x1F, 0xFF, 0xE7, 0x80, 0x3F, 0xFF, 0x1E,
  0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x83,
  0xFF, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x79, 0xFF, 0xFE, 0x01, 0xEF, 0x83,
  0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0x3F,
  0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x0E,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x07, 0x07, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF8,
  0x01, 0xF0, 0x03, 0x9C, 0x00, 0xF8, 0x03, 0xCE, 0x00, 0xFC, 0x01, 0xE7,
  0x00, 0x7E, 0x00, 0xE3, 0x80, 0x3F, 0x00, 0xF1, 0xC0, 0x3B, 0x80, 0x78,
  0xE0, 0x1D, 0xC0, 0x38, 0x70, 0x0E, 0xE0, 0x3C, 0x38, 0x0E, 0x70, 0x1E,
  0x1C, 0x07, 0x38, 0x0E, 0x0E, 0x03, 0x9C, 0x0F, 0x07, 0x03, 0x8E, 0x07,
  0x83, 0x81, 0xC7, 0x03, 0x81, 0xC0, 0xE3, 0x83, 0xC0, 0xE0, 0xE1, 0xC1,
  0xE0, 0x70, 0x70, 0xE0, 0xE0, 0x38, 0x38, 0x70, 0x70, 0x1C, 0x38, 0x38,
  0x78, 0x0E, 0x1C, 0x1C, 0x38, 0x07, 0x0E, 0x0E, 0x1C, 0x03, 0x8E, 0x07,
  0x1E, 0x01, 0xC7, 0x03, 0x8F, 0x00, 0xE3, 0x81, 0xC7, 0x00, 0x73, 0x80,
  0xE7, 0x80, 0x39, 0xC0, 0x73, 0xC0, 0x1C, 0xE0, 0x39, 0xC0, 0x0E, 0xE0,
  0x1D, 0xE0, 0x07, 0x70, 0x0E, 0xF0, 0x03, 0xB8, 0x07, 0x70, 0x01, 0xF8,
  0x03, 0xB8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x0D, 0xE0, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x1E, 0xF0, 0x0F, 0xFF, 0xE7, 0x80, 0x3F, 0xFE, 0x3C, 0x00, 0xFF,
  0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x3C, 0x3F, 0xF0, 0x01, 0xE3, 0xFF, 0xE0, 0x07, 0x8F, 0x8F,
  0x80, 0x1E, 0x78, 0x1F, 0x00, 0x79, 0xE0, 0x3E, 0x01, 0xE7, 0x00, 0x7C,
  0x0F, 0x3C, 0x01, 0xF8, 0x3C, 0xF0, 0x03, 0xFF, 0xE3, 0xC0, 0x07, 0xFF,
  0x8F, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_ExtraLightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 14, 46, 38, 12, -46 },
  { 82, 20, 19, 38, 12, -46 },
  { 130, 36, 46, 38, 2, -46 },
  { 337, 33, 64, 38, 3, -55 },
  { 601, 43, 46, 38, -2, -46 },
  { 849, 34, 48, 38, 2, -47 },
  { 1053, 8, 19, 38, 18, -46 },
  { 1072, 25, 61, 38, 11, -53 },
  { 1263, 25, 61, 38, 3, -53 },
  { 1454, 33, 32, 38, 4, -38 },
  { 1586, 29, 30, 38, 5, -36 },
  { 1695, 15, 20, 38, 7, -10 },
  { 1733, 21, 4, 38, 9, -23 },
  { 1744, 10, 10, 38, 12, -9 },
  { 1757, 36, 59, 38, 2, -52 },
  { 2023, 31, 48, 38, 4, -47 },
  { 2209, 28, 46, 38, 3, -46 },
  { 2370, 32, 47, 38, 3, -47 },
  { 2558, 31, 47, 38, 4, -46 },
  { 2741, 28, 46, 38, 5, -46 },
  { 2902, 31, 47, 38, 4, -46 },
  { 3085, 29, 47, 38, 4, -46 },
  { 3256, 30, 46, 38, 8, -46 },
  { 3429, 31, 48, 38, 4, -47 },
  { 3615, 29, 47, 38, 7, -47 },
  { 3786, 14, 36, 38, 12, -35 },
  { 3849, 19, 45, 38, 7, -35 },
  { 3956, 29, 32, 38, 6, -37 },
  { 4072, 29, 18, 38, 5, -30 },
  { 4138, 29, 32, 38, 4, -37 },
  { 4254, 25, 46, 38, 10, -46 },
  { 4398, 37, 58, 38, 1, -47 },
  { 4667, 30, 46, 38, 1, -46 },
  { 4840, 31, 46, 38, 4, -46 },
  { 5019, 30, 48, 38, 5, -47 },
  { 5199, 31, 46, 38, 4, -46 },
  { 5378, 33, 46, 38, 4, -46 },
  { 5568, 34, 46, 38, 4, -46 },
  { 5764, 30, 48, 38, 5, -47 },
  { 5944, 32, 46, 38, 4, -46 },
  { 6128, 31, 46, 38, 4, -46 },
  { 6307, 33, 47, 38, 2, -46 },
  { 6501, 34, 46, 38, 4, -46 },
  { 6697, 26, 46, 38, 5, -46 },
  { 6847, 34, 46, 38, 3, -46 },
  { 7043, 32, 46, 38, 4, -46 },
  { 7227, 30, 48, 38, 5, -47 },
  { 7407, 33, 46, 38, 4, -46 },
  { 7597, 30, 58, 38, 5, -47 },
  { 7815, 32, 46, 38, 4, -46 },
  { 7999, 33, 48, 38, 3, -47 },
  { 8197, 31, 46, 38, 8, -46 },
  { 8376, 31, 47, 38, 5, -46 },
  { 8559, 31, 46, 38, 8, -46 },
  { 8738, 35, 46, 38, 5, -46 },
  { 8940, 39, 46, 38, 0, -46 },
  { 9165, 33, 46, 38, 7, -46 },
  { 9355, 33, 46, 38, 3, -46 },
  { 9545, 24, 59, 38, 10, -52 },
  { 9722, 17, 59, 38, 11, -52 },
  { 9848, 24, 59, 38, 6, -52 },
  { 10025, 27, 25, 38, 6, -46 },
  { 10110, 31, 3, 38, 0, 2 },
  { 10122, 10, 8, 38, 17, -49 },
  { 10132, 30, 36, 38, 4, -35 },
  { 10267, 29, 47, 38, 4, -46 },
  { 10438, 29, 36, 38, 5, -35 },
  { 10569, 32, 47, 38, 4, -46 },
  { 10757, 28, 36, 38, 5, -35 },
  { 10883, 41, 57, 38, -2, -46 },
  { 11176, 29, 46, 38, 5, -35 },
  { 11343, 29, 46, 38, 4, -46 },
  { 11510, 29, 49, 38, 3, -49 },
  { 11688, 32, 60, 38, 1, -49 },
  { 11928, 32, 46, 38, 4, -46 },
  { 12112, 25, 46, 38, 7, -46 },
  { 12256, 33, 35, 38, 2, -35 },
  { 12401, 29, 35, 38, 4, -35 },
  { 12528, 28, 36, 38, 5, -35 },
  { 12654, 31, 46, 38, 2, -35 },
  { 12833, 30, 46, 38, 4, -35 },
  { 13006, 30, 35, 38, 5, -35 },
  { 13138, 29, 36, 38, 4, -35 },
  { 13269, 29, 44, 38, 6, -44 },
  { 13429, 29, 36, 38, 5, -35 },
  { 13560, 29, 35, 38, 7, -35 },
  { 13687, 33, 35, 38, 5, -35 },
  { 13832, 35, 35, 38, 1, -35 },
  { 13986, 29, 46, 38, 5, -35 },
  { 14153, 31, 35, 38, 3, -35 },
  { 14289, 31, 59, 38, 6, -52 },
  { 14518, 13, 59, 38, 13, -52 },
  { 14614, 31, 59, 38, 2, -52 },
  { 14843, 30, 12, 38, 5, -28 },
};

const GFXfont JetBrainsMono_ExtraLightItalic63pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic63pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC63PT7B_H_
