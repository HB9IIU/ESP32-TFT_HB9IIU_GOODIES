#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC71PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80,
  0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8,
  0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x8F, 0x1F, 0xC0,
  0x07, 0xE0, 0xF0, 0xFC, 0x00, 0x7C, 0x0E, 0x07, 0xE0, 0x0F, 0x80, 0xE0,
  0x3E, 0x01, 0xF0, 0x0E, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xF0,
  0x3C, 0x00, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x01, 0xFC, 0x38, 0x00, 0x00,
  0x0F, 0xE3, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0x0E, 0x07,
  0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x1F, 0x0F, 0x80, 0x1C, 0x01,
  0xF0, 0xF8, 0x01, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0xF8, 0x03,
  0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x7C, 0x07,
  0xE0, 0x38, 0x0F, 0x80, 0x3F, 0x03, 0x81, 0xF8, 0x03, 0xFC, 0x38, 0x7F,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xE0,
  0x0F, 0x87, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x3E, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x06,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3C, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x7F, 0x1F, 0x80, 0x00, 0x00,
  0xF0, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x81, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x81, 0xF8, 0x00, 0x78, 0x3E, 0x03,
  0xE0, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0xF8, 0x0F, 0x80, 0x07, 0xE3, 0xC0, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x07,
  0xFC, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xC0, 0x01, 0xF3, 0xE0, 0x1F,
  0x80, 0x0F, 0xC7, 0xC0, 0x7F, 0x00, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xE0,
  0x3E, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x07,
  0xFF, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x04, 0x78, 0x00,
  0xF0, 0x01, 0xE7, 0xF8, 0x07, 0x80, 0x7F, 0xBF, 0xF0, 0x3C, 0x0F, 0xFF,
  0xFF, 0xE1, 0xC3, 0xFF, 0xE7, 0xFF, 0xCE, 0x7F, 0xFC, 0x07, 0xFF, 0x77,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x0F, 0xC3, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x7F, 0xC3, 0xF8, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x0F, 0x00, 0x7C, 0x1E,
  0x03, 0xF8, 0x0F, 0x87, 0xC0, 0x7F, 0x01, 0xF0, 0xF8, 0x0F, 0xE0, 0x3C,
  0x1F, 0x01, 0xFC, 0x0F, 0x83, 0xE0, 0x3F, 0x81, 0xF0, 0x7C, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0x38, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xBC, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x07,
  0xF1, 0xF0, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x03, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0xF8, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xF8,
  0x00, 0x1E, 0x1F, 0xFF, 0x80, 0x07, 0x8F, 0xFF, 0xF0, 0x01, 0xE7, 0xFF,
  0xFE, 0x00, 0xFB, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x78, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0xC0, 0x00, 0x07, 0xCF, 0xFF, 0x00, 0x07, 0xCF, 0xFF,
  0xC0, 0x07, 0xDF, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xEF, 0x80, 0x03, 0xFF, 0xCF,
  0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3F, 0xF1, 0xE0, 0x78, 0x00,
  0x3F, 0xFC, 0xF0, 0x3C, 0x00, 0x7F, 0xFF, 0x78, 0x1E, 0x00, 0x3F, 0x87,
  0xBC, 0x0F, 0x00, 0x3E, 0x00, 0xDE, 0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x07,
  0xC0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x0F,
  0x80, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x01,
  0xF0, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x78, 0x1F,
  0x00, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x01, 0xE0, 0x78,
  0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0x03, 0xE0, 0x07, 0xFF, 0xF7, 0x81, 0xE0,
  0x01, 0xFF, 0xF3, 0xC0, 0xF0, 0x00, 0x7F, 0xF1, 0xE0, 0x78, 0x00, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x00,
  0x01, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x83, 0xE0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x7F, 0xF0,
  0x01, 0xE0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x08,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0xFF,
  0x81, 0xE0, 0x0F, 0xFF, 0xF0, 0x3C, 0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x3F,
  0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x10, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x0E, 0xE0, 0x00, 0x3F, 0xC0, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x07, 0x9C, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x03, 0xCE, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x78, 0xF0,
  0x0F, 0x1F, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x01, 0xE1, 0xC0, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x0F, 0x87, 0x83, 0xC3, 0xE0, 0x1F, 0x0F,
  0x07, 0x87, 0xC0, 0x3E, 0x0E, 0x1E, 0x0F, 0x80, 0x78, 0x1C, 0x3C, 0x1E,
  0x00, 0xF0, 0x3C, 0xF0, 0x3C, 0x01, 0xE0, 0x79, 0xE0, 0xF8, 0x07, 0xC0,
  0xF7, 0x81, 0xF0, 0x0F, 0x80, 0xEF, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0x01,
  0xFF, 0x00, 0x01, 0xE0, 0x1E, 0xF0, 0x00, 0x1E, 0x01, 0xEF, 0x00, 0x01,
  0xE0, 0x1E, 0x78, 0x00, 0x3E, 0x01, 0xE7, 0x80, 0x03, 0xE0, 0x1E, 0x78,
  0x00, 0x3E, 0x03, 0xE7, 0x80, 0x03, 0xE0, 0x3E, 0x7C, 0x00, 0x3C, 0x03,
  0xE3, 0xC0, 0x03, 0xC0, 0x3C, 0x3C, 0x00, 0x7C, 0x03, 0xC3, 0xC0, 0x07,
  0xC0, 0x3C, 0x3C, 0x00, 0x7C, 0x07, 0xC1, 0xE0, 0x07, 0xC0, 0x7C, 0x1E,
  0x00, 0x78, 0x07, 0xC1, 0xE0, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x78, 0x07,
  0x81, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x07, 0x81, 0xF0, 0x0F,
  0x00, 0x78, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x3C, 0x1E,
  0x01, 0xF0, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x03,
  0xE3, 0xE0, 0x1E, 0x00, 0x1E, 0x3E, 0x03, 0xE0, 0x01, 0xE3, 0xE0, 0x3E,
  0x00, 0x1E, 0x3C, 0x03, 0xE0, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x1F, 0x3C,
  0x03, 0xC0, 0x00, 0xF3, 0xC0, 0x3C, 0x00, 0x0F, 0x7C, 0x07, 0xC0, 0x00,
  0xF7, 0xC0, 0x7C, 0x00, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x7C,
  0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x78, 0x00, 0x07, 0xF8,
  0x07, 0x80, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0x80,
  0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x01, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0xFC, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0xFC, 0x00, 0x3D, 0xF0, 0x01,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0xE0, 0x03,
  0xCF, 0x80, 0x1D, 0xC0, 0x0F, 0x9F, 0x00, 0x3B, 0x80, 0x1F, 0x3C, 0x00,
  0x77, 0x00, 0x3C, 0x78, 0x01, 0xEE, 0x00, 0x78, 0xF0, 0x03, 0x9C, 0x01,
  0xF1, 0xE0, 0x07, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x70, 0x07, 0x87, 0x80,
  0x38, 0xE0, 0x0F, 0x0F, 0x00, 0x71, 0xC0, 0x3E, 0x1E, 0x00, 0xE3, 0x80,
  0x78, 0x3C, 0x03, 0xC7, 0x00, 0xF0, 0x78, 0x07, 0x0E, 0x03, 0xE0, 0xF0,
  0x0E, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0xF0,
  0x1E, 0x07, 0x80, 0xE1, 0xE0, 0x7C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x1E,
  0x07, 0x87, 0x81, 0xE0, 0x3C, 0x0E, 0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x1C,
  0x0F, 0x00, 0xF0, 0x78, 0x38, 0x1E, 0x03, 0xE0, 0xE0, 0x70, 0x3C, 0x07,
  0xC1, 0xC0, 0xE0, 0xF8, 0x0F, 0x87, 0x81, 0xC1, 0xE0, 0x1F, 0x0E, 0x03,
  0x83, 0xC0, 0x3E, 0x1C, 0x07, 0x07, 0x80, 0x78, 0x38, 0x0E, 0x1F, 0x00,
  0xF0, 0xF0, 0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0x38, 0x78, 0x03, 0xC3, 0x80,
  0x70, 0xF0, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x0F, 0x1C, 0x01, 0xC7, 0x80,
  0x1E, 0x38, 0x03, 0x8F, 0x00, 0x3C, 0xF0, 0x07, 0x1E, 0x00, 0x79, 0xC0,
  0x0E, 0x78, 0x00, 0xF3, 0x80, 0x1C, 0xF0, 0x01, 0xE7, 0x00, 0x39, 0xE0,
  0x03, 0xDE, 0x00, 0x77, 0x80, 0x07, 0xB8, 0x00, 0xEF, 0x00, 0x0F, 0x70,
  0x01, 0xDE, 0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFB, 0xC0,
  0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x83, 0xC0, 0x0F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0xF9, 0xF0, 0x0F, 0xF0,
  0x7E, 0xF8, 0x0F, 0xC0, 0x07, 0x7C, 0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x1F,
  0xDF, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x87, 0x80, 0x07, 0xFF,
  0x83, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0xF8, 0x3F, 0xFC, 0x00, 0x3E, 0x3F, 0xFF, 0x80, 0x0F,
  0x9F, 0xFF, 0xF0, 0x03, 0xCF, 0xC3, 0xFE, 0x00, 0xF7, 0x80, 0x1F, 0xC0,
  0x7F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x7F, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x00, 0x7C, 0x07, 0xF8,
  0x00, 0x3E, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x79, 0xF8, 0x7F, 0xC0, 0x1E,
  0x7F, 0xFF, 0xE0, 0x0F, 0x8F, 0xFF, 0xE0, 0x03, 0xE0, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0xFE, 0x0F, 0x00, 0x0F, 0xFF, 0xE3,
  0xE0, 0x03, 0xFF, 0xFE, 0x7C, 0x00, 0xFF, 0x07, 0xEF, 0x80, 0x3F, 0x00,
  0x1D, 0xF0, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF1, 0xFD, 0xF0, 0x03, 0xFF, 0xFF, 0x3E, 0x00, 0x3F, 0xFF,
  0x87, 0x80, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xF1, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0x00, 0x7F, 0xFF,
  0x1F, 0x00, 0xFF, 0xFF, 0x9F, 0x01, 0xFE, 0x0F, 0xDF, 0x03, 0xF0, 0x01,
  0xDF, 0x07, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1D, 0xF0, 0x3F, 0x80, 0x7D,
  0xE0, 0x1F, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xC3,
  0xE0, 0x03, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x1F, 0x07, 0xFF, 0x80, 0x0F, 0x8F, 0xFF, 0xE0, 0x07,
  0xCF, 0xFF, 0xF8, 0x03, 0xCF, 0xC3, 0xFE, 0x01, 0xEF, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x1F, 0xE0,
  0x7F, 0x80, 0x3C, 0xFF, 0xC7, 0xFF, 0x00, 0xF7, 0xFF, 0x9F, 0xFE, 0x03,
  0xD8, 0x7E, 0xE1, 0xF8, 0x0F, 0x80, 0xFA, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0xF8,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x1F, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x3C,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x0F, 0x81,
  0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x7F, 0xF8, 0x00, 0xF8,
  0xFF, 0xFE, 0x00, 0x7C, 0xFF, 0xFF, 0x80, 0x3C, 0xFC, 0x3F, 0xE0, 0x1E,
  0xF0, 0x03, 0xF8, 0x1F, 0x60, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x83, 0xFF, 0xC0, 0x00, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0x9F, 0xFF,
  0xF0, 0x00, 0xF3, 0xF0, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x3E, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x1E, 0x7E, 0x1F, 0xF0, 0x01, 0xE7, 0xFF, 0xFE, 0x00, 0x3E, 0x3F,
  0xFF, 0x80, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x83, 0xC0, 0x0F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF, 0xF9, 0xF0, 0x0F,
  0xF0, 0x7E, 0xF8, 0x0F, 0xC0, 0x0F, 0x7C, 0x0F, 0xC0, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xBE, 0x01, 0xFF,
  0x1F, 0xDF, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0x87, 0x80, 0x07,
  0xFF, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x3F, 0xFC, 0x00, 0x3E, 0x3F, 0xFF, 0xC0, 0x0F, 0x9F,
  0xFF, 0xF8, 0x03, 0xEF, 0xC1, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x3D,
  0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xBC, 0x00, 0x7E, 0x00, 0x3D, 0xE0, 0x03, 0xF0, 0x03, 0xCF,
  0x00, 0x3F, 0x80, 0x1E, 0x78, 0x01, 0xDC, 0x00, 0xF3, 0xC0, 0x0E, 0xE0,
  0x0F, 0x1E, 0x00, 0xF7, 0x00, 0x78, 0xF0, 0x07, 0x38, 0x03, 0xC7, 0x80,
  0x39, 0xC0, 0x3C, 0x3C, 0x03, 0xCE, 0x01, 0xE1, 0xE0, 0x1C, 0x70, 0x0F,
  0x0F, 0x00, 0xE3, 0x80, 0xF0, 0x78, 0x0F, 0x1C, 0x07, 0x83, 0xC0, 0x70,
  0xE0, 0x3C, 0x1E, 0x03, 0x87, 0x03, 0xC0, 0xF0, 0x3C, 0x38, 0x1E, 0x07,
  0x81, 0xC1, 0xC0, 0xF0, 0x3C, 0x0E, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x70,
  0x78, 0x0F, 0x07, 0x03, 0x83, 0xC0, 0x78, 0x38, 0x1C, 0x3E, 0x03, 0xC3,
  0xC0, 0xE1, 0xE0, 0x1E, 0x1C, 0x07, 0x0F, 0x00, 0xF0, 0xE0, 0x38, 0xF8,
  0x07, 0x8F, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x0E, 0x3C, 0x01, 0xE3, 0x80,
  0x71, 0xE0, 0x0F, 0x3C, 0x03, 0x9E, 0x00, 0x79, 0xC0, 0x1C, 0xF0, 0x03,
  0xCE, 0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x07, 0x78, 0x00, 0xF7, 0x00, 0x3B,
  0xC0, 0x07, 0xB8, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x0E, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0x37, 0x80, 0xFC, 0x00, 0x3B, 0xC0, 0x3F, 0x80, 0x7B, 0xE0,
  0x1F, 0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xF8, 0x7C,
  0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0x80, 0x01, 0xF0,
  0xFF, 0xF0, 0x00, 0x7C, 0x7F, 0xFE, 0x00, 0x1F, 0x1F, 0x0F, 0xC0, 0x07,
  0x8F, 0x81, 0xF8, 0x01, 0xE3, 0xC0, 0x3F, 0x00, 0x79, 0xF0, 0x07, 0xC0,
  0x3E, 0x78, 0x00, 0xF8, 0x0F, 0x1E, 0x00, 0x3F, 0x8F, 0xC7, 0x80, 0x07,
  0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 15, 52, 43, 14, -52 },
  { 99, 22, 21, 43, 14, -52 },
  { 157, 41, 52, 43, 2, -52 },
  { 424, 36, 72, 43, 4, -62 },
  { 748, 48, 52, 43, -2, -52 },
  { 1060, 38, 54, 43, 2, -53 },
  { 1317, 8, 21, 43, 21, -52 },
  { 1338, 29, 69, 43, 12, -60 },
  { 1589, 28, 69, 43, 4, -60 },
  { 1831, 37, 36, 43, 4, -43 },
  { 1998, 33, 33, 43, 5, -40 },
  { 2135, 17, 22, 43, 8, -11 },
  { 2182, 24, 5, 43, 10, -26 },
  { 2197, 12, 11, 43, 13, -10 },
  { 2214, 41, 67, 43, 2, -59 },
  { 2558, 35, 54, 43, 5, -53 },
  { 2795, 31, 52, 43, 4, -52 },
  { 2997, 36, 53, 43, 4, -53 },
  { 3236, 35, 53, 43, 4, -52 },
  { 3468, 32, 52, 43, 5, -52 },
  { 3676, 34, 53, 43, 5, -52 },
  { 3902, 33, 53, 43, 4, -52 },
  { 4121, 34, 52, 43, 9, -52 },
  { 4342, 36, 54, 43, 4, -53 },
  { 4585, 33, 53, 43, 7, -53 },
  { 4804, 16, 41, 43, 13, -40 },
  { 4886, 22, 51, 43, 8, -40 },
  { 5027, 34, 37, 43, 6, -42 },
  { 5185, 33, 21, 43, 5, -34 },
  { 5272, 33, 37, 43, 4, -42 },
  { 5425, 28, 52, 43, 11, -52 },
  { 5607, 41, 66, 43, 1, -53 },
  { 5946, 34, 52, 43, 1, -52 },
  { 6167, 36, 52, 43, 4, -52 },
  { 6401, 35, 54, 43, 5, -53 },
  { 6638, 35, 52, 43, 4, -52 },
  { 6866, 37, 52, 43, 5, -52 },
  { 7107, 38, 52, 43, 4, -52 },
  { 7354, 35, 54, 43, 5, -53 },
  { 7591, 36, 52, 43, 4, -52 },
  { 7825, 35, 52, 43, 5, -52 },
  { 8053, 38, 53, 43, 2, -52 },
  { 8305, 39, 52, 43, 4, -52 },
  { 8559, 30, 52, 43, 5, -52 },
  { 8754, 39, 52, 43, 3, -52 },
  { 9008, 36, 52, 43, 4, -52 },
  { 9242, 34, 54, 43, 5, -53 },
  { 9472, 38, 52, 43, 4, -52 },
  { 9719, 34, 66, 43, 5, -53 },
  { 10000, 37, 52, 43, 4, -52 },
  { 10241, 36, 54, 43, 4, -53 },
  { 10484, 35, 52, 43, 9, -52 },
  { 10712, 36, 53, 43, 5, -52 },
  { 10951, 34, 52, 43, 9, -52 },
  { 11172, 39, 52, 43, 6, -52 },
  { 11426, 43, 52, 43, 0, -52 },
  { 11706, 37, 52, 43, 8, -52 },
  { 11947, 38, 52, 43, 3, -52 },
  { 12194, 27, 67, 43, 11, -59 },
  { 12421, 20, 67, 43, 12, -59 },
  { 12589, 27, 67, 43, 7, -59 },
  { 12816, 30, 28, 43, 7, -52 },
  { 12921, 35, 4, 43, 0, 2 },
  { 12939, 11, 10, 43, 20, -56 },
  { 12953, 33, 41, 43, 5, -40 },
  { 13123, 34, 53, 43, 4, -52 },
  { 13349, 33, 41, 43, 5, -40 },
  { 13519, 35, 53, 43, 5, -52 },
  { 13751, 32, 41, 43, 5, -40 },
  { 13915, 45, 65, 43, -2, -52 },
  { 14281, 32, 53, 43, 6, -40 },
  { 14493, 33, 52, 43, 4, -52 },
  { 14708, 33, 55, 43, 3, -55 },
  { 14935, 36, 68, 43, 1, -55 },
  { 15241, 37, 52, 43, 4, -52 },
  { 15482, 28, 52, 43, 8, -52 },
  { 15664, 38, 40, 43, 2, -40 },
  { 15854, 33, 40, 43, 4, -40 },
  { 16019, 32, 41, 43, 5, -40 },
  { 16183, 36, 53, 43, 2, -40 },
  { 16422, 33, 53, 43, 5, -40 },
  { 16641, 34, 40, 43, 5, -40 },
  { 16811, 32, 41, 43, 5, -40 },
  { 16975, 32, 50, 43, 7, -50 },
  { 17175, 33, 40, 43, 5, -39 },
  { 17340, 33, 39, 43, 8, -39 },
  { 17501, 37, 39, 43, 6, -39 },
  { 17682, 38, 39, 43, 2, -39 },
  { 17868, 33, 52, 43, 5, -39 },
  { 18083, 34, 39, 43, 4, -39 },
  { 18249, 35, 67, 43, 7, -59 },
  { 18543, 15, 67, 43, 15, -59 },
  { 18669, 35, 67, 43, 2, -59 },
  { 18963, 34, 14, 43, 5, -32 },
};

const GFXfont JetBrainsMono_ExtraLightItalic71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC71PT7B_H_
