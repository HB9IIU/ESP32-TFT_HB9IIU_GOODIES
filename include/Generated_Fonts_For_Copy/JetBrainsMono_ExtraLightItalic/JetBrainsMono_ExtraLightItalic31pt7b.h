#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC31PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC1,
  0x02, 0x0C, 0x18, 0x30, 0x00, 0x00, 0x07, 0x1E, 0x3C, 0x00, 0x71, 0xD8,
  0x76, 0x1D, 0x86, 0x61, 0xB8, 0x6E, 0x1B, 0x0E, 0xC3, 0x30, 0xC0, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x18, 0x10, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC0,
  0x80, 0x30, 0x60, 0xFF, 0xFF, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x60, 0x0C, 0x18, 0x02, 0x06, 0x01, 0x83, 0x03, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x30,
  0x0C, 0x18, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x01,
  0xF0, 0x07, 0xFC, 0x0E, 0x4E, 0x18, 0xC6, 0x18, 0xC6, 0x18, 0xC6, 0x30,
  0x80, 0x38, 0x80, 0x18, 0x80, 0x1D, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x01, 0x38, 0x01, 0x18, 0x01, 0x0C, 0x03, 0x0C, 0xC3, 0x0C, 0xC3,
  0x18, 0xC2, 0x18, 0xE2, 0x30, 0x7F, 0xE0, 0x3F, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x03, 0xC0, 0x18, 0x3F, 0x01, 0x83, 0x0C,
  0x08, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x0C, 0x10, 0xC0, 0x61, 0x8C, 0x03,
  0x0C, 0xC0, 0x18, 0xE4, 0x00, 0x7E, 0x60, 0x00, 0x86, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x67, 0xC0, 0x06, 0x77, 0x00, 0x22, 0x08, 0x03,
  0x30, 0x40, 0x31, 0x82, 0x03, 0x0C, 0x30, 0x30, 0x61, 0x83, 0x03, 0x0C,
  0x30, 0x1D, 0xC3, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xC3,
  0x01, 0xC1, 0xC0, 0xC0, 0x60, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x13, 0x18, 0x33, 0x0E, 0x31,
  0x83, 0x18, 0xC1, 0xD8, 0x60, 0x78, 0x60, 0x1C, 0x30, 0x0C, 0x18, 0x0F,
  0x0E, 0x0D, 0xC3, 0xFC, 0x60, 0xFC, 0x18, 0x77, 0x66, 0x6E, 0xEC, 0xCC,
  0x00, 0x18, 0x03, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x80, 0x0C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xE1, 0x87, 0xF9, 0xBF,
  0x3F, 0x7C, 0x03, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0xE0, 0x18, 0x60,
  0x38, 0x70, 0x70, 0x30, 0x20, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFE, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x0F,
  0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0x7F, 0xFF, 0xF8,
  0x27, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xF8, 0x38, 0x78, 0xE0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0xE0, 0x0D, 0x8E, 0x33, 0x1C, 0x66, 0x38, 0xCC, 0x01,
  0x98, 0x03, 0x30, 0x06, 0xE0, 0x1D, 0x80, 0x33, 0x00, 0x67, 0x01, 0xC6,
  0x07, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x1C,
  0xC1, 0xC6, 0x08, 0x30, 0x81, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0xF8,
  0x30, 0x38, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x1F,
  0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x19,
  0x80, 0x33, 0x00, 0x66, 0x01, 0x8E, 0x07, 0x0F, 0xFC, 0x0F, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC6, 0x03, 0x38, 0x1C, 0xC0,
  0x66, 0x01, 0x98, 0x06, 0x7F, 0xFB, 0xFF, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x31, 0xE0, 0x6F, 0xF0,
  0xF0, 0xE1, 0xC0, 0xE3, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x33, 0x00, 0x67, 0x01, 0x86, 0x07, 0x0F, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x77, 0x81, 0xFF, 0x8E, 0x0E, 0x70, 0x1D,
  0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB8, 0x0E,
  0x60, 0x71, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFB, 0x80, 0x36,
  0x00, 0x6C, 0x01, 0x98, 0x07, 0x30, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x63,
  0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18, 0x1C, 0x18, 0x70, 0x1F, 0x80, 0x1E,
  0x00, 0xEE, 0x07, 0x07, 0x1C, 0x06, 0x30, 0x0C, 0xC0, 0x1D, 0x80, 0x33,
  0x00, 0x66, 0x00, 0xCE, 0x03, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0xF0, 0x70, 0x71, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x06, 0xE0, 0x0D, 0xC0, 0x39, 0x80, 0x63, 0x81, 0xC3, 0xFF, 0x03, 0xEC,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x7C, 0xF9, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0x7C, 0xF0, 0x03, 0xC1, 0xF0,
  0x7C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x30, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x04, 0x3F, 0xFE, 0x7F, 0xFD, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x20, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x00, 0x1C, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00,
  0x20, 0x00, 0x3E, 0x03, 0xFC, 0x01, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC1, 0xF8, 0x3E, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x60, 0x30, 0x30, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x7D, 0x88, 0x3F, 0xE6,
  0x1C, 0x39, 0x86, 0x0E, 0x61, 0x83, 0x18, 0x60, 0xC6, 0x30, 0x31, 0x8C,
  0x0C, 0xC3, 0x03, 0x30, 0xC0, 0xCC, 0x30, 0x63, 0x0E, 0x28, 0xC1, 0xF6,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xB0, 0x06, 0x40, 0x19, 0x80, 0xC6, 0x03, 0x18, 0x18,
  0x60, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x81, 0x87, 0xFF, 0x3F,
  0xFC, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0xC0,
  0x1F, 0xC0, 0x3F, 0xF0, 0x60, 0x70, 0xC0, 0x71, 0x80, 0x63, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x30, 0x0C, 0x60, 0x30, 0xFF, 0xC1, 0xFF, 0x07, 0x07,
  0x8C, 0x03, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x66,
  0x01, 0xCC, 0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF8,
  0x38, 0x38, 0xE0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x04, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xC7, 0x07, 0x07,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x60, 0xF0, 0xC0, 0x61,
  0x80, 0xE3, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98, 0x07, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0xE6, 0x01, 0x8C, 0x0E, 0x1F, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3F, 0xFC, 0x3F, 0xF8,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF,
  0x8F, 0xFF, 0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xF8, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x01,
  0x98, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x1F, 0xCC,
  0x3F, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0x80, 0x63, 0x01,
  0xC7, 0x07, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x18, 0x03, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30,
  0x0C, 0x30, 0x0C, 0x3F, 0xFC, 0x3F, 0xFC, 0x70, 0x0C, 0x60, 0x1C, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x18, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x30, 0x0F, 0xFE, 0x1F, 0xFC, 0x43, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x20, 0x0C, 0xC0,
  0x1C, 0xE0, 0x18, 0xE0, 0x18, 0x60, 0x30, 0x7F, 0xE0, 0x1F, 0xC0, 0x18,
  0x03, 0x8C, 0x01, 0x86, 0x01, 0xC3, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x60, 0x60, 0x30, 0x70, 0x18, 0x30, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x70,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xE3, 0x40, 0xB1, 0xA0,
  0xD8, 0xD8, 0x48, 0x6C, 0x6C, 0x36, 0x26, 0x19, 0x33, 0x18, 0x91, 0x8C,
  0x78, 0xC6, 0x38, 0xC3, 0x1C, 0x61, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C,
  0x60, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0x63, 0x00, 0x30, 0x1C, 0x03, 0x1C, 0x07, 0x1E, 0x06, 0x1E, 0x06, 0x1E,
  0x06, 0x1E, 0x06, 0x33, 0x06, 0x33, 0x06, 0x33, 0x0C, 0x33, 0x0C, 0x31,
  0x0C, 0x31, 0x8C, 0x61, 0x8C, 0x61, 0x8C, 0x61, 0x98, 0x60, 0xD8, 0x60,
  0xD8, 0x60, 0xD8, 0xE0, 0xD8, 0xC0, 0x58, 0xC0, 0x70, 0xC0, 0x70, 0xC0,
  0x70, 0x01, 0xF0, 0x0F, 0xF8, 0x38, 0x30, 0xE0, 0x71, 0x80, 0x67, 0x00,
  0xCC, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x80, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x07, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80,
  0x63, 0x01, 0x86, 0x07, 0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x18, 0x0E, 0x18, 0x07, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x07, 0x30, 0x06, 0x30, 0x0C, 0x3F, 0xF8, 0x7F, 0xF0, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xF8, 0x38,
  0x30, 0xE0, 0x71, 0x80, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x0E, 0x60, 0x19, 0xC0, 0x33, 0x80, 0x63, 0x01, 0x86, 0x07, 0x0F, 0xFC,
  0x07, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x18, 0x1E, 0x18, 0x06, 0x18, 0x07,
  0x18, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x1C,
  0x3F, 0xF8, 0x7F, 0xE0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xE0, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x70, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18,
  0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x18, 0xE0, 0x30, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x18, 0x03, 0x18, 0x07, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0x70,
  0x3F, 0xE0, 0x1F, 0x80, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xE6,
  0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x81,
  0x83, 0x06, 0x06, 0x0C, 0x06, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x33, 0x00,
  0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x60, 0xE0, 0xD8, 0x38, 0x26, 0x0E, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x98,
  0x58, 0xC6, 0x16, 0x31, 0x8D, 0x8C, 0x62, 0x63, 0x18, 0x91, 0x86, 0x64,
  0x61, 0x99, 0x18, 0x64, 0x44, 0x19, 0x13, 0x06, 0xC4, 0xC1, 0xA1, 0x30,
  0x48, 0x58, 0x16, 0x16, 0x05, 0x05, 0x81, 0x41, 0x40, 0xF0, 0x70, 0x3C,
  0x1C, 0x0E, 0x07, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x06, 0x03,
  0x81, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x98, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x80, 0x70,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xE0, 0x0C, 0x38, 0x01, 0xC0, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xD8, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF0, 0xFE, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xFE, 0x00, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x0F, 0xF0, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0xFE, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x06, 0x80, 0x66, 0x07, 0x30, 0x31, 0x83, 0x06, 0x18, 0x31,
  0x81, 0x9C, 0x05, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xC6, 0x73, 0x07,
  0xE6, 0x1E, 0xFC, 0x60, 0x71, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03,
  0x30, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C,
  0x07, 0x18, 0x1C, 0x3F, 0xF8, 0x3F, 0x30, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x3F, 0x0D, 0xDE, 0x38, 0x1C, 0xE0,
  0x33, 0x00, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x01, 0xD8, 0x06, 0x60,
  0x19, 0x80, 0x66, 0x01, 0xB8, 0x0C, 0xF0, 0x73, 0x77, 0x8C, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xF0, 0x60, 0x71, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x98,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0xC6, 0x01,
  0x8C, 0x07, 0x1C, 0x1C, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0xE6, 0x0F, 0x7E,
  0x18, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C,
  0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38,
  0x60, 0x70, 0x7F, 0xF0, 0x3F, 0x30, 0x07, 0xF0, 0x3D, 0xE1, 0x81, 0xCC,
  0x03, 0x30, 0x0D, 0xC0, 0x36, 0x00, 0xDF, 0xFF, 0x7F, 0xFD, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0xC6, 0x07, 0x1F, 0x78, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE6, 0x1E, 0xFC, 0x60, 0x71, 0x80, 0x63, 0x00, 0xC6, 0x01,
  0x98, 0x03, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6,
  0x03, 0x8E, 0x0B, 0x0F, 0xEC, 0x0F, 0x98, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x0F, 0xF8, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0xBF, 0x0D, 0xDE, 0x38,
  0x1C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x01, 0x98,
  0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB0, 0x06, 0xC0, 0x3B, 0x00, 0xCC,
  0x03, 0x00, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x0F, 0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x07, 0x30, 0x0E,
  0x30, 0x1C, 0x30, 0x38, 0x30, 0x70, 0x30, 0x60, 0x30, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0x61, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x60, 0xE0, 0x60,
  0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0x7F, 0x07, 0xF8, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0F, 0xFC, 0x1F, 0xE0, 0x17, 0x9E, 0x3D, 0xF7,
  0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x60, 0x86,
  0x61, 0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x86, 0xC1, 0x06,
  0xC3, 0x0C, 0xC3, 0x0C, 0xC3, 0x0C, 0x3B, 0xF0, 0xDD, 0xE3, 0x81, 0xCE,
  0x03, 0x30, 0x0C, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0x60, 0x19, 0x80, 0x66,
  0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x30,
  0x07, 0xF0, 0x3D, 0xE1, 0x81, 0xCC, 0x03, 0x30, 0x0D, 0xC0, 0x36, 0x00,
  0xD8, 0x03, 0x60, 0x1D, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80,
  0xC6, 0x07, 0x1F, 0xF8, 0x1F, 0x80, 0x1D, 0xF8, 0x37, 0x78, 0x70, 0x38,
  0xE0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60,
  0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCE, 0x03, 0x1E, 0x0E, 0x37, 0x78,
  0x67, 0xE0, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x07, 0xE6, 0x1E, 0xF8, 0x60, 0x71, 0x80, 0x63, 0x00, 0xCE,
  0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xCE, 0x01, 0x8C, 0x07, 0x18, 0x1C, 0x3F, 0xF8, 0x3F, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x19, 0xF8,
  0x3E, 0x78, 0x70, 0x30, 0xC0, 0x73, 0x80, 0x66, 0x00, 0xCC, 0x03, 0x98,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x7D, 0xF3, 0x80, 0xCC,
  0x03, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x01, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x1B, 0x00, 0x6E, 0x03, 0x9F, 0xFC, 0x3F, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x03, 0xFF, 0xFF, 0xFF,
  0xC1, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x38, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63,
  0x00, 0xC6, 0x01, 0x8C, 0x06, 0x1C, 0x1C, 0x1F, 0xF0, 0x1F, 0x80, 0xE0,
  0x0E, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xC6, 0x03, 0x84, 0x06, 0x0C, 0x1C,
  0x18, 0x30, 0x30, 0xE0, 0x61, 0x80, 0xC7, 0x00, 0xCC, 0x01, 0xB8, 0x03,
  0x60, 0x06, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xC3, 0x83, 0xC3, 0x86, 0xC3,
  0x86, 0xC7, 0x84, 0xC5, 0x8C, 0xC5, 0x8C, 0xCD, 0x88, 0x89, 0x98, 0x89,
  0x98, 0x99, 0x90, 0x91, 0xB0, 0x91, 0xB0, 0xB1, 0xA0, 0xA0, 0xE0, 0xA0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x18, 0x03, 0x86, 0x03, 0x03, 0x03, 0x00,
  0xC3, 0x80, 0x63, 0x80, 0x19, 0x80, 0x0D, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0x98, 0x01, 0xCC, 0x01, 0xC3, 0x00, 0xC1, 0x80, 0xC0,
  0x60, 0xC0, 0x30, 0xE0, 0x0C, 0x00, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x31,
  0x80, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x8E, 0x1F, 0x0F, 0xEC, 0x0F, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x0F, 0xF8, 0x1F,
  0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x7C, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x3F, 0x80, 0x7F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x1C, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x7F, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xE0, 0x0F,
  0x80, 0x00, 0x1E, 0x06, 0x7E, 0x0D, 0x8C, 0x1B, 0x0C, 0x64, 0x0F, 0xD8,
  0x0F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 10, 10, 19, 6, -23 },
  { 35, 18, 23, 19, 1, -23 },
  { 87, 16, 31, 19, 2, -27 },
  { 149, 21, 23, 19, -1, -23 },
  { 210, 17, 23, 19, 1, -23 },
  { 259, 4, 10, 19, 9, -23 },
  { 264, 13, 30, 19, 5, -26 },
  { 313, 12, 30, 19, 2, -26 },
  { 358, 16, 16, 19, 2, -19 },
  { 390, 15, 15, 19, 2, -18 },
  { 419, 8, 10, 19, 3, -5 },
  { 429, 11, 2, 19, 4, -11 },
  { 432, 5, 5, 19, 6, -5 },
  { 436, 18, 29, 19, 1, -26 },
  { 502, 15, 23, 19, 2, -23 },
  { 546, 13, 23, 19, 2, -23 },
  { 584, 15, 23, 19, 2, -23 },
  { 628, 15, 23, 19, 2, -23 },
  { 672, 14, 23, 19, 2, -23 },
  { 713, 15, 23, 19, 2, -23 },
  { 757, 14, 23, 19, 2, -23 },
  { 798, 15, 23, 19, 4, -23 },
  { 842, 15, 23, 19, 2, -23 },
  { 886, 15, 23, 19, 3, -23 },
  { 930, 7, 17, 19, 6, -17 },
  { 945, 10, 22, 19, 3, -17 },
  { 973, 14, 16, 19, 3, -18 },
  { 1001, 15, 9, 19, 2, -15 },
  { 1018, 14, 16, 19, 2, -18 },
  { 1046, 12, 23, 19, 5, -23 },
  { 1081, 18, 29, 19, 1, -23 },
  { 1147, 14, 23, 19, 1, -23 },
  { 1188, 15, 23, 19, 2, -23 },
  { 1232, 15, 23, 19, 2, -23 },
  { 1276, 15, 23, 19, 2, -23 },
  { 1320, 16, 23, 19, 2, -23 },
  { 1366, 17, 23, 19, 2, -23 },
  { 1415, 15, 23, 19, 2, -23 },
  { 1459, 16, 23, 19, 2, -23 },
  { 1505, 15, 23, 19, 2, -23 },
  { 1549, 16, 23, 19, 1, -23 },
  { 1595, 17, 23, 19, 2, -23 },
  { 1644, 13, 23, 19, 2, -23 },
  { 1682, 17, 23, 19, 1, -23 },
  { 1731, 16, 23, 19, 2, -23 },
  { 1777, 15, 23, 19, 2, -23 },
  { 1821, 16, 23, 19, 2, -23 },
  { 1867, 15, 29, 19, 2, -23 },
  { 1922, 16, 23, 19, 2, -23 },
  { 1968, 16, 23, 19, 2, -23 },
  { 2014, 15, 23, 19, 4, -23 },
  { 2058, 16, 23, 19, 2, -23 },
  { 2104, 15, 23, 19, 4, -23 },
  { 2148, 18, 23, 19, 2, -23 },
  { 2200, 19, 23, 19, 0, -23 },
  { 2255, 15, 23, 19, 4, -23 },
  { 2299, 17, 23, 19, 1, -23 },
  { 2348, 12, 29, 19, 5, -26 },
  { 2392, 9, 29, 19, 5, -26 },
  { 2425, 12, 29, 19, 3, -26 },
  { 2469, 13, 12, 19, 3, -23 },
  { 2489, 15, 2, 19, 0, 1 },
  { 2493, 4, 4, 19, 9, -24 },
  { 2495, 15, 17, 19, 2, -17 },
  { 2527, 14, 23, 19, 2, -23 },
  { 2568, 15, 17, 19, 2, -17 },
  { 2600, 16, 23, 19, 2, -23 },
  { 2646, 14, 17, 19, 2, -17 },
  { 2676, 20, 29, 19, -1, -23 },
  { 2749, 15, 23, 19, 2, -17 },
  { 2793, 14, 23, 19, 2, -23 },
  { 2834, 15, 24, 19, 1, -24 },
  { 2879, 15, 30, 19, 1, -24 },
  { 2936, 16, 23, 19, 2, -23 },
  { 2982, 13, 23, 19, 3, -23 },
  { 3020, 16, 17, 19, 1, -17 },
  { 3054, 14, 17, 19, 2, -17 },
  { 3084, 14, 17, 19, 2, -17 },
  { 3114, 15, 23, 19, 1, -17 },
  { 3158, 15, 23, 19, 2, -17 },
  { 3202, 15, 17, 19, 2, -17 },
  { 3234, 14, 17, 19, 2, -17 },
  { 3264, 14, 22, 19, 3, -22 },
  { 3303, 15, 17, 19, 2, -17 },
  { 3335, 15, 17, 19, 3, -17 },
  { 3367, 16, 17, 19, 3, -17 },
  { 3401, 17, 17, 19, 1, -17 },
  { 3438, 15, 23, 19, 2, -17 },
  { 3482, 15, 17, 19, 2, -17 },
  { 3514, 15, 29, 19, 3, -26 },
  { 3569, 7, 29, 19, 6, -26 },
  { 3595, 15, 29, 19, 1, -26 },
  { 3650, 15, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC31PT7B_H_
