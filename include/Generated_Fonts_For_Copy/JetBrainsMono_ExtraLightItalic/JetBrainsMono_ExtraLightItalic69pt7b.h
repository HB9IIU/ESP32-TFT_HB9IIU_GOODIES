#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC69PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x9C, 0xFF, 0x00,
  0x1F, 0x83, 0x87, 0xE0, 0x07, 0xE0, 0xF0, 0x7E, 0x00, 0xF8, 0x1E, 0x07,
  0xC0, 0x3E, 0x03, 0x80, 0xF8, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x0E,
  0x01, 0xE0, 0x3E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0x7C, 0x07, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x01, 0xF8, 0x3C, 0x00,
  0x00, 0x3F, 0x07, 0x80, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0x7F, 0x9C,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xDF, 0xF0, 0x00, 0x00, 0x38, 0x7E,
  0x00, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3C,
  0x0F, 0xC0, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00,
  0x1C, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x87,
  0xC0, 0x1E, 0x01, 0xF0, 0xF8, 0x03, 0x80, 0x3E, 0x1F, 0x00, 0x70, 0x07,
  0x83, 0xE0, 0x0E, 0x01, 0xF0, 0x7C, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0x38,
  0x0F, 0x80, 0xF8, 0x0F, 0x03, 0xF0, 0x1F, 0x81, 0xE0, 0xFC, 0x01, 0xFC,
  0x38, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x03,
  0xC1, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x1F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x9F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x03,
  0xE0, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0xF0, 0x3E, 0x00, 0x3E,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0xF8, 0x0F, 0x00, 0x07, 0xCF, 0x80, 0x78,
  0x00, 0x1F, 0x78, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x03, 0xFC,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x01, 0xFE, 0x00,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x3F,
  0x1F, 0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF9, 0xFF, 0x03, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0x00, 0xFF, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x00, 0xF8, 0x00, 0x23, 0xC0, 0x0F,
  0x80, 0x1E, 0x7F, 0x80, 0xF0, 0x0F, 0xF7, 0xFE, 0x0F, 0x07, 0xFF, 0xFF,
  0xF8, 0xF1, 0xFF, 0xF1, 0xFF, 0xC6, 0x7F, 0xF8, 0x07, 0xFF, 0xEF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0,
  0x0F, 0x87, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF,
  0x8F, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x1E, 0x01, 0xF0, 0xF8,
  0x0F, 0xC0, 0x7C, 0x3E, 0x07, 0xF0, 0x1E, 0x0F, 0x81, 0xFE, 0x07, 0x83,
  0xE0, 0x7F, 0x03, 0xE0, 0xF0, 0x1F, 0xC0, 0xF8, 0x3C, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x74,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF7, 0x80, 0x00, 0x7F, 0x1E,
  0x00, 0x03, 0xF8, 0x78, 0x00, 0x3F, 0x83, 0xE0, 0x01, 0xFC, 0x0F, 0x80,
  0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x02,
  0x00, 0x0F, 0x00, 0x10, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x0F, 0x1F, 0x80, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0xFF, 0x80, 0x01, 0xE1, 0xFF, 0xF0, 0x01, 0xF3, 0xFF,
  0xFC, 0x00, 0xFB, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x3D, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF1, 0xFF, 0xC0, 0x01, 0xF7,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x1F, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xE7, 0x80, 0x01, 0xFF, 0x8F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x06,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xFF, 0x1E, 0x07, 0x80, 0x07, 0xFF, 0x9E,
  0x07, 0x80, 0x0F, 0xFF, 0xDE, 0x07, 0x80, 0x1F, 0xC3, 0xDE, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x00,
  0x7C, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x0F,
  0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x3C,
  0x01, 0xE0, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x06, 0xE0, 0x78, 0x00, 0xFF, 0x7D, 0xE0,
  0x78, 0x00, 0xFF, 0xFD, 0xE0, 0x78, 0x00, 0x7F, 0xF1, 0xE0, 0x78, 0x00,
  0x1F, 0xE1, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x0F, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x1F, 0xE0,
  0x07, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x01, 0xF8, 0x07, 0x80, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x1F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xE0, 0xF8, 0x07, 0xFF,
  0xF8, 0x3E, 0x01, 0xFF, 0xFE, 0x0F, 0x80, 0x7F, 0xFF, 0x83, 0xE0, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0xEE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x77, 0x80, 0xF7, 0x00, 0x07, 0xBC, 0x07, 0xB8, 0x00, 0x39, 0xC0,
  0x39, 0xE0, 0x03, 0xDE, 0x03, 0xCF, 0x00, 0x1C, 0xF0, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0xF1, 0xC0, 0x0E, 0x3C, 0x07, 0x8E, 0x00, 0xF3, 0xE0, 0x3C,
  0x78, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0x87,
  0x80, 0xF8, 0xF0, 0x3C, 0x3C, 0x07, 0x83, 0x81, 0xC3, 0xE0, 0x3C, 0x1C,
  0x1E, 0x1F, 0x01, 0xE0, 0xF0, 0xE0, 0xF0, 0x0F, 0x07, 0x8F, 0x07, 0x80,
  0x78, 0x3C, 0x70, 0x3C, 0x07, 0xC0, 0xE7, 0x81, 0xE0, 0x3E, 0x07, 0x38,
  0x1F, 0x01, 0xF0, 0x3F, 0xC0, 0xF8, 0x0F, 0x01, 0xFC, 0x07, 0xC0, 0x78,
  0x0F, 0xE0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x1F, 0xC0, 0x00, 0x3C, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x7B, 0xC0,
  0x00, 0xF0, 0x0F, 0x78, 0x00, 0x1E, 0x01, 0xEF, 0x00, 0x07, 0xC0, 0x7D,
  0xE0, 0x00, 0xF8, 0x0F, 0x9E, 0x00, 0x1F, 0x01, 0xE3, 0xC0, 0x03, 0xC0,
  0x3C, 0x78, 0x00, 0x78, 0x07, 0x8F, 0x00, 0x0F, 0x00, 0xF1, 0xE0, 0x01,
  0xE0, 0x3E, 0x1E, 0x00, 0x7C, 0x07, 0xC3, 0xC0, 0x0F, 0x80, 0xF8, 0x78,
  0x01, 0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x03, 0xC1, 0xF0, 0x07, 0x80, 0x78,
  0x1E, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC0,
  0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x1F, 0x01, 0xF0, 0x0F,
  0x83, 0xE0, 0x3E, 0x00, 0xF0, 0x7C, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0xF0,
  0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x07, 0x87, 0x80,
  0xF8, 0x00, 0xF1, 0xF0, 0x1F, 0x00, 0x1E, 0x3E, 0x03, 0xE0, 0x03, 0xC7,
  0x80, 0x78, 0x00, 0x7C, 0xF0, 0x0F, 0x00, 0x07, 0x9E, 0x01, 0xE0, 0x00,
  0xF3, 0xC0, 0x7C, 0x00, 0x1E, 0x78, 0x0F, 0x80, 0x03, 0xCF, 0x01, 0xF0,
  0x00, 0x3F, 0xE0, 0x3C, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x3E, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xFC, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xE0,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xD0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x1E, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x78, 0x00, 0x7C, 0x00, 0x7C, 0xF0, 0x01, 0xF8, 0x00, 0xF1, 0xE0, 0x03,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0xC0, 0x0F,
  0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x1E, 0x00, 0x77, 0x00, 0x3C, 0x3C, 0x01,
  0xEE, 0x00, 0xF8, 0x78, 0x03, 0x9C, 0x01, 0xE0, 0xF0, 0x07, 0x38, 0x03,
  0xC1, 0xE0, 0x0E, 0x70, 0x07, 0x83, 0xC0, 0x3C, 0xE0, 0x1E, 0x07, 0x80,
  0x71, 0xC0, 0x3C, 0x0F, 0x00, 0xE3, 0x80, 0x78, 0x1E, 0x03, 0xC7, 0x01,
  0xF0, 0x3C, 0x07, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x1C, 0x07, 0x80, 0xF0,
  0x1C, 0x38, 0x0F, 0x01, 0xE0, 0x70, 0x70, 0x3C, 0x07, 0xC0, 0xE0, 0xE0,
  0x78, 0x0F, 0x81, 0xC1, 0xC0, 0xF0, 0x1E, 0x07, 0x83, 0x81, 0xE0, 0x3C,
  0x0E, 0x07, 0x07, 0x80, 0x78, 0x1C, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x1C,
  0x1E, 0x01, 0xE0, 0xE0, 0x78, 0x78, 0x03, 0xC1, 0xC0, 0xF0, 0xF0, 0x07,
  0x83, 0x81, 0xE1, 0xE0, 0x0F, 0x0E, 0x03, 0x83, 0xC0, 0x1E, 0x1C, 0x07,
  0x0F, 0x00, 0x3C, 0x38, 0x0E, 0x1E, 0x00, 0x78, 0xF0, 0x1C, 0x3C, 0x00,
  0xF1, 0xC0, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x71, 0xE0, 0x03, 0xC7, 0x00,
  0xE3, 0xC0, 0x07, 0x9C, 0x01, 0xC7, 0x80, 0x0F, 0x38, 0x03, 0x9E, 0x00,
  0x1E, 0x70, 0x07, 0x3C, 0x00, 0x3D, 0xE0, 0x0E, 0x78, 0x00, 0x7B, 0x80,
  0x1C, 0xF0, 0x00, 0xF7, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x77, 0x80,
  0x03, 0xF8, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x0F, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x0F, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0xFF, 0xFF, 0x9F, 0x01, 0xFF,
  0x0F, 0xDF, 0x03, 0xF8, 0x01, 0xDF, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xC0,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0D, 0xE0, 0x3F, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFB, 0xE0, 0x1F, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF,
  0xE3, 0xE0, 0x03, 0xFF, 0x83, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x3E, 0x0F, 0xFE, 0x00, 0x1E, 0x1F, 0xFF, 0x80, 0x0F, 0x3F, 0xFF, 0xE0,
  0x07, 0xBF, 0x0F, 0xF8, 0x07, 0xDC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x78, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x7C, 0x07,
  0xF0, 0x00, 0x7E, 0x03, 0xDE, 0x00, 0x7E, 0x01, 0xEF, 0xC1, 0xFE, 0x01,
  0xF3, 0xFF, 0xFE, 0x00, 0xF8, 0xFF, 0xFE, 0x00, 0x7C, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x20, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x0F, 0xFF, 0xC3, 0xC0, 0x0F, 0xFF, 0xF9,
  0xF0, 0x07, 0xFC, 0x3F, 0x7C, 0x03, 0xF8, 0x01, 0xDF, 0x00, 0xF8, 0x00,
  0x3F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0D, 0xE0, 0x0F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xBE, 0x00, 0x7F, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0xE3,
  0xE0, 0x00, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x3F,
  0xFF, 0x0F, 0x00, 0x7F, 0xFF, 0x9F, 0x01, 0xFF, 0x0F, 0xDF, 0x03, 0xF8,
  0x01, 0xDF, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0x80,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x3D, 0xF0, 0x1F, 0xFF,
  0xF9, 0xE0, 0x0F, 0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0xE3, 0xE0, 0x01, 0xFF,
  0x83, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x03, 0xC3, 0xFF, 0xF0, 0x03, 0xCF,
  0xFF, 0xF8, 0x03, 0xDF, 0x83, 0xFC, 0x07, 0xDC, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x1E, 0x3F, 0xC1, 0xFE, 0x00, 0xF3, 0xFE, 0x1F, 0xF8, 0x07, 0xBF, 0xF9,
  0xFF, 0xC0, 0x3F, 0x07, 0xDC, 0x3F, 0x03, 0xD0, 0x1E, 0x80, 0xF8, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x7C, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0xF8, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x78, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x3E, 0x00,
  0xF0, 0x07, 0xC1, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x78, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x78,
  0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0xF0, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xE1, 0xFF, 0xE0, 0x03, 0xC3, 0xFF, 0xF0, 0x03, 0xCF, 0xFF, 0xF8,
  0x03, 0xDF, 0x83, 0xFC, 0x07, 0xDC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x03, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x07, 0xFF, 0x00, 0x03, 0xC3, 0xFF, 0xF0, 0x00, 0x79, 0xFF, 0xFF,
  0x00, 0x0F, 0x7E, 0x0F, 0xF0, 0x03, 0xEE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xD8, 0x00, 0x3F, 0x00,
  0x7B, 0xC0, 0x0F, 0xC0, 0x0F, 0x7E, 0x0F, 0xF0, 0x03, 0xE7, 0xFF, 0xFC,
  0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x0F, 0x87, 0xFF, 0x80, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00,
  0x3F, 0xFF, 0x1F, 0x00, 0xFF, 0xFF, 0x9F, 0x01, 0xFF, 0x0F, 0xDF, 0x03,
  0xF8, 0x01, 0xDF, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0D, 0xE0, 0x3F, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFB, 0xE0, 0x1F, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xE3, 0xC0, 0x03,
  0xFF, 0x83, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xFF, 0xF0, 0x00,
  0xF8, 0xFF, 0xFE, 0x00, 0x79, 0xFF, 0xFF, 0x80, 0x3C, 0xF8, 0x3F, 0xC0,
  0x1E, 0xE0, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x7C,
  0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xF1,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x3D,
  0xE0, 0x0F, 0xE0, 0x0F, 0xBC, 0x01, 0xDC, 0x01, 0xE7, 0x80, 0x3B, 0x80,
  0x3C, 0xF0, 0x0F, 0x70, 0x07, 0x9E, 0x01, 0xCE, 0x01, 0xE3, 0xC0, 0x39,
  0xC0, 0x3C, 0x78, 0x0F, 0x38, 0x07, 0x8F, 0x01, 0xC7, 0x01, 0xE1, 0xE0,
  0x38, 0xE0, 0x3C, 0x3C, 0x0F, 0x1C, 0x07, 0x87, 0x81, 0xC3, 0x81, 0xE0,
  0xF0, 0x38, 0x70, 0x3C, 0x1E, 0x0F, 0x0E, 0x07, 0x83, 0xC1, 0xC1, 0xC1,
  0xE0, 0x78, 0x38, 0x38, 0x3C, 0x0F, 0x0F, 0x07, 0x07, 0x81, 0xE1, 0xC0,
  0xE1, 0xE0, 0x3C, 0x38, 0x1C, 0x3C, 0x07, 0x8F, 0x03, 0x87, 0x80, 0xF1,
  0xC0, 0x71, 0xE0, 0x1E, 0x38, 0x0E, 0x3C, 0x03, 0xCF, 0x01, 0xC7, 0x80,
  0x79, 0xC0, 0x39, 0xE0, 0x0F, 0x38, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x07, 0xB8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x1D, 0xE0, 0x3F, 0x80, 0x3D,
  0xE0, 0x1F, 0xFF, 0xF9, 0xE0, 0x0F, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xC3,
  0xE0, 0x01, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0x83, 0xFF, 0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x03, 0xE3, 0xFF,
  0xF0, 0x01, 0xE3, 0xE0, 0xFC, 0x00, 0xF1, 0xE0, 0x3E, 0x00, 0x79, 0xF0,
  0x0F, 0x80, 0x3C, 0xF0, 0x03, 0xE0, 0x3E, 0x78, 0x01, 0xF8, 0x3E, 0x3C,
  0x00, 0x7F, 0x7F, 0x1E, 0x00, 0x1F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x0F,
  0x80, 0x01, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 14, 50, 41, 14, -50 },
  { 89, 22, 20, 41, 13, -50 },
  { 144, 40, 50, 41, 2, -50 },
  { 394, 35, 70, 41, 4, -60 },
  { 701, 47, 51, 41, -2, -51 },
  { 1001, 37, 52, 41, 2, -51 },
  { 1242, 8, 20, 41, 20, -50 },
  { 1262, 28, 67, 41, 12, -58 },
  { 1497, 27, 67, 41, 4, -58 },
  { 1724, 36, 35, 41, 4, -42 },
  { 1882, 32, 32, 41, 5, -39 },
  { 2010, 16, 21, 41, 8, -10 },
  { 2052, 23, 4, 41, 10, -25 },
  { 2064, 11, 11, 41, 13, -10 },
  { 2080, 39, 65, 41, 2, -57 },
  { 2397, 34, 52, 41, 5, -51 },
  { 2618, 30, 50, 41, 4, -50 },
  { 2806, 36, 51, 41, 3, -51 },
  { 3036, 34, 51, 41, 4, -50 },
  { 3253, 31, 50, 41, 5, -50 },
  { 3447, 33, 51, 41, 5, -50 },
  { 3658, 32, 51, 41, 4, -50 },
  { 3862, 33, 50, 41, 8, -50 },
  { 4069, 34, 52, 41, 4, -51 },
  { 4290, 32, 51, 41, 7, -51 },
  { 4494, 16, 40, 41, 13, -39 },
  { 4574, 21, 50, 41, 8, -39 },
  { 4706, 33, 35, 41, 6, -40 },
  { 4851, 32, 20, 41, 5, -33 },
  { 4931, 32, 35, 41, 4, -40 },
  { 5071, 27, 50, 41, 11, -50 },
  { 5240, 40, 63, 41, 1, -51 },
  { 5555, 33, 50, 41, 1, -50 },
  { 5762, 35, 50, 41, 4, -50 },
  { 5981, 34, 52, 41, 5, -51 },
  { 6202, 34, 50, 41, 4, -50 },
  { 6415, 35, 50, 41, 5, -50 },
  { 6634, 37, 50, 41, 4, -50 },
  { 6866, 34, 52, 41, 5, -51 },
  { 7087, 35, 50, 41, 4, -50 },
  { 7306, 34, 50, 41, 5, -50 },
  { 7519, 37, 51, 41, 2, -50 },
  { 7755, 38, 50, 41, 4, -50 },
  { 7993, 29, 50, 41, 5, -50 },
  { 8175, 37, 50, 41, 3, -50 },
  { 8407, 35, 50, 41, 4, -50 },
  { 8626, 33, 52, 41, 5, -51 },
  { 8841, 37, 50, 41, 4, -50 },
  { 9073, 33, 63, 41, 5, -51 },
  { 9333, 36, 50, 41, 4, -50 },
  { 9558, 35, 52, 41, 4, -51 },
  { 9786, 34, 50, 41, 8, -50 },
  { 9999, 34, 51, 41, 5, -50 },
  { 10216, 33, 50, 41, 9, -50 },
  { 10423, 39, 50, 41, 5, -50 },
  { 10667, 42, 50, 41, 0, -50 },
  { 10930, 35, 50, 41, 8, -50 },
  { 11149, 36, 50, 41, 3, -50 },
  { 11374, 26, 65, 41, 11, -57 },
  { 11586, 19, 65, 41, 12, -57 },
  { 11741, 27, 65, 41, 6, -57 },
  { 11961, 29, 27, 41, 7, -50 },
  { 12059, 34, 4, 41, 0, 2 },
  { 12076, 11, 10, 41, 19, -54 },
  { 12090, 32, 40, 41, 5, -39 },
  { 12250, 33, 51, 41, 4, -50 },
  { 12461, 32, 40, 41, 5, -39 },
  { 12621, 34, 51, 41, 5, -50 },
  { 12838, 31, 40, 41, 5, -39 },
  { 12993, 44, 62, 41, -2, -50 },
  { 13334, 32, 51, 41, 5, -39 },
  { 13538, 32, 50, 41, 4, -50 },
  { 13738, 32, 53, 41, 3, -53 },
  { 13950, 35, 65, 41, 1, -53 },
  { 14235, 36, 50, 41, 4, -50 },
  { 14460, 28, 50, 41, 7, -50 },
  { 14635, 37, 39, 41, 2, -39 },
  { 14816, 32, 39, 41, 4, -39 },
  { 14972, 31, 40, 41, 5, -39 },
  { 15127, 35, 51, 41, 2, -39 },
  { 15351, 32, 51, 41, 5, -39 },
  { 15555, 33, 39, 41, 5, -39 },
  { 15716, 32, 40, 41, 4, -39 },
  { 15876, 31, 48, 41, 7, -48 },
  { 16062, 32, 39, 41, 5, -38 },
  { 16218, 32, 38, 41, 8, -38 },
  { 16370, 35, 38, 41, 6, -38 },
  { 16537, 37, 38, 41, 2, -38 },
  { 16713, 32, 50, 41, 5, -38 },
  { 16913, 33, 38, 41, 4, -38 },
  { 17070, 34, 65, 41, 7, -57 },
  { 17347, 15, 65, 41, 14, -57 },
  { 17469, 34, 65, 41, 2, -57 },
  { 17746, 33, 13, 41, 5, -31 },
};

const GFXfont JetBrainsMono_ExtraLightItalic69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC69PT7B_H_
