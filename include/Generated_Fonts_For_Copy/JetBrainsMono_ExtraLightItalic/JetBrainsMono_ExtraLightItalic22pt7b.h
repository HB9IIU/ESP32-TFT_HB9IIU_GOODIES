#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC22PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x21, 0x08, 0xC6, 0x21, 0x08, 0x00, 0x01, 0x9C, 0x66,
  0xCD, 0x1A, 0x34, 0x58, 0xB1, 0x00, 0x06, 0x30, 0x42, 0x04, 0x20, 0xC6,
  0x7F, 0xF7, 0xFF, 0x18, 0xC1, 0x08, 0x10, 0x83, 0x18, 0xFF, 0xE2, 0x10,
  0x43, 0x04, 0x20, 0xC2, 0x08, 0x40, 0x01, 0x00, 0x20, 0x04, 0x07, 0xE1,
  0x96, 0x24, 0x4C, 0x89, 0x90, 0x32, 0x03, 0x40, 0x7C, 0x03, 0xC0, 0x4C,
  0x08, 0x81, 0x16, 0x22, 0xC4, 0xCD, 0xB0, 0xFC, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x0F, 0x02, 0x32, 0x08, 0x46, 0x20, 0x88, 0x83, 0x13, 0x06, 0x2C,
  0x07, 0x90, 0x00, 0x40, 0x01, 0x00, 0x04, 0xF0, 0x12, 0x20, 0x64, 0x41,
  0x98, 0x82, 0x31, 0x08, 0x66, 0x60, 0x78, 0x0F, 0x83, 0x18, 0x41, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x01, 0xC0, 0x4C, 0x38, 0xCB, 0x0B, 0x61, 0xC8,
  0x11, 0x07, 0x31, 0xB3, 0xC2, 0x6D, 0xA4, 0xB0, 0x00, 0x81, 0x83, 0x83,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0E, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x07, 0x0E, 0x04, 0x00, 0x03, 0x00,
  0x20, 0x02, 0x06, 0x67, 0xFD, 0xE0, 0xF0, 0x0A, 0x01, 0xB0, 0x31, 0x06,
  0x18, 0x21, 0x00, 0x04, 0x01, 0x00, 0xC0, 0x30, 0xFF, 0xC2, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x00, 0x1C, 0xE3, 0x08, 0x61, 0x0C, 0x00, 0xFE, 0x6F,
  0xE0, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x0F, 0xC3, 0x0C, 0xC1, 0x98,
  0x12, 0x02, 0x40, 0xD8, 0x1B, 0x33, 0x66, 0x48, 0x09, 0x01, 0x20, 0x64,
  0x0C, 0x81, 0x18, 0x61, 0xF0, 0x03, 0x83, 0x41, 0x90, 0x84, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x43,
  0xFF, 0x0F, 0xC3, 0x0C, 0xC0, 0x90, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x07, 0xFE, 0x1F,
  0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xE0, 0x4C, 0x00, 0xC0,
  0x08, 0x03, 0x00, 0x6C, 0x08, 0x81, 0x18, 0xC1, 0xF0, 0x00, 0xC0, 0x40,
  0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC2, 0x60, 0xB0, 0x68, 0x1B, 0xFE,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x3F, 0xC8, 0x02, 0x01, 0x80, 0x60, 0x19,
  0x85, 0xF9, 0x86, 0x40, 0x80, 0x20, 0x08, 0x06, 0x81, 0xA0, 0x4C, 0x31,
  0xF0, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x05, 0xC1, 0xCE,
  0x60, 0xCC, 0x09, 0x01, 0x60, 0x2C, 0x0C, 0x81, 0x18, 0x61, 0xF0, 0xFF,
  0xF0, 0x3C, 0x0A, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x0F, 0xC3, 0x0C, 0x40, 0x98,
  0x13, 0x06, 0x60, 0x86, 0x60, 0x78, 0x1B, 0x86, 0x11, 0x83, 0x20, 0x2C,
  0x0C, 0x81, 0x98, 0x61, 0xF8, 0x1F, 0x86, 0x19, 0x81, 0x20, 0x24, 0x05,
  0x80, 0xB0, 0x33, 0x0C, 0x77, 0x83, 0xA0, 0x08, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x03, 0x80, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x3D, 0xC0, 0x0E,
  0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04, 0x30, 0x61, 0x82, 0x0C, 0x10,
  0x60, 0x00, 0x40, 0x70, 0x70, 0x70, 0x70, 0x30, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x20,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x03, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0C,
  0x3C, 0x18, 0x08, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x07, 0xE0, 0x61,
  0x86, 0x06, 0x20, 0x13, 0x00, 0x90, 0x6C, 0x8E, 0xE4, 0x42, 0x62, 0x13,
  0x30, 0x99, 0x84, 0x88, 0x64, 0x43, 0x23, 0x39, 0x0E, 0x88, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x60,
  0x6C, 0x09, 0x83, 0x30, 0x42, 0x08, 0x43, 0x08, 0x7F, 0x1F, 0xE2, 0x06,
  0xC0, 0xD8, 0x1E, 0x03, 0x1F, 0xC2, 0x1C, 0xC1, 0x98, 0x13, 0x06, 0x40,
  0xC8, 0x31, 0xF8, 0x61, 0xCC, 0x19, 0x81, 0x20, 0x24, 0x04, 0x81, 0x90,
  0xE7, 0xF0, 0x1F, 0x8C, 0x32, 0x05, 0x81, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x81, 0xA0, 0x4C, 0x31, 0xF0, 0x1F, 0x82,
  0x18, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xC8, 0x19, 0x02, 0x60, 0x4C, 0x09,
  0x83, 0x20, 0x64, 0x08, 0x83, 0x10, 0xC7, 0xF0, 0x1F, 0xF1, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x4F, 0xF8, 0x1F, 0xF1, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x3F, 0xC6, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x1F, 0x8C, 0x32, 0x05,
  0x81, 0x40, 0x10, 0x04, 0x01, 0x00, 0xCF, 0xF0, 0x2C, 0x0A, 0x02, 0x81,
  0xA0, 0x4C, 0x31, 0xF0, 0x10, 0x31, 0x02, 0x30, 0x23, 0x06, 0x30, 0x62,
  0x06, 0x20, 0x43, 0xFC, 0x60, 0x46, 0x04, 0x60, 0xC4, 0x0C, 0x40, 0xC4,
  0x08, 0x40, 0x8C, 0x08, 0x3F, 0xC1, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x83, 0xFC,
  0x03, 0xE0, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x20, 0x48, 0x09, 0x83, 0x38, 0xC3, 0xF0, 0x10, 0x31,
  0x02, 0x30, 0x63, 0x0C, 0x30, 0x82, 0x18, 0x23, 0x03, 0xE0, 0x63, 0x06,
  0x30, 0x61, 0x04, 0x18, 0x41, 0x84, 0x08, 0x40, 0xCC, 0x0C, 0x30, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C,
  0x04, 0x02, 0x01, 0xFF, 0x38, 0x32, 0x87, 0x28, 0x62, 0x8A, 0x28, 0xA2,
  0x92, 0x65, 0x66, 0x66, 0x66, 0x64, 0x04, 0x40, 0x44, 0x04, 0xC0, 0xCC,
  0x0C, 0xC0, 0xC8, 0x08, 0x18, 0x31, 0x82, 0x38, 0x23, 0xC2, 0x34, 0x62,
  0x46, 0x24, 0x62, 0x44, 0x66, 0x46, 0x24, 0x62, 0xC4, 0x2C, 0x43, 0xC4,
  0x38, 0x41, 0x8C, 0x18, 0x1F, 0x8C, 0x32, 0x0D, 0x81, 0x40, 0xD0, 0x34,
  0x0D, 0x02, 0xC0, 0xB0, 0x2C, 0x0A, 0x06, 0x81, 0xA0, 0x4C, 0x31, 0xF0,
  0x1F, 0xC1, 0x06, 0x30, 0x33, 0x03, 0x30, 0x32, 0x03, 0x20, 0x62, 0x0C,
  0x7F, 0x86, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x1F, 0x8C, 0x32, 0x0D, 0x81, 0x40, 0x50, 0x34, 0x0F, 0x02, 0xC0, 0xB0,
  0x28, 0x0A, 0x06, 0x81, 0xA0, 0x4C, 0x31, 0xF0, 0x04, 0x01, 0x80, 0x60,
  0x0C, 0x1F, 0xC1, 0x06, 0x30, 0x23, 0x03, 0x30, 0x22, 0x02, 0x20, 0x62,
  0x1C, 0x7F, 0x06, 0x30, 0x63, 0x04, 0x10, 0x41, 0x84, 0x18, 0x40, 0x8C,
  0x0C, 0x0F, 0xC3, 0x0C, 0x40, 0x98, 0x13, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0x00, 0x2C, 0x05, 0x81, 0x98, 0x61, 0xF8, 0xFF,
  0xE1, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x64, 0x09,
  0x81, 0x30, 0x26, 0x0C, 0x81, 0x90, 0x32, 0x04, 0xC0, 0x98, 0x13, 0x06,
  0x40, 0xC8, 0x19, 0x02, 0x30, 0xC3, 0xE0, 0x80, 0x70, 0x3C, 0x0B, 0x06,
  0xC1, 0x10, 0x44, 0x31, 0x08, 0x46, 0x11, 0x04, 0xC1, 0xB0, 0x68, 0x1E,
  0x07, 0x00, 0xC0, 0xC6, 0x1C, 0x63, 0xC6, 0x2C, 0xA2, 0x8A, 0x68, 0xA4,
  0x92, 0x49, 0x24, 0x92, 0xC9, 0x28, 0xA2, 0x8A, 0x28, 0xA3, 0x8C, 0x30,
  0xC3, 0x0C, 0x30, 0x18, 0x18, 0x40, 0x82, 0x0C, 0x18, 0xC0, 0x44, 0x03,
  0x40, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x2C, 0x03, 0x60, 0x31, 0x01, 0x0C,
  0x18, 0x21, 0x81, 0x98, 0x0C, 0x80, 0x78, 0x1B, 0x02, 0x20, 0x86, 0x30,
  0xC4, 0x09, 0x81, 0xE0, 0x38, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x0F, 0xF8, 0x0F, 0x8C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x1F, 0x80, 0x83, 0x0C, 0x10, 0x41, 0x86, 0x08, 0x20, 0x83, 0x0C, 0x10,
  0x41, 0x86, 0x08, 0x20, 0xC3, 0x1F, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0xF8, 0x06, 0x03, 0x02, 0xC3, 0x21, 0x11, 0x8D, 0x86, 0x81, 0xC0, 0x80,
  0xFF, 0xE0, 0xC6, 0x30, 0x1E, 0xD8, 0x74, 0x09, 0x02, 0xC0, 0xB0, 0x2C,
  0x1A, 0x06, 0x81, 0xA0, 0x4C, 0x31, 0xF4, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0xF8, 0x51, 0x8C, 0x11, 0x02, 0x60, 0x4C, 0x09, 0x81, 0x20, 0x64,
  0x0C, 0xC1, 0x18, 0x66, 0xF8, 0x1F, 0x0C, 0x64, 0x0D, 0x03, 0xC0, 0x30,
  0x0C, 0x02, 0x00, 0x81, 0xA0, 0x4C, 0x31, 0xF0, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x21, 0xEC, 0xC3, 0x90, 0x32, 0x04, 0xC0, 0x98, 0x13, 0x06, 0x40,
  0xC8, 0x19, 0x02, 0x30, 0xC3, 0xE8, 0x1F, 0x08, 0x64, 0x09, 0x02, 0xC0,
  0xBF, 0xEC, 0x02, 0x00, 0x80, 0x20, 0x6C, 0x31, 0xF0, 0x00, 0x7C, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x7F, 0xE0, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x3E, 0x00, 0x1E, 0xC8, 0x74, 0x09,
  0x02, 0xC0, 0xB0, 0x2C, 0x1A, 0x06, 0xC1, 0xB0, 0xC7, 0xD0, 0x04, 0x03,
  0x00, 0xC0, 0x63, 0xF0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x51,
  0x8C, 0x11, 0x02, 0x60, 0x4C, 0x09, 0x83, 0x20, 0x64, 0x0C, 0x81, 0x10,
  0x26, 0x04, 0x03, 0x80, 0xE0, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC0,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0xFC, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x72, 0x04, 0x20, 0x82, 0x18, 0x23, 0x07, 0xE0, 0x66,
  0x06, 0x30, 0x43, 0x04, 0x18, 0x41, 0x8C, 0x0C, 0xFC, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x3F, 0x7F, 0xEC, 0xC5, 0x98, 0xA3, 0x14, 0x46, 0x88, 0xD1, 0x16,
  0x22, 0xC4, 0x51, 0x8A, 0x33, 0x44, 0x60, 0x3F, 0x85, 0x18, 0xC1, 0x10,
  0x26, 0x04, 0xC0, 0x98, 0x32, 0x06, 0x40, 0xC8, 0x11, 0x02, 0x60, 0x40,
  0x1F, 0x08, 0x64, 0x09, 0x02, 0xC0, 0xB0, 0x2C, 0x0A, 0x06, 0x81, 0xA0,
  0x4C, 0x31, 0xF0, 0x3F, 0x85, 0x18, 0xC1, 0x10, 0x26, 0x04, 0xC0, 0x98,
  0x12, 0x06, 0x40, 0xCC, 0x11, 0x86, 0x6F, 0x8C, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x1E, 0xD8, 0x74, 0x09, 0x02, 0xC0, 0xB0, 0x2C, 0x1A, 0x06, 0x81,
  0xA0, 0x4C, 0x31, 0xF4, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x2F, 0x9C, 0x36,
  0x0D, 0x83, 0x40, 0xD0, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x1F, 0xC6, 0x08, 0x81, 0x90, 0x03, 0x00, 0x3E, 0x00, 0xE0, 0x06, 0x00,
  0xD8, 0x19, 0x86, 0x1F, 0x80, 0x0C, 0x03, 0x00, 0x83, 0xFF, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xF0,
  0x60, 0xD0, 0x34, 0x0D, 0x02, 0xC0, 0xB0, 0x2C, 0x1A, 0x06, 0x81, 0xA0,
  0x4C, 0x61, 0xF0, 0xC0, 0x68, 0x19, 0x02, 0x30, 0xC6, 0x10, 0x46, 0x08,
  0x81, 0x30, 0x24, 0x07, 0x80, 0xE0, 0x0C, 0x00, 0x84, 0x31, 0x8E, 0x31,
  0x46, 0x29, 0x4D, 0x29, 0x25, 0x25, 0x2C, 0xA5, 0x14, 0xA3, 0x14, 0x63,
  0x00, 0x18, 0x30, 0x86, 0x0C, 0x40, 0x48, 0x07, 0x80, 0x30, 0x07, 0x00,
  0xD0, 0x19, 0x81, 0x08, 0x20, 0xCE, 0x06, 0x60, 0xD0, 0x34, 0x09, 0x02,
  0xC0, 0xB0, 0x68, 0x1A, 0x06, 0xC1, 0x31, 0xC7, 0xD0, 0x04, 0x03, 0x00,
  0xC0, 0x63, 0xF0, 0x3F, 0xE0, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x1F, 0x83, 0xE0, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x20, 0x07, 0x80,
  0x11, 0x33, 0x22, 0x22, 0x66, 0x64, 0x44, 0xCC, 0xC8, 0x88, 0x1E, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFC,
  0x1F, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x78, 0x00, 0x70, 0x76, 0x18, 0xCE, 0x1E,
};

const GFXglyph JetBrainsMono_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 7, 13, 4, -16 },
  { 18, 12, 16, 13, 1, -16 },
  { 42, 11, 22, 13, 1, -19 },
  { 73, 15, 16, 13, -1, -16 },
  { 103, 11, 16, 13, 1, -16 },
  { 125, 3, 7, 13, 6, -16 },
  { 128, 9, 22, 13, 4, -19 },
  { 153, 9, 22, 13, 1, -19 },
  { 178, 12, 11, 13, 1, -13 },
  { 195, 10, 10, 13, 2, -12 },
  { 208, 6, 7, 13, 2, -3 },
  { 214, 7, 1, 13, 3, -8 },
  { 215, 4, 3, 13, 4, -3 },
  { 217, 12, 20, 13, 1, -18 },
  { 247, 11, 16, 13, 1, -16 },
  { 269, 10, 16, 13, 1, -16 },
  { 289, 11, 16, 13, 1, -16 },
  { 311, 11, 16, 13, 1, -16 },
  { 333, 10, 16, 13, 2, -16 },
  { 353, 10, 16, 13, 2, -16 },
  { 373, 11, 16, 13, 1, -16 },
  { 395, 10, 16, 13, 3, -16 },
  { 415, 11, 16, 13, 1, -16 },
  { 437, 11, 16, 13, 2, -16 },
  { 459, 5, 12, 13, 4, -12 },
  { 467, 7, 16, 13, 2, -12 },
  { 481, 10, 11, 13, 2, -13 },
  { 495, 10, 6, 13, 2, -10 },
  { 503, 11, 11, 13, 1, -13 },
  { 519, 9, 16, 13, 3, -16 },
  { 537, 13, 20, 13, 0, -16 },
  { 570, 11, 16, 13, 0, -16 },
  { 592, 11, 16, 13, 1, -16 },
  { 614, 10, 16, 13, 2, -16 },
  { 634, 11, 16, 13, 1, -16 },
  { 656, 12, 16, 13, 1, -16 },
  { 680, 12, 16, 13, 1, -16 },
  { 704, 10, 16, 13, 2, -16 },
  { 724, 12, 16, 13, 1, -16 },
  { 748, 10, 16, 13, 2, -16 },
  { 768, 11, 16, 13, 1, -16 },
  { 790, 12, 16, 13, 1, -16 },
  { 814, 9, 16, 13, 2, -16 },
  { 832, 12, 16, 13, 1, -16 },
  { 856, 12, 16, 13, 1, -16 },
  { 880, 10, 16, 13, 2, -16 },
  { 900, 12, 16, 13, 1, -16 },
  { 924, 10, 20, 13, 2, -16 },
  { 949, 12, 16, 13, 1, -16 },
  { 973, 11, 16, 13, 1, -16 },
  { 995, 11, 16, 13, 3, -16 },
  { 1017, 11, 16, 13, 2, -16 },
  { 1039, 10, 16, 13, 3, -16 },
  { 1059, 12, 16, 13, 2, -16 },
  { 1083, 13, 16, 13, 0, -16 },
  { 1109, 11, 16, 13, 3, -16 },
  { 1131, 12, 16, 13, 1, -16 },
  { 1155, 9, 20, 13, 3, -18 },
  { 1178, 6, 20, 13, 4, -18 },
  { 1193, 8, 20, 13, 2, -18 },
  { 1213, 9, 9, 13, 2, -16 },
  { 1224, 11, 1, 13, 0, 1 },
  { 1226, 4, 3, 13, 6, -17 },
  { 1228, 10, 12, 13, 2, -12 },
  { 1243, 11, 16, 13, 1, -16 },
  { 1265, 10, 12, 13, 2, -12 },
  { 1280, 11, 16, 13, 2, -16 },
  { 1302, 10, 12, 13, 2, -12 },
  { 1317, 14, 20, 13, -1, -16 },
  { 1352, 10, 16, 13, 2, -12 },
  { 1372, 11, 16, 13, 1, -16 },
  { 1394, 10, 17, 13, 1, -17 },
  { 1416, 12, 21, 13, 0, -17 },
  { 1448, 12, 16, 13, 1, -16 },
  { 1472, 9, 16, 13, 2, -16 },
  { 1490, 11, 12, 13, 1, -12 },
  { 1507, 11, 12, 13, 1, -12 },
  { 1524, 10, 12, 13, 2, -12 },
  { 1539, 11, 16, 13, 1, -12 },
  { 1561, 10, 16, 13, 2, -12 },
  { 1581, 10, 12, 13, 2, -12 },
  { 1596, 11, 12, 13, 1, -12 },
  { 1613, 10, 15, 13, 2, -15 },
  { 1632, 10, 12, 13, 2, -12 },
  { 1647, 11, 12, 13, 2, -12 },
  { 1664, 11, 12, 13, 2, -12 },
  { 1681, 12, 12, 13, 0, -12 },
  { 1699, 10, 16, 13, 2, -12 },
  { 1719, 11, 12, 13, 1, -12 },
  { 1736, 11, 20, 13, 2, -18 },
  { 1764, 4, 20, 13, 5, -18 },
  { 1774, 11, 20, 13, 1, -18 },
  { 1802, 10, 4, 13, 2, -10 },
};

const GFXfont JetBrainsMono_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC22PT7B_H_
