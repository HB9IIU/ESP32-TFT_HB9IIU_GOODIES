#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC70PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01,
  0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x0E, 0x1F, 0xC0, 0x07, 0xE0,
  0xE0, 0xFC, 0x00, 0xF8, 0x0E, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x3E, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x03,
  0xE0, 0x3E, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x3E, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x38, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x38, 0x00,
  0x00, 0x1F, 0x83, 0x80, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x00, 0x0F, 0xF7,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x00, 0x0E,
  0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0x00, 0x0E, 0x07, 0xE0, 0x00,
  0x00, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x1C,
  0x01, 0xE0, 0xF8, 0x01, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0xF8,
  0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x7C,
  0x07, 0xC0, 0x38, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0xF8, 0x03, 0xF0, 0x78,
  0x3F, 0x00, 0x3F, 0x87, 0x8F, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xE0,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x3E, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3C, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xF0, 0x78, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x43, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x81, 0xF8, 0x00, 0xF0, 0x7C, 0x03,
  0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0x00, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0x01,
  0xF1, 0xF0, 0x0F, 0x00, 0x03, 0xE7, 0x80, 0x3C, 0x00, 0x0F, 0xBE, 0x01,
  0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0x80, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x0F,
  0xFC, 0x01, 0xF0, 0x00, 0x7D, 0xF8, 0x07, 0xE0, 0x03, 0xE3, 0xE0, 0x1F,
  0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0xEF, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xC0,
  0x3E, 0x01, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE7, 0xE0, 0x07, 0x80,
  0x3F, 0x3F, 0xE0, 0x3C, 0x0F, 0xFB, 0xFF, 0xC1, 0xC1, 0xFF, 0xCF, 0xFF,
  0x8E, 0x3F, 0xFF, 0x0F, 0xFE, 0x67, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xCF, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x04, 0x00,
  0xF0, 0x78, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF8, 0x1F, 0x0F, 0x81, 0xFE,
  0x07, 0xC3, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x0F, 0xE0, 0x7C, 0x3E, 0x03,
  0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0x7C, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xE1, 0xF0,
  0x00, 0x3F, 0x83, 0xC0, 0x01, 0xFC, 0x07, 0x80, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x30, 0x00, 0xF8, 0x00,
  0x40, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x1E, 0x3F, 0xFF, 0x80, 0x0F, 0x9F,
  0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3D,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x0F, 0x9F, 0xFF, 0x00, 0x0F, 0xBF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xDE, 0x00, 0x0F, 0xFF, 0x9F, 0x00, 0x01, 0xFE, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x3F, 0x83, 0xC0, 0xF0, 0x00, 0x7F, 0xF3, 0xE0, 0x78, 0x00,
  0x7F, 0xFD, 0xE0, 0x3C, 0x00, 0x7F, 0xFE, 0xF0, 0x1E, 0x00, 0x7E, 0x03,
  0xF8, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x07,
  0x80, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x01,
  0xE0, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x1E,
  0x00, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0x81, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x00, 0xDE,
  0x07, 0x80, 0x0F, 0xFF, 0xEF, 0x03, 0xC0, 0x07, 0xFF, 0xE7, 0x81, 0xE0,
  0x01, 0xFF, 0xE7, 0x80, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x3E, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0xF8,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0x00,
  0x01, 0xF8, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xE0, 0x1E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x0F, 0xC0,
  0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x08, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFC, 0x3E, 0x00, 0xFF, 0xFF,
  0x0F, 0x80, 0x7F, 0xFF, 0x83, 0xE0, 0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0xFE, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x07, 0xB8, 0x00, 0x1F,
  0xE0, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x03, 0xDE, 0x01, 0xEF,
  0x00, 0x1E, 0x78, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x3C, 0x70, 0x03, 0xCF,
  0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x1F, 0x00, 0xF0, 0xE0, 0x3C, 0x7C,
  0x07, 0xC3, 0x81, 0xE1, 0xE0, 0x1F, 0x0F, 0x07, 0x87, 0x80, 0x78, 0x3C,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0xF0, 0xF8, 0x07, 0x81, 0xC7, 0x83, 0xE0,
  0x1E, 0x07, 0x1E, 0x0F, 0x80, 0xF8, 0x1E, 0xF0, 0x3C, 0x03, 0xE0, 0x7B,
  0x80, 0xF0, 0x0F, 0x81, 0xFE, 0x03, 0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x0F, 0xE0, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x1E, 0xF0,
  0x00, 0x1E, 0x01, 0xEF, 0x00, 0x03, 0xE0, 0x1E, 0xF0, 0x00, 0x3E, 0x01,
  0xEF, 0x00, 0x03, 0xE0, 0x1E, 0xF8, 0x00, 0x3C, 0x03, 0xE7, 0x80, 0x03,
  0xC0, 0x3E, 0x78, 0x00, 0x3C, 0x03, 0xE7, 0x80, 0x07, 0xC0, 0x3C, 0x78,
  0x00, 0x7C, 0x03, 0xC3, 0xC0, 0x07, 0xC0, 0x3C, 0x3C, 0x00, 0x78, 0x03,
  0xC3, 0xC0, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0x78, 0x07, 0xC3, 0xE0, 0x0F,
  0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x80, 0x78, 0x1E,
  0x00, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x07,
  0x81, 0xE0, 0x1F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x07, 0x83, 0xE0, 0x1E,
  0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x03, 0xC3, 0xE0, 0x1E, 0x00, 0x3C, 0x3C,
  0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x3E, 0x00, 0x3E, 0x3C, 0x03, 0xE0, 0x01,
  0xE3, 0xC0, 0x3E, 0x00, 0x1E, 0x7C, 0x03, 0xC0, 0x01, 0xE7, 0xC0, 0x3C,
  0x00, 0x1E, 0x78, 0x03, 0xC0, 0x00, 0xF7, 0x80, 0x7C, 0x00, 0x0F, 0x78,
  0x07, 0xC0, 0x00, 0xF7, 0x80, 0x7C, 0x00, 0x0F, 0x78, 0x07, 0x80, 0x00,
  0xFF, 0x80, 0x78, 0x00, 0x07, 0xF8, 0x07, 0x80, 0x00, 0x7F, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x01, 0xF8, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x3E,
  0x00, 0x3F, 0x00, 0x1E, 0x3E, 0x00, 0x3F, 0x00, 0x1E, 0x3C, 0x00, 0x7F,
  0x00, 0x3E, 0x3C, 0x00, 0x77, 0x00, 0x3C, 0x3C, 0x00, 0x77, 0x00, 0x3C,
  0x3C, 0x00, 0xF7, 0x00, 0x3C, 0x3C, 0x00, 0xEF, 0x00, 0x7C, 0x3C, 0x00,
  0xEF, 0x00, 0x78, 0x3C, 0x00, 0xEF, 0x00, 0x78, 0x3C, 0x01, 0xEE, 0x00,
  0xF8, 0x3C, 0x01, 0xCE, 0x00, 0xF0, 0x3C, 0x01, 0xCE, 0x00, 0xF0, 0x3C,
  0x03, 0xCE, 0x00, 0xF0, 0x3C, 0x03, 0x8E, 0x01, 0xF0, 0x3C, 0x03, 0x8E,
  0x01, 0xE0, 0x3C, 0x03, 0x8E, 0x01, 0xE0, 0x3C, 0x07, 0x8E, 0x01, 0xE0,
  0x3C, 0x07, 0x0E, 0x03, 0xC0, 0x3C, 0x07, 0x0E, 0x03, 0xC0, 0x3C, 0x0F,
  0x0E, 0x03, 0xC0, 0x3C, 0x0E, 0x0E, 0x07, 0xC0, 0x3C, 0x0E, 0x0E, 0x07,
  0x80, 0x7C, 0x1E, 0x0E, 0x07, 0x80, 0x7C, 0x1C, 0x0E, 0x07, 0x80, 0x7C,
  0x1C, 0x0E, 0x0F, 0x00, 0x7C, 0x1C, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x0E,
  0x0F, 0x00, 0x78, 0x38, 0x0E, 0x0F, 0x00, 0x78, 0x38, 0x0E, 0x1E, 0x00,
  0x78, 0x78, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x0E, 0x1E, 0x00, 0x78, 0x70,
  0x0E, 0x3E, 0x00, 0x78, 0x70, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x0E, 0x3C,
  0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x0E, 0x78, 0x00, 0x79,
  0xE0, 0x0E, 0x78, 0x00, 0x79, 0xC0, 0x0E, 0x78, 0x00, 0x79, 0xC0, 0x1E,
  0x78, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x1E, 0xF0, 0x00,
  0x7B, 0x80, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x1D, 0xE0, 0x00, 0x7F, 0x00,
  0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x00, 0x7F, 0x00, 0x1D, 0xE0,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xFC, 0x0F, 0x80, 0x0F,
  0xFF, 0x87, 0xC0, 0x1F, 0xFF, 0xE3, 0xE0, 0x1F, 0xFF, 0xF9, 0xE0, 0x1F,
  0xC0, 0x3E, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F,
  0x80, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0x7C, 0x03, 0xFC, 0x1F, 0x3C, 0x01, 0xFF,
  0xFF, 0x1E, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x0F, 0xFE, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x1F, 0x0F, 0xFF,
  0x80, 0x0F, 0x1F, 0xFF, 0xE0, 0x07, 0x9F, 0xFF, 0xF8, 0x03, 0xDF, 0x01,
  0xFE, 0x03, 0xEE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F,
  0x01, 0xEF, 0x00, 0x3F, 0x00, 0xF3, 0xE0, 0xFF, 0x00, 0x79, 0xFF, 0xFF,
  0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x3E, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x1F, 0xFF, 0xE3, 0xE0,
  0x07, 0xFF, 0xFE, 0x78, 0x01, 0xFC, 0x03, 0xEF, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0x07, 0xCF, 0x00,
  0x1F, 0xFF, 0xF1, 0xE0, 0x01, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0xFE, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0x1F, 0x01, 0xFF,
  0xFF, 0x9E, 0x03, 0xF8, 0x07, 0xDE, 0x07, 0xE0, 0x01, 0xFE, 0x07, 0xC0,
  0x00, 0xFE, 0x0F, 0x80, 0x00, 0xFE, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x1D, 0xE0, 0x3F, 0x80, 0x7B, 0xE0, 0x3F, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF,
  0xF3, 0xE0, 0x0F, 0xFF, 0xC3, 0xC0, 0x03, 0xFF, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x1F, 0x0F, 0xFF, 0x80,
  0x0F, 0x9F, 0xFF, 0xE0, 0x07, 0x9F, 0xFF, 0xF8, 0x03, 0xDF, 0x00, 0xFE,
  0x03, 0xEE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x07,
  0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x78,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xC3, 0xF0, 0x1F, 0xC0, 0x1E, 0x7F, 0xC1, 0xFF, 0x00, 0xF7, 0xFF,
  0x1F, 0xFC, 0x07, 0xBF, 0xFD, 0xFF, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xC0,
  0x1F, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x07, 0xC1, 0xE0, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x0F, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x0F, 0x83, 0xC0, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x80, 0x1E, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x1E, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x83, 0xE0, 0x0F, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x01, 0xF0, 0xFF, 0xF8, 0x00, 0xF9, 0xFF,
  0xFE, 0x00, 0x79, 0xFF, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0xE0, 0x3E, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3E, 0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x1F, 0xF0, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0x03, 0xE7, 0xFF, 0xF8, 0x00,
  0x79, 0xFF, 0xFF, 0x80, 0x0F, 0x7C, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x7B, 0xC0, 0x0F, 0xC0, 0x0F, 0x3E, 0x0F, 0xF8, 0x03,
  0xE7, 0xFF, 0xFC, 0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x0F, 0x83, 0xFF, 0x80,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x0F, 0x80, 0x0F, 0xFF, 0x87, 0xC0, 0x1F, 0xFF, 0xE3, 0xC0, 0x1F,
  0xFF, 0xF9, 0xE0, 0x1F, 0xC0, 0x3E, 0xF0, 0x1F, 0x80, 0x07, 0xF8, 0x1F,
  0x80, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0xFE, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00,
  0x3E, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0x78, 0x07, 0xFC,
  0x1F, 0x3C, 0x01, 0xFF, 0xFF, 0x1E, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x0F,
  0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7F,
  0xC0, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x3E, 0x7F, 0xFF, 0xC0, 0x0F, 0xBF,
  0xFF, 0xF8, 0x03, 0xDF, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x7C,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x00, 0x1E, 0xF0,
  0x03, 0xF0, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x03, 0xF0, 0x03,
  0xCF, 0x00, 0x77, 0x00, 0x3C, 0xF0, 0x07, 0x70, 0x07, 0x8F, 0x00, 0x77,
  0x00, 0x78, 0xF0, 0x0E, 0x70, 0x07, 0x8F, 0x00, 0xE3, 0x00, 0xF0, 0xF0,
  0x0E, 0x38, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x1C, 0x38, 0x1E,
  0x0F, 0x01, 0xC3, 0x81, 0xE0, 0xF0, 0x38, 0x38, 0x1E, 0x0F, 0x03, 0x83,
  0x83, 0xC0, 0xF0, 0x38, 0x38, 0x3C, 0x0F, 0x07, 0x03, 0x83, 0xC0, 0xF0,
  0x70, 0x38, 0x78, 0x0F, 0x07, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x38, 0x78,
  0x0F, 0x0E, 0x03, 0x8F, 0x00, 0xF1, 0xE0, 0x38, 0xF0, 0x0F, 0x1C, 0x03,
  0x8F, 0x00, 0xF1, 0xC0, 0x39, 0xE0, 0x0F, 0x3C, 0x03, 0x9E, 0x00, 0xF3,
  0x80, 0x39, 0xE0, 0x0F, 0x38, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x3B, 0xC0,
  0x0F, 0x70, 0x03, 0xBC, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7B, 0xE0, 0x1F, 0xFF, 0xF9, 0xF0, 0x07,
  0xFF, 0xF8, 0xF0, 0x01, 0xFF, 0xF8, 0x78, 0x00, 0x3F, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x83, 0xFF, 0x80,
  0x03, 0xC7, 0xFF, 0xE0, 0x01, 0xE3, 0xF7, 0xF8, 0x00, 0xF3, 0xE0, 0x7C,
  0x00, 0xF9, 0xE0, 0x1F, 0x00, 0x7D, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x03,
  0xE0, 0x3E, 0x78, 0x00, 0xFC, 0x3F, 0x3C, 0x00, 0x7F, 0xFF, 0x1E, 0x00,
  0x1F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x0F, 0x80, 0x00, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 15, 51, 42, 14, -51 },
  { 97, 22, 21, 42, 14, -51 },
  { 155, 40, 51, 42, 2, -51 },
  { 410, 36, 71, 42, 4, -61 },
  { 730, 48, 51, 42, -2, -51 },
  { 1036, 38, 53, 42, 2, -52 },
  { 1288, 8, 21, 42, 21, -51 },
  { 1309, 28, 68, 42, 12, -59 },
  { 1547, 27, 68, 42, 4, -59 },
  { 1777, 37, 36, 42, 4, -43 },
  { 1944, 33, 33, 42, 5, -40 },
  { 2081, 16, 22, 42, 8, -11 },
  { 2125, 23, 4, 42, 10, -25 },
  { 2137, 11, 11, 42, 13, -10 },
  { 2153, 40, 66, 42, 2, -58 },
  { 2483, 34, 53, 42, 5, -52 },
  { 2709, 31, 51, 42, 4, -51 },
  { 2907, 36, 52, 42, 3, -52 },
  { 3141, 35, 52, 42, 4, -51 },
  { 3369, 32, 51, 42, 5, -51 },
  { 3573, 34, 52, 42, 5, -51 },
  { 3794, 33, 52, 42, 4, -51 },
  { 4009, 33, 51, 42, 9, -51 },
  { 4220, 35, 53, 42, 4, -52 },
  { 4452, 33, 52, 42, 7, -52 },
  { 4667, 16, 40, 42, 13, -39 },
  { 4747, 21, 50, 42, 8, -39 },
  { 4879, 33, 36, 42, 6, -41 },
  { 5028, 33, 20, 42, 5, -33 },
  { 5111, 33, 36, 42, 4, -41 },
  { 5260, 28, 51, 42, 11, -51 },
  { 5439, 41, 65, 42, 1, -52 },
  { 5773, 34, 51, 42, 1, -51 },
  { 5990, 35, 51, 42, 4, -51 },
  { 6214, 34, 53, 42, 5, -52 },
  { 6440, 35, 51, 42, 4, -51 },
  { 6664, 36, 51, 42, 5, -51 },
  { 6894, 38, 51, 42, 4, -51 },
  { 7137, 34, 53, 42, 5, -52 },
  { 7363, 36, 51, 42, 4, -51 },
  { 7593, 34, 51, 42, 5, -51 },
  { 7810, 37, 52, 42, 2, -51 },
  { 8051, 39, 51, 42, 4, -51 },
  { 8300, 30, 51, 42, 5, -51 },
  { 8492, 38, 51, 42, 3, -51 },
  { 8735, 36, 51, 42, 4, -51 },
  { 8965, 34, 53, 42, 5, -52 },
  { 9191, 37, 51, 42, 4, -51 },
  { 9427, 34, 65, 42, 5, -52 },
  { 9704, 36, 51, 42, 4, -51 },
  { 9934, 36, 53, 42, 4, -52 },
  { 10173, 35, 51, 42, 8, -51 },
  { 10397, 35, 52, 42, 5, -51 },
  { 10625, 34, 51, 42, 9, -51 },
  { 10842, 40, 51, 42, 5, -51 },
  { 11097, 43, 51, 42, 0, -51 },
  { 11372, 36, 51, 42, 8, -51 },
  { 11602, 37, 51, 42, 3, -51 },
  { 11838, 26, 66, 42, 11, -58 },
  { 12053, 20, 66, 42, 12, -58 },
  { 12218, 27, 66, 42, 6, -58 },
  { 12441, 29, 27, 42, 7, -51 },
  { 12539, 34, 4, 42, 0, 2 },
  { 12556, 11, 10, 42, 19, -55 },
  { 12570, 33, 40, 42, 5, -39 },
  { 12735, 33, 52, 42, 4, -51 },
  { 12950, 32, 40, 42, 5, -39 },
  { 13110, 35, 52, 42, 5, -51 },
  { 13338, 32, 40, 42, 5, -39 },
  { 13498, 45, 64, 42, -2, -51 },
  { 13858, 32, 52, 42, 6, -39 },
  { 14066, 33, 51, 42, 4, -51 },
  { 14277, 32, 54, 42, 3, -54 },
  { 14493, 36, 67, 42, 1, -54 },
  { 14795, 36, 51, 42, 4, -51 },
  { 15025, 28, 51, 42, 8, -51 },
  { 15204, 37, 39, 42, 2, -39 },
  { 15385, 33, 39, 42, 4, -39 },
  { 15546, 32, 40, 42, 5, -39 },
  { 15706, 35, 52, 42, 2, -39 },
  { 15934, 33, 52, 42, 5, -39 },
  { 16149, 34, 39, 42, 5, -39 },
  { 16315, 33, 40, 42, 4, -39 },
  { 16480, 32, 49, 42, 7, -49 },
  { 16676, 33, 40, 42, 5, -39 },
  { 16841, 32, 39, 42, 8, -39 },
  { 16997, 36, 39, 42, 6, -39 },
  { 17173, 38, 39, 42, 2, -39 },
  { 17359, 33, 52, 42, 5, -39 },
  { 17574, 33, 39, 42, 4, -39 },
  { 17735, 35, 66, 42, 7, -58 },
  { 18024, 15, 66, 42, 14, -58 },
  { 18148, 35, 66, 42, 2, -58 },
  { 18437, 33, 13, 42, 5, -31 },
};

const GFXfont JetBrainsMono_ExtraLightItalic70pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic70pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC70PT7B_H_
