#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC62PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF3, 0xE0,
  0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x70, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x83, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x38, 0xFC, 0x00, 0xFC, 0x38, 0x7E,
  0x00, 0xF8, 0x38, 0x3E, 0x01, 0xF0, 0x38, 0x1E, 0x01, 0xE0, 0x38, 0x1E,
  0x03, 0xE0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x01, 0xF0, 0xE0, 0x00, 0x01, 0xFC, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC7, 0xE0,
  0x00, 0x01, 0xC3, 0xE0, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x03, 0x81, 0xF0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x80, 0xF8,
  0x00, 0x03, 0x80, 0xF0, 0x78, 0x03, 0x00, 0xF0, 0x78, 0x07, 0x00, 0xF0,
  0x78, 0x07, 0x00, 0xF0, 0x78, 0x07, 0x01, 0xF0, 0x78, 0x07, 0x01, 0xE0,
  0x7C, 0x07, 0x03, 0xE0, 0x3E, 0x07, 0x07, 0xC0, 0x3F, 0x0E, 0x0F, 0x80,
  0x1F, 0xCE, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x01, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0x80, 0x0F, 0x81, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00,
  0x78, 0x07, 0x00, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x78, 0x00, 0x00,
  0x7C, 0x1F, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x7F, 0xF0, 0x00, 0x00,
  0x1E, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x87, 0x81, 0xF0, 0x00, 0x00, 0xE1,
  0xE0, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x00,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00,
  0x70, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x8F, 0x01, 0xE0, 0x07, 0x8F,
  0x80, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0xC1,
  0xE0, 0x07, 0xC3, 0xC1, 0xF0, 0x01, 0xE3, 0xC0, 0xF0, 0x00, 0xFB, 0xE0,
  0x78, 0x00, 0x3D, 0xE0, 0x3C, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x07, 0xE0,
  0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x78, 0x00, 0xF9,
  0xE0, 0x3E, 0x00, 0xF8, 0xF8, 0x1F, 0x81, 0xF8, 0x3C, 0x07, 0xFF, 0xF8,
  0x1F, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x7F, 0xE0, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xC7, 0x8F, 0x3E, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40, 0x03,
  0xC0, 0x02, 0x78, 0x03, 0xC0, 0x0E, 0x7E, 0x03, 0xC0, 0x7F, 0xFF, 0xC3,
  0x83, 0xFF, 0xFF, 0xF3, 0x8F, 0xFF, 0x1F, 0xFB, 0xBF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x87,
  0xF8, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x3F, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x7C, 0x07, 0x83,
  0xC0, 0xFC, 0x0F, 0x0F, 0x83, 0xF8, 0x3E, 0x1F, 0x07, 0xF0, 0x7C, 0x3C,
  0x0F, 0xE0, 0xF0, 0x78, 0x0F, 0x81, 0xE0, 0xF0, 0x06, 0x03, 0xC1, 0xE0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xDE, 0x00, 0x03,
  0xF1, 0xE0, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0x81, 0xE0, 0x03, 0xF0, 0x1E,
  0x00, 0x3C, 0x03, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x20, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x07, 0x8F, 0xFF, 0x00, 0x3C, 0x7F,
  0xFE, 0x00, 0xF7, 0xFF, 0xFC, 0x03, 0xDE, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0xF8, 0x07, 0xBF, 0xFF,
  0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7C,
  0x78, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x05, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF,
  0x78, 0x01, 0xFF, 0xF7, 0x80, 0x07, 0xFE, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0xF1, 0xE0, 0xF0, 0x01, 0xFF, 0x9E, 0x0F, 0x00, 0x3F, 0xFD,
  0xE0, 0xF0, 0x07, 0xE1, 0xDE, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x0F,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x3C, 0x1E,
  0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x1C, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x03,
  0xC1, 0xE0, 0x3C, 0x00, 0x78, 0x1C, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x3C,
  0x00, 0x78, 0x3C, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x38, 0x00, 0x78, 0x3C,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x70, 0x38, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x7C,
  0x01, 0xF0, 0x78, 0x03, 0xE0, 0x7F, 0x07, 0x80, 0x3F, 0xFE, 0xE0, 0x78,
  0x01, 0xFF, 0xCE, 0x07, 0x00, 0x0F, 0xF8, 0xE0, 0x70, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0x1F,
  0x80, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x00,
  0x7F, 0xC0, 0x1E, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0xF8, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xF0, 0x1F, 0xF8,
  0x03, 0xC0, 0x03, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x1E,
  0x00, 0x1F, 0x80, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x04, 0x3C, 0x07,
  0xFF, 0xE0, 0xF0, 0x1F, 0xFF, 0x87, 0xC0, 0x7F, 0xFE, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F,
  0xC0, 0xEE, 0x00, 0x0F, 0xE0, 0x77, 0x00, 0x07, 0x70, 0x3B, 0x80, 0x07,
  0xF8, 0x1D, 0xC0, 0x03, 0xB8, 0x0E, 0xF0, 0x03, 0xDC, 0x07, 0x38, 0x01,
  0xCE, 0x07, 0x9C, 0x01, 0xEF, 0x03, 0xCE, 0x00, 0xE7, 0x81, 0xE7, 0x00,
  0xF3, 0xC0, 0xF3, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0x70,
  0x38, 0xF0, 0x3C, 0x38, 0x3C, 0x78, 0x1E, 0x1C, 0x1C, 0x3C, 0x0F, 0x0F,
  0x1E, 0x1E, 0x07, 0x87, 0x8E, 0x0F, 0x03, 0xC1, 0xCF, 0x0F, 0x01, 0xE0,
  0xE7, 0x07, 0x81, 0xE0, 0x77, 0x83, 0xC0, 0xF0, 0x3B, 0x81, 0xE0, 0x78,
  0x1F, 0xC0, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x1E, 0x03, 0xE0, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x07, 0xF0, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x78, 0x1F, 0xC0,
  0x00, 0xF0, 0x3F, 0x80, 0x01, 0xE0, 0x7F, 0x80, 0x07, 0x80, 0xEF, 0x00,
  0x0F, 0x01, 0xDE, 0x00, 0x1E, 0x07, 0x9C, 0x00, 0x3C, 0x0F, 0x38, 0x00,
  0x78, 0x1E, 0x78, 0x00, 0xF0, 0x3C, 0xF0, 0x03, 0xC0, 0x79, 0xE0, 0x07,
  0x80, 0xF1, 0xC0, 0x0F, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x87, 0x80, 0x3C,
  0x0F, 0x0F, 0x00, 0x78, 0x1E, 0x0E, 0x00, 0xF0, 0x3C, 0x1C, 0x03, 0xC0,
  0x78, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x3C,
  0x07, 0x83, 0xC0, 0x78, 0x07, 0x07, 0x81, 0xE0, 0x0E, 0x0F, 0x03, 0xC0,
  0x1E, 0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x0F, 0x00, 0x78, 0xF0, 0x1E, 0x00,
  0x71, 0xE0, 0x3C, 0x00, 0xF3, 0xC0, 0xF0, 0x01, 0xE7, 0x81, 0xE0, 0x03,
  0xCF, 0x03, 0xC0, 0x03, 0x9E, 0x07, 0x80, 0x07, 0xBC, 0x0F, 0x00, 0x0F,
  0x70, 0x1E, 0x00, 0x1E, 0xE0, 0x78, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x3F,
  0x81, 0xE0, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0xFE, 0x07, 0x80, 0x01, 0xF8,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x7E, 0x00,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0xFF,
  0x80, 0x3C, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x7E,
  0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF8, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xEF, 0x00, 0x3E, 0x00, 0x79, 0xE0, 0x07, 0xC0, 0x0F, 0x3C, 0x00,
  0xF8, 0x01, 0xE7, 0x80, 0x3B, 0x00, 0x78, 0xF0, 0x07, 0x60, 0x0F, 0x1E,
  0x00, 0xEC, 0x01, 0xE3, 0xC0, 0x39, 0x80, 0x38, 0x78, 0x07, 0x70, 0x0F,
  0x0F, 0x00, 0xEE, 0x01, 0xE1, 0xE0, 0x19, 0xC0, 0x3C, 0x3C, 0x07, 0x38,
  0x07, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0xF0, 0x1C, 0xE0, 0x3C, 0x1E, 0x07,
  0x1C, 0x07, 0x03, 0xC0, 0xE3, 0x81, 0xE0, 0x78, 0x1C, 0x70, 0x3C, 0x0F,
  0x03, 0x0E, 0x07, 0x81, 0xE0, 0xE1, 0xC0, 0xE0, 0x38, 0x1C, 0x38, 0x3C,
  0x07, 0x03, 0x87, 0x07, 0x80, 0xE0, 0xE0, 0xE0, 0xE0, 0x1C, 0x1C, 0x1C,
  0x1C, 0x03, 0x83, 0x83, 0x87, 0x80, 0x70, 0xE0, 0x70, 0xF0, 0x0E, 0x1C,
  0x0E, 0x1C, 0x01, 0xC3, 0x81, 0xC7, 0x80, 0x78, 0x60, 0x38, 0xF0, 0x0F,
  0x1C, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0xE3, 0x80, 0x3C, 0x70, 0x1C, 0xF0,
  0x07, 0x9C, 0x03, 0x9E, 0x00, 0xF3, 0x80, 0x73, 0x80, 0x1E, 0x70, 0x0C,
  0x70, 0x03, 0xCC, 0x01, 0x9E, 0x00, 0x7B, 0x80, 0x33, 0xC0, 0x0F, 0x70,
  0x06, 0x70, 0x01, 0xEC, 0x00, 0xDE, 0x00, 0x3F, 0x80, 0x1B, 0xC0, 0x07,
  0xF0, 0x03, 0x70, 0x00, 0xEE, 0x00, 0x6E, 0x00, 0x1D, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x78,
  0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x1F, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x1E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x07,
  0xFF, 0xE7, 0x80, 0x3F, 0xFF, 0x9E, 0x01, 0xF8, 0x0F, 0x78, 0x0F, 0x80,
  0x0D, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0x78, 0x0F,
  0xE0, 0x3D, 0xE0, 0x1F, 0xFF, 0xEF, 0x80, 0x3F, 0xFF, 0x3C, 0x00, 0x7F,
  0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x0F,
  0xFE, 0x00, 0x78, 0xFF, 0xF8, 0x03, 0xDF, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F,
  0x81, 0xEC, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF7, 0x00, 0x3E, 0x07, 0xBC,
  0x07, 0xE0, 0x3C, 0xFF, 0xFE, 0x01, 0xE3, 0xFF, 0xE0, 0x0F, 0x0F, 0xFC,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x04, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFF, 0xC3, 0xC0, 0x07, 0xFF,
  0xE7, 0x80, 0x1F, 0xFF, 0xCF, 0x00, 0x7E, 0x03, 0xDE, 0x01, 0xF0, 0x01,
  0xBC, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x37, 0x80, 0x7F, 0x01, 0xEF, 0x00, 0x7F, 0xFF, 0xBE, 0x00, 0x7F, 0xFE,
  0x78, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF0,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x87, 0xC0,
  0x3F, 0xFF, 0x3C, 0x03, 0xFF, 0xF9, 0xE0, 0x3F, 0x01, 0xEF, 0x03, 0xE0,
  0x03, 0x78, 0x3E, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7E, 0x1E, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x1E,
  0xF0, 0x0F, 0xFF, 0xE7, 0x80, 0x3F, 0xFE, 0x3C, 0x00, 0xFF, 0xC1, 0xE0,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x79,
  0xFF, 0xF8, 0x03, 0xDF, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0x81, 0xEC, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8,
  0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xE0,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x00,
  0x38, 0x03, 0xCF, 0xE0, 0xFE, 0x01, 0xEF, 0xF8, 0xFF, 0x80, 0xEF, 0xFE,
  0xFF, 0xE0, 0x74, 0x1F, 0x41, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x3E, 0x03,
  0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x07, 0x83, 0xC0, 0x3C, 0x03, 0xC1, 0xC0, 0x1C, 0x01, 0xE1, 0xE0,
  0x0E, 0x00, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0x0F, 0x0F,
  0x00, 0x70, 0x07, 0x07, 0x80, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x03, 0xC1,
  0xE0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x78,
  0x38, 0x03, 0x80, 0x3C, 0x3C, 0x01, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x03,
  0xC1, 0xC0, 0x1C, 0x01, 0xE1, 0xE0, 0x0E, 0x00, 0xE0, 0xF0, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x3C, 0x3F, 0xF8, 0x01, 0xE7, 0xFF, 0xE0, 0x0F, 0x7F, 0xFF,
  0x80, 0xFF, 0x80, 0x7E, 0x07, 0xB0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x3E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xC3, 0xFF, 0x80, 0x07, 0x9F, 0xFF, 0x80, 0x0F, 0x7F, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0x80, 0x7B, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xF0, 0x00, 0xF8, 0x0F, 0x70, 0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0xC0, 0x3C,
  0xFF, 0xFF, 0x00, 0x78, 0xFF, 0xF8, 0x00, 0xF0, 0xFF, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xC3, 0xC0, 0x1F, 0xFF, 0x9E, 0x01, 0xFF, 0xFC, 0xF0, 0x1F, 0x80, 0xF7,
  0x81, 0xF0, 0x01, 0xBC, 0x1F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0xDE, 0x07, 0xF0,
  0x1E, 0xF0, 0x1F, 0xFF, 0xEF, 0x00, 0x7F, 0xFC, 0x78, 0x01, 0xFF, 0xC3,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x3F, 0xF8,
  0x01, 0xE7, 0xFF, 0xE0, 0x0F, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x7E, 0x07,
  0xB0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x7C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x07,
  0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0,
  0x0F, 0xF0, 0x07, 0xC0, 0x0E, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x06, 0xC0,
  0x1E, 0xF0, 0x0E, 0xC0, 0x1C, 0xF0, 0x0E, 0xC0, 0x3C, 0xF0, 0x0C, 0xC0,
  0x3C, 0xF0, 0x1C, 0xC0, 0x38, 0xF0, 0x1C, 0xC0, 0x78, 0xF0, 0x18, 0xC0,
  0x78, 0xF0, 0x38, 0xE0, 0x70, 0xF0, 0x38, 0xE0, 0xF0, 0xF0, 0x30, 0xE0,
  0xF0, 0x70, 0x70, 0xE0, 0xE0, 0x70, 0x70, 0xE1, 0xE0, 0x70, 0x60, 0xE1,
  0xE0, 0x70, 0xE0, 0xE1, 0xC0, 0x70, 0xE0, 0xE1, 0xC0, 0x70, 0xC0, 0xE3,
  0xC0, 0x71, 0xC0, 0xE3, 0x80, 0x71, 0xC0, 0xE3, 0x80, 0x73, 0x80, 0xE7,
  0x80, 0x73, 0x80, 0xE7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x77, 0x00, 0xEF,
  0x00, 0x77, 0x00, 0xEE, 0x00, 0x77, 0x00, 0xEE, 0x00, 0x76, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x7C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x78, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x6F, 0x03, 0xF0, 0x1E, 0xF0,
  0x3F, 0xFF, 0xCF, 0x01, 0xFF, 0xF9, 0xF0, 0x07, 0xFE, 0x1E, 0x00, 0x06,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x7F, 0xC0,
  0x03, 0xC7, 0xFF, 0x00, 0x1E, 0x7F, 0xFC, 0x00, 0xF7, 0xC1, 0xF0, 0x07,
  0x3C, 0x07, 0x80, 0x79, 0xC0, 0x3E, 0x03, 0xDE, 0x00, 0xF8, 0x3E, 0xF0,
  0x03, 0xE3, 0xE7, 0x80, 0x1F, 0xFE, 0x3C, 0x00, 0x7F, 0xE1, 0xE0, 0x00,
  0xFE, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 14, 45, 37, 12, -45 },
  { 80, 20, 18, 37, 12, -45 },
  { 125, 36, 45, 37, 1, -45 },
  { 328, 32, 63, 37, 3, -54 },
  { 580, 43, 46, 37, -2, -46 },
  { 828, 33, 47, 37, 2, -46 },
  { 1022, 7, 18, 37, 18, -45 },
  { 1038, 25, 60, 37, 11, -52 },
  { 1226, 25, 60, 37, 3, -52 },
  { 1414, 32, 32, 37, 4, -38 },
  { 1542, 29, 29, 37, 5, -35 },
  { 1648, 14, 19, 37, 7, -9 },
  { 1682, 20, 3, 37, 9, -22 },
  { 1690, 11, 10, 37, 11, -9 },
  { 1704, 35, 58, 37, 2, -51 },
  { 1958, 31, 47, 37, 4, -46 },
  { 2141, 28, 45, 37, 3, -45 },
  { 2299, 32, 46, 37, 3, -46 },
  { 2483, 30, 46, 37, 4, -45 },
  { 2656, 28, 45, 37, 5, -45 },
  { 2814, 30, 46, 37, 4, -45 },
  { 2987, 28, 46, 37, 4, -45 },
  { 3148, 29, 45, 37, 8, -45 },
  { 3312, 31, 47, 37, 4, -46 },
  { 3495, 29, 46, 37, 6, -46 },
  { 3662, 15, 36, 37, 11, -35 },
  { 3730, 19, 45, 37, 7, -35 },
  { 3837, 29, 31, 37, 6, -36 },
  { 3950, 29, 19, 37, 5, -30 },
  { 4019, 30, 31, 37, 3, -36 },
  { 4136, 24, 45, 37, 10, -45 },
  { 4271, 36, 57, 37, 1, -46 },
  { 4528, 30, 45, 37, 1, -45 },
  { 4697, 31, 45, 37, 4, -45 },
  { 4872, 30, 47, 37, 5, -46 },
  { 5049, 30, 45, 37, 4, -45 },
  { 5218, 32, 45, 37, 4, -45 },
  { 5398, 33, 45, 37, 4, -45 },
  { 5584, 30, 47, 37, 5, -46 },
  { 5761, 31, 45, 37, 4, -45 },
  { 5936, 31, 45, 37, 4, -45 },
  { 6111, 33, 46, 37, 2, -45 },
  { 6301, 34, 45, 37, 4, -45 },
  { 6493, 26, 45, 37, 5, -45 },
  { 6640, 33, 45, 37, 3, -45 },
  { 6826, 31, 45, 37, 4, -45 },
  { 7001, 29, 47, 37, 5, -46 },
  { 7172, 33, 45, 37, 4, -45 },
  { 7358, 30, 57, 37, 4, -46 },
  { 7572, 32, 45, 37, 4, -45 },
  { 7752, 32, 47, 37, 3, -46 },
  { 7940, 31, 45, 37, 7, -45 },
  { 8115, 30, 46, 37, 5, -45 },
  { 8288, 30, 45, 37, 8, -45 },
  { 8457, 35, 45, 37, 5, -45 },
  { 8654, 38, 45, 37, 0, -45 },
  { 8868, 32, 45, 37, 7, -45 },
  { 9048, 32, 45, 37, 3, -45 },
  { 9228, 24, 58, 37, 9, -51 },
  { 9402, 17, 58, 37, 11, -51 },
  { 9526, 23, 58, 37, 6, -51 },
  { 9693, 26, 24, 37, 6, -45 },
  { 9771, 31, 3, 37, 0, 2 },
  { 9783, 10, 9, 37, 17, -49 },
  { 9795, 30, 36, 37, 4, -35 },
  { 9930, 29, 46, 37, 4, -45 },
  { 10097, 28, 36, 37, 5, -35 },
  { 10223, 31, 46, 37, 4, -45 },
  { 10402, 27, 36, 37, 5, -35 },
  { 10524, 40, 56, 37, -2, -45 },
  { 10804, 29, 46, 37, 5, -35 },
  { 10971, 29, 45, 37, 4, -45 },
  { 11135, 28, 48, 37, 3, -48 },
  { 11303, 31, 59, 37, 1, -48 },
  { 11532, 32, 45, 37, 4, -45 },
  { 11712, 25, 45, 37, 7, -45 },
  { 11853, 33, 35, 37, 2, -35 },
  { 11998, 29, 35, 37, 4, -35 },
  { 12125, 27, 36, 37, 5, -35 },
  { 12247, 31, 46, 37, 2, -35 },
  { 12426, 29, 46, 37, 4, -35 },
  { 12593, 29, 35, 37, 5, -35 },
  { 12720, 29, 36, 37, 4, -35 },
  { 12851, 28, 43, 37, 6, -43 },
  { 13002, 29, 35, 37, 5, -34 },
  { 13129, 29, 34, 37, 7, -34 },
  { 13253, 32, 34, 37, 5, -34 },
  { 13389, 34, 34, 37, 1, -34 },
  { 13534, 28, 45, 37, 5, -34 },
  { 13692, 30, 34, 37, 3, -34 },
  { 13820, 31, 58, 37, 6, -51 },
  { 14045, 13, 58, 37, 13, -51 },
  { 14140, 30, 58, 37, 2, -51 },
  { 14358, 29, 12, 37, 5, -28 },
};

const GFXfont JetBrainsMono_ExtraLightItalic62pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic62pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC62PT7B_H_
