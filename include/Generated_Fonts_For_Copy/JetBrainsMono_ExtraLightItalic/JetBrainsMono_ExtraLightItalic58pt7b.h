#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC58PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x3E, 0x03,
  0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x1C, 0x7C, 0x01,
  0xF0, 0x60, 0xF8, 0x07, 0x81, 0x81, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xF0,
  0x38, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0x78, 0x0E,
  0x00, 0x01, 0xE0, 0x30, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1F, 0x07, 0x00,
  0x00, 0x7C, 0x1C, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x03, 0xF1, 0xC0, 0x00,
  0x07, 0xE6, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xC7, 0xE0, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x60, 0x1C, 0x1E, 0x03, 0x80, 0xF0, 0x70, 0x0E, 0x03, 0xC1,
  0xE0, 0x38, 0x0F, 0x07, 0x80, 0xE0, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0x7C,
  0x0C, 0x0F, 0x00, 0xF8, 0x70, 0x7C, 0x03, 0xF9, 0xC7, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xF0,
  0x00, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0xFC, 0xF8, 0x00, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x03,
  0x80, 0x38, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x3C, 0x00, 0x03, 0x80, 0x38,
  0x38, 0x00, 0x03, 0x80, 0x78, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0xE0, 0x00,
  0x03, 0xE1, 0xE1, 0xC0, 0x00, 0x01, 0xFF, 0xE3, 0xC0, 0x00, 0x00, 0xFF,
  0x87, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0x01, 0xE1,
  0xFF, 0x80, 0x00, 0x01, 0xC3, 0xFF, 0xC0, 0x00, 0x03, 0x87, 0x83, 0xC0,
  0x00, 0x07, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x0E, 0x01, 0xE0, 0x00, 0x1E,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1C, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x07, 0xC0, 0x1E,
  0x3C, 0x07, 0x80, 0x78, 0x78, 0x07, 0x81, 0xE0, 0xE0, 0x0F, 0x83, 0xC3,
  0xC0, 0x0F, 0x0F, 0x07, 0x80, 0x1F, 0x3C, 0x0F, 0x00, 0x1E, 0x78, 0x1E,
  0x00, 0x1F, 0xE0, 0x3C, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xF8, 0x0F, 0x00,
  0x0F, 0xF0, 0x1F, 0x00, 0x3E, 0xF0, 0x3E, 0x00, 0xF9, 0xE0, 0x3E, 0x07,
  0xE1, 0xE0, 0x7F, 0xFF, 0x83, 0xE0, 0x7F, 0xFC, 0x03, 0xC0, 0x3F, 0xF0,
  0x03, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x9F,
  0x3C, 0x78, 0xF1, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x20, 0x03, 0xC0, 0x04, 0x78, 0x07, 0x80, 0x79, 0xFC, 0x0E,
  0x07, 0xF7, 0xFF, 0x1C, 0x3F, 0xF3, 0xFF, 0x39, 0xFF, 0x80, 0xFF, 0xEF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x1F, 0x03, 0xC3, 0xC1, 0xF8, 0x1E,
  0x1E, 0x0F, 0xC0, 0xF0, 0xF0, 0x7E, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x78,
  0x07, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7E,
  0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x0E, 0x00, 0x1F, 0x87, 0x80, 0x0F,
  0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x60, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0xF1, 0xFF, 0xC0, 0x0F, 0x7F, 0xFE, 0x00, 0xEF, 0xFF, 0xF0,
  0x0E, 0xE0, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x79, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x3F, 0xC0,
  0xFE, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x07, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x78, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xBC, 0x00, 0xFF, 0xCF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xF8, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x10, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x7F, 0x1E, 0x0F, 0x00, 0x7F, 0xF7, 0x83, 0x80, 0x3F, 0xFD, 0xC0, 0xE0,
  0x1F, 0x03, 0x70, 0x78, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xC0, 0x0F, 0x07,
  0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x38, 0x00, 0xF0, 0x70, 0x0E, 0x00, 0x38,
  0x1C, 0x07, 0x80, 0x0E, 0x0F, 0x01, 0xE0, 0x03, 0x83, 0xC0, 0x78, 0x01,
  0xE0, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x07, 0x00, 0x1E, 0x0E, 0x01, 0xC0,
  0x07, 0x83, 0x80, 0xF0, 0x01, 0xC0, 0xE0, 0x3C, 0x00, 0x70, 0x78, 0x0F,
  0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0xF0, 0x07, 0xC1, 0xE0,
  0x3E, 0x03, 0xF0, 0x70, 0x07, 0xE3, 0xB8, 0x1C, 0x01, 0xFF, 0xEE, 0x07,
  0x00, 0x3F, 0xF3, 0x83, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01,
  0xC0, 0x03, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0x80, 0x0F, 0xC0, 0x3C, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x3F,
  0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0x80, 0x3F, 0x80, 0x3C,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x7E, 0x01, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x1F,
  0xFF, 0x87, 0x80, 0xFF, 0xF8, 0x3C, 0x07, 0xFF, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x77, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xB8, 0x00,
  0xEE, 0x03, 0xB8, 0x00, 0xEE, 0x03, 0x9C, 0x01, 0xCE, 0x03, 0x9C, 0x01,
  0xDE, 0x03, 0x9C, 0x03, 0x9E, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x9C, 0x07,
  0x1C, 0x07, 0x8E, 0x07, 0x1C, 0x07, 0x8E, 0x0E, 0x3C, 0x07, 0x8E, 0x0E,
  0x3C, 0x07, 0x0E, 0x1C, 0x3C, 0x07, 0x0E, 0x1C, 0x38, 0x0F, 0x07, 0x38,
  0x38, 0x0F, 0x07, 0x38, 0x78, 0x0F, 0x07, 0x70, 0x78, 0x0F, 0x07, 0x70,
  0x78, 0x0F, 0x07, 0xE0, 0x78, 0x0E, 0x07, 0xE0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00,
  0xF0, 0x1F, 0x80, 0x03, 0xC0, 0xFE, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x38,
  0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x07, 0x80, 0xE7, 0x00, 0x1E, 0x03,
  0x9C, 0x00, 0x78, 0x0E, 0x70, 0x01, 0xE0, 0x79, 0xE0, 0x07, 0x01, 0xE7,
  0x80, 0x3C, 0x07, 0x8E, 0x00, 0xF0, 0x1E, 0x38, 0x03, 0xC0, 0x70, 0xF0,
  0x0F, 0x01, 0xC3, 0xC0, 0x3C, 0x0F, 0x07, 0x00, 0xE0, 0x3C, 0x1C, 0x03,
  0x80, 0xF0, 0x70, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x0E, 0x07, 0x81, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x38, 0x1C, 0x07, 0x80, 0xF0, 0x70, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x07, 0x0F, 0x01, 0xE0, 0x1C, 0x3C, 0x07, 0x00,
  0x70, 0xF0, 0x3C, 0x01, 0xE3, 0x80, 0xF0, 0x07, 0x8E, 0x03, 0xC0, 0x0E,
  0x78, 0x0F, 0x00, 0x39, 0xE0, 0x3C, 0x00, 0xF7, 0x80, 0xE0, 0x03, 0xDE,
  0x03, 0x80, 0x07, 0x78, 0x1E, 0x00, 0x1D, 0xC0, 0x78, 0x00, 0x77, 0x01,
  0xE0, 0x01, 0xFC, 0x07, 0x80, 0x07, 0xF0, 0x1C, 0x00, 0x0F, 0xC0, 0x70,
  0x00, 0x3F, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x3F, 0x80, 0x3C, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x03,
  0xE0, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x3C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x78, 0x03, 0xE0,
  0x0F, 0x78, 0x03, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x1E, 0x70, 0x07, 0xE0,
  0x1E, 0x70, 0x06, 0xE0, 0x1C, 0x70, 0x0E, 0xE0, 0x1C, 0x70, 0x0E, 0xE0,
  0x3C, 0x70, 0x0E, 0xE0, 0x3C, 0x70, 0x0C, 0xE0, 0x38, 0x70, 0x1C, 0xE0,
  0x78, 0x70, 0x1C, 0xC0, 0x78, 0x70, 0x18, 0xC0, 0x70, 0x70, 0x38, 0xC0,
  0x70, 0x70, 0x38, 0xC0, 0xF0, 0x70, 0x30, 0xC0, 0xF0, 0xF0, 0x70, 0xC0,
  0xE0, 0xF0, 0x70, 0xC0, 0xE0, 0xF0, 0x70, 0xC1, 0xE0, 0xF0, 0x60, 0xC1,
  0xC0, 0xF0, 0xE0, 0xC1, 0xC0, 0xF0, 0xE0, 0xC3, 0xC0, 0xF0, 0xC0, 0xC3,
  0xC0, 0xF1, 0xC0, 0xC3, 0x80, 0xF1, 0xC0, 0xC3, 0x80, 0xF1, 0x81, 0xC7,
  0x80, 0xF1, 0x81, 0xC7, 0x00, 0xE3, 0x81, 0xC7, 0x00, 0xE3, 0x81, 0xC7,
  0x00, 0xE3, 0x01, 0xCF, 0x00, 0xE7, 0x01, 0xCE, 0x00, 0xE7, 0x01, 0xCE,
  0x00, 0xE6, 0x01, 0xDE, 0x00, 0xEE, 0x01, 0xDE, 0x00, 0xEE, 0x01, 0xDC,
  0x00, 0xEE, 0x01, 0xDC, 0x00, 0xEC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70,
  0x01, 0xE0, 0x78, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0x80, 0x00, 0x3F, 0xE1, 0xE0, 0x1F, 0xFF, 0x3C, 0x07, 0xFF, 0xF7,
  0x81, 0xF8, 0x0E, 0xF0, 0x7C, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xC3, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3F,
  0x03, 0xF0, 0x1D, 0xE0, 0x3F, 0xFF, 0xBC, 0x07, 0xFF, 0xC7, 0x80, 0x3F,
  0xF0, 0xE0, 0x00, 0x60, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x87, 0xFE, 0x00, 0x78, 0xFF, 0xF0,
  0x07, 0xBF, 0xFF, 0x80, 0x7B, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0,
  0x7E, 0x00, 0x1E, 0x07, 0xF0, 0x03, 0xE0, 0x7F, 0x80, 0xFC, 0x07, 0xBF,
  0xFF, 0x80, 0x79, 0xFF, 0xF0, 0x0F, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF8, 0x78, 0x01, 0xFF, 0xF3,
  0xC0, 0x1F, 0xFF, 0xDE, 0x01, 0xF8, 0x0E, 0xF0, 0x1F, 0x00, 0x3F, 0x81,
  0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xFC,
  0x07, 0x78, 0x03, 0xFF, 0xFB, 0xC0, 0x1F, 0xFF, 0x1E, 0x00, 0x3F, 0xF0,
  0xE0, 0x00, 0x18, 0x08, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x9E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x01, 0xF0,
  0x3F, 0x00, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC3, 0xC0, 0x7F, 0xFC, 0xF0, 0x3F, 0xFF, 0xBC, 0x1F, 0x80,
  0xEF, 0x0F, 0x80, 0x1F, 0xC7, 0xC0, 0x03, 0xF1, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0xDE, 0x1F, 0x80, 0x77,
  0x03, 0xFF, 0xFB, 0xC0, 0x7F, 0xFC, 0xF0, 0x0F, 0xFE, 0x3C, 0x00, 0xFC,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x87, 0xFE, 0x00, 0x78, 0xFF, 0xF0, 0x07,
  0xBF, 0xFF, 0x80, 0x7B, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x1F, 0x01, 0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x0F,
  0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x03, 0x80, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3E, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8,
  0x01, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0x3F,
  0x87, 0xF0, 0x1D, 0xFF, 0x3F, 0xE0, 0xFF, 0xFC, 0xFF, 0xC3, 0xE0, 0xFE,
  0x1F, 0x0F, 0x01, 0xF0, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xE0, 0x1E, 0x03,
  0xC3, 0x80, 0x70, 0x0F, 0x1E, 0x01, 0xC0, 0x3C, 0x78, 0x07, 0x00, 0xF1,
  0xE0, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0x0E, 0x1C, 0x03, 0xC0, 0x78, 0x70,
  0x0E, 0x01, 0xE3, 0xC0, 0x38, 0x07, 0x8F, 0x00, 0xE0, 0x1E, 0x3C, 0x03,
  0x80, 0x70, 0xF0, 0x1E, 0x01, 0xC3, 0x80, 0x78, 0x0F, 0x0E, 0x01, 0xE0,
  0x3C, 0x38, 0x07, 0x00, 0xF1, 0xE0, 0x1C, 0x03, 0xC7, 0x80, 0x70, 0x0E,
  0x1E, 0x03, 0xC0, 0x38, 0x78, 0x0F, 0x00, 0xE1, 0xC0, 0x3C, 0x07, 0x87,
  0x00, 0xE0, 0x1E, 0x3C, 0x03, 0x80, 0x78, 0xF0, 0x0E, 0x01, 0xE3, 0xC0,
  0x38, 0x07, 0x0F, 0x01, 0xE0, 0x1C, 0x38, 0x07, 0x80, 0xF0, 0x07, 0x87,
  0xFE, 0x00, 0x78, 0xFF, 0xF0, 0x07, 0xBF, 0xFF, 0x80, 0x7B, 0x80, 0xFC,
  0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3F, 0x01, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x03, 0xC3, 0xFF, 0x00, 0x1E, 0x3F, 0xFC, 0x00, 0xF7, 0xFF,
  0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C,
  0x0F, 0xC0, 0x03, 0xC0, 0x7F, 0x00, 0x3E, 0x03, 0xFC, 0x07, 0xE0, 0x1E,
  0xFF, 0xFE, 0x00, 0xE3, 0xFF, 0xE0, 0x0F, 0x0F, 0xFC, 0x00, 0x78, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE1, 0xE0, 0x1F, 0xFF, 0x3C, 0x07, 0xFF, 0xF7, 0x81, 0xF8, 0x0E,
  0xF0, 0x7C, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x1D,
  0xE0, 0x7F, 0xFF, 0x3C, 0x07, 0xFF, 0xC7, 0x80, 0x3F, 0xF0, 0xE0, 0x00,
  0x60, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xFE,
  0x00, 0x79, 0xFF, 0xF0, 0x07, 0xBF, 0xFF, 0x80, 0x7B, 0x80, 0xFC, 0x07,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x07,
  0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0xE0,
  0x01, 0xE0, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x80,
  0x3E, 0x00, 0xEE, 0x00, 0xF8, 0x03, 0xB8, 0x03, 0xE0, 0x1E, 0xE0, 0x1F,
  0x80, 0x73, 0x80, 0x7E, 0x01, 0xCE, 0x01, 0xB8, 0x0F, 0x38, 0x0E, 0xE0,
  0x38, 0xE0, 0x3B, 0x80, 0xE3, 0x80, 0xCE, 0x07, 0x8E, 0x07, 0x38, 0x1C,
  0x38, 0x1C, 0x60, 0x70, 0xE0, 0x61, 0x83, 0xC3, 0x83, 0x86, 0x0E, 0x0E,
  0x0E, 0x18, 0x38, 0x38, 0x30, 0x61, 0xE0, 0xE1, 0xC1, 0x87, 0x03, 0x87,
  0x06, 0x1C, 0x0E, 0x18, 0x18, 0xF0, 0x38, 0xE0, 0x63, 0x80, 0xE3, 0x81,
  0x8E, 0x03, 0x8C, 0x06, 0x78, 0x0E, 0x70, 0x19, 0xC0, 0x39, 0xC0, 0x67,
  0x00, 0xE6, 0x01, 0x9C, 0x03, 0xB8, 0x06, 0xE0, 0x0E, 0xE0, 0x1B, 0x80,
  0x3B, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0x78, 0x07, 0xFF,
  0xCF, 0x00, 0x7F, 0xE1, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF0,
  0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x00, 0xE3, 0xE3, 0xE0, 0x0E, 0x38, 0x1F,
  0x00, 0xE7, 0x80, 0xF0, 0x1E, 0x78, 0x07, 0x81, 0xE7, 0x00, 0x7C, 0x3C,
  0x70, 0x03, 0xFF, 0x87, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x7E, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 13, 42, 35, 11, -42 },
  { 70, 19, 17, 35, 11, -42 },
  { 111, 34, 42, 35, 1, -42 },
  { 290, 30, 58, 35, 3, -50 },
  { 508, 40, 43, 35, -2, -43 },
  { 723, 31, 44, 35, 2, -43 },
  { 894, 7, 17, 35, 17, -42 },
  { 909, 23, 56, 35, 10, -49 },
  { 1070, 23, 56, 35, 3, -49 },
  { 1231, 31, 29, 35, 3, -35 },
  { 1344, 27, 27, 35, 4, -33 },
  { 1436, 14, 18, 35, 6, -9 },
  { 1468, 19, 4, 35, 8, -21 },
  { 1478, 9, 9, 35, 11, -8 },
  { 1489, 33, 54, 35, 2, -48 },
  { 1712, 29, 44, 35, 4, -43 },
  { 1872, 26, 42, 35, 3, -42 },
  { 2009, 30, 43, 35, 3, -43 },
  { 2171, 29, 43, 35, 3, -42 },
  { 2327, 27, 42, 35, 4, -42 },
  { 2469, 28, 43, 35, 4, -42 },
  { 2620, 27, 43, 35, 3, -42 },
  { 2766, 28, 42, 35, 7, -42 },
  { 2913, 29, 44, 35, 3, -43 },
  { 3073, 27, 43, 35, 6, -43 },
  { 3219, 13, 33, 35, 11, -32 },
  { 3273, 17, 41, 35, 7, -32 },
  { 3361, 28, 30, 35, 5, -34 },
  { 3466, 27, 17, 35, 4, -28 },
  { 3524, 28, 30, 35, 3, -34 },
  { 3629, 23, 42, 35, 9, -42 },
  { 3750, 34, 53, 35, 1, -43 },
  { 3976, 28, 42, 35, 1, -42 },
  { 4123, 29, 42, 35, 3, -42 },
  { 4276, 29, 44, 35, 4, -43 },
  { 4436, 29, 42, 35, 3, -42 },
  { 4589, 30, 42, 35, 4, -42 },
  { 4747, 31, 42, 35, 4, -42 },
  { 4910, 29, 44, 35, 4, -43 },
  { 5070, 30, 42, 35, 3, -42 },
  { 5228, 28, 42, 35, 4, -42 },
  { 5375, 30, 43, 35, 2, -42 },
  { 5537, 32, 42, 35, 3, -42 },
  { 5705, 25, 42, 35, 4, -42 },
  { 5837, 32, 42, 35, 2, -42 },
  { 6005, 30, 42, 35, 3, -42 },
  { 6163, 28, 44, 35, 4, -43 },
  { 6317, 31, 42, 35, 3, -42 },
  { 6480, 28, 53, 35, 4, -43 },
  { 6666, 31, 42, 35, 3, -42 },
  { 6829, 30, 44, 35, 3, -43 },
  { 6994, 29, 42, 35, 7, -42 },
  { 7147, 29, 43, 35, 4, -42 },
  { 7303, 27, 42, 35, 8, -42 },
  { 7445, 32, 42, 35, 5, -42 },
  { 7613, 35, 42, 35, 0, -42 },
  { 7797, 29, 42, 35, 7, -42 },
  { 7950, 30, 42, 35, 3, -42 },
  { 8108, 22, 54, 35, 9, -48 },
  { 8257, 16, 54, 35, 10, -48 },
  { 8365, 22, 54, 35, 5, -48 },
  { 8514, 24, 22, 35, 6, -42 },
  { 8580, 29, 4, 35, 0, 1 },
  { 8595, 9, 9, 35, 16, -46 },
  { 8606, 27, 33, 35, 4, -32 },
  { 8718, 28, 43, 35, 3, -42 },
  { 8869, 27, 33, 35, 4, -32 },
  { 8981, 29, 43, 35, 4, -42 },
  { 9137, 26, 33, 35, 4, -32 },
  { 9245, 38, 52, 35, -2, -42 },
  { 9492, 26, 42, 35, 5, -32 },
  { 9629, 28, 42, 35, 3, -42 },
  { 9776, 26, 45, 35, 3, -45 },
  { 9923, 29, 55, 35, 1, -45 },
  { 10123, 29, 42, 35, 4, -42 },
  { 10276, 24, 42, 35, 6, -42 },
  { 10402, 30, 32, 35, 2, -32 },
  { 10522, 28, 32, 35, 3, -32 },
  { 10634, 26, 33, 35, 4, -32 },
  { 10742, 29, 42, 35, 2, -32 },
  { 10895, 27, 42, 35, 4, -32 },
  { 11037, 28, 32, 35, 4, -32 },
  { 11149, 27, 33, 35, 4, -32 },
  { 11261, 26, 41, 35, 6, -41 },
  { 11395, 27, 33, 35, 4, -32 },
  { 11507, 26, 32, 35, 7, -32 },
  { 11611, 30, 32, 35, 5, -32 },
  { 11731, 32, 32, 35, 1, -32 },
  { 11859, 27, 42, 35, 4, -32 },
  { 12001, 28, 32, 35, 3, -32 },
  { 12113, 28, 54, 35, 6, -48 },
  { 12302, 12, 54, 35, 12, -48 },
  { 12383, 28, 54, 35, 2, -48 },
  { 12572, 28, 11, 35, 4, -26 },
};

const GFXfont JetBrainsMono_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC58PT7B_H_
