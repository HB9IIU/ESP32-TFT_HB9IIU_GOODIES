#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC60PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xF8,
  0x00, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF9, 0xDF, 0xC0, 0x0F, 0xC7, 0x0F, 0x80,
  0x1E, 0x0E, 0x0F, 0x80, 0x78, 0x1C, 0x0F, 0x00, 0xF0, 0x38, 0x1E, 0x03,
  0xC0, 0x70, 0x3C, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x01, 0x80, 0xF0, 0x1C,
  0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x07, 0xE3,
  0x80, 0x00, 0x07, 0xF7, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xBF, 0x80, 0x00, 0x07, 0x1F, 0x80, 0x00, 0x0E, 0x0F,
  0x80, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x60, 0x3C,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0,
  0xF0, 0x0E, 0x03, 0xC1, 0xE0, 0x1C, 0x07, 0x83, 0xC0, 0x30, 0x0F, 0x07,
  0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0xF8, 0x1F, 0x03, 0x81, 0xE0, 0x1F,
  0x07, 0x0F, 0x80, 0x3F, 0x8E, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x03,
  0x80, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x1F, 0x07, 0x80, 0x03, 0x80, 0x0F,
  0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0x81, 0xE0, 0x00, 0x38, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x01, 0xC1,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0xE0, 0x00,
  0x03, 0xE1, 0xF0, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x7F, 0xE0, 0x00, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x00, 0x78, 0x7C,
  0x7C, 0x00, 0x00, 0x38, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x38, 0x07, 0x80,
  0x00, 0x38, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x80,
  0x38, 0x00, 0x1C, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x0E, 0x00, 0x07, 0xFF,
  0xC0, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x07, 0x80, 0x1E,
  0x3E, 0x07, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x3C, 0x3C, 0x01, 0xE0, 0x78,
  0x3C, 0x01, 0xF0, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x78, 0x00, 0xF9, 0xE0,
  0x78, 0x00, 0x7B, 0xC0, 0x78, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x3F, 0x80,
  0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0xF3, 0xC0,
  0x7C, 0x03, 0xE3, 0xE0, 0x7E, 0x0F, 0xC1, 0xE0, 0x3F, 0xFF, 0x81, 0xF0,
  0x3F, 0xFF, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0x78, 0x01, 0x80, 0x00, 0x00,
  0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xE7, 0xCF, 0x1E,
  0x3C, 0x78, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x01, 0xE0, 0x02, 0x3C, 0x01,
  0xC0, 0x1E, 0x7F, 0x01, 0xC0, 0xFE, 0x7F, 0xE1, 0xC3, 0xFF, 0xBF, 0xF1,
  0x8F, 0xFE, 0x0F, 0xFD, 0xBF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0x7F, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x0F, 0x81, 0xE0, 0x3C, 0x3C, 0x0F, 0xC0, 0xF0, 0xF0,
  0x3F, 0x03, 0xC3, 0xC0, 0xFC, 0x1E, 0x0F, 0x03, 0xF0, 0x78, 0x3C, 0x07,
  0x81, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x7E,
  0x78, 0x00, 0x3F, 0x0F, 0x00, 0x0F, 0xC1, 0xE0, 0x03, 0xE0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01, 0x00, 0x3C, 0x00, 0x40, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x7F, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x7E, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x79, 0xFF, 0xF8,
  0x03, 0xDF, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x7C, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x3F, 0xF0, 0x03, 0xDF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xC0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x7F,
  0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xDE, 0x00, 0x7F, 0xF3, 0xC0, 0x01,
  0xFC, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC, 0x3F,
  0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x81,
  0xFC, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xF0, 0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x7F, 0x1E, 0x0F, 0x00, 0x3F, 0xF3, 0xC1, 0xE0, 0x0F, 0xFF,
  0x78, 0x3C, 0x03, 0xF0, 0x6E, 0x07, 0x00, 0xF8, 0x07, 0xC1, 0xE0, 0x1E,
  0x00, 0x78, 0x3C, 0x03, 0x80, 0x0F, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0,
  0x1E, 0x00, 0x3C, 0x1E, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x78, 0x00, 0xE0,
  0x70, 0x0E, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0x07, 0x83, 0xC0, 0x78, 0x00,
  0xF0, 0x78, 0x0F, 0x00, 0x1E, 0x0F, 0x01, 0xE0, 0x03, 0xC1, 0xC0, 0x3C,
  0x00, 0x70, 0x38, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x03, 0xC1, 0xE0,
  0x1E, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x7C, 0x07, 0xE0,
  0xF0, 0x0F, 0xF7, 0xB8, 0x1C, 0x00, 0xFF, 0xE7, 0x03, 0x80, 0x0F, 0xF8,
  0xE0, 0x70, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E,
  0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0xE0, 0x7C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x07, 0xF0, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0x80,
  0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0x01, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0xFE, 0x01, 0xE0,
  0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0,
  0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xF0, 0x1E, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0x8F, 0x00, 0xFF, 0xF8, 0x78, 0x0F,
  0xFF, 0xC3, 0xC0, 0x7F, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7F, 0x01, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x77, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xB8, 0x00, 0xEE,
  0x07, 0xB8, 0x01, 0xEE, 0x07, 0xB8, 0x01, 0xCE, 0x07, 0xB8, 0x03, 0xDE,
  0x07, 0x3C, 0x03, 0x9E, 0x07, 0x1C, 0x07, 0x9E, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0F, 0x1E, 0x1E, 0x3C,
  0x0F, 0x0E, 0x1C, 0x3C, 0x0F, 0x0E, 0x3C, 0x3C, 0x0F, 0x0E, 0x38, 0x38,
  0x0E, 0x0E, 0x78, 0x78, 0x1E, 0x0E, 0x70, 0x78, 0x1E, 0x07, 0xF0, 0x78,
  0x1E, 0x07, 0xE0, 0x78, 0x1E, 0x07, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0x70,
  0x1C, 0x07, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1E,
  0x03, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0xF0,
  0x1F, 0xC0, 0x01, 0xE0, 0x3F, 0x80, 0x03, 0x80, 0xF7, 0x00, 0x0F, 0x01,
  0xEE, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x3C, 0x07, 0xBC, 0x00, 0x78, 0x0F,
  0x38, 0x00, 0xF0, 0x1C, 0x70, 0x01, 0xC0, 0x78, 0xE0, 0x07, 0x80, 0xF1,
  0xE0, 0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x03, 0xC3, 0x80, 0x3C, 0x07, 0x87,
  0x00, 0x78, 0x0F, 0x0F, 0x00, 0xE0, 0x1C, 0x1E, 0x03, 0xC0, 0x78, 0x1C,
  0x07, 0x80, 0xF0, 0x38, 0x0F, 0x01, 0xE0, 0x70, 0x1E, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x03, 0x83,
  0xC0, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x0E, 0x1E,
  0x03, 0xC0, 0x1C, 0x3C, 0x07, 0x00, 0x3C, 0x70, 0x1E, 0x00, 0x79, 0xE0,
  0x3C, 0x00, 0xF3, 0xC0, 0x78, 0x00, 0xE7, 0x80, 0xF0, 0x01, 0xCF, 0x01,
  0xE0, 0x03, 0xDE, 0x03, 0xC0, 0x07, 0xB8, 0x0F, 0x00, 0x07, 0x70, 0x1E,
  0x00, 0x0E, 0xE0, 0x3C, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x3F, 0x80, 0xF0,
  0x00, 0x7F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC1,
  0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7E, 0x03, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xF0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xBC, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0xFC, 0x01,
  0xEF, 0x00, 0x7E, 0x00, 0xE7, 0x80, 0x3F, 0x00, 0xF3, 0xC0, 0x1B, 0x80,
  0x79, 0xE0, 0x1D, 0x80, 0x3C, 0xF0, 0x0E, 0xC0, 0x1C, 0x78, 0x06, 0x60,
  0x1E, 0x3C, 0x07, 0x30, 0x0F, 0x1E, 0x03, 0x98, 0x07, 0x0E, 0x01, 0xCC,
  0x07, 0x87, 0x01, 0xC6, 0x03, 0xC3, 0x80, 0xE3, 0x01, 0xE1, 0xC0, 0x71,
  0x80, 0xE0, 0xE0, 0x30, 0xC0, 0xF0, 0x70, 0x38, 0x60, 0x78, 0x38, 0x1C,
  0x70, 0x38, 0x1C, 0x0C, 0x38, 0x1C, 0x0E, 0x0E, 0x1C, 0x1E, 0x07, 0x07,
  0x0E, 0x0F, 0x03, 0x83, 0x87, 0x07, 0x03, 0xC1, 0x83, 0x83, 0x81, 0xE1,
  0xC1, 0xC3, 0xC0, 0xF0, 0xE0, 0xE1, 0xC0, 0x78, 0x60, 0x70, 0xE0, 0x3C,
  0x70, 0x38, 0xF0, 0x1E, 0x38, 0x1C, 0x78, 0x0F, 0x1C, 0x0E, 0x38, 0x07,
  0x9C, 0x07, 0x1C, 0x03, 0xCE, 0x03, 0x9E, 0x01, 0xE7, 0x01, 0xCF, 0x00,
  0xF3, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x3B, 0xC0,
  0x1C, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xF0,
  0x03, 0xB8, 0x03, 0xF8, 0x01, 0xD8, 0x01, 0xB8, 0x00, 0xFC, 0x00, 0xDC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x1E,
  0x07, 0x80, 0x07, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00,
  0xF3, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x7F, 0xFC, 0xF0, 0x1F, 0xFF, 0xEF,
  0x03, 0xF0, 0x1E, 0xF0, 0x7C, 0x00, 0x6F, 0x07, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xF0, 0x3F, 0x01, 0xEF, 0x01, 0xFF,
  0xFC, 0xF0, 0x0F, 0xFF, 0x8E, 0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x7F, 0xE0, 0x07, 0x1F, 0xFF, 0x00, 0xF3,
  0xFF, 0xF8, 0x0F, 0x78, 0x0F, 0xC0, 0xFE, 0x00, 0x7C, 0x0F, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0x1E, 0x0F, 0xE0, 0x07, 0xE0, 0xF7, 0x80, 0xFC,
  0x0F, 0x7F, 0xFF, 0x80, 0xF3, 0xFF, 0xE0, 0x0F, 0x0F, 0xFC, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x18, 0x07, 0x80, 0x0F, 0xFC, 0x3C, 0x00,
  0x7F, 0xFC, 0xF0, 0x07, 0xFF, 0xFB, 0xC0, 0x3F, 0x01, 0xEF, 0x01, 0xF0,
  0x01, 0xBC, 0x07, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0x01, 0xEF, 0x00,
  0x7F, 0xFF, 0x3C, 0x00, 0xFF, 0xF8, 0xE0, 0x01, 0xFF, 0x87, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x81, 0xE0, 0x03, 0xE0, 0xF0,
  0x00, 0x7C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x3C, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFC, 0x3C, 0x03, 0xFF, 0xE7,
  0x81, 0xFF, 0xFE, 0xF0, 0x7E, 0x03, 0xDE, 0x1F, 0x80, 0x1B, 0xC3, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0xFF,
  0x03, 0xFF, 0xFD, 0xE0, 0x3F, 0xFF, 0x3C, 0x03, 0xFF, 0x87, 0x80, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x78, 0x7F, 0xE0, 0x07, 0x1F, 0xFF, 0x00, 0xF3, 0xFF, 0xF8, 0x0F,
  0x78, 0x0F, 0xC0, 0xFE, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0xC0,
  0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x07, 0x9F, 0xC3, 0xF8, 0x07,
  0x3F, 0xE7, 0xFC, 0x07, 0x7F, 0xEF, 0xFE, 0x0F, 0xC1, 0xE8, 0x3E, 0x0F,
  0x81, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0x1E, 0x0F,
  0x00, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E,
  0x01, 0xE0, 0x1C, 0x1E, 0x01, 0xE0, 0x1C, 0x1E, 0x01, 0xC0, 0x3C, 0x1E,
  0x01, 0xC0, 0x3C, 0x1C, 0x01, 0xC0, 0x3C, 0x1C, 0x03, 0xC0, 0x3C, 0x3C,
  0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x38, 0x3C, 0x03, 0x80, 0x78, 0x3C,
  0x03, 0x80, 0x78, 0x3C, 0x03, 0x80, 0x78, 0x38, 0x07, 0x80, 0x78, 0x78,
  0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0x70, 0x78, 0x07, 0x00, 0x70, 0x78,
  0x07, 0x00, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x00, 0xE0, 0xF0,
  0x0E, 0x01, 0xE0, 0xF0, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x78,
  0x7F, 0xE0, 0x07, 0x1F, 0xFF, 0x00, 0xF3, 0xFF, 0xF8, 0x0F, 0x78, 0x0F,
  0xC0, 0xFE, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF0,
  0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x3F, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0x87, 0xFE, 0x00, 0x1C, 0x7F, 0xFC, 0x00,
  0xF3, 0xFF, 0xF8, 0x03, 0xDE, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07,
  0x80, 0xF6, 0x00, 0x7E, 0x03, 0xDE, 0x03, 0xF0, 0x0F, 0x7F, 0xFF, 0x80,
  0x3C, 0xFF, 0xFC, 0x00, 0xF0, 0xFF, 0xC0, 0x07, 0x80, 0x60, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0xFF, 0xFC, 0xF0,
  0x1F, 0xFF, 0xEF, 0x03, 0xF0, 0x1E, 0xF0, 0x7E, 0x00, 0x6F, 0x07, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xF0, 0x3F, 0x01,
  0xEF, 0x01, 0xFF, 0xFC, 0xF0, 0x0F, 0xFF, 0x9E, 0x00, 0x7F, 0xE1, 0xE0,
  0x00, 0x60, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x78, 0x7F, 0xE0, 0x07, 0x9F,
  0xFF, 0x00, 0xF3, 0xFF, 0xF8, 0x0F, 0x78, 0x0F, 0xC0, 0xFE, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7E,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3B, 0xC0, 0x1F, 0x00, 0x77, 0x80,
  0x7E, 0x01, 0xEF, 0x00, 0xFC, 0x03, 0x9E, 0x01, 0xB8, 0x07, 0x3C, 0x07,
  0x70, 0x1E, 0x78, 0x0E, 0xE0, 0x3C, 0xF0, 0x19, 0xC0, 0x71, 0xE0, 0x73,
  0x81, 0xE3, 0xC0, 0xE7, 0x03, 0xC7, 0x81, 0x8E, 0x07, 0x0F, 0x07, 0x1C,
  0x1E, 0x1E, 0x0E, 0x38, 0x3C, 0x3C, 0x18, 0x70, 0x70, 0x78, 0x70, 0xE1,
  0xE0, 0xF0, 0xE1, 0xC3, 0xC1, 0xE1, 0x83, 0x87, 0x03, 0xC7, 0x07, 0x1E,
  0x07, 0x8E, 0x0E, 0x3C, 0x0F, 0x18, 0x1C, 0x70, 0x1E, 0x70, 0x38, 0xE0,
  0x3C, 0xE0, 0x73, 0xC0, 0x79, 0x80, 0xE7, 0x00, 0xF7, 0x01, 0xCE, 0x01,
  0xEE, 0x03, 0xBC, 0x03, 0xD8, 0x07, 0x70, 0x07, 0xF0, 0x0E, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0xC1, 0xF8, 0x07, 0x78, 0x1F, 0xFF, 0xCF, 0x01, 0xFF,
  0xF1, 0xE0, 0x1F, 0xF8, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x7F, 0xC0, 0x03, 0xC7, 0xFF,
  0x80, 0x1E, 0x3E, 0x7C, 0x00, 0xE3, 0xC1, 0xF0, 0x07, 0x1C, 0x07, 0xC0,
  0x79, 0xE0, 0x1E, 0x03, 0xCF, 0x00, 0x78, 0x3C, 0x78, 0x03, 0xFF, 0xE3,
  0x80, 0x0F, 0xFE, 0x1C, 0x00, 0x3F, 0xE1, 0xE0, 0x00, 0x30, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 13, 44, 36, 12, -44 },
  { 73, 19, 18, 36, 12, -44 },
  { 116, 35, 44, 36, 1, -44 },
  { 309, 31, 60, 36, 3, -52 },
  { 542, 41, 44, 36, -2, -44 },
  { 768, 32, 45, 36, 2, -44 },
  { 948, 7, 18, 36, 18, -44 },
  { 964, 25, 59, 36, 10, -51 },
  { 1149, 24, 59, 36, 3, -51 },
  { 1326, 32, 31, 36, 3, -37 },
  { 1450, 29, 28, 36, 4, -34 },
  { 1552, 14, 19, 36, 7, -9 },
  { 1586, 19, 4, 36, 9, -22 },
  { 1596, 10, 10, 36, 11, -9 },
  { 1609, 34, 57, 36, 2, -50 },
  { 1852, 30, 45, 36, 4, -44 },
  { 2021, 27, 44, 36, 3, -44 },
  { 2170, 31, 44, 36, 3, -44 },
  { 2341, 29, 45, 36, 4, -44 },
  { 2505, 28, 44, 36, 4, -44 },
  { 2659, 29, 45, 36, 4, -44 },
  { 2823, 27, 45, 36, 4, -44 },
  { 2975, 29, 44, 36, 7, -44 },
  { 3135, 30, 45, 36, 3, -44 },
  { 3304, 28, 44, 36, 6, -44 },
  { 3458, 14, 35, 36, 11, -34 },
  { 3520, 18, 44, 36, 7, -34 },
  { 3619, 29, 31, 36, 5, -35 },
  { 3732, 27, 18, 36, 5, -29 },
  { 3793, 29, 31, 36, 3, -35 },
  { 3906, 24, 44, 36, 9, -44 },
  { 4038, 35, 55, 36, 1, -44 },
  { 4279, 29, 44, 36, 1, -44 },
  { 4439, 30, 44, 36, 4, -44 },
  { 4604, 29, 45, 36, 5, -44 },
  { 4768, 29, 44, 36, 4, -44 },
  { 4928, 31, 44, 36, 4, -44 },
  { 5099, 32, 44, 36, 4, -44 },
  { 5275, 29, 45, 36, 5, -44 },
  { 5439, 30, 44, 36, 4, -44 },
  { 5604, 29, 44, 36, 4, -44 },
  { 5764, 31, 45, 36, 2, -44 },
  { 5939, 33, 44, 36, 4, -44 },
  { 6121, 26, 44, 36, 4, -44 },
  { 6264, 32, 44, 36, 3, -44 },
  { 6440, 31, 44, 36, 3, -44 },
  { 6611, 28, 45, 36, 5, -44 },
  { 6769, 31, 44, 36, 4, -44 },
  { 6940, 29, 55, 36, 4, -44 },
  { 7140, 31, 44, 36, 4, -44 },
  { 7311, 31, 45, 36, 3, -44 },
  { 7486, 30, 44, 36, 7, -44 },
  { 7651, 30, 45, 36, 4, -44 },
  { 7820, 29, 44, 36, 8, -44 },
  { 7980, 33, 44, 36, 5, -44 },
  { 8162, 37, 44, 36, 0, -44 },
  { 8366, 31, 44, 36, 7, -44 },
  { 8537, 31, 44, 36, 3, -44 },
  { 8708, 23, 57, 36, 9, -50 },
  { 8872, 17, 57, 36, 10, -50 },
  { 8994, 22, 57, 36, 6, -50 },
  { 9151, 25, 24, 36, 6, -44 },
  { 9226, 30, 4, 36, 0, 1 },
  { 9241, 9, 8, 36, 17, -47 },
  { 9250, 28, 35, 36, 4, -34 },
  { 9373, 28, 45, 36, 4, -44 },
  { 9531, 27, 35, 36, 5, -34 },
  { 9650, 30, 45, 36, 4, -44 },
  { 9819, 26, 35, 36, 5, -34 },
  { 9933, 39, 55, 36, -2, -44 },
  { 10202, 27, 45, 36, 5, -34 },
  { 10354, 28, 44, 36, 4, -44 },
  { 10508, 27, 46, 36, 3, -46 },
  { 10664, 30, 57, 36, 1, -46 },
  { 10878, 31, 44, 36, 4, -44 },
  { 11049, 25, 44, 36, 6, -44 },
  { 11187, 32, 34, 36, 2, -34 },
  { 11323, 28, 34, 36, 4, -34 },
  { 11442, 26, 35, 36, 5, -34 },
  { 11556, 30, 45, 36, 2, -34 },
  { 11725, 28, 45, 36, 4, -34 },
  { 11883, 28, 34, 36, 5, -34 },
  { 12002, 28, 35, 36, 4, -34 },
  { 12125, 27, 42, 36, 6, -42 },
  { 12267, 29, 34, 36, 4, -33 },
  { 12391, 27, 33, 36, 7, -33 },
  { 12503, 31, 33, 36, 5, -33 },
  { 12631, 33, 33, 36, 1, -33 },
  { 12768, 27, 44, 36, 5, -33 },
  { 12917, 29, 33, 36, 3, -33 },
  { 13037, 30, 57, 36, 6, -50 },
  { 13251, 13, 57, 36, 12, -50 },
  { 13344, 29, 57, 36, 2, -50 },
  { 13551, 29, 12, 36, 4, -27 },
};

const GFXfont JetBrainsMono_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC60PT7B_H_
