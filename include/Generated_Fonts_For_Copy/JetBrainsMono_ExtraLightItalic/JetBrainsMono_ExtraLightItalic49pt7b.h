#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC49PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0xC7,
  0x80, 0x78, 0x61, 0xE0, 0x78, 0x70, 0xF0, 0x38, 0x38, 0x38, 0x3C, 0x18,
  0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x60, 0x00, 0x1F,
  0xB0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0x3F, 0x00, 0x01, 0x87, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x60, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0E,
  0x38, 0x0C, 0x0F, 0x1C, 0x06, 0x07, 0x0E, 0x03, 0x03, 0x87, 0x83, 0x83,
  0xC1, 0xE1, 0xC3, 0xC0, 0xF8, 0xE3, 0xC0, 0x3F, 0xEF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x7F, 0xC0, 0x03, 0x80,
  0x7F, 0xE0, 0x03, 0x80, 0x70, 0x78, 0x03, 0x80, 0x70, 0x1C, 0x01, 0x80,
  0x38, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x81, 0xC0,
  0x0E, 0x01, 0x81, 0xC0, 0x07, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xE1, 0xC0,
  0x01, 0xC0, 0x70, 0xC0, 0x00, 0xE0, 0x70, 0xE0, 0x00, 0x38, 0x78, 0xE0,
  0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x00, 0x71, 0xFF, 0x00, 0x00, 0x71,
  0xF7, 0xC0, 0x00, 0x70, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x38,
  0x70, 0x1C, 0x00, 0x38, 0x30, 0x0C, 0x00, 0x38, 0x38, 0x06, 0x00, 0x38,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0xF9, 0xE0, 0x1C,
  0x00, 0x3F, 0xE0, 0x1C, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x70, 0x07,
  0x8F, 0x0F, 0x00, 0xE3, 0xC0, 0xE0, 0x38, 0x70, 0x1E, 0x0F, 0x0E, 0x01,
  0xE3, 0xC1, 0xC0, 0x1C, 0x70, 0x38, 0x03, 0xDC, 0x0F, 0x00, 0x3F, 0x81,
  0xE0, 0x07, 0xE0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x03,
  0xF0, 0x1C, 0x00, 0x7E, 0x03, 0xC0, 0x1D, 0xE0, 0x78, 0x0F, 0x1C, 0x07,
  0xEF, 0xC3, 0xC0, 0xFF, 0xF0, 0x3C, 0x07, 0xF8, 0x03, 0x80, 0x3C, 0xF3,
  0xCF, 0x39, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0x73, 0xCE, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x80, 0x3C, 0x01, 0x78, 0x1C, 0x07, 0xFF, 0x0E,
  0x1F, 0xFF, 0xE3, 0x3F, 0xE3, 0xFD, 0x7F, 0xC0, 0x7F, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7C,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38,
  0x78, 0x38, 0x1C, 0x3C, 0x3E, 0x0E, 0x1C, 0x1F, 0x07, 0x0E, 0x0F, 0x87,
  0x87, 0x07, 0xC3, 0xC3, 0x81, 0x81, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0xFB, 0x80, 0x0F, 0xBC, 0x01, 0xF1, 0xE0, 0x1E, 0x0E,
  0x01, 0xE0, 0x70, 0x0C, 0x03, 0x80, 0x40, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0x78, 0x03, 0xC0, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x07, 0x80,
  0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x71,
  0xE0, 0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x0E, 0x3F, 0xE0, 0x0E,
  0xFF, 0xF0, 0x1F, 0xF3, 0xF8, 0x1D, 0x80, 0x78, 0x1F, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x3F, 0xBF, 0xC0, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE3, 0xE0,
  0x03, 0xBF, 0xF0, 0x0E, 0xFF, 0xF0, 0x3F, 0x01, 0xF0, 0x7C, 0x01, 0xF1,
  0xE0, 0x01, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0x7C, 0x03, 0xE0, 0x7F, 0x3F, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0x80, 0x00,
  0xF7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x71, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x1C,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xE3, 0xC0, 0x0F, 0x81, 0xF0,
  0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xE0,
  0x3F, 0x9F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x03, 0xC3,
  0x80, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01,
  0xE0, 0xF8, 0x0F, 0xC1, 0xFF, 0xF7, 0x01, 0xFF, 0xDC, 0x00, 0xFE, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE,
  0x1F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xFC, 0x1F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xC1, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x00, 0x10, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x78, 0x71, 0xC0, 0x1F, 0xEE, 0x1C, 0x03, 0xFF, 0xE1, 0xC0, 0x78, 0x3E,
  0x1C, 0x0F, 0x01, 0xE1, 0xC0, 0xE0, 0x1E, 0x38, 0x0E, 0x01, 0xE3, 0x81,
  0xC0, 0x1C, 0x38, 0x1C, 0x01, 0xC3, 0x81, 0xC0, 0x1C, 0x38, 0x1C, 0x01,
  0xC3, 0x81, 0xC0, 0x1C, 0x78, 0x1C, 0x01, 0xC7, 0x03, 0x80, 0x38, 0x70,
  0x38, 0x03, 0x87, 0x03, 0x80, 0x38, 0x70, 0x38, 0x07, 0x87, 0x03, 0xC0,
  0x78, 0xF0, 0x1F, 0x1B, 0x8E, 0x01, 0xFF, 0xB8, 0xE0, 0x0F, 0xE3, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x80,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x70,
  0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0xCF, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x70, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0x00, 0x7E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1C,
  0x00, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3C,
  0x01, 0xF8, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70,
  0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0,
  0x01, 0xE0, 0x78, 0x07, 0xC0, 0x7F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0x00, 0xFC, 0x07, 0x00, 0x3E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x0F,
  0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x70,
  0x03, 0xC0, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x10, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x1F, 0xFC, 0x78, 0x3F, 0xFC, 0x70, 0x3F, 0xF8, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x7F,
  0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x03, 0x83,
  0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0x80, 0x03, 0x83, 0xC0,
  0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x1F, 0x8F, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x3C, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xC0, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x1C,
  0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x07, 0x60, 0x7E, 0x00, 0xFC, 0x0E, 0xC0, 0x3B, 0x81, 0x98,
  0x07, 0x70, 0x33, 0x81, 0xCE, 0x0E, 0x70, 0x3B, 0x81, 0xCE, 0x0E, 0x70,
  0x38, 0xC1, 0xCE, 0x07, 0x18, 0x71, 0xC0, 0xE3, 0x0E, 0x38, 0x1C, 0x73,
  0x8F, 0x07, 0x8E, 0x71, 0xC0, 0xE1, 0xCC, 0x38, 0x1C, 0x1B, 0x87, 0x03,
  0x83, 0x60, 0xE0, 0x70, 0x7C, 0x1C, 0x0E, 0x0F, 0x03, 0x81, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x03, 0x83, 0xE0, 0x01, 0xC1, 0xF0,
  0x01, 0xE0, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0x38, 0x1F,
  0x80, 0x1C, 0x1C, 0xC0, 0x0E, 0x0E, 0x70, 0x0F, 0x07, 0x38, 0x07, 0x03,
  0x9C, 0x03, 0x81, 0xC6, 0x01, 0xC0, 0xE3, 0x80, 0xE0, 0xF1, 0xC0, 0x70,
  0x70, 0xE0, 0x38, 0x38, 0x70, 0x3C, 0x1C, 0x18, 0x1C, 0x0E, 0x0E, 0x0E,
  0x07, 0x07, 0x07, 0x07, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0x71,
  0xE0, 0xE0, 0x38, 0xE0, 0x70, 0x1C, 0x70, 0x38, 0x0E, 0x38, 0x3C, 0x03,
  0x9C, 0x1C, 0x01, 0xCE, 0x0E, 0x00, 0xE7, 0x07, 0x00, 0x77, 0x03, 0x80,
  0x3B, 0x81, 0xC0, 0x0F, 0xC0, 0xE0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0x70,
  0x01, 0xF8, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x03, 0xE0, 0x78, 0x03, 0xC1,
  0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x38,
  0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00,
  0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xFE, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x1C, 0x00, 0xFC, 0x07, 0x00, 0x0F, 0x81, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x3E,
  0x07, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E,
  0x03, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x79, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x0F, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x78, 0x07,
  0x80, 0xFE, 0x7F, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xE0, 0x0F,
  0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x1C, 0x00, 0x7C, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x00,
  0x1E, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7C, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x1F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00,
  0x38, 0x70, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03,
  0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x1E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xEE, 0x01, 0xE0,
  0x1D, 0xC0, 0x3C, 0x03, 0xB8, 0x0F, 0x80, 0xE7, 0x01, 0xB0, 0x1C, 0xE0,
  0x36, 0x03, 0x9C, 0x06, 0xC0, 0x73, 0x81, 0xD8, 0x1C, 0x70, 0x33, 0x03,
  0x8E, 0x06, 0x60, 0x71, 0xC1, 0xCC, 0x1C, 0x38, 0x31, 0x83, 0x87, 0x06,
  0x30, 0x70, 0xE0, 0xC6, 0x0E, 0x1C, 0x30, 0xC3, 0x83, 0x06, 0x38, 0x70,
  0x60, 0xC7, 0x0E, 0x0C, 0x38, 0xE1, 0x83, 0x86, 0x1C, 0x70, 0x70, 0xC3,
  0x8E, 0x0E, 0x38, 0x71, 0xC1, 0xC6, 0x0E, 0x70, 0x38, 0xC1, 0x8E, 0x07,
  0x18, 0x31, 0xC0, 0xE7, 0x06, 0x30, 0x1C, 0xC0, 0xCE, 0x03, 0x98, 0x19,
  0xC0, 0x77, 0x03, 0x38, 0x0E, 0xC0, 0x66, 0x01, 0xD8, 0x0D, 0xC0, 0x3B,
  0x01, 0xB8, 0x07, 0xC0, 0x36, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7,
  0x00, 0x01, 0xC3, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0,
  0x3C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x70,
  0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x3C,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3,
  0x80, 0x38, 0x1C, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x01, 0xC0, 0xE0,
  0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xF7, 0x80, 0x07, 0xF0,
  0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xE1, 0xC1, 0xC3, 0xC0, 0x00, 0x7F, 0x8F, 0x01, 0xFF, 0xCE, 0x03,
  0xF3, 0xEE, 0x07, 0x80, 0x6E, 0x0F, 0x00, 0x3E, 0x0E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0x3C, 0x03, 0x70, 0x3F, 0x9F, 0xF0, 0x1F, 0xFC, 0xE0, 0x0F,
  0xF8, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x3F, 0xC0, 0x39, 0xFF, 0xC0, 0x77, 0xDF,
  0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x00,
  0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xFC, 0x03,
  0xE1, 0xFF, 0x3F, 0x83, 0x9F, 0xFE, 0x07, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xE0, 0x3E, 0x1E, 0x00, 0x78,
  0x70, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0x8F, 0x00,
  0x1E, 0x1E, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC7, 0x00, 0x7F, 0xF3, 0x80,
  0x7E, 0x7D, 0xC0, 0x78, 0x06, 0xE0, 0x78, 0x01, 0xF0, 0x38, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00,
  0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xE0,
  0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x03, 0x70, 0x1F, 0xCF, 0xF8, 0x07,
  0xFF, 0x38, 0x01, 0xFF, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x7E, 0x3F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xE3, 0xC0,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x1E, 0x01, 0xF0,
  0x7F, 0x1F, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x04, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x1E,
  0x07, 0xFF, 0x38, 0x1F, 0xDF, 0x70, 0x78, 0x06, 0xE1, 0xE0, 0x07, 0xC3,
  0x80, 0x07, 0x8F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0,
  0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x8E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0xDC,
  0x0F, 0xFF, 0xB8, 0x0F, 0xFC, 0x70, 0x0F, 0xF1, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x3F, 0xC0, 0x39, 0xFF,
  0xC0, 0x77, 0x8F, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x07,
  0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71,
  0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0xF0, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xC3, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x70,
  0x01, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x0E,
  0x01, 0xE0, 0x07, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00,
  0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x07, 0x7E, 0x1F, 0x83, 0xBF, 0xCF, 0xE0,
  0xE8, 0xF6, 0x3C, 0x3C, 0x1D, 0x07, 0x0E, 0x07, 0x81, 0xC3, 0x81, 0xC0,
  0x70, 0xE0, 0x70, 0x1C, 0x38, 0x1C, 0x07, 0x1C, 0x07, 0x03, 0xC7, 0x01,
  0xC0, 0xE1, 0xC0, 0x70, 0x38, 0x70, 0x18, 0x0E, 0x1C, 0x0E, 0x03, 0x87,
  0x03, 0x80, 0xE3, 0xC0, 0xE0, 0x38, 0xE0, 0x38, 0x1C, 0x38, 0x0E, 0x07,
  0x0E, 0x03, 0x01, 0xC3, 0x81, 0xC0, 0x70, 0xE0, 0x70, 0x1C, 0x78, 0x1C,
  0x07, 0x1C, 0x07, 0x03, 0xC7, 0x01, 0xC0, 0xE1, 0xC0, 0x70, 0x38, 0x70,
  0x18, 0x0E, 0x1C, 0x0E, 0x03, 0x8F, 0x03, 0x80, 0xE0, 0x0E, 0x1F, 0xE0,
  0x1C, 0xFF, 0xE0, 0x3B, 0xC7, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xC3,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00,
  0x71, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xC0, 0x01, 0xE3,
  0x80, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0x7F, 0x03,
  0xC0, 0x3C, 0x1E, 0x00, 0x78, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0,
  0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x7F, 0x3F, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x87, 0xF8, 0x01, 0xCF, 0xFE,
  0x00, 0xEF, 0xBF, 0x80, 0x7C, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F,
  0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xC0,
  0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0xE7, 0xF0,
  0x1C, 0xFF, 0xF0, 0x0E, 0x3F, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x8E, 0x03, 0xFF, 0x9C, 0x0F, 0xCF, 0xB8, 0x3C, 0x03, 0x70, 0xF0,
  0x03, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x38,
  0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x1E, 0x01, 0xB8, 0x3F, 0x9E, 0xF0, 0x3F,
  0xF9, 0xC0, 0x3F, 0xE3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x3F, 0xE0, 0x1C, 0xFF,
  0xE0, 0x3B, 0xC7, 0xE0, 0xFC, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x03,
  0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0xF0, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xC7, 0xF0, 0x7C, 0x01,
  0xE0, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xCF, 0x00,
  0x03, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x7F, 0x0F,
  0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00,
  0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0x3F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00,
  0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0xC0, 0x0E, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x0F, 0x00, 0xFC,
  0x07, 0x80, 0xEE, 0x03, 0xC0, 0x77, 0x03, 0xF0, 0x3B, 0x81, 0xB8, 0x39,
  0xC0, 0xDC, 0x1C, 0xE0, 0xEE, 0x0E, 0x70, 0x67, 0x0E, 0x38, 0x33, 0x87,
  0x1C, 0x38, 0xC3, 0x8E, 0x18, 0x63, 0x87, 0x0C, 0x31, 0xC3, 0x8E, 0x18,
  0xE1, 0xC6, 0x0C, 0x60, 0xE3, 0x06, 0x70, 0x73, 0x83, 0x38, 0x39, 0x81,
  0x98, 0x1C, 0xC0, 0xDC, 0x0E, 0xE0, 0x6E, 0x07, 0x60, 0x36, 0x03, 0xB0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x70, 0x00, 0x70, 0x0F, 0x00,
  0x1E, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00,
  0x3C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x38,
  0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xC0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x38, 0x00,
  0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x39,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xF0, 0x3B, 0x83,
  0xFF, 0xCE, 0x07, 0xFE, 0x78, 0x0F, 0xE1, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x0E, 0x3F, 0xC0, 0x1C, 0xFF, 0xC0, 0x3B, 0x87, 0x80, 0xE7,
  0x07, 0x81, 0xDC, 0x07, 0x83, 0xB8, 0x07, 0x8E, 0x70, 0x0F, 0xFC, 0xE0,
  0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 10, 36, 29, 10, -36 },
  { 46, 15, 15, 29, 10, -36 },
  { 75, 29, 36, 29, 1, -36 },
  { 206, 25, 50, 29, 3, -43 },
  { 363, 33, 36, 29, -1, -36 },
  { 512, 27, 36, 29, 1, -36 },
  { 634, 6, 15, 29, 14, -36 },
  { 646, 20, 47, 29, 8, -41 },
  { 764, 20, 47, 29, 2, -41 },
  { 882, 25, 25, 29, 3, -30 },
  { 961, 23, 23, 29, 4, -28 },
  { 1028, 12, 15, 29, 5, -7 },
  { 1051, 16, 3, 29, 7, -18 },
  { 1057, 8, 7, 29, 9, -7 },
  { 1064, 28, 46, 29, 1, -41 },
  { 1225, 25, 36, 29, 3, -36 },
  { 1338, 21, 36, 29, 3, -36 },
  { 1433, 26, 36, 29, 2, -36 },
  { 1550, 24, 36, 29, 3, -36 },
  { 1658, 22, 36, 29, 4, -36 },
  { 1757, 24, 36, 29, 3, -36 },
  { 1865, 23, 36, 29, 3, -36 },
  { 1969, 23, 36, 29, 6, -36 },
  { 2073, 24, 36, 29, 3, -36 },
  { 2181, 23, 36, 29, 5, -36 },
  { 2285, 11, 27, 29, 9, -27 },
  { 2323, 14, 35, 29, 6, -27 },
  { 2385, 23, 25, 29, 4, -29 },
  { 2457, 23, 14, 29, 4, -23 },
  { 2498, 23, 25, 29, 3, -29 },
  { 2570, 19, 36, 29, 8, -36 },
  { 2656, 28, 45, 29, 1, -36 },
  { 2814, 23, 36, 29, 1, -36 },
  { 2918, 24, 36, 29, 3, -36 },
  { 3026, 24, 36, 29, 4, -36 },
  { 3134, 24, 36, 29, 3, -36 },
  { 3242, 26, 36, 29, 3, -36 },
  { 3359, 26, 36, 29, 3, -36 },
  { 3476, 24, 36, 29, 4, -36 },
  { 3584, 25, 36, 29, 3, -36 },
  { 3697, 24, 36, 29, 3, -36 },
  { 3805, 25, 36, 29, 2, -36 },
  { 3918, 27, 36, 29, 3, -36 },
  { 4040, 20, 36, 29, 4, -36 },
  { 4130, 27, 36, 29, 2, -36 },
  { 4252, 25, 36, 29, 3, -36 },
  { 4365, 23, 36, 29, 4, -36 },
  { 4469, 26, 36, 29, 3, -36 },
  { 4586, 23, 45, 29, 4, -36 },
  { 4716, 25, 36, 29, 3, -36 },
  { 4829, 25, 36, 29, 3, -36 },
  { 4942, 24, 36, 29, 6, -36 },
  { 5050, 24, 36, 29, 4, -36 },
  { 5158, 23, 36, 29, 7, -36 },
  { 5262, 27, 36, 29, 4, -36 },
  { 5384, 30, 36, 29, 0, -36 },
  { 5519, 25, 36, 29, 6, -36 },
  { 5632, 26, 36, 29, 2, -36 },
  { 5749, 19, 46, 29, 7, -41 },
  { 5859, 13, 46, 29, 9, -41 },
  { 5934, 18, 46, 29, 5, -41 },
  { 6038, 20, 19, 29, 5, -36 },
  { 6086, 24, 3, 29, 0, 1 },
  { 6095, 7, 6, 29, 14, -38 },
  { 6101, 24, 27, 29, 3, -27 },
  { 6182, 23, 36, 29, 3, -36 },
  { 6286, 22, 27, 29, 4, -27 },
  { 6361, 25, 36, 29, 3, -36 },
  { 6474, 22, 27, 29, 4, -27 },
  { 6549, 32, 45, 29, -2, -36 },
  { 6729, 23, 36, 29, 4, -27 },
  { 6833, 23, 36, 29, 3, -36 },
  { 6937, 23, 38, 29, 2, -38 },
  { 7047, 25, 47, 29, 1, -38 },
  { 7194, 25, 36, 29, 3, -36 },
  { 7307, 20, 36, 29, 5, -36 },
  { 7397, 26, 27, 29, 1, -27 },
  { 7485, 23, 27, 29, 3, -27 },
  { 7563, 22, 27, 29, 4, -27 },
  { 7638, 25, 36, 29, 1, -27 },
  { 7751, 23, 36, 29, 3, -27 },
  { 7855, 23, 27, 29, 4, -27 },
  { 7933, 23, 27, 29, 3, -27 },
  { 8011, 22, 34, 29, 5, -34 },
  { 8105, 23, 27, 29, 4, -27 },
  { 8183, 22, 27, 29, 6, -27 },
  { 8258, 25, 27, 29, 4, -27 },
  { 8343, 27, 27, 29, 1, -27 },
  { 8435, 22, 36, 29, 4, -27 },
  { 8534, 23, 27, 29, 3, -27 },
  { 8612, 24, 46, 29, 5, -41 },
  { 8750, 11, 46, 29, 10, -41 },
  { 8814, 24, 46, 29, 2, -41 },
  { 8952, 23, 9, 29, 4, -22 },
};

const GFXfont JetBrainsMono_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC49PT7B_H_
