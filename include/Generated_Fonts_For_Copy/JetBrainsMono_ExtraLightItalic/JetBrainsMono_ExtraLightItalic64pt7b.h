#ifndef _JETBRAINSMONO_EXTRALIGHTITALIC64PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0xE3, 0xF0, 0x01, 0xF0, 0x70, 0x7C,
  0x01, 0xF0, 0x38, 0x3E, 0x01, 0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0x1C, 0x07,
  0xC0, 0x78, 0x0E, 0x03, 0xE0, 0x7C, 0x07, 0x01, 0xF0, 0x3C, 0x03, 0x80,
  0xF0, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x03, 0xE0, 0x70, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00, 0x7C, 0x1C,
  0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x38, 0xFE, 0x00, 0x00, 0x1C, 0x3F, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x70, 0x0F, 0x07,
  0x80, 0x38, 0x07, 0x83, 0xC0, 0x1C, 0x03, 0xC1, 0xE0, 0x0E, 0x01, 0xE0,
  0xF0, 0x07, 0x01, 0xF0, 0x7C, 0x07, 0x00, 0xF0, 0x3E, 0x03, 0x80, 0xF0,
  0x0F, 0x81, 0xC0, 0xF8, 0x07, 0xE0, 0xE1, 0xF8, 0x01, 0xFE, 0x77, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0xE3, 0xE0, 0x00,
  0x78, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x0E,
  0x03, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x87, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x70, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x87, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x03, 0xC0, 0x00,
  0x07, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x00, 0x78, 0x07,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0xF8, 0x01,
  0xE1, 0xE0, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC0, 0x7C, 0x3C, 0x00, 0xF8,
  0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x03, 0xC0, 0x07, 0xC7, 0xC0, 0xF0, 0x01,
  0xF1, 0xE0, 0x7C, 0x00, 0x3E, 0xF0, 0x1E, 0x00, 0x07, 0xF8, 0x07, 0x80,
  0x01, 0xFE, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x80,
  0x78, 0x00, 0x3D, 0xE0, 0x1F, 0x00, 0x1F, 0x7C, 0x07, 0xC0, 0x1F, 0x8F,
  0x81, 0xFC, 0x1F, 0xC1, 0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x07, 0xFF, 0xE0,
  0x0F, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0x40, 0x00, 0x00, 0x3E, 0x7C,
  0xF9, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x78,
  0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x20, 0x00, 0xF0, 0x00, 0x5E, 0x00, 0x78, 0x01, 0xCF, 0xC0, 0x3C, 0x07,
  0xFF, 0xFC, 0x1C, 0x1F, 0xFF, 0xFF, 0x8E, 0x3F, 0xFC, 0xFF, 0xE6, 0x7F,
  0xF0, 0x0F, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x8F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x3C, 0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x07, 0xE0, 0x3C, 0x1E, 0x07, 0xF0,
  0x7C, 0x1E, 0x07, 0xF0, 0x7C, 0x3E, 0x07, 0xF0, 0x7C, 0x3E, 0x07, 0xE0,
  0x78, 0x3C, 0x03, 0xC0, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0xF0, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0xFC, 0x3C, 0x00, 0x1F, 0xC1, 0xE0, 0x01, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0x20, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x03, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x3C, 0xFF, 0xFE, 0x00, 0x7B, 0xFF, 0xFE,
  0x01, 0xFF, 0x81, 0xFC, 0x03, 0xDC, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0xFF, 0xC0, 0x03, 0xCF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x00, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0xFF,
  0x80, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0x78, 0x03, 0xFF, 0xF7, 0x80,
  0x0F, 0xFE, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xF8, 0xF0, 0x78, 0x00, 0x7F, 0xE7,
  0x83, 0xC0, 0x0F, 0xFF, 0xBC, 0x1E, 0x00, 0xFE, 0x3D, 0xE0, 0xF0, 0x07,
  0xC0, 0x3F, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x07, 0x83,
  0xE0, 0x1E, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x78, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x03, 0xC1, 0xE0,
  0x1E, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x78, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x07, 0xC1, 0xE0, 0x0F, 0x80,
  0x7E, 0x0F, 0x00, 0x7E, 0x06, 0xF0, 0x78, 0x01, 0xFF, 0xF7, 0x03, 0xC0,
  0x0F, 0xFF, 0x38, 0x1E, 0x00, 0x1F, 0xE1, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xC0, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xF0,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xFF, 0xF8, 0x78, 0x07, 0xFF, 0xE0, 0xF0,
  0x0F, 0xFF, 0xC1, 0xE0, 0x3F, 0xFF, 0x87, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x0E, 0xE0, 0x3F, 0xC0, 0x03, 0xDC, 0x07, 0xF8, 0x00, 0x77, 0x80,
  0xF7, 0x00, 0x1E, 0xF0, 0x1C, 0xE0, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0xF3,
  0x80, 0x73, 0xC0, 0x1C, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xC7, 0x00,
  0xE3, 0xC0, 0x78, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x07, 0x1E, 0x01, 0xE3,
  0xC1, 0xE3, 0xC0, 0x3C, 0x78, 0x38, 0x78, 0x07, 0x07, 0x0F, 0x0F, 0x01,
  0xE0, 0xE1, 0xC1, 0xE0, 0x3C, 0x1C, 0x78, 0x3C, 0x07, 0x83, 0x8E, 0x0F,
  0x00, 0xF0, 0x7B, 0xC1, 0xE0, 0x1E, 0x07, 0x70, 0x3C, 0x03, 0xC0, 0xEE,
  0x07, 0x80, 0xF8, 0x1F, 0x80, 0xF0, 0x1E, 0x03, 0xF0, 0x1E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x0F, 0x01,
  0xF8, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x0F, 0x03,
  0xFC, 0x00, 0x1F, 0x03, 0xDC, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x1E, 0x03,
  0xDE, 0x00, 0x1E, 0x03, 0x9E, 0x00, 0x1E, 0x07, 0x8E, 0x00, 0x1E, 0x07,
  0x8F, 0x00, 0x3E, 0x07, 0x8F, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x3C, 0x07,
  0x8F, 0x00, 0x3C, 0x07, 0x87, 0x00, 0x3C, 0x0F, 0x07, 0x80, 0x3C, 0x0F,
  0x07, 0x80, 0x7C, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x03, 0x80, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x1E,
  0x01, 0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x3E, 0x00, 0xE0, 0xF0, 0x3C,
  0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF1, 0xF0, 0x3C, 0x00, 0xF1, 0xE0, 0x3C,
  0x00, 0xF1, 0xE0, 0x3C, 0x00, 0x71, 0xE0, 0x3C, 0x00, 0x79, 0xE0, 0x78,
  0x00, 0x79, 0xE0, 0x78, 0x00, 0x79, 0xE0, 0x78, 0x00, 0x39, 0xC0, 0x78,
  0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3F, 0xC0, 0xF8,
  0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x1F, 0x80, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x01,
  0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x1F,
  0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0xC0, 0x3C,
  0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F,
  0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0x80, 0x0F, 0x3C, 0x00, 0xF8,
  0x01, 0xE3, 0x80, 0x1F, 0x80, 0x1E, 0x38, 0x01, 0xF8, 0x01, 0xE3, 0x80,
  0x1F, 0x80, 0x3C, 0x38, 0x01, 0xF8, 0x03, 0xC7, 0x80, 0x3B, 0x80, 0x3C,
  0x78, 0x03, 0xB8, 0x03, 0xC7, 0x80, 0x3B, 0x80, 0x78, 0x78, 0x07, 0x38,
  0x07, 0x87, 0x80, 0x73, 0x80, 0x78, 0x78, 0x07, 0x38, 0x07, 0x07, 0x80,
  0x73, 0x80, 0xF0, 0x78, 0x0E, 0x38, 0x0F, 0x07, 0x80, 0xE3, 0x80, 0xF0,
  0x78, 0x0E, 0x38, 0x1E, 0x07, 0x81, 0xC3, 0x81, 0xE0, 0x78, 0x1C, 0x38,
  0x1E, 0x07, 0x81, 0xC3, 0x81, 0xC0, 0x78, 0x38, 0x38, 0x3C, 0x07, 0x83,
  0x83, 0x83, 0xC0, 0x78, 0x38, 0x38, 0x3C, 0x07, 0x83, 0x83, 0x83, 0x80,
  0x78, 0x70, 0x38, 0x78, 0x07, 0x87, 0x03, 0x87, 0x80, 0x78, 0x70, 0x38,
  0x70, 0x07, 0x0E, 0x03, 0x8F, 0x00, 0x70, 0xE0, 0x30, 0xF0, 0x07, 0x0E,
  0x03, 0x0F, 0x00, 0x70, 0xC0, 0x30, 0xE0, 0x07, 0x1C, 0x03, 0x1E, 0x00,
  0x71, 0xC0, 0x71, 0xE0, 0x0F, 0x1C, 0x07, 0x1E, 0x00, 0xF3, 0x80, 0x71,
  0xC0, 0x0F, 0x38, 0x07, 0x3C, 0x00, 0xF3, 0x80, 0x73, 0xC0, 0x0F, 0x70,
  0x07, 0x38, 0x00, 0xF7, 0x00, 0x77, 0x80, 0x0F, 0x70, 0x07, 0x78, 0x00,
  0xF7, 0x00, 0x77, 0x80, 0x0F, 0xE0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x1E, 0x07,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xC7, 0x80, 0x7F, 0xFF, 0x9E,
  0x03, 0xF0, 0x0F, 0x78, 0x1F, 0x80, 0x0D, 0xE0, 0xF8, 0x00, 0x3F, 0x83,
  0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x1D, 0xE0, 0x3F, 0x81, 0xEF,
  0x80, 0xFF, 0xFF, 0x3C, 0x01, 0xFF, 0xF8, 0xF0, 0x01, 0xFF, 0x83, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0x83, 0xFF, 0x80, 0x1E, 0x3F, 0xFF, 0x00, 0x79, 0xFF, 0xFE,
  0x01, 0xEF, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x07, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xF0, 0x03, 0xF0, 0x3E, 0xF0, 0x3F,
  0x80, 0xF3, 0xFF, 0xFC, 0x03, 0xC7, 0xFF, 0xE0, 0x0F, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0,
  0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xFF, 0x87, 0xC0, 0x1F, 0xFF,
  0x8F, 0x00, 0x7F, 0xFF, 0x9E, 0x01, 0xF8, 0x07, 0xBC, 0x07, 0xE0, 0x03,
  0x78, 0x1F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x01, 0xDE, 0x01, 0xFC, 0x0F, 0x7C, 0x03, 0xFF, 0xFC,
  0xF0, 0x03, 0xFF, 0xF1, 0xE0, 0x01, 0xFF, 0x83, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF0, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x81, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0xE7, 0x80, 0x7F, 0xFF, 0x9E, 0x03, 0xF8,
  0x0F, 0x78, 0x1F, 0x80, 0x0D, 0xE0, 0x78, 0x00, 0x3F, 0x83, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00,
  0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x37, 0x80, 0xFE, 0x07, 0xDE, 0x01,
  0xFF, 0xFE, 0x78, 0x03, 0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0x0F, 0x80, 0x00,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0x87, 0xFF, 0x80, 0x1E, 0x3F, 0xFF, 0x00,
  0x79, 0xFF, 0xFE, 0x01, 0xEF, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x3F,
  0x80, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C,
  0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0x7C, 0x01, 0xE7, 0xF8, 0x3F, 0xC0, 0x7B, 0xFF,
  0x3F, 0xF0, 0x1E, 0xFF, 0xCF, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0x81, 0xF0,
  0x1F, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0x1E, 0x0F,
  0x00, 0x78, 0x07, 0x83, 0xC0, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x00, 0x78,
  0x3C, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x03,
  0xC1, 0xE0, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xE0,
  0x0F, 0x07, 0x80, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0x78, 0x07,
  0x80, 0x78, 0x3C, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x07, 0x83, 0xC0,
  0x1C, 0x01, 0xE0, 0xF0, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x1E, 0x0F,
  0x00, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0xF0,
  0x78, 0x03, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x03,
  0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0,
  0x1E, 0x0F, 0x00, 0x70, 0x07, 0x83, 0xC0, 0x1C, 0x01, 0xE0, 0x00, 0x40,
  0xFC, 0x00, 0x1E, 0x1F, 0xFE, 0x00, 0x78, 0xFF, 0xFC, 0x01, 0xE7, 0xFF,
  0xF8, 0x07, 0xBC, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0xFE, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x7C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0x3C,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x81, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x10, 0x3F, 0x80, 0x01, 0xE1, 0xFF, 0xE0,
  0x01, 0xE3, 0xFF, 0xF0, 0x01, 0xE7, 0xFF, 0xF8, 0x01, 0xEF, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x01, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x3E, 0xF0, 0x3F, 0x80, 0x3C, 0xFF, 0xFF, 0x00, 0x3C, 0x7F, 0xFE, 0x00,
  0x3C, 0x3F, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x02, 0x00, 0x3F, 0xF8, 0x78,
  0x01, 0xFF, 0xFC, 0xF0, 0x07, 0xFF, 0xF9, 0xE0, 0x1F, 0x80, 0x7B, 0xC0,
  0x7E, 0x00, 0x77, 0x81, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00,
  0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x1D, 0xE0, 0x1F, 0xC0, 0xF7, 0xC0,
  0x3F, 0xFF, 0xCF, 0x00, 0x3F, 0xFF, 0x1E, 0x00, 0x1F, 0xF8, 0x3C, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0x1F, 0xFE, 0x00, 0x78, 0xFF, 0xFE, 0x01, 0xE7, 0xFF,
  0xF8, 0x07, 0xBC, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xF0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x78, 0x7C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xE0,
  0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x07, 0xC0, 0x1E, 0xE0,
  0x0F, 0xC0, 0x1E, 0xE0, 0x0F, 0xC0, 0x1C, 0xE0, 0x0D, 0xC0, 0x3C, 0xE0,
  0x1D, 0xC0, 0x3C, 0xE0, 0x1D, 0xC0, 0x38, 0xE0, 0x39, 0xC0, 0x78, 0xE0,
  0x38, 0xC0, 0x78, 0xE0, 0x38, 0xC0, 0x78, 0xE0, 0x70, 0xC0, 0xF0, 0xE0,
  0x70, 0xC0, 0xF0, 0xE0, 0x70, 0xC0, 0xF0, 0xE0, 0xE0, 0xC0, 0xE0, 0xE0,
  0xE0, 0xC1, 0xE0, 0xE0, 0xE0, 0xC1, 0xE0, 0xE1, 0xC0, 0xC1, 0xC0, 0xE1,
  0xC0, 0xC3, 0xC0, 0xE1, 0xC0, 0xC3, 0xC0, 0xE3, 0x80, 0xC3, 0x80, 0xE3,
  0x80, 0xE7, 0x80, 0xE3, 0x80, 0xE7, 0x80, 0xE7, 0x00, 0xE7, 0x00, 0xE7,
  0x00, 0xEF, 0x00, 0xE7, 0x00, 0xEF, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xEE,
  0x00, 0xFE, 0x00, 0xEE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3C, 0x7C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0xEF, 0x03, 0xF8, 0x1E, 0x78, 0x0F, 0xFF,
  0xE7, 0xC0, 0x3F, 0xFE, 0x3E, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x3F, 0xE0, 0x00, 0xF1, 0xFF, 0xC0, 0x03, 0xCF, 0xFF, 0x80,
  0x0F, 0x3C, 0x1F, 0x00, 0x3D, 0xE0, 0x3E, 0x01, 0xE7, 0x80, 0x78, 0x07,
  0x9C, 0x01, 0xF0, 0x1E, 0xF0, 0x03, 0xE0, 0xF3, 0xC0, 0x07, 0xFF, 0xCF,
  0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 13, 47, 38, 13, -47 },
  { 78, 21, 19, 38, 12, -47 },
  { 128, 37, 47, 38, 2, -47 },
  { 346, 33, 65, 38, 3, -56 },
  { 615, 44, 47, 38, -2, -47 },
  { 874, 34, 48, 38, 2, -47 },
  { 1078, 7, 19, 38, 19, -47 },
  { 1095, 26, 62, 38, 11, -54 },
  { 1297, 26, 62, 38, 3, -54 },
  { 1499, 33, 33, 38, 4, -39 },
  { 1636, 30, 30, 38, 5, -36 },
  { 1749, 15, 20, 38, 7, -10 },
  { 1787, 21, 4, 38, 9, -23 },
  { 1798, 10, 10, 38, 12, -9 },
  { 1811, 36, 60, 38, 2, -53 },
  { 2081, 32, 48, 38, 4, -47 },
  { 2273, 29, 47, 38, 3, -47 },
  { 2444, 33, 47, 38, 3, -47 },
  { 2638, 31, 48, 38, 4, -47 },
  { 2824, 29, 47, 38, 5, -47 },
  { 2995, 31, 48, 38, 5, -47 },
  { 3181, 30, 48, 38, 4, -47 },
  { 3361, 30, 47, 38, 8, -47 },
  { 3538, 32, 48, 38, 4, -47 },
  { 3730, 29, 47, 38, 7, -47 },
  { 3901, 15, 37, 38, 12, -36 },
  { 3971, 20, 46, 38, 7, -36 },
  { 4086, 30, 33, 38, 6, -38 },
  { 4210, 30, 18, 38, 5, -30 },
  { 4278, 30, 33, 38, 4, -38 },
  { 4402, 25, 47, 38, 10, -47 },
  { 4549, 37, 58, 38, 1, -47 },
  { 4818, 31, 47, 38, 1, -47 },
  { 5001, 32, 47, 38, 4, -47 },
  { 5189, 31, 48, 38, 5, -47 },
  { 5375, 31, 47, 38, 4, -47 },
  { 5558, 34, 47, 38, 4, -47 },
  { 5758, 34, 47, 38, 4, -47 },
  { 5958, 31, 48, 38, 5, -47 },
  { 6144, 32, 47, 38, 4, -47 },
  { 6332, 32, 47, 38, 4, -47 },
  { 6520, 34, 48, 38, 2, -47 },
  { 6724, 35, 47, 38, 4, -47 },
  { 6930, 27, 47, 38, 5, -47 },
  { 7089, 35, 47, 38, 3, -47 },
  { 7295, 32, 47, 38, 4, -47 },
  { 7483, 30, 48, 38, 5, -47 },
  { 7663, 34, 47, 38, 4, -47 },
  { 7863, 31, 59, 38, 5, -47 },
  { 8092, 33, 47, 38, 4, -47 },
  { 8286, 33, 48, 38, 3, -47 },
  { 8484, 31, 47, 38, 8, -47 },
  { 8667, 32, 48, 38, 5, -47 },
  { 8859, 30, 47, 38, 9, -47 },
  { 9036, 36, 47, 38, 5, -47 },
  { 9248, 39, 47, 38, 0, -47 },
  { 9478, 33, 47, 38, 7, -47 },
  { 9672, 34, 47, 38, 3, -47 },
  { 9872, 24, 60, 38, 10, -53 },
  { 10052, 18, 60, 38, 11, -53 },
  { 10187, 24, 60, 38, 6, -53 },
  { 10367, 26, 25, 38, 7, -47 },
  { 10449, 31, 3, 38, 0, 2 },
  { 10461, 10, 9, 38, 18, -50 },
  { 10473, 30, 37, 38, 5, -36 },
  { 10612, 30, 48, 38, 4, -47 },
  { 10792, 29, 37, 38, 5, -36 },
  { 10927, 31, 48, 38, 5, -47 },
  { 11113, 29, 37, 38, 5, -36 },
  { 11248, 41, 59, 38, -2, -47 },
  { 11551, 30, 48, 38, 5, -36 },
  { 11731, 30, 47, 38, 4, -47 },
  { 11908, 29, 49, 38, 3, -49 },
  { 12086, 33, 61, 38, 1, -49 },
  { 12338, 33, 47, 38, 4, -47 },
  { 12532, 26, 47, 38, 7, -47 },
  { 12685, 34, 36, 38, 2, -36 },
  { 12838, 30, 36, 38, 4, -36 },
  { 12973, 29, 37, 38, 5, -36 },
  { 13108, 32, 48, 38, 2, -36 },
  { 13300, 31, 48, 38, 4, -36 },
  { 13486, 30, 36, 38, 5, -36 },
  { 13621, 30, 37, 38, 4, -36 },
  { 13760, 29, 45, 38, 6, -45 },
  { 13924, 30, 36, 38, 5, -35 },
  { 14059, 30, 35, 38, 7, -35 },
  { 14191, 32, 35, 38, 6, -35 },
  { 14331, 35, 35, 38, 1, -35 },
  { 14485, 29, 47, 38, 5, -35 },
  { 14656, 31, 35, 38, 3, -35 },
  { 14792, 31, 60, 38, 7, -53 },
  { 15025, 14, 60, 38, 13, -53 },
  { 15130, 32, 60, 38, 2, -53 },
  { 15370, 30, 13, 38, 5, -29 },
};

const GFXfont JetBrainsMono_ExtraLightItalic64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLightItalic64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLightItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_EXTRALIGHTITALIC64PT7B_H_
