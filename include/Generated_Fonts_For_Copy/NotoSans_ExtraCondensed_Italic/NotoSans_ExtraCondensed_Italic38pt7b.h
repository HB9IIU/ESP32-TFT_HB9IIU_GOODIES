#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x07, 0x00, 0x79,
  0xDC, 0x77, 0x1D, 0xCE, 0x63, 0xB8, 0xEE, 0x3B, 0x8C, 0xC3, 0x31, 0xC0,
  0x00, 0xE3, 0x80, 0x61, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x38, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xC6, 0x00,
  0xC3, 0x00, 0x63, 0x80, 0x71, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC7,
  0x00, 0xE3, 0x00, 0x61, 0x80, 0x31, 0xC0, 0x38, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x0E, 0x66,
  0x0C, 0x40, 0x1C, 0x40, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0x80, 0x0E, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0x70, 0x03, 0x78,
  0x03, 0x38, 0x03, 0x38, 0x02, 0x38, 0x02, 0x30, 0x86, 0x70, 0xF7, 0xE0,
  0xFF, 0xC0, 0x7F, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xF0, 0x1C, 0x1F, 0x81, 0x83, 0x98, 0x38, 0x31, 0x83,
  0x07, 0x18, 0x70, 0x61, 0x86, 0x06, 0x18, 0xE0, 0xE3, 0x8C, 0x0E, 0x39,
  0xC0, 0xC3, 0x18, 0x0C, 0x33, 0x88, 0xC7, 0x33, 0xEC, 0x66, 0x7F, 0xCE,
  0x66, 0x7F, 0xCC, 0xE7, 0x79, 0xCC, 0x72, 0x19, 0xC7, 0x03, 0x9C, 0x70,
  0x31, 0x86, 0x07, 0x18, 0x60, 0x61, 0x86, 0x0E, 0x38, 0xE0, 0xC3, 0x8C,
  0x1C, 0x39, 0xC1, 0x81, 0x98, 0x38, 0x1F, 0x87, 0x01, 0xF0, 0x00, 0x20,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0x9C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x06, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0xC7, 0x39, 0xCE, 0x71, 0xCE, 0x71, 0xCE,
  0xE0, 0xFC, 0xE0, 0xFC, 0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0xF0, 0xE0, 0xF8,
  0xF3, 0xF8, 0x7F, 0xB8, 0x3E, 0x3C, 0x7B, 0x9C, 0xE7, 0x33, 0x9C, 0xC6,
  0x00, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xC0, 0x18, 0x63, 0x0F, 0x67, 0xFF, 0xC7, 0xF8, 0xF0,
  0x3F, 0x0E, 0x63, 0x8E, 0x11, 0xC0, 0x10, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x30, 0xE0, 0xFF, 0xFF, 0xFF,
  0x77, 0xF7, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x40, 0x07, 0xC0, 0x7F, 0x81, 0xCE, 0x0E, 0x1C,
  0x38, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x0E,
  0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07,
  0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE3, 0xC3, 0xDE,
  0x07, 0xF0, 0x1F, 0x80, 0x03, 0x83, 0xC3, 0xE3, 0xF7, 0xB7, 0xBB, 0x9C,
  0x8E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x00,
  0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x9F, 0x02, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x20, 0x01, 0xFC, 0x07,
  0xFE, 0x07, 0x8F, 0x02, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x80, 0xF0, 0xE3, 0xE0, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x6E, 0x00, 0x6E, 0x00, 0xCC, 0x01, 0xDC, 0x01, 0x9C, 0x03,
  0x1C, 0x07, 0x1C, 0x06, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xFF, 0x03, 0xFF, 0x02, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x40, 0xF0, 0xE3, 0xC1, 0xFF, 0x03, 0xFC, 0x00,
  0x00, 0x18, 0x01, 0xFC, 0x07, 0xF0, 0x1E, 0x10, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x9F, 0x07, 0x7F,
  0x0F, 0xFE, 0x1E, 0x1C, 0x38, 0x3C, 0xF0, 0x39, 0xC0, 0xF3, 0x81, 0xE7,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xE0, 0xE7,
  0x81, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x07, 0xF8,
  0x1F, 0xF0, 0x38, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x1C, 0x38, 0x38, 0x70, 0x7B, 0xC0, 0x7F, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0x70, 0x3C, 0xF0, 0xF0, 0xE1, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xE3, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0x00, 0x40, 0x03, 0xF0, 0x1F, 0xF0, 0x39, 0xE0, 0xE1, 0xC3, 0xC1,
  0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3,
  0x81, 0xC7, 0x07, 0x8F, 0x1F, 0x0F, 0xFE, 0x1F, 0xD8, 0x1E, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC1,
  0x0F, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x04, 0x0E, 0x0F, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xF0, 0xF0, 0xE0, 0x00, 0x80, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x00,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x01, 0x01,
  0xFC, 0x3F, 0xE1, 0x8E, 0x20, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x70, 0x38,
  0x07, 0x00, 0xE0, 0x70, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x83,
  0xC3, 0x18, 0x7F, 0x19, 0xC7, 0x38, 0xCC, 0x31, 0x86, 0xE3, 0x0C, 0x76,
  0x18, 0xE3, 0x31, 0xC7, 0x19, 0x8C, 0x30, 0xDC, 0x61, 0x86, 0xE3, 0x1C,
  0x66, 0x38, 0xE3, 0x31, 0xC6, 0x39, 0x8E, 0x71, 0x8C, 0x3E, 0xD8, 0x61,
  0xE7, 0xC3, 0x06, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x20, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B,
  0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0,
  0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0F, 0xFE, 0x3F, 0xFC, 0x70, 0x38, 0xE0,
  0x73, 0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xC0, 0x1F,
  0x80, 0x38, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0xE0, 0x70,
  0x78, 0x38, 0x3C, 0x38, 0x1E, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x87,
  0x87, 0x83, 0x8F, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x70, 0xF0, 0x78, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x81,
  0xE1, 0xC0, 0xE0, 0xE0, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xC2, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x7E, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x38, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x38,
  0xE0, 0x3C, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03,
  0x87, 0x03, 0xC7, 0x01, 0xC3, 0x81, 0xE1, 0xC1, 0xE0, 0xE1, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0x81, 0xF1, 0xE0, 0x78, 0x08, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x0F, 0xC3, 0x81, 0xF8, 0x70, 0x47, 0x1E, 0x01,
  0xE3, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x1C, 0x07,
  0x83, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0xC7, 0x80, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x78, 0x0E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0x01,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x1C, 0x03, 0x83, 0x80, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x2F, 0x80, 0x7E, 0x01, 0xF8,
  0x00, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x07, 0x0E,
  0x01, 0xC7, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0xBC, 0x01,
  0xEE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xF7,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xF0,
  0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x78, 0x38, 0x1E, 0x0E,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03,
  0xF0, 0x7C, 0x01, 0xF0, 0x36, 0x01, 0xF8, 0x3B, 0x00, 0xFC, 0x1D, 0x80,
  0xEE, 0x0E, 0xC0, 0x77, 0x07, 0x60, 0x37, 0x07, 0x30, 0x3B, 0x83, 0x98,
  0x19, 0xC1, 0xCC, 0x1C, 0xE0, 0xE6, 0x0E, 0x70, 0x73, 0x8E, 0x70, 0x71,
  0xC7, 0x38, 0x38, 0xE7, 0x1C, 0x1C, 0x73, 0x8E, 0x0E, 0x3B, 0x8E, 0x06,
  0x1D, 0xC7, 0x07, 0x0E, 0xC3, 0x83, 0x87, 0xE1, 0xC1, 0xC3, 0xE0, 0xE0,
  0xE1, 0xF0, 0xE0, 0x60, 0xF8, 0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x7C, 0x07, 0x07, 0xC0, 0x70, 0x7C, 0x07, 0x07,
  0xC0, 0xE0, 0x6C, 0x0E, 0x0E, 0xC0, 0xE0, 0xEE, 0x0E, 0x0E, 0xE0, 0xE0,
  0xEE, 0x1C, 0x1C, 0xE1, 0xC1, 0xC6, 0x1C, 0x1C, 0x61, 0xC1, 0xC7, 0x18,
  0x1C, 0x73, 0x83, 0x87, 0x38, 0x38, 0x73, 0x83, 0x83, 0x38, 0x38, 0x37,
  0x03, 0x83, 0xF0, 0x70, 0x3F, 0x07, 0x03, 0xF0, 0x70, 0x3F, 0x07, 0x01,
  0xE0, 0x60, 0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x00, 0x00, 0x10, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0x79, 0xE0, 0x70, 0x78, 0x70, 0x1C, 0x78, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x77, 0x80,
  0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xBC,
  0x03, 0xDE, 0x01, 0xCE, 0x00, 0xE7, 0x80, 0xE3, 0xC0, 0x70, 0xE0, 0x70,
  0x70, 0x78, 0x3E, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E,
  0x07, 0x0E, 0x07, 0x0E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1C,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x79, 0xE0,
  0x70, 0x78, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xE0,
  0x0E, 0x70, 0x07, 0x78, 0x03, 0xBC, 0x03, 0xDE, 0x01, 0xCE, 0x00, 0xE7,
  0x80, 0xF3, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x78, 0x3E, 0xF8, 0x0F, 0xF8,
  0x03, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0x0F,
  0x07, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0F,
  0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xF0, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0x00, 0x10,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFD, 0xE0, 0x70, 0x10, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x80, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x38, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x1C,
  0x1C, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E,
  0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0xC1, 0xC0,
  0x79, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x77, 0x00, 0xEE, 0x03, 0xDC, 0x07, 0x38, 0x1E, 0x70, 0x38, 0xE0, 0x71,
  0xC1, 0xC3, 0x83, 0x87, 0x0F, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71,
  0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x1C,
  0x07, 0xF0, 0x0E, 0x03, 0xB8, 0x0F, 0x01, 0xDC, 0x07, 0x81, 0xCE, 0x07,
  0xC0, 0xE7, 0x03, 0xE0, 0xF3, 0x81, 0xF0, 0x71, 0xC1, 0xF8, 0x38, 0xE0,
  0xDC, 0x38, 0x70, 0xEE, 0x1C, 0x38, 0x77, 0x0E, 0x1C, 0x33, 0x8E, 0x0E,
  0x39, 0xC7, 0x07, 0x18, 0xC7, 0x03, 0x9C, 0x63, 0x81, 0xCE, 0x31, 0xC0,
  0xE6, 0x19, 0xC0, 0x77, 0x0C, 0xE0, 0x3B, 0x86, 0xE0, 0x1D, 0x83, 0x70,
  0x0F, 0xC1, 0xB8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03,
  0x81, 0xE0, 0x70, 0x38, 0x0F, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x01, 0xE7,
  0x00, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x3F, 0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x70,
  0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x70, 0x1D,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0xE3, 0x8E, 0x38, 0xE1, 0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x0E,
  0x38, 0xE3, 0x8E, 0x38, 0x61, 0x87, 0x1C, 0x71, 0xC0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00,
  0x60, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3B, 0x00, 0x77, 0x01, 0xCE,
  0x03, 0x1C, 0x0E, 0x18, 0x38, 0x38, 0x70, 0x71, 0xC0, 0x63, 0x00, 0xFE,
  0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0xE7, 0x1C, 0xE3, 0x1C, 0x01, 0xC0, 0x0F,
  0xDC, 0x3F, 0xB8, 0xF1, 0xE1, 0xC3, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E,
  0x70, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x78, 0xE0, 0xF1, 0xC3, 0xC3, 0xCF, 0x83, 0xF7, 0x03, 0xCE,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x38, 0x1D, 0xF8, 0x3F, 0xF0, 0x78, 0xF1,
  0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x1C, 0xE0,
  0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x78,
  0xF0, 0xE3, 0xE3, 0xC7, 0x7F, 0x0E, 0xFC, 0x00, 0x01, 0xE0, 0x7F, 0x0F,
  0xF1, 0xE2, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF1,
  0x87, 0xF8, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x01, 0x8E, 0x03,
  0xF7, 0x03, 0xFB, 0x83, 0xC7, 0x81, 0xC3, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0xE0, 0x78, 0x70, 0x38, 0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03,
  0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0xF0, 0x3C,
  0xF8, 0x0F, 0xDC, 0x07, 0xCE, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFE, 0x3C,
  0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x0E, 0x70, 0xF3, 0xFF, 0x3F, 0xE1,
  0xFC, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x30, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFD, 0xC0,
  0xFE, 0xE0, 0xF1, 0xE0, 0x70, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x1E,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC1, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x3C, 0x0F, 0x3E, 0x03,
  0xFF, 0x01, 0xF3, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x20, 0x78, 0x1E, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x38, 0x1D, 0xF8, 0x3F, 0xF0, 0x78, 0xF1, 0xE1, 0xE3,
  0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x61, 0xC1,
  0xC3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1,
  0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x1C, 0x38, 0x70, 0x71, 0xC0, 0xC7, 0x83, 0x8E, 0x07, 0x38, 0x0E,
  0xE0, 0x1F, 0xC0, 0x77, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x70, 0xE0, 0xE1, 0xC1, 0x83, 0x87, 0x07, 0x0E,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x00, 0x00,
  0x30, 0x70, 0x3B, 0xF3, 0xF0, 0xDF, 0xDF, 0xC3, 0xC7, 0xC7, 0x1E, 0x1E,
  0x1C, 0x78, 0x78, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C,
  0xE0, 0x60, 0xE3, 0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0xE0,
  0xE0, 0xE7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x71, 0xC1, 0xC1,
  0xCE, 0x07, 0x06, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE0, 0x00, 0x70, 0x1D,
  0xF8, 0x37, 0xF0, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0x87, 0x07, 0x0E, 0x0E,
  0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x61, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x1C,
  0x0E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E,
  0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0x8E, 0x1C, 0x38, 0xE0, 0xE3,
  0x83, 0xDC, 0x0E, 0x70, 0x39, 0xC0, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x87, 0x8F, 0x3C, 0x1F, 0xE0,
  0x3F, 0x00, 0x00, 0x0C, 0x01, 0xDF, 0x80, 0xFF, 0xC0, 0x68, 0xF0, 0x78,
  0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3,
  0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x70, 0x3C, 0x38, 0x1C,
  0x1C, 0x1E, 0x0F, 0x0E, 0x07, 0x8F, 0x07, 0x7F, 0x03, 0x9F, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xDC, 0x3F, 0xB8,
  0xF1, 0xE1, 0xC3, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x1E, 0x70, 0x38, 0xE0,
  0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x78,
  0xE0, 0xF1, 0xC3, 0xC3, 0xCF, 0x83, 0xF7, 0x07, 0xCE, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x02, 0x30, 0xCF, 0x0D, 0xF0, 0xF9, 0x1F, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x7F, 0xC7, 0xFC, 0x38, 0x43, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC4, 0x1E, 0x31, 0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xC3, 0xFD, 0xFE, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x91,
  0xF8, 0x7C, 0x00, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81,
  0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC3,
  0x83, 0x86, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x70, 0xE1, 0xE1, 0xE7,
  0xC3, 0xFB, 0x83, 0xE6, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE,
  0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0xEE, 0x1F, 0x0E,
  0xE1, 0xF0, 0xEE, 0x3F, 0x1C, 0xE3, 0xF1, 0xCE, 0x37, 0x38, 0xE7, 0x73,
  0x8E, 0x67, 0x38, 0xEE, 0x77, 0x0E, 0xE7, 0x70, 0xEC, 0x76, 0x0F, 0xC7,
  0xE0, 0xF8, 0x6E, 0x0F, 0x86, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0x07, 0x07, 0x83, 0x87, 0x01, 0xC3, 0x80, 0x73,
  0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x38, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x00, 0x03,
  0x81, 0xE0, 0x70, 0x38, 0x06, 0x07, 0x00, 0xC1, 0xC0, 0x18, 0x38, 0x03,
  0x0E, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x06,
  0x70, 0x00, 0xCE, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0x00, 0xE0, 0x03, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1F, 0x00, 0x38, 0x0F, 0xC0, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x03, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x1C, 0x02, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xE8, 0x07, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 27, 9, 0, -27 },
  { 35, 10, 10, 13, 4, -27 },
  { 48, 17, 27, 16, 0, -27 },
  { 106, 16, 31, 15, 0, -29 },
  { 168, 20, 28, 23, 2, -28 },
  { 238, 16, 28, 16, 0, -28 },
  { 294, 5, 10, 7, 4, -27 },
  { 301, 11, 33, 10, 1, -27 },
  { 347, 12, 33, 10, -3, -27 },
  { 397, 11, 13, 14, 4, -29 },
  { 415, 14, 17, 16, 2, -22 },
  { 445, 7, 9, 8, -2, -4 },
  { 453, 8, 3, 10, 1, -12 },
  { 456, 4, 4, 8, 0, -4 },
  { 458, 18, 27, 13, -2, -27 },
  { 519, 14, 28, 15, 1, -28 },
  { 568, 9, 27, 15, 4, -27 },
  { 599, 16, 28, 15, -1, -28 },
  { 655, 16, 28, 15, -1, -28 },
  { 711, 16, 27, 15, -1, -27 },
  { 765, 15, 27, 15, 0, -27 },
  { 816, 15, 28, 15, 1, -28 },
  { 869, 15, 27, 15, 1, -27 },
  { 920, 15, 28, 15, 0, -28 },
  { 973, 15, 28, 15, 0, -28 },
  { 1026, 8, 21, 8, 0, -21 },
  { 1047, 10, 26, 8, -2, -21 },
  { 1080, 15, 17, 16, 1, -22 },
  { 1112, 14, 11, 16, 2, -19 },
  { 1132, 14, 17, 16, 2, -22 },
  { 1162, 12, 28, 11, 1, -28 },
  { 1204, 21, 30, 22, 1, -27 },
  { 1283, 15, 27, 15, -2, -27 },
  { 1334, 17, 27, 16, 0, -27 },
  { 1392, 16, 28, 15, 1, -28 },
  { 1448, 17, 27, 18, 0, -27 },
  { 1506, 16, 27, 14, 0, -27 },
  { 1560, 16, 27, 13, 0, -27 },
  { 1614, 19, 28, 19, 1, -28 },
  { 1681, 19, 27, 18, 0, -27 },
  { 1746, 15, 27, 10, -2, -27 },
  { 1797, 15, 34, 8, -6, -27 },
  { 1861, 18, 27, 15, 0, -27 },
  { 1922, 10, 27, 13, 0, -27 },
  { 1956, 25, 27, 25, 0, -27 },
  { 2041, 20, 27, 20, 0, -27 },
  { 2109, 17, 28, 19, 1, -28 },
  { 2169, 16, 27, 15, 0, -27 },
  { 2223, 17, 34, 19, 1, -28 },
  { 2296, 16, 27, 16, 0, -27 },
  { 2350, 17, 28, 14, -1, -28 },
  { 2410, 13, 27, 13, 3, -27 },
  { 2454, 18, 27, 18, 1, -27 },
  { 2515, 15, 27, 15, 3, -27 },
  { 2566, 25, 27, 25, 3, -27 },
  { 2651, 19, 27, 14, -2, -27 },
  { 2716, 14, 27, 14, 3, -27 },
  { 2764, 17, 27, 13, -2, -27 },
  { 2822, 14, 33, 11, -1, -27 },
  { 2880, 6, 27, 13, 4, -27 },
  { 2901, 15, 33, 11, -3, -27 },
  { 2963, 15, 14, 15, 0, -27 },
  { 2990, 12, 2, 12, -3, 3 },
  { 2993, 5, 6, 9, 6, -29 },
  { 2997, 15, 21, 16, 1, -21 },
  { 3037, 15, 29, 16, 0, -29 },
  { 3092, 12, 21, 12, 1, -21 },
  { 3124, 17, 29, 16, 1, -29 },
  { 3186, 13, 21, 15, 1, -21 },
  { 3221, 18, 38, 9, -5, -29 },
  { 3307, 17, 30, 16, -1, -21 },
  { 3371, 15, 29, 16, 0, -29 },
  { 3426, 9, 28, 7, 0, -28 },
  { 3458, 14, 37, 7, -5, -28 },
  { 3523, 15, 29, 14, 0, -29 },
  { 3578, 9, 29, 7, 0, -29 },
  { 3611, 22, 21, 23, 0, -21 },
  { 3669, 15, 21, 16, 0, -21 },
  { 3709, 14, 21, 15, 1, -21 },
  { 3746, 17, 30, 16, -2, -21 },
  { 3810, 15, 30, 16, 1, -21 },
  { 3867, 12, 21, 10, 0, -21 },
  { 3899, 13, 21, 12, 0, -21 },
  { 3934, 9, 25, 9, 1, -25 },
  { 3963, 15, 20, 16, 1, -20 },
  { 4001, 13, 20, 13, 2, -20 },
  { 4034, 20, 20, 21, 2, -20 },
  { 4084, 17, 20, 13, -2, -20 },
  { 4127, 19, 29, 13, -4, -20 },
  { 4196, 13, 20, 11, -1, -20 },
  { 4229, 14, 33, 12, 1, -27 },
  { 4287, 2, 38, 14, 6, -29 },
  { 4297, 13, 33, 12, -2, -27 },
  { 4351, 15, 5, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Italic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC38PT7B_H_
