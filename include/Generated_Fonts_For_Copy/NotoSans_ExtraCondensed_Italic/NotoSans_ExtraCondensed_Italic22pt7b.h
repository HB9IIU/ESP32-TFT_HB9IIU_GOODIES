#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x18, 0x01, 0x0E,
  0x30, 0x6D, 0xB4, 0xD2, 0xCB, 0x60, 0x04, 0xC1, 0x20, 0xC8, 0x26, 0x09,
  0x0F, 0xF5, 0x30, 0x48, 0x32, 0x09, 0x8F, 0xF1, 0x90, 0x6C, 0x12, 0x04,
  0x83, 0x60, 0x02, 0x01, 0x03, 0xC3, 0xF3, 0x41, 0x20, 0xD0, 0x70, 0x18,
  0x07, 0x03, 0x81, 0x41, 0x24, 0xB3, 0xF8, 0xF0, 0x20, 0x10, 0x00, 0x38,
  0x62, 0x84, 0x4C, 0x84, 0x88, 0xC9, 0x0C, 0xB0, 0x9A, 0x69, 0x6E, 0xF5,
  0xB6, 0xD3, 0x09, 0x31, 0xB2, 0x13, 0x23, 0x36, 0x23, 0x46, 0x1C, 0x0E,
  0x0D, 0x86, 0xC2, 0x61, 0x30, 0xB0, 0x70, 0x30, 0x38, 0x36, 0xF3, 0x58,
  0xEC, 0x66, 0x33, 0x3C, 0xF6, 0x6D, 0x25, 0x80, 0x06, 0x08, 0x20, 0xC1,
  0x06, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x81,
  0x80, 0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x20,
  0xC1, 0x86, 0x0C, 0x30, 0x43, 0x80, 0x18, 0x33, 0x43, 0xF3, 0x0D, 0x33,
  0x04, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x36,
  0x64, 0xC0, 0x7F, 0xC0, 0x5F, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x07, 0x07, 0x86, 0x46, 0x33, 0x19, 0x09, 0x84, 0xC6, 0x63,
  0x21, 0x90, 0xC8, 0x4C, 0x62, 0x21, 0xB0, 0xF0, 0x0C, 0x73, 0xBE, 0x58,
  0x61, 0x04, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x07, 0x07, 0xE0, 0x8C,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x08, 0x07, 0xE3, 0xF8, 0x0E, 0x1F, 0x88, 0x60, 0x30, 0x18, 0x18, 0x18,
  0x38, 0x3C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x32, 0x71, 0xF0, 0x01, 0x81,
  0x81, 0xC0, 0xE0, 0xB0, 0xD8, 0x48, 0x64, 0x26, 0x23, 0x31, 0x9F, 0xEF,
  0xF0, 0x60, 0x30, 0x10, 0x1F, 0x8F, 0xC4, 0x06, 0x03, 0x01, 0x80, 0xF0,
  0xFC, 0x06, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x32, 0x71, 0xF0, 0x07, 0x1F,
  0x30, 0x20, 0x60, 0x40, 0xDC, 0xFE, 0xC6, 0xC6, 0x86, 0x86, 0x84, 0x8C,
  0xD8, 0x78, 0x7F, 0xBF, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0x0F, 0x0F, 0xCC, 0x66,
  0x33, 0x19, 0x98, 0x58, 0x38, 0x3C, 0x33, 0x30, 0x98, 0x4C, 0x26, 0x33,
  0x38, 0xF8, 0x0E, 0x0F, 0x8C, 0x46, 0x36, 0x1B, 0x09, 0x8C, 0xC6, 0x77,
  0x1D, 0x80, 0x80, 0xC0, 0x60, 0x62, 0x61, 0xE0, 0x13, 0x30, 0x00, 0x00,
  0x04, 0xCC, 0x08, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x88, 0xC6, 0x22, 0x00,
  0x01, 0x03, 0x0E, 0x38, 0xE0, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0x1E, 0x38,
  0xE0, 0x80, 0x1C, 0x7C, 0x18, 0x10, 0x60, 0x83, 0x0C, 0x30, 0x40, 0x83,
  0x00, 0x08, 0x38, 0x60, 0x03, 0x80, 0xC6, 0x18, 0x23, 0x02, 0x23, 0x34,
  0x7B, 0x49, 0x3D, 0x92, 0x91, 0x29, 0x32, 0x92, 0x69, 0x24, 0x9F, 0x88,
  0x80, 0x80, 0x0C, 0x00, 0x66, 0x03, 0xC0, 0x03, 0x03, 0x07, 0x05, 0x0D,
  0x0D, 0x09, 0x19, 0x11, 0x3F, 0x3F, 0x61, 0x61, 0x61, 0xC1, 0xC1, 0x1F,
  0x07, 0xE1, 0x9C, 0x43, 0x30, 0x8C, 0x63, 0x18, 0xF8, 0x3F, 0x18, 0xC6,
  0x11, 0x8C, 0x63, 0x10, 0xCF, 0xE3, 0xF0, 0x07, 0x8F, 0xCE, 0x06, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x90,
  0xF8, 0x1E, 0x07, 0xE1, 0x9C, 0x43, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x20,
  0xD8, 0x66, 0x19, 0x86, 0x43, 0x11, 0x8F, 0xE3, 0xE0, 0x1F, 0x8F, 0xC6,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x7C, 0x3E, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC6, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3E, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x07, 0x87, 0xF3,
  0x84, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC7, 0xB0, 0x6C, 0x13, 0x0C,
  0xC3, 0x30, 0xC6, 0x71, 0xF8, 0x18, 0x63, 0x0C, 0x61, 0x88, 0x23, 0x0C,
  0x61, 0x8C, 0x31, 0xFE, 0x3F, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x18, 0x82,
  0x30, 0xC6, 0x18, 0x1F, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x03, 0x02, 0x06,
  0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0x10, 0xB0, 0xE0, 0x18, 0x63, 0x18, 0x66, 0x08, 0x83, 0x30, 0x6C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0x90, 0x33, 0x06, 0x60, 0x8C, 0x31, 0x86,
  0x18, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x0F,
  0xFF, 0x1C, 0x0E, 0x38, 0x18, 0x70, 0x70, 0xE0, 0xE3, 0xC3, 0xC7, 0x85,
  0x8F, 0x1A, 0x16, 0x2C, 0x24, 0xD8, 0xC9, 0xB1, 0x96, 0x63, 0x2C, 0x84,
  0x53, 0x08, 0xE6, 0x31, 0x8C, 0x63, 0x10, 0x18, 0x31, 0xC3, 0x1C, 0x21,
  0xC6, 0x34, 0x63, 0x46, 0x34, 0x42, 0x64, 0x26, 0xC6, 0x6C, 0x62, 0xC6,
  0x28, 0x42, 0x84, 0x38, 0xC3, 0x8C, 0x38, 0x0F, 0x07, 0xE3, 0x18, 0xC3,
  0x60, 0xD8, 0x3C, 0x0B, 0x02, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31,
  0x8E, 0xE1, 0xE0, 0x1E, 0x0F, 0xC6, 0x62, 0x33, 0x19, 0x8C, 0xC6, 0x66,
  0x3F, 0x3E, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x0F, 0x07, 0xE3,
  0x18, 0xC3, 0x60, 0xD8, 0x3C, 0x0B, 0x02, 0xC1, 0xB0, 0x6C, 0x1B, 0x0C,
  0xC3, 0x31, 0x8E, 0xE1, 0xF0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x1E, 0x0F,
  0xC6, 0x62, 0x33, 0x19, 0x8C, 0xC6, 0x66, 0x3E, 0x36, 0x19, 0x0C, 0xC4,
  0x62, 0x33, 0x19, 0x8C, 0x07, 0x83, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC6, 0xE3, 0xF0,
  0x7F, 0x7F, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0xC0, 0x30, 0xCC, 0x33, 0x08, 0x82, 0x61, 0x98, 0x66,
  0x19, 0x04, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC6, 0x31, 0x8C, 0xC1, 0xE0,
  0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x23, 0x31, 0x98, 0xD8, 0x6C, 0x34,
  0x1E, 0x0E, 0x05, 0x03, 0x81, 0x80, 0xC3, 0x0F, 0x0C, 0x3C, 0x71, 0xB1,
  0xC6, 0xC7, 0x12, 0x3C, 0xC8, 0xB3, 0x26, 0xD8, 0x9B, 0x62, 0x49, 0x0B,
  0x2C, 0x28, 0xB0, 0xE2, 0x83, 0x8E, 0x0C, 0x30, 0x30, 0xC0, 0x18, 0x61,
  0x18, 0x22, 0x06, 0xC0, 0xD0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x1B, 0x03, 0x60, 0xCC, 0x10, 0x86, 0x18, 0xC3, 0xC6, 0xC6, 0xCC,
  0xCC, 0xD8, 0x50, 0x70, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x80,
  0x1F, 0xC7, 0xE0, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x20, 0x18, 0x0F, 0xE3, 0xF8, 0x0F, 0x87, 0x83, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x1E, 0x1F, 0x00, 0xCC, 0x44, 0x44, 0x66, 0x66,
  0x62, 0x22, 0x33, 0x0F, 0x1F, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0xF0, 0xF0, 0x06,
  0x03, 0x03, 0x83, 0x41, 0x31, 0x98, 0x84, 0xC2, 0xC1, 0x80, 0xFE, 0xCD,
  0x90, 0x1D, 0x3F, 0x63, 0x43, 0xC2, 0xC6, 0xC6, 0x86, 0x84, 0x8C, 0xD4,
  0xFC, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0xB8, 0xFC, 0x63, 0x31, 0x90,
  0xD8, 0x6C, 0x26, 0x33, 0x19, 0x99, 0xCC, 0xFC, 0x00, 0x1E, 0x79, 0x82,
  0x0C, 0x18, 0x20, 0x40, 0x81, 0x03, 0x27, 0xC0, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0xF8, 0xFC, 0xC6, 0x43, 0x61, 0x31, 0x98, 0xC8, 0x64, 0x22,
  0x31, 0xB8, 0xFC, 0x00, 0x1C, 0x6D, 0x9E, 0x3C, 0x5F, 0xB8, 0x40, 0x81,
  0x03, 0x23, 0xC0, 0x00, 0xE0, 0x38, 0x0C, 0x01, 0x80, 0x20, 0x0F, 0x03,
  0xE0, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x01, 0xC0, 0x00, 0x0E, 0x8F,
  0xCC, 0x64, 0x36, 0x13, 0x19, 0x8C, 0x86, 0x42, 0x23, 0x1B, 0x8F, 0xC0,
  0x60, 0x20, 0x31, 0x38, 0xF8, 0x00, 0x08, 0x18, 0x18, 0x18, 0x10, 0x37,
  0x3F, 0x31, 0x31, 0x23, 0x63, 0x63, 0x62, 0x42, 0x46, 0xC6, 0xC6, 0x18,
  0xC0, 0x03, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0xE0, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01,
  0x8C, 0xCC, 0x6C, 0x24, 0x16, 0x1E, 0x0F, 0x86, 0xC2, 0x61, 0x31, 0x88,
  0xC6, 0x00, 0x08, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18,
  0xC0, 0x37, 0x71, 0xFF, 0xCC, 0x66, 0x66, 0x32, 0x31, 0xB1, 0x89, 0x8C,
  0xCC, 0x46, 0x46, 0x32, 0x31, 0x31, 0x89, 0x88, 0xC0, 0x37, 0x3F, 0x31,
  0x31, 0x23, 0x63, 0x63, 0x62, 0x42, 0x46, 0xC6, 0xC6, 0x1C, 0x6D, 0x8A,
  0x1C, 0x38, 0x61, 0xC3, 0x87, 0x1B, 0x67, 0x80, 0x1B, 0x87, 0x61, 0x8C,
  0x63, 0x10, 0xCC, 0x33, 0x08, 0xC6, 0x31, 0x8C, 0xC7, 0x31, 0xF8, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1D, 0x3F, 0x63, 0x43, 0xC2, 0xC6,
  0xC6, 0x86, 0x84, 0x8C, 0xDC, 0xFC, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x36,
  0x7C, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x00, 0x1E, 0x6D,
  0x83, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x1A, 0x67, 0x80, 0x31, 0x1F, 0xF6,
  0x31, 0x18, 0xC6, 0x21, 0x0A, 0x70, 0x63, 0x63, 0x62, 0x42, 0x46, 0xC6,
  0xC6, 0xC4, 0x8C, 0x8C, 0xDC, 0xEC, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xC8,
  0xD8, 0xD0, 0xF0, 0xE0, 0xE0, 0xE0, 0xC6, 0x3C, 0x62, 0xCE, 0x6C, 0xA6,
  0xCA, 0x4D, 0xAC, 0xD2, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x0C, 0x60,
  0x11, 0x8C, 0xC6, 0xC3, 0x41, 0xE0, 0x60, 0x70, 0x38, 0x34, 0x13, 0x19,
  0x98, 0xC0, 0x18, 0x63, 0x18, 0x63, 0x0C, 0xC0, 0x98, 0x12, 0x02, 0xC0,
  0x50, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0xE0, 0x00, 0x1F, 0x1F, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60,
  0x40, 0xFC, 0x01, 0x83, 0x83, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18,
  0x38, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x10, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x1C, 0x06, 0x06, 0x04, 0x04,
  0x0C, 0x0C, 0x0C, 0x07, 0x0E, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0xE0, 0xF1, 0x9F, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 6, 6, 7, 2, -16 },
  { 18, 10, 16, 9, 0, -16 },
  { 38, 9, 18, 9, 0, -17 },
  { 59, 12, 16, 13, 1, -16 },
  { 83, 9, 16, 9, 0, -16 },
  { 101, 3, 6, 4, 2, -16 },
  { 104, 7, 19, 6, 0, -16 },
  { 121, 7, 19, 6, -2, -16 },
  { 138, 7, 8, 8, 2, -17 },
  { 145, 8, 10, 9, 1, -13 },
  { 155, 4, 5, 4, -1, -2 },
  { 158, 5, 2, 6, 0, -7 },
  { 160, 3, 3, 4, 0, -3 },
  { 162, 10, 16, 7, -1, -16 },
  { 182, 9, 16, 9, 0, -16 },
  { 200, 6, 16, 9, 2, -16 },
  { 212, 10, 16, 9, -1, -16 },
  { 232, 9, 16, 9, 0, -16 },
  { 250, 9, 16, 9, 0, -16 },
  { 268, 9, 16, 9, 0, -16 },
  { 286, 8, 16, 9, 1, -16 },
  { 302, 9, 16, 9, 1, -16 },
  { 320, 9, 16, 9, 0, -16 },
  { 338, 9, 16, 9, 0, -16 },
  { 356, 4, 12, 4, 0, -12 },
  { 362, 5, 15, 4, -1, -12 },
  { 372, 8, 10, 9, 1, -13 },
  { 382, 8, 6, 9, 1, -11 },
  { 388, 8, 10, 9, 1, -13 },
  { 398, 7, 16, 6, 0, -16 },
  { 412, 12, 18, 13, 1, -16 },
  { 439, 8, 16, 9, -1, -16 },
  { 455, 10, 16, 9, 0, -16 },
  { 475, 9, 16, 8, 1, -16 },
  { 493, 10, 16, 10, 0, -16 },
  { 513, 9, 16, 8, 0, -16 },
  { 531, 9, 16, 8, 0, -16 },
  { 549, 10, 16, 11, 1, -16 },
  { 569, 11, 16, 11, 0, -16 },
  { 591, 8, 16, 6, -1, -16 },
  { 607, 8, 20, 4, -3, -16 },
  { 627, 11, 16, 9, 0, -16 },
  { 649, 6, 16, 7, 0, -16 },
  { 661, 15, 16, 14, 0, -16 },
  { 691, 12, 16, 11, 0, -16 },
  { 715, 10, 16, 11, 1, -16 },
  { 735, 9, 16, 9, 0, -16 },
  { 753, 10, 20, 11, 1, -16 },
  { 778, 9, 16, 9, 0, -16 },
  { 796, 10, 16, 8, -1, -16 },
  { 816, 8, 16, 8, 1, -16 },
  { 832, 10, 16, 10, 1, -16 },
  { 852, 9, 16, 9, 2, -16 },
  { 870, 14, 16, 14, 2, -16 },
  { 898, 11, 16, 8, -1, -16 },
  { 920, 8, 16, 8, 2, -16 },
  { 936, 10, 16, 7, -1, -16 },
  { 956, 9, 20, 6, -1, -16 },
  { 979, 4, 16, 7, 2, -16 },
  { 987, 8, 20, 6, -1, -16 },
  { 1007, 9, 9, 9, 0, -16 },
  { 1018, 7, 1, 7, -2, 2 },
  { 1019, 3, 4, 5, 3, -17 },
  { 1021, 8, 12, 9, 1, -12 },
  { 1033, 9, 17, 9, 0, -17 },
  { 1053, 7, 12, 7, 1, -12 },
  { 1064, 9, 17, 9, 1, -17 },
  { 1084, 7, 12, 8, 1, -12 },
  { 1095, 11, 22, 5, -3, -17 },
  { 1126, 9, 17, 9, 0, -12 },
  { 1146, 8, 17, 9, 0, -17 },
  { 1163, 5, 16, 4, 0, -16 },
  { 1173, 8, 21, 4, -3, -16 },
  { 1194, 9, 17, 8, 0, -17 },
  { 1214, 5, 17, 4, 0, -17 },
  { 1225, 13, 12, 13, 0, -12 },
  { 1245, 8, 12, 9, 0, -12 },
  { 1257, 7, 12, 9, 1, -12 },
  { 1268, 10, 17, 9, -1, -12 },
  { 1290, 8, 17, 9, 1, -12 },
  { 1307, 7, 12, 6, 0, -12 },
  { 1318, 7, 12, 7, 0, -12 },
  { 1329, 5, 14, 5, 1, -14 },
  { 1338, 8, 12, 9, 1, -12 },
  { 1350, 8, 12, 7, 1, -12 },
  { 1362, 12, 12, 12, 1, -12 },
  { 1380, 9, 12, 8, -1, -12 },
  { 1394, 11, 17, 7, -2, -12 },
  { 1418, 8, 12, 6, -1, -12 },
  { 1430, 9, 19, 7, 0, -16 },
  { 1452, 2, 22, 8, 3, -17 },
  { 1458, 8, 19, 7, -1, -16 },
  { 1477, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Italic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC22PT7B_H_
