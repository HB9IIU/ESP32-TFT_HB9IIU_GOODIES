#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x02,
  0x00, 0x00, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x1F, 0x1E,
  0x0F, 0x8F, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x81, 0xE1, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x03, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFE, 0xCF, 0x80, 0xFC, 0x60, 0xC0, 0x7C, 0x70, 0x00,
  0x3C, 0x38, 0x00, 0x3E, 0x18, 0x00, 0x1F, 0x0C, 0x00, 0x0F, 0x86, 0x00,
  0x07, 0xC7, 0x00, 0x03, 0xE3, 0x80, 0x00, 0xF1, 0x80, 0x00, 0x7C, 0xC0,
  0x00, 0x3F, 0x60, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xBF, 0x00, 0x00, 0xCF, 0x80, 0x00, 0xE3, 0xE0, 0x00,
  0x71, 0xF0, 0x00, 0x30, 0xF8, 0x00, 0x18, 0x7C, 0x00, 0x0C, 0x3E, 0x00,
  0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x04, 0x03, 0x0F, 0x83, 0x81, 0x8F, 0x81,
  0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0xFF,
  0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x78,
  0xF0, 0x0F, 0x00, 0x78, 0x38, 0x07, 0x80, 0x38, 0x1C, 0x07, 0x80, 0x3C,
  0x1E, 0x03, 0xC0, 0x1E, 0x0F, 0x03, 0xC0, 0x0E, 0x07, 0x81, 0xE0, 0x0F,
  0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0xF0, 0x01,
  0xE0, 0x78, 0x78, 0x01, 0xE0, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x3C, 0x00,
  0x78, 0x1E, 0x3C, 0x00, 0x3C, 0x0E, 0x3C, 0x1F, 0x1E, 0x0F, 0x1E, 0x1F,
  0xCF, 0x07, 0x9E, 0x1F, 0xF7, 0x87, 0x8F, 0x1F, 0xFB, 0xC3, 0xCF, 0x1E,
  0x3D, 0xE3, 0xC7, 0x8F, 0x0F, 0xFF, 0xE7, 0x8F, 0x07, 0xBF, 0xE3, 0xC7,
  0x83, 0xCF, 0xE3, 0xC7, 0x81, 0xE3, 0xC1, 0xE3, 0xC0, 0xF0, 0x01, 0xE1,
  0xE0, 0xF0, 0x00, 0xF1, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0x78,
  0x78, 0x1E, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x07, 0x00, 0x3C,
  0x0E, 0x07, 0x80, 0x1E, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x81, 0xE0, 0x0F,
  0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0xF0, 0xF0, 0x07,
  0x80, 0x78, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0x03, 0xC0, 0x0F, 0xFC, 0x03,
  0xE0, 0x07, 0xFC, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x07, 0xC3, 0xE7, 0xC1,
  0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x1F, 0x03,
  0xE7, 0xC7, 0xC0, 0xF9, 0xE1, 0xE0, 0x1F, 0xF8, 0xF8, 0x07, 0xFC, 0x3E,
  0x01, 0xFF, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x3F, 0xE0, 0xFC, 0x1F,
  0xF8, 0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xCF, 0xC0, 0xFF, 0xE1, 0xF0, 0x1F,
  0xF0, 0x7E, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x04, 0x0F, 0x00, 0xE1, 0xE0, 0x1F, 0x3C,
  0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x7C, 0x3E,
  0x07, 0x83, 0xC0, 0x60, 0x7C, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF8, 0x39, 0xFF, 0xFF, 0xFF, 0xEF, 0x88, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x0F,
  0x80, 0x7C, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xBC, 0x3F,
  0x7C, 0xFC, 0x7C, 0x78, 0x7C, 0x30, 0x78, 0x20, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0x00, 0x7C, 0x00, 0x80,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0x80, 0xFC, 0x01, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC1, 0x00, 0x0F, 0xC0, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x3D, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x3E, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x08, 0x00, 0x7E, 0x03,
  0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x7F, 0xC0, 0x3C, 0xFF, 0xC0, 0x7D, 0xFF, 0xE0, 0x7F,
  0xEF, 0xE0, 0x7F, 0x83, 0xF0, 0x7E, 0x01, 0xF0, 0xFE, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00,
  0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x07,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01,
  0xF8, 0x3E, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x0F,
  0x80, 0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0xC3, 0xFE, 0x0F, 0xFF, 0xBC, 0x07,
  0xFF, 0x7C, 0x07, 0xFE, 0x7C, 0x03, 0xFC, 0x7C, 0x00, 0x70, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x80, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xC0, 0x78, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x60, 0x3E, 0x04, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0xC0, 0x1E, 0x07, 0x00, 0xFF, 0x83, 0xC1, 0xE0, 0x3F,
  0xF8, 0x78, 0x38, 0x0F, 0xFE, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x0F, 0x07, 0x0F, 0x07, 0x83, 0xC0, 0xE1,
  0xC0, 0xF0, 0x78, 0x1C, 0x78, 0x3C, 0x0F, 0x07, 0x8F, 0x07, 0x81, 0xE0,
  0xF1, 0xE0, 0xE0, 0x78, 0x1E, 0x38, 0x3C, 0x0F, 0x03, 0x87, 0x07, 0x81,
  0xE0, 0xF1, 0xE0, 0xF0, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x03, 0x87, 0x83,
  0x81, 0xE0, 0x70, 0xF0, 0x70, 0x3C, 0x1E, 0x1C, 0x1E, 0x0F, 0x83, 0x83,
  0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x7C, 0x1C, 0x0E, 0x07, 0x8D, 0xC7,
  0x83, 0xC0, 0xFF, 0xBF, 0xE0, 0x78, 0x1F, 0xE7, 0xF8, 0x0F, 0x01, 0xF8,
  0xFE, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x10, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x79,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03,
  0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0x81, 0xFC, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF8, 0x1F, 0x00, 0xFE, 0x03, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x81, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xF8, 0x3F, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0x7C,
  0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0xE0, 0x03, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x1F, 0x00,
  0x3F, 0xF0, 0x7C, 0x01, 0xFF, 0xC1, 0xF0, 0x07, 0xFF, 0x0F, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x3F, 0x80, 0x7C, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x00, 0x79, 0xF0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xC0, 0x1F, 0x3E,
  0x01, 0xF1, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0x7C,
  0x78, 0x07, 0x8F, 0x80, 0x3E, 0x3C, 0x07, 0xC7, 0xC0, 0x1E, 0x1E, 0x03,
  0xC3, 0xE0, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x81, 0xE1, 0xF0,
  0x07, 0xC3, 0xC1, 0xF0, 0xF8, 0x03, 0xC1, 0xE0, 0xF8, 0x7C, 0x03, 0xE0,
  0xF0, 0x78, 0x3E, 0x01, 0xF0, 0x78, 0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x3C,
  0x1F, 0x00, 0x7C, 0x1E, 0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x1E, 0x07, 0xC0,
  0x3E, 0x07, 0x9F, 0x03, 0xE0, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x0F, 0x81,
  0xFF, 0x81, 0xF0, 0x07, 0xC0, 0xFF, 0x80, 0xF8, 0x03, 0xC0, 0x7F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0xE0, 0x3C, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x00,
  0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0xF0, 0x0F, 0x80, 0x3C, 0x03,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x07, 0xC0, 0x1F,
  0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x07,
  0xF8, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3E, 0x01,
  0xFF, 0x80, 0x1E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7D, 0xE0, 0x0F, 0x80,
  0x3E, 0xF0, 0x07, 0xC0, 0x1E, 0x78, 0x03, 0xE0, 0x1F, 0x3E, 0x03, 0xE0,
  0x0F, 0x9F, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0xF8, 0x03, 0xE3, 0xC0, 0x7C,
  0x01, 0xE1, 0xE0, 0x3C, 0x01, 0xF0, 0xF0, 0x3E, 0x00, 0xF8, 0x78, 0x1F,
  0x00, 0x7C, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0x83,
  0xC0, 0x1F, 0x03, 0xC3, 0xE0, 0x0F, 0x81, 0xE1, 0xF0, 0x07, 0xC0, 0xF0,
  0xF8, 0x03, 0xC0, 0x7C, 0x7C, 0x03, 0xE0, 0x3E, 0x3C, 0x01, 0xF0, 0x0F,
  0x3E, 0x00, 0xF8, 0x07, 0x9F, 0x00, 0x7C, 0x03, 0xCF, 0x80, 0x3C, 0x01,
  0xE7, 0x80, 0x3E, 0x00, 0xFB, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xC0, 0x07, 0xF8, 0x03, 0xE0,
  0x03, 0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xF8,
  0x7F, 0x80, 0x3E, 0x07, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x3E,
  0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0xFC, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0xF8, 0x3F, 0x80, 0x3E, 0x07, 0xF0, 0x0F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x7C,
  0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0x00, 0x7E, 0x00, 0x40, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x20, 0x00, 0xFC, 0x06, 0x00,
  0x3F, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC1, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7,
  0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xE0, 0x00,
  0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0xC0, 0x07, 0xCF, 0x80, 0x07, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xFE, 0x00, 0x7C,
  0x3E, 0x00, 0xFF, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x0F, 0x80,
  0x3F, 0xC0, 0x1F, 0x07, 0xC0, 0x3D, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0xF0,
  0x0F, 0x81, 0xF0, 0x1F, 0x78, 0x07, 0xC0, 0xF8, 0x0F, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x9E, 0x03, 0xE0, 0x3E, 0x07, 0x8F, 0x03, 0xE0, 0x1F, 0x03,
  0xC7, 0x81, 0xF0, 0x0F, 0x83, 0xE3, 0xC0, 0xF8, 0x07, 0xC1, 0xE1, 0xE0,
  0xF8, 0x03, 0xE0, 0xF0, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x78, 0x7C, 0x00,
  0xF8, 0x78, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x1E, 0x1F, 0x00, 0x3E, 0x3C,
  0x0F, 0x1F, 0x00, 0x1E, 0x1E, 0x07, 0x8F, 0x80, 0x0F, 0x1F, 0x03, 0xCF,
  0x80, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x81, 0xF3, 0xE0, 0x01,
  0xE7, 0x80, 0xFB, 0xE0, 0x00, 0xF3, 0xC0, 0x79, 0xF0, 0x00, 0x7B, 0xE0,
  0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x0F, 0x7C,
  0x00, 0x0F, 0xF0, 0x07, 0xBC, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x07, 0xC0,
  0x3C, 0x1F, 0x00, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x79, 0xF0,
  0x00, 0xF9, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF8,
  0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F,
  0x07, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x8F, 0x01, 0xFF, 0x9F, 0x03, 0xFF,
  0xDF, 0x07, 0xFB, 0xDE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x1F, 0xC0, 0xFC, 0x3B, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7,
  0xC0, 0x7F, 0xE7, 0x80, 0x3F, 0xC7, 0x80, 0x06, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xCF, 0xF0, 0x03, 0xCF, 0xFC,
  0x03, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0x80, 0xFF, 0x07, 0xC0, 0x7F, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x87,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8,
  0x0F, 0x7F, 0xF8, 0x0F, 0xBF, 0xFC, 0x07, 0x8F, 0xFC, 0x03, 0xC3, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xF9, 0xC0, 0x7E, 0x04, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x7F, 0xCF,
  0x80, 0x0F, 0xFC, 0xF8, 0x01, 0xFF, 0xEF, 0x00, 0x3F, 0xDE, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0x7C,
  0x1F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xE0, 0x03, 0xFF, 0x3C,
  0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0xF8, 0x0F, 0x81,
  0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x06, 0x03, 0xFD, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x06,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE,
  0x3C, 0x00, 0xFF, 0xEF, 0x80, 0x3F, 0xFD, 0xE0, 0x0F, 0xF7, 0xBC, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x3E, 0x0F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xC0, 0x0F, 0xFC, 0xF0, 0x00, 0xFF, 0x3E,
  0x00, 0x07, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x02, 0x00, 0x3E, 0x00, 0x60, 0x0F, 0xC0, 0x0F, 0x87,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x01, 0xF3,
  0xFC, 0x01, 0xEF, 0xFE, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF8,
  0x3F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0,
  0x1E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3E, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xC0, 0x00, 0x18, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xDF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F,
  0x80, 0x07, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xDF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC3, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x78, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x1E,
  0x3F, 0xC3, 0xFE, 0x01, 0xEF, 0xFE, 0x7F, 0xE0, 0x3E, 0xFF, 0xEF, 0xFF,
  0x03, 0xDF, 0xFF, 0xFF, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0x03, 0xF0, 0x3F,
  0x81, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F,
  0x0F, 0x80, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF0,
  0x07, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x01, 0xE3, 0xFC, 0x01, 0xEF, 0xFE,
  0x03, 0xEF, 0xFE, 0x03, 0xDF, 0xFF, 0x03, 0xF8, 0x3F, 0x03, 0xF0, 0x1F,
  0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF3, 0xF8, 0x1F,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1F,
  0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x8F, 0x00, 0x7C, 0x3E,
  0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xF0, 0x7C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x3C, 0xFF, 0xC0, 0x07, 0xDF, 0xFC,
  0x00, 0x7F, 0xC7, 0xE0, 0x07, 0xB8, 0x3E, 0x00, 0x7F, 0x03, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0x7F, 0xF8, 0x00, 0xF7,
  0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x06, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xE3, 0xC0, 0x3F, 0xFB, 0xE0, 0x3F, 0xFD, 0xE0, 0x3F,
  0xDE, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF0, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0xFE, 0x03, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xF7, 0xC0, 0x3F, 0xF3, 0xC0, 0x0F, 0xF3, 0xE0, 0x01, 0xC1, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E,
  0x3F, 0x01, 0xEF, 0xE0, 0x3C, 0xFE, 0x03, 0xDF, 0xE0, 0x3D, 0xE2, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x0F, 0x03, 0xF0,
  0x18, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x08, 0x01,
  0xF0, 0x70, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x78, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x7C,
  0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83,
  0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0,
  0xFC, 0x0F, 0x83, 0xF8, 0x1F, 0xFE, 0xF0, 0x3F, 0xF9, 0xE0, 0x3F, 0xE3,
  0xC0, 0x3F, 0x8F, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E,
  0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F,
  0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x03,
  0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0,
  0xF8, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F,
  0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xDF, 0x00,
  0xFC, 0x03, 0xE7, 0xC0, 0x7F, 0x00, 0xF9, 0xE0, 0x1F, 0xC0, 0x7C, 0x78,
  0x07, 0xF0, 0x1F, 0x1E, 0x03, 0xFC, 0x07, 0x87, 0x80, 0xFF, 0x03, 0xE1,
  0xE0, 0x3B, 0xC0, 0xF8, 0x78, 0x1E, 0xF0, 0x7C, 0x1E, 0x07, 0xBC, 0x1F,
  0x07, 0x83, 0xCF, 0x07, 0x81, 0xE0, 0xF3, 0xC3, 0xE0, 0x78, 0x3C, 0xF0,
  0xF8, 0x1E, 0x1E, 0x78, 0x3C, 0x07, 0x87, 0x9E, 0x1F, 0x01, 0xE3, 0xC7,
  0x87, 0x80, 0x78, 0xF1, 0xE3, 0xE0, 0x1E, 0x3C, 0x78, 0xF8, 0x07, 0x9E,
  0x1E, 0x3C, 0x01, 0xE7, 0x87, 0x9F, 0x00, 0x7B, 0xE1, 0xE7, 0x80, 0x3E,
  0xF0, 0x7B, 0xE0, 0x0F, 0xBC, 0x1E, 0xF8, 0x03, 0xFE, 0x07, 0xBC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1B, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x3F, 0xE0, 0x03, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xC0,
  0x0F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 45, 15, 1, -44 },
  { 86, 17, 16, 21, 6, -44 },
  { 120, 28, 44, 26, 0, -44 },
  { 274, 25, 51, 24, 0, -47 },
  { 434, 33, 46, 38, 3, -45 },
  { 624, 26, 46, 27, 0, -45 },
  { 774, 8, 16, 12, 6, -44 },
  { 790, 19, 55, 16, 1, -45 },
  { 921, 19, 55, 16, -5, -45 },
  { 1052, 19, 20, 22, 6, -47 },
  { 1100, 23, 29, 27, 2, -36 },
  { 1184, 11, 15, 13, -3, -7 },
  { 1205, 14, 5, 16, 1, -19 },
  { 1214, 6, 8, 13, 1, -7 },
  { 1220, 28, 44, 21, -3, -44 },
  { 1374, 23, 46, 24, 1, -45 },
  { 1507, 16, 44, 24, 6, -44 },
  { 1595, 26, 45, 24, -2, -45 },
  { 1742, 25, 46, 24, -1, -45 },
  { 1886, 26, 45, 24, -1, -45 },
  { 2033, 26, 45, 24, -1, -44 },
  { 2180, 24, 46, 24, 2, -45 },
  { 2318, 25, 44, 24, 2, -44 },
  { 2456, 25, 46, 24, 0, -45 },
  { 2600, 24, 46, 24, 0, -45 },
  { 2738, 12, 34, 13, 0, -33 },
  { 2789, 16, 41, 13, -3, -33 },
  { 2871, 23, 28, 27, 2, -36 },
  { 2952, 23, 18, 27, 2, -31 },
  { 3004, 23, 28, 27, 2, -36 },
  { 3085, 20, 46, 18, 1, -45 },
  { 3200, 35, 50, 36, 1, -45 },
  { 3419, 25, 44, 25, -4, -44 },
  { 3557, 27, 44, 27, 0, -44 },
  { 3706, 27, 46, 24, 2, -45 },
  { 3862, 28, 44, 29, 0, -44 },
  { 4016, 25, 44, 23, 0, -44 },
  { 4154, 25, 44, 21, 0, -44 },
  { 4292, 30, 46, 31, 2, -45 },
  { 4465, 31, 44, 30, 0, -44 },
  { 4636, 24, 44, 16, -3, -44 },
  { 4768, 23, 56, 13, -9, -44 },
  { 4929, 30, 44, 25, 0, -44 },
  { 5094, 17, 44, 21, 0, -44 },
  { 5188, 41, 44, 40, 0, -44 },
  { 5414, 33, 44, 32, 0, -44 },
  { 5596, 28, 46, 31, 2, -45 },
  { 5757, 26, 44, 25, 0, -44 },
  { 5900, 28, 56, 31, 2, -45 },
  { 6096, 26, 44, 26, 0, -44 },
  { 6239, 27, 46, 23, -1, -45 },
  { 6395, 22, 44, 21, 4, -44 },
  { 6516, 29, 45, 29, 2, -44 },
  { 6680, 25, 44, 25, 5, -44 },
  { 6818, 41, 44, 40, 4, -44 },
  { 7044, 31, 44, 23, -4, -44 },
  { 7215, 22, 44, 22, 5, -44 },
  { 7336, 28, 44, 21, -3, -44 },
  { 7490, 24, 55, 17, -2, -45 },
  { 7655, 10, 44, 21, 6, -44 },
  { 7710, 23, 55, 17, -4, -45 },
  { 7869, 24, 23, 25, 1, -44 },
  { 7938, 19, 4, 19, -5, 5 },
  { 7948, 8, 9, 15, 9, -47 },
  { 7957, 24, 35, 26, 2, -34 },
  { 8062, 25, 48, 26, 0, -47 },
  { 8212, 20, 35, 20, 2, -34 },
  { 8300, 28, 48, 26, 1, -47 },
  { 8468, 22, 35, 24, 1, -34 },
  { 8565, 29, 62, 14, -8, -47 },
  { 8790, 27, 49, 26, -1, -34 },
  { 8956, 24, 47, 25, 0, -47 },
  { 9097, 14, 46, 12, 0, -46 },
  { 9178, 22, 61, 12, -8, -46 },
  { 9346, 25, 47, 22, 0, -47 },
  { 9493, 15, 47, 12, 0, -47 },
  { 9582, 36, 34, 38, 0, -34 },
  { 9735, 24, 34, 25, 0, -34 },
  { 9837, 22, 35, 25, 2, -34 },
  { 9934, 28, 48, 26, -3, -34 },
  { 10102, 25, 49, 26, 1, -34 },
  { 10256, 20, 34, 17, 0, -34 },
  { 10341, 21, 35, 20, -1, -34 },
  { 10433, 16, 42, 15, 1, -41 },
  { 10517, 23, 34, 26, 2, -33 },
  { 10615, 20, 33, 21, 4, -33 },
  { 10698, 34, 33, 34, 3, -33 },
  { 10839, 27, 33, 21, -3, -33 },
  { 10951, 30, 48, 21, -6, -33 },
  { 11131, 21, 33, 18, -2, -33 },
  { 11218, 23, 54, 20, 1, -44 },
  { 11374, 4, 62, 23, 9, -47 },
  { 11405, 23, 54, 20, -4, -44 },
  { 11561, 24, 8, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Italic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC62PT7B_H_
