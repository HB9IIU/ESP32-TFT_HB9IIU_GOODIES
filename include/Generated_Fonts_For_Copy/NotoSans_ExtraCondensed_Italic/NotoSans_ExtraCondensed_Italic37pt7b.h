#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0xF0, 0x38, 0x00, 0x71, 0xDC, 0xE7, 0x39, 0x8E,
  0xE3, 0xB8, 0xCE, 0x33, 0x1C, 0xC7, 0x00, 0x00, 0xE3, 0x00, 0x63, 0x80,
  0x71, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x30, 0x3F, 0xFF,
  0x1F, 0xFF, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61,
  0x80, 0x31, 0xC0, 0x38, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x0E, 0x30, 0x06,
  0x18, 0x03, 0x1C, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0x63, 0x00,
  0x71, 0x80, 0x00, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x0F, 0xE0, 0x7F,
  0xE1, 0xFB, 0x83, 0x91, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x72, 0x00,
  0xF4, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x06,
  0xE0, 0x0C, 0xC0, 0x11, 0x80, 0x23, 0x00, 0xCE, 0x21, 0x9C, 0x7B, 0xF0,
  0xFF, 0xC0, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x43, 0xE0, 0x30, 0xEE, 0x0E, 0x18, 0xC1, 0x87, 0x18, 0x60,
  0xC3, 0x0C, 0x18, 0xE3, 0x07, 0x1C, 0x60, 0xE3, 0x98, 0x18, 0x63, 0x03,
  0x0C, 0xC0, 0x63, 0xB9, 0xEC, 0x66, 0x7F, 0x9D, 0xDC, 0xFF, 0x33, 0x1F,
  0xCE, 0x63, 0x71, 0x98, 0x60, 0x73, 0x0C, 0x0C, 0x61, 0x83, 0x9C, 0x70,
  0x63, 0x8C, 0x1C, 0x61, 0x83, 0x0C, 0x70, 0xE1, 0x8C, 0x18, 0x3B, 0x87,
  0x07, 0xE1, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x38,
  0xC0, 0x71, 0x80, 0xC3, 0x01, 0x8E, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE1, 0x9D, 0xC7, 0x31,
  0xCE, 0xE3, 0x9B, 0x87, 0x77, 0x07, 0xCE, 0x0F, 0x9C, 0x1E, 0x38, 0x3C,
  0x70, 0xF8, 0xF3, 0xF8, 0xFF, 0x71, 0xF8, 0xF0, 0x7B, 0x9C, 0xC6, 0x73,
  0x98, 0xC0, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x00,
  0xC2, 0x18, 0x77, 0x0F, 0xDE, 0xFF, 0xC7, 0xF9, 0xF0, 0x77, 0x1E, 0x61,
  0x8E, 0x11, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x38, 0x71, 0xC3, 0x86, 0x1C, 0x30, 0xE0, 0xFF, 0xFE, 0x77, 0xF7, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x1F,
  0x81, 0xFE, 0x1E, 0x70, 0xE3, 0x8E, 0x0C, 0x70, 0x67, 0x03, 0x38, 0x39,
  0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x0E, 0xE0,
  0x77, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70,
  0xF7, 0x83, 0xF8, 0x1F, 0x80, 0x07, 0x87, 0xC7, 0xC7, 0xE7, 0x77, 0x39,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00,
  0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0x0E, 0x02, 0x0E, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x06,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x80, 0xF0, 0xE3, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x6E, 0x00,
  0x6C, 0x00, 0xDC, 0x01, 0xDC, 0x01, 0x9C, 0x03, 0x1C, 0x07, 0x18, 0x06,
  0x38, 0x0E, 0x38, 0x0C, 0x38, 0x18, 0x38, 0x38, 0x70, 0x30, 0x70, 0x70,
  0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7F, 0x01, 0xFF, 0x01, 0x9F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x20, 0x78,
  0x61, 0xE0, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x18, 0x1D, 0xF8, 0x7F, 0xF1, 0xE3, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x70,
  0x73, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x80, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F,
  0xF0, 0x70, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xF8, 0x1E,
  0x70, 0x78, 0x70, 0xE0, 0xE3, 0x81, 0xC7, 0x01, 0xCE, 0x03, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xF1, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xE0,
  0x0F, 0xE0, 0x7F, 0x83, 0xC7, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE1, 0xF3, 0xCF,
  0x87, 0xFE, 0x0F, 0xB8, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x87, 0x83, 0xFC, 0x0F, 0xC0, 0x00, 0x0E, 0x1C,
  0x78, 0xF0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x71, 0xE3, 0xC7, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x0E, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0E, 0x00,
  0x30, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x88, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x01, 0xF3, 0xC0,
  0x38, 0x0E, 0x07, 0x00, 0x70, 0x60, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03,
  0x18, 0x3F, 0x33, 0x8F, 0xE3, 0x30, 0xC6, 0x33, 0x18, 0xE3, 0x61, 0x8E,
  0x36, 0x30, 0xC3, 0x63, 0x0C, 0x7E, 0x31, 0xC6, 0xC7, 0x1C, 0x6C, 0x71,
  0x86, 0xC7, 0x38, 0xCC, 0x73, 0x8C, 0xC7, 0x79, 0x8C, 0x3C, 0xF0, 0xC1,
  0x8E, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x81, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x66, 0x01, 0xCC,
  0x03, 0x98, 0x0E, 0x30, 0x1C, 0x60, 0x38, 0xC0, 0xE1, 0x81, 0xC3, 0x07,
  0x06, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xE0, 0xF3, 0x81, 0xE7, 0x03,
  0xDE, 0x07, 0xB8, 0x0F, 0x70, 0x1F, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x3C, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1C, 0xF8, 0x38, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0x82, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x7C, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xC7, 0xC0, 0xE1, 0xE0, 0x70, 0x70, 0x70, 0x3C, 0x38, 0x1E, 0x1C,
  0x0F, 0x0E, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70,
  0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07,
  0x0E, 0x03, 0x87, 0x03, 0x83, 0x83, 0xC1, 0xC3, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x3F,
  0xFC, 0x1F, 0x06, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x0F, 0xC7, 0x07, 0xF3, 0xC1, 0xF8, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x3C, 0x07, 0x07, 0x01, 0xC1, 0xE0, 0x70,
  0x3C, 0x38, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0x81, 0xE0, 0xE0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x00, 0x07, 0xFC, 0x0F,
  0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0x70, 0x70,
  0x1C, 0x38, 0x07, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xF7, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01,
  0xC3, 0x80, 0x70, 0xF0, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xB0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xDC, 0x0F, 0xC0, 0xEE, 0x0E, 0xE0, 0x77, 0x07, 0x30, 0x77, 0x03,
  0x98, 0x3B, 0x81, 0xCC, 0x39, 0xC0, 0xC6, 0x1C, 0xE0, 0xE3, 0x0C, 0x70,
  0x71, 0x8E, 0x70, 0x38, 0xC6, 0x38, 0x1C, 0x67, 0x1C, 0x0C, 0x33, 0x0E,
  0x0E, 0x1B, 0x87, 0x07, 0x0D, 0xC7, 0x03, 0x87, 0xC3, 0x81, 0xC3, 0xE1,
  0xC0, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x60, 0x70, 0x70, 0x70, 0x00, 0x07,
  0x80, 0x70, 0x78, 0x06, 0x07, 0xC0, 0xE0, 0x7C, 0x0E, 0x07, 0xC0, 0xE0,
  0xFC, 0x0E, 0x0E, 0xC1, 0xC0, 0xEC, 0x1C, 0x0E, 0xE1, 0xC1, 0xCE, 0x1C,
  0x1C, 0xE1, 0xC1, 0xCE, 0x38, 0x1C, 0x63, 0x81, 0x86, 0x38, 0x38, 0x73,
  0x83, 0x87, 0x30, 0x38, 0x77, 0x03, 0x87, 0x70, 0x30, 0x37, 0x07, 0x03,
  0x70, 0x70, 0x3E, 0x07, 0x03, 0xE0, 0x70, 0x3E, 0x06, 0x03, 0xE0, 0xE0,
  0x1E, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF0,
  0xE0, 0xF0, 0x70, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0xF0, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01,
  0xC7, 0x01, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x79, 0xF0, 0x1F, 0xF0, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0x1E, 0x07, 0x0E, 0x07, 0x0F,
  0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E,
  0x1C, 0x1C, 0x1C, 0x78, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0xF0, 0xE0, 0xF0, 0x70, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x1C, 0xE0, 0x0E, 0xF0, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03,
  0xCE, 0x01, 0xC7, 0x01, 0xE1, 0xC0, 0xE0, 0xE0, 0xF0, 0x79, 0xF0, 0x1F,
  0xF0, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0x1E, 0x07,
  0x0E, 0x07, 0x0F, 0x0E, 0x07, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x0E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x39,
  0xC0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70,
  0x70, 0x70, 0x70, 0x60, 0x70, 0xE0, 0x70, 0xE0, 0x78, 0x00, 0x78, 0x01,
  0xFF, 0x03, 0xFF, 0x07, 0x86, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x80, 0xF0, 0xFB, 0xE0, 0xFF,
  0xE0, 0x7F, 0x80, 0x7F, 0xFD, 0xFF, 0xE0, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x70,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0x83,
  0xC1, 0xC0, 0xF3, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0xE0, 0x1F, 0xC0,
  0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0x73, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x3C,
  0x07, 0xE0, 0x38, 0x0E, 0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x0E, 0xE0, 0x78,
  0x1C, 0xE0, 0xF8, 0x1C, 0xE0, 0xF8, 0x38, 0xE0, 0xD8, 0x38, 0xE1, 0xD8,
  0x38, 0xE1, 0x98, 0x70, 0xE1, 0x98, 0x70, 0xE3, 0x98, 0xE0, 0xE3, 0x18,
  0xE0, 0xE7, 0x18, 0xE0, 0xE7, 0x19, 0xC0, 0xE6, 0x39, 0xC0, 0xEE, 0x3B,
  0x80, 0xEC, 0x3B, 0x80, 0xFC, 0x3B, 0x80, 0xDC, 0x3F, 0x00, 0xD8, 0x3F,
  0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x06,
  0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x01, 0xD8,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x38, 0x0E, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xE1, 0xC7, 0x0E, 0x38,
  0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x10,
  0x3F, 0x80, 0xFE, 0x00, 0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0x87,
  0x1C, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x61,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x3B, 0x00, 0xE6, 0x01, 0xCE, 0x07, 0x1C, 0x0C, 0x18,
  0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF,
  0xFC, 0xF3, 0x8C, 0x71, 0x84, 0x07, 0xCE, 0x1F, 0xD8, 0x7D, 0xF0, 0xE1,
  0xE3, 0x83, 0xC7, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73,
  0x80, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1,
  0xE1, 0xE7, 0xC1, 0xFB, 0x83, 0xE6, 0x00, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x78,
  0x1F, 0xF8, 0x36, 0x70, 0xF8, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E,
  0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x01, 0xCE, 0x07,
  0x1C, 0x0E, 0x38, 0x38, 0x70, 0x71, 0xF1, 0xC3, 0xBF, 0x06, 0x7C, 0x00,
  0x03, 0xF0, 0xFE, 0x1F, 0x21, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x10, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0xCC,
  0x0F, 0xFC, 0x1F, 0x7C, 0x1C, 0x3C, 0x38, 0x3C, 0x38, 0x38, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70,
  0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xE0, 0xF3, 0xE0, 0x7E, 0xE0,
  0x7C, 0xC0, 0x03, 0xE0, 0x7F, 0x87, 0x9C, 0x38, 0x73, 0x83, 0x1C, 0x19,
  0xC1, 0xCE, 0x1E, 0x73, 0xE7, 0xFE, 0x3F, 0x81, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x86, 0x1F, 0xF0, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xC8, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF3, 0x81, 0xFD, 0x81, 0xF7, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0C, 0x07, 0x0E, 0x03, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x78, 0x1E,
  0x7C, 0x07, 0xEE, 0x03, 0xE6, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x40, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0xF8, 0x3F, 0xF0, 0xFB, 0xC7, 0x87, 0x1E, 0x1C,
  0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8E, 0x0E,
  0x30, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x8E, 0x0E,
  0x38, 0x38, 0x03, 0x03, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x63, 0xC1, 0xC7,
  0x03, 0x9C, 0x07, 0x70, 0x0D, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xEE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x70, 0xE0, 0xC1,
  0xC3, 0x83, 0x87, 0x07, 0x00, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x00, 0x0E, 0xF8, 0xF8, 0x37, 0xF7, 0xE0, 0xFB, 0xFB, 0xC7, 0x87, 0x87,
  0x1E, 0x1C, 0x1C, 0x70, 0x70, 0x61, 0xC1, 0xC3, 0x87, 0x06, 0x0E, 0x38,
  0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x0E, 0x0E, 0x1C, 0x30, 0x70,
  0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x18, 0x70, 0x60, 0xE3,
  0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0x0E, 0xF8, 0x37, 0xF0,
  0xFB, 0xC7, 0x87, 0x1E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x18,
  0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x30, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x1C,
  0x70, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0x03, 0xE0, 0x7F, 0x87, 0x9E,
  0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x9E,
  0x1F, 0xE0, 0x7E, 0x00, 0x03, 0x9E, 0x01, 0xBF, 0x80, 0xD9, 0xC0, 0x78,
  0xF0, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x0E, 0x07, 0x07,
  0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x38, 0x1E, 0x1C, 0x0F, 0x1C, 0x0E, 0xFC, 0x07, 0x7C, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xCE, 0x1F, 0xD8, 0x79, 0xF0,
  0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0,
  0x73, 0x80, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70,
  0xE1, 0xE1, 0xE7, 0xC1, 0xFB, 0x83, 0xE6, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x0C, 0xF0, 0xDF, 0x0D, 0xE1, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xE1, 0xFF, 0x1C, 0x63,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x38, 0x03, 0x8C, 0x78, 0xFF, 0x0F,
  0xE0, 0x06, 0x07, 0x03, 0x01, 0x81, 0xFB, 0xFD, 0xFC, 0x30, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x23, 0xE0, 0xF0, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x06, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x8C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xE1, 0xE3, 0xCF, 0x0F,
  0xEC, 0x1F, 0x30, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C,
  0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0xF0, 0x7E,
  0x0F, 0x0E, 0xE0, 0xF0, 0xEE, 0x1F, 0x0E, 0xE1, 0xF1, 0xCE, 0x3F, 0x1C,
  0xE3, 0x61, 0x8E, 0x36, 0x38, 0xE7, 0x63, 0x8E, 0x66, 0x70, 0xEE, 0x67,
  0x0E, 0xC6, 0x60, 0xEC, 0x6E, 0x0F, 0xC6, 0xE0, 0xF8, 0x6C, 0x0F, 0x87,
  0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x03, 0x38, 0x03, 0xB8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0x60, 0x38, 0x70, 0x70,
  0x70, 0xF0, 0x70, 0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x30, 0x1C, 0x1C,
  0x07, 0x07, 0x01, 0xC3, 0x80, 0x30, 0xE0, 0x0C, 0x70, 0x03, 0x1C, 0x00,
  0xC6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x36,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0x83, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x78, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0F, 0x03, 0xF0, 0x1E, 0x00, 0xF8, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0xF8, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x7E,
  0x03, 0xE0, 0x1C, 0x00, 0x7E, 0x07, 0xFF, 0x3E, 0x3F, 0xE0, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 26, 9, 0, -26 },
  { 31, 10, 9, 13, 4, -26 },
  { 43, 17, 26, 16, 0, -26 },
  { 99, 15, 30, 14, 0, -28 },
  { 156, 19, 27, 23, 2, -27 },
  { 221, 15, 27, 16, 0, -27 },
  { 272, 5, 9, 7, 4, -26 },
  { 278, 11, 33, 10, 1, -27 },
  { 324, 11, 33, 10, -3, -27 },
  { 370, 11, 12, 13, 4, -28 },
  { 387, 14, 18, 16, 1, -22 },
  { 419, 7, 9, 7, -2, -4 },
  { 427, 8, 2, 10, 1, -11 },
  { 429, 4, 4, 7, 0, -4 },
  { 431, 17, 27, 12, -2, -27 },
  { 489, 13, 27, 14, 1, -27 },
  { 533, 9, 26, 14, 4, -26 },
  { 563, 16, 27, 14, -1, -27 },
  { 617, 16, 27, 14, -1, -27 },
  { 671, 16, 27, 14, -1, -27 },
  { 725, 15, 26, 14, 0, -26 },
  { 774, 14, 27, 14, 1, -27 },
  { 822, 15, 26, 14, 1, -26 },
  { 871, 15, 27, 14, 0, -27 },
  { 922, 14, 27, 14, 0, -27 },
  { 970, 7, 20, 8, 0, -20 },
  { 988, 10, 25, 8, -2, -20 },
  { 1020, 14, 16, 16, 1, -21 },
  { 1048, 14, 10, 16, 1, -18 },
  { 1066, 14, 16, 16, 1, -21 },
  { 1094, 11, 27, 11, 1, -27 },
  { 1132, 20, 30, 22, 1, -27 },
  { 1207, 15, 27, 15, -2, -27 },
  { 1258, 16, 26, 16, 0, -26 },
  { 1310, 16, 27, 14, 1, -27 },
  { 1364, 17, 26, 17, 0, -26 },
  { 1420, 15, 26, 14, 0, -26 },
  { 1469, 15, 26, 13, 0, -26 },
  { 1518, 18, 27, 18, 1, -27 },
  { 1579, 19, 26, 18, 0, -26 },
  { 1641, 14, 26, 10, -2, -26 },
  { 1687, 14, 33, 7, -5, -26 },
  { 1745, 18, 26, 15, 0, -26 },
  { 1804, 10, 26, 12, 0, -26 },
  { 1837, 25, 26, 24, 0, -26 },
  { 1919, 20, 26, 19, 0, -26 },
  { 1984, 17, 27, 18, 1, -27 },
  { 2042, 16, 26, 15, 0, -26 },
  { 2094, 17, 33, 18, 1, -27 },
  { 2165, 16, 26, 15, 0, -26 },
  { 2217, 16, 27, 14, -1, -27 },
  { 2271, 14, 26, 13, 2, -26 },
  { 2317, 17, 26, 17, 1, -26 },
  { 2373, 15, 26, 15, 3, -26 },
  { 2422, 24, 26, 24, 3, -26 },
  { 2500, 18, 26, 14, -2, -26 },
  { 2559, 13, 26, 13, 3, -26 },
  { 2602, 17, 26, 12, -2, -26 },
  { 2658, 14, 33, 10, -1, -27 },
  { 2716, 6, 27, 13, 4, -27 },
  { 2737, 13, 33, 10, -2, -27 },
  { 2791, 15, 14, 15, 0, -26 },
  { 2818, 11, 2, 11, -3, 3 },
  { 2821, 5, 6, 9, 5, -28 },
  { 2825, 15, 20, 16, 1, -20 },
  { 2863, 15, 28, 15, 0, -28 },
  { 2916, 12, 20, 12, 1, -20 },
  { 2946, 16, 28, 16, 1, -28 },
  { 3002, 13, 20, 14, 1, -20 },
  { 3035, 18, 37, 9, -5, -28 },
  { 3119, 17, 29, 16, -1, -20 },
  { 3181, 14, 28, 15, 0, -28 },
  { 3230, 9, 27, 7, 0, -27 },
  { 3261, 14, 36, 7, -5, -27 },
  { 3324, 15, 28, 13, 0, -28 },
  { 3377, 9, 28, 7, 0, -28 },
  { 3409, 22, 20, 23, 0, -20 },
  { 3464, 14, 20, 15, 0, -20 },
  { 3499, 13, 20, 15, 1, -20 },
  { 3532, 17, 29, 15, -2, -20 },
  { 3594, 15, 29, 16, 1, -20 },
  { 3649, 12, 20, 10, 0, -20 },
  { 3679, 12, 20, 12, 0, -20 },
  { 3709, 9, 24, 9, 1, -24 },
  { 3736, 14, 20, 15, 1, -20 },
  { 3771, 12, 20, 12, 2, -20 },
  { 3801, 20, 20, 20, 2, -20 },
  { 3851, 16, 20, 13, -2, -20 },
  { 3891, 18, 29, 13, -3, -20 },
  { 3957, 13, 20, 10, -1, -20 },
  { 3990, 13, 32, 12, 1, -26 },
  { 4042, 3, 37, 14, 5, -28 },
  { 4056, 13, 32, 12, -2, -26 },
  { 4108, 14, 4, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Italic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC37PT7B_H_
