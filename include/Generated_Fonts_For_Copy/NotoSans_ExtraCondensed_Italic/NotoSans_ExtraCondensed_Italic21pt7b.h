#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x21, 0x18, 0x00, 0x63, 0x00, 0x6D,
  0x34, 0xB2, 0xD8, 0x04, 0x86, 0xC2, 0x41, 0x23, 0xFB, 0xFC, 0x48, 0x64,
  0x26, 0x7F, 0x99, 0x09, 0x84, 0x82, 0x43, 0x60, 0x02, 0x02, 0x07, 0xE6,
  0xA2, 0x41, 0x40, 0xE0, 0x70, 0x1C, 0x07, 0x05, 0x82, 0x41, 0x66, 0xE3,
  0xE0, 0x40, 0x20, 0x00, 0x38, 0xCD, 0x11, 0x26, 0x24, 0x8C, 0xB1, 0x34,
  0x25, 0xBC, 0xA9, 0xED, 0x21, 0x64, 0x69, 0x89, 0x33, 0x24, 0x45, 0x98,
  0xE0, 0x0E, 0x0D, 0x84, 0xC2, 0x41, 0x60, 0xA0, 0x70, 0x70, 0x69, 0xA6,
  0xB3, 0xD8, 0xCC, 0x66, 0x71, 0xCC, 0x69, 0x6C, 0x06, 0x18, 0x60, 0x83,
  0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC0,
  0x0C, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0x83,
  0x06, 0x18, 0x21, 0xC0, 0x10, 0x4D, 0x4F, 0x33, 0x24, 0x80, 0x10, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x36, 0x64, 0x80, 0xF8,
  0xF0, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x0E, 0x1B, 0x11, 0x31,
  0x21, 0x63, 0x63, 0x63, 0x43, 0x42, 0x46, 0xC6, 0x4C, 0x6C, 0x78, 0x19,
  0xDF, 0xB1, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x00, 0x0F, 0x0C, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03,
  0x03, 0xF8, 0x1E, 0x33, 0x01, 0x01, 0x03, 0x02, 0x0C, 0x3C, 0x06, 0x06,
  0x06, 0x06, 0x04, 0x9C, 0xF8, 0x03, 0x03, 0x07, 0x0F, 0x0A, 0x12, 0x36,
  0x26, 0x46, 0xC4, 0xFF, 0xFE, 0x0C, 0x08, 0x18, 0x1F, 0x1F, 0x10, 0x30,
  0x30, 0x20, 0x7C, 0x46, 0x06, 0x06, 0x06, 0x06, 0x06, 0x9C, 0xF8, 0x0F,
  0x19, 0x30, 0x60, 0x40, 0x40, 0xFC, 0xC4, 0xC6, 0x84, 0x84, 0x8C, 0x8C,
  0xD8, 0xF0, 0x7F, 0x7F, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0xC0, 0x1F, 0x33, 0x31, 0x31, 0x33, 0x32, 0x1C,
  0x1C, 0x64, 0xC6, 0xC6, 0x86, 0xC6, 0xCC, 0x78, 0x1E, 0x3B, 0x33, 0x21,
  0x63, 0x63, 0x63, 0x67, 0x3A, 0x02, 0x06, 0x04, 0x0C, 0x98, 0xF0, 0x33,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x11, 0x18,
  0x84, 0x40, 0x03, 0x07, 0x1C, 0x70, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x0E, 0x38,
  0xE0, 0x80, 0x3C, 0x4C, 0x18, 0x30, 0x41, 0x86, 0x18, 0x20, 0x41, 0x80,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0xC0, 0xC2, 0x18, 0x31, 0x01, 0x23, 0x92,
  0x49, 0x6C, 0x94, 0x99, 0x49, 0x34, 0x92, 0x4B, 0x2C, 0xFC, 0x4C, 0x84,
  0x00, 0x40, 0x03, 0x20, 0x1C, 0x00, 0x03, 0x07, 0x05, 0x0D, 0x0D, 0x09,
  0x1B, 0x13, 0x33, 0x3F, 0x23, 0x63, 0x43, 0xC3, 0xC3, 0x1F, 0x0D, 0xC4,
  0x66, 0x33, 0x19, 0x8C, 0xFC, 0x7C, 0x63, 0x31, 0x98, 0xC8, 0x64, 0x66,
  0x73, 0xF0, 0x0F, 0x8C, 0x8C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0x21, 0xE0, 0x1F, 0x0F, 0xC4, 0x66, 0x13,
  0x09, 0x84, 0x82, 0x43, 0x61, 0xB0, 0xD8, 0xC8, 0x64, 0x67, 0xE3, 0xE0,
  0x1F, 0x8F, 0x84, 0x06, 0x03, 0x01, 0x80, 0xF8, 0x7C, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x84, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x7C, 0x7E, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x00, 0x0F, 0xC6,
  0x23, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x1E, 0xC7, 0x30, 0xCC, 0x33,
  0x0C, 0xC2, 0x39, 0x87, 0xE0, 0x18, 0x63, 0x08, 0x43, 0x18, 0x63, 0x0C,
  0x61, 0x0F, 0xE1, 0xFC, 0x61, 0x8C, 0x31, 0x84, 0x21, 0x84, 0x31, 0x86,
  0x30, 0xC0, 0x1F, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0xF0, 0xE0,
  0x18, 0xC6, 0x61, 0x10, 0xCC, 0x36, 0x0D, 0x02, 0xC0, 0xF0, 0x7C, 0x1B,
  0x06, 0xC1, 0x10, 0x46, 0x31, 0x8C, 0x60, 0x18, 0x61, 0x0C, 0x30, 0xC2,
  0x08, 0x61, 0x86, 0x10, 0x43, 0xFF, 0x80, 0x1C, 0x1C, 0x70, 0x71, 0xC3,
  0xCF, 0x0E, 0x3C, 0x38, 0xF1, 0xE2, 0xC5, 0x8B, 0x34, 0x6C, 0x91, 0xB6,
  0xC6, 0xD3, 0x13, 0xCC, 0x4E, 0x23, 0x18, 0x8C, 0x66, 0x00, 0x18, 0x23,
  0x0C, 0x71, 0x9E, 0x33, 0xC4, 0x69, 0x89, 0x31, 0x26, 0x66, 0x8C, 0xD1,
  0x9E, 0x21, 0xC4, 0x39, 0x86, 0x30, 0xC0, 0x0F, 0x0D, 0xCC, 0x6C, 0x36,
  0x1A, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xA0, 0xD8, 0x6C, 0x66, 0x61, 0xE0,
  0x1F, 0x0F, 0x84, 0x66, 0x33, 0x19, 0x8C, 0x8C, 0x4E, 0x7C, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x00, 0x0F, 0x0D, 0xCC, 0x6C, 0x36, 0x1A, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xA0, 0xD8, 0x6C, 0x66, 0x61, 0xE0, 0x30, 0x18,
  0x06, 0x03, 0x00, 0x1F, 0x0F, 0x84, 0x66, 0x33, 0x19, 0x8C, 0x8C, 0x7C,
  0x7C, 0x36, 0x1B, 0x08, 0x84, 0x66, 0x33, 0x18, 0x1F, 0x9C, 0x8C, 0x04,
  0x02, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x44, 0xE3,
  0xE0, 0x7F, 0x7F, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x60, 0x60, 0x40, 0xC0, 0x30, 0x90, 0xC8, 0x6C, 0x36, 0x13, 0x09, 0x0C,
  0x86, 0xC3, 0x61, 0x30, 0x90, 0xC8, 0x66, 0x61, 0xE0, 0xC3, 0xC3, 0xC6,
  0x86, 0x84, 0x8C, 0x88, 0x98, 0x98, 0xB0, 0xB0, 0xA0, 0xE0, 0xC0, 0xC0,
  0x41, 0x0D, 0x0C, 0x34, 0x30, 0x91, 0xC6, 0x47, 0x19, 0x14, 0x44, 0xD3,
  0x12, 0x48, 0x49, 0x61, 0x65, 0x85, 0x14, 0x1C, 0x70, 0x61, 0x81, 0x8E,
  0x0E, 0x38, 0x00, 0x18, 0xC6, 0x20, 0x98, 0x24, 0x0F, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x03, 0x60, 0x98, 0x66, 0x11, 0x8C, 0x60, 0xC7, 0x8B,
  0x36, 0x4D, 0x9A, 0x3C, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x00,
  0x1F, 0x8F, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C,
  0x04, 0x06, 0x03, 0xF3, 0xF0, 0x0F, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0xF8, 0xCC,
  0xC4, 0x44, 0x46, 0x66, 0x62, 0x22, 0x30, 0x1F, 0x02, 0x06, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30,
  0xF0, 0x04, 0x0E, 0x0E, 0x1A, 0x32, 0x23, 0x63, 0xC1, 0xFE, 0xC9, 0x80,
  0x3F, 0x66, 0x46, 0xC6, 0xC6, 0x86, 0x84, 0x8C, 0x8C, 0xDC, 0xEC, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x3F, 0x33, 0x31, 0x21, 0x63, 0x63, 0x63, 0x42,
  0x46, 0xEC, 0xBC, 0x3D, 0x84, 0x30, 0xC2, 0x08, 0x20, 0x83, 0x4F, 0x00,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x87, 0xE3, 0x30, 0x8C, 0x63, 0x18,
  0xC4, 0x31, 0x08, 0x46, 0x31, 0x86, 0xE1, 0xD8, 0x1E, 0x33, 0x23, 0x62,
  0x6E, 0x78, 0x40, 0xC0, 0x40, 0x64, 0x7C, 0x01, 0xC0, 0xD0, 0x30, 0x08,
  0x02, 0x03, 0xE0, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x02, 0xC0, 0xE0, 0x00, 0x1F, 0x99,
  0x88, 0xCC, 0x66, 0x32, 0x19, 0x08, 0x8C, 0xC6, 0x37, 0x1D, 0x80, 0x80,
  0xC0, 0x62, 0x61, 0xE0, 0x18, 0x18, 0x10, 0x10, 0x30, 0x3F, 0x33, 0x33,
  0x23, 0x63, 0x62, 0x62, 0x46, 0x46, 0xC6, 0xC4, 0x18, 0x80, 0x03, 0x18,
  0x84, 0x63, 0x18, 0x84, 0x63, 0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x06,
  0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30,
  0xB0, 0xE0, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x09, 0x98, 0xD8, 0x48, 0x2C,
  0x3C, 0x1E, 0x0D, 0x84, 0xC2, 0x63, 0x31, 0x88, 0x18, 0xC4, 0x23, 0x18,
  0xC4, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x3F, 0xF3, 0x39, 0x33, 0x12, 0x33,
  0x62, 0x36, 0x23, 0x66, 0x24, 0x62, 0x46, 0x6C, 0x46, 0xCC, 0x60, 0x3F,
  0x33, 0x33, 0x23, 0x63, 0x62, 0x62, 0x46, 0x46, 0xC6, 0xC4, 0x3C, 0xCD,
  0x1E, 0x3C, 0x70, 0xE1, 0xC2, 0x8D, 0xB3, 0xC0, 0x1F, 0x8C, 0xC6, 0x22,
  0x13, 0x09, 0x8C, 0xC6, 0x42, 0x23, 0x3B, 0x1F, 0x8C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x1F, 0x99, 0x88, 0xCC, 0x66, 0x32, 0x19, 0x08, 0x8C, 0xC6,
  0x37, 0x1D, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x3E, 0x50, 0xC1, 0x06,
  0x0C, 0x18, 0x20, 0x41, 0x83, 0x00, 0x3E, 0xC5, 0x83, 0x03, 0x07, 0x06,
  0x04, 0x09, 0x33, 0xC0, 0x18, 0x41, 0x1F, 0x30, 0x82, 0x18, 0x61, 0x84,
  0x10, 0xC1, 0xC0, 0x63, 0x62, 0x46, 0x46, 0xC6, 0xC4, 0xC4, 0x8C, 0x8C,
  0x9C, 0xE8, 0xC7, 0x8B, 0x36, 0x4D, 0x9B, 0x34, 0x78, 0xE1, 0xC3, 0x00,
  0xC6, 0x79, 0xCF, 0x39, 0x6F, 0x6D, 0x69, 0xAD, 0x3D, 0xE7, 0x28, 0xE7,
  0x1C, 0xC3, 0x18, 0x00, 0x11, 0x8D, 0x86, 0x83, 0xC0, 0xC0, 0xE0, 0x70,
  0x78, 0x24, 0x32, 0x31, 0x80, 0x18, 0xC6, 0x21, 0x98, 0x66, 0x19, 0x06,
  0xC0, 0xA0, 0x38, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x0B, 0x03,
  0x80, 0x1F, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0x44, 0xF8,
  0x03, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x70, 0xE0, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1C, 0x18, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x60, 0xC1, 0x02,
  0x0C, 0x18, 0x61, 0xC0, 0x61, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 15, 5, 0, -15 },
  { 11, 6, 5, 7, 2, -15 },
  { 15, 9, 15, 9, 0, -15 },
  { 32, 9, 17, 8, 0, -16 },
  { 52, 11, 15, 13, 1, -15 },
  { 73, 9, 15, 9, 0, -15 },
  { 90, 3, 5, 4, 2, -15 },
  { 92, 7, 18, 5, 0, -15 },
  { 108, 7, 18, 5, -2, -15 },
  { 124, 6, 7, 8, 2, -16 },
  { 130, 8, 10, 9, 1, -12 },
  { 140, 4, 5, 4, -1, -2 },
  { 143, 5, 1, 5, 0, -6 },
  { 144, 2, 2, 4, 0, -2 },
  { 145, 10, 15, 7, -1, -15 },
  { 164, 8, 15, 8, 0, -15 },
  { 179, 5, 15, 8, 2, -15 },
  { 189, 9, 15, 8, -1, -15 },
  { 206, 8, 15, 8, 0, -15 },
  { 221, 8, 15, 8, 0, -15 },
  { 236, 8, 15, 8, 0, -15 },
  { 251, 8, 15, 8, 1, -15 },
  { 266, 8, 15, 8, 1, -15 },
  { 281, 8, 15, 8, 0, -15 },
  { 296, 8, 15, 8, 0, -15 },
  { 311, 4, 11, 4, 0, -11 },
  { 317, 5, 14, 4, -1, -11 },
  { 326, 8, 9, 9, 1, -12 },
  { 335, 8, 6, 9, 1, -10 },
  { 341, 8, 9, 9, 1, -12 },
  { 350, 7, 15, 6, 0, -15 },
  { 364, 12, 17, 12, 0, -15 },
  { 390, 8, 15, 8, -1, -15 },
  { 405, 9, 15, 9, 0, -15 },
  { 422, 9, 15, 8, 1, -15 },
  { 439, 9, 15, 10, 0, -15 },
  { 456, 9, 15, 8, 0, -15 },
  { 473, 9, 15, 7, 0, -15 },
  { 490, 10, 15, 10, 1, -15 },
  { 509, 11, 15, 10, 0, -15 },
  { 530, 8, 15, 5, -1, -15 },
  { 545, 8, 19, 4, -3, -15 },
  { 564, 10, 15, 9, 0, -15 },
  { 583, 6, 15, 7, 0, -15 },
  { 595, 14, 15, 14, 0, -15 },
  { 622, 11, 15, 11, 0, -15 },
  { 643, 9, 15, 10, 1, -15 },
  { 660, 9, 15, 8, 0, -15 },
  { 677, 9, 19, 10, 1, -15 },
  { 699, 9, 15, 9, 0, -15 },
  { 716, 9, 15, 8, 0, -15 },
  { 733, 8, 15, 7, 1, -15 },
  { 748, 9, 15, 10, 1, -15 },
  { 765, 8, 15, 8, 2, -15 },
  { 780, 14, 15, 14, 1, -15 },
  { 807, 10, 15, 8, -1, -15 },
  { 826, 7, 15, 7, 2, -15 },
  { 840, 9, 15, 7, -1, -15 },
  { 857, 8, 18, 6, -1, -15 },
  { 875, 4, 15, 7, 2, -15 },
  { 883, 8, 18, 6, -1, -15 },
  { 901, 8, 8, 8, 0, -15 },
  { 909, 7, 1, 6, -2, 2 },
  { 910, 3, 3, 5, 3, -16 },
  { 912, 8, 11, 9, 1, -11 },
  { 923, 8, 16, 9, 0, -16 },
  { 939, 6, 11, 7, 1, -11 },
  { 948, 10, 16, 9, 0, -16 },
  { 968, 8, 11, 8, 0, -11 },
  { 979, 10, 21, 5, -3, -16 },
  { 1006, 9, 16, 9, 0, -11 },
  { 1024, 8, 16, 9, 0, -16 },
  { 1040, 5, 15, 4, 0, -15 },
  { 1050, 8, 20, 4, -3, -15 },
  { 1070, 9, 16, 8, 0, -16 },
  { 1088, 5, 16, 4, 0, -16 },
  { 1098, 12, 11, 13, 0, -11 },
  { 1115, 8, 11, 9, 0, -11 },
  { 1126, 7, 11, 9, 1, -11 },
  { 1136, 9, 16, 9, -1, -11 },
  { 1154, 9, 16, 9, 0, -11 },
  { 1172, 7, 11, 6, 0, -11 },
  { 1182, 7, 11, 7, 0, -11 },
  { 1192, 6, 14, 5, 0, -14 },
  { 1203, 8, 11, 9, 1, -11 },
  { 1214, 7, 11, 7, 1, -11 },
  { 1224, 11, 11, 11, 1, -11 },
  { 1240, 9, 11, 7, -1, -11 },
  { 1253, 10, 16, 7, -2, -11 },
  { 1273, 8, 11, 6, -1, -11 },
  { 1284, 8, 18, 7, 0, -15 },
  { 1302, 2, 21, 8, 3, -16 },
  { 1308, 7, 18, 7, -1, -15 },
  { 1324, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Italic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC21PT7B_H_
