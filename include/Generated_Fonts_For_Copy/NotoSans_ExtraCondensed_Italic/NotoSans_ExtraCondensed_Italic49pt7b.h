#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x7C, 0xF1, 0xE7, 0x87, 0x9E,
  0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x0F, 0x1C, 0x3C, 0xF0, 0xE3, 0xC3, 0x8E,
  0x0E, 0x38, 0x70, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1C,
  0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7C, 0xCE, 0x07, 0x98, 0x20, 0x71, 0x80, 0x0F, 0x18, 0x00, 0xF1, 0x80,
  0x0F, 0x18, 0x00, 0xF3, 0x00, 0x0F, 0x30, 0x00, 0x7B, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xCF, 0x00, 0x0C, 0xF0, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x00,
  0xC7, 0x00, 0x18, 0x70, 0x01, 0x8F, 0x08, 0x18, 0xF0, 0xE1, 0x9E, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0xE0,
  0x0F, 0x01, 0xFC, 0x03, 0x80, 0xF7, 0x01, 0xE0, 0x71, 0xC0, 0x70, 0x1C,
  0x70, 0x3C, 0x0E, 0x1E, 0x0E, 0x03, 0x87, 0x07, 0x00, 0xE1, 0xC1, 0xC0,
  0x70, 0x70, 0xE0, 0x1C, 0x1C, 0x38, 0x07, 0x07, 0x1C, 0x01, 0xC1, 0xC7,
  0x00, 0x70, 0xE3, 0x80, 0x3C, 0x38, 0xE0, 0x0E, 0x0E, 0x71, 0xFB, 0x87,
  0x1C, 0xFE, 0xE1, 0xCE, 0x3B, 0xFC, 0xF3, 0x9C, 0x77, 0x79, 0xCE, 0x1D,
  0xFC, 0x73, 0x87, 0x3E, 0x38, 0xE1, 0xC0, 0x0E, 0x70, 0x70, 0x07, 0x1C,
  0x1C, 0x03, 0xC7, 0x07, 0x00, 0xE1, 0xC3, 0xC0, 0x78, 0xE0, 0xE0, 0x1C,
  0x38, 0x38, 0x0F, 0x0E, 0x0E, 0x03, 0x83, 0x87, 0x01, 0xE0, 0xE1, 0xC0,
  0x70, 0x38, 0x70, 0x3C, 0x0E, 0x38, 0x0E, 0x03, 0xDE, 0x07, 0x00, 0x7F,
  0x01, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38,
  0x03, 0xC3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xDE,
  0x00, 0x3D, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x71, 0xEF, 0x0F, 0x3C, 0x78, 0xF3, 0xC7, 0x8E, 0x78,
  0x79, 0xE7, 0x83, 0xDE, 0xF0, 0x3F, 0xCF, 0x03, 0xFC, 0xF0, 0x1F, 0x8F,
  0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x8F, 0xF8,
  0xFF, 0xF7, 0x87, 0xFE, 0x78, 0x3F, 0x87, 0xC0, 0x3C, 0xF3, 0xDE, 0x79,
  0xE7, 0x9C, 0x71, 0xCF, 0x38, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x02, 0x1C, 0x06, 0x38, 0x1F, 0x71, 0xBF,
  0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x1F, 0x00, 0x7F, 0x01, 0xEF, 0x07, 0x8E,
  0x0E, 0x1E, 0x0C, 0x1C, 0x00, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x0F,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFB,
  0xFF, 0x7F, 0xE0, 0x37, 0xBF, 0xFF, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x1F, 0xF8, 0x0F, 0x9F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0E, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x70, 0x07, 0x1C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x81, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE,
  0x7D, 0xEF, 0x9E, 0x71, 0xE6, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xE1, 0xF0, 0x0C, 0x07, 0x80, 0x40, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1C, 0x1F, 0x01, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x80, 0x3E, 0x0E, 0x07, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0x70,
  0x00, 0x3F, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x01, 0xCE, 0x00, 0x1E,
  0xF0, 0x00, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x80, 0x38, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0E,
  0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0E, 0x01, 0xC0, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x98, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x20, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x82, 0x00,
  0x78, 0x1C, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7C, 0x10, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0xF8, 0x0F, 0x7F, 0x81,
  0xDF, 0xF8, 0x7F, 0x9F, 0x0F, 0xC1, 0xE1, 0xF0, 0x3C, 0x3E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x1E,
  0x0F, 0x03, 0xC3, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3C, 0x1E, 0x07, 0x81,
  0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x1E, 0x07, 0x01, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x7C, 0xF8, 0x03,
  0xDF, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01,
  0xF3, 0xE0, 0x3E, 0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x70, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01,
  0xF1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC1, 0xF8, 0x7E,
  0xFF, 0x07, 0xFD, 0xE0, 0xFF, 0x38, 0x0F, 0xCF, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x04, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x61, 0xF0, 0x81, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x38, 0x1F, 0xE3, 0x87, 0x07, 0xFC, 0x71,
  0xC1, 0xC7, 0x0E, 0x38, 0x70, 0xE1, 0xCE, 0x0E, 0x1C, 0x39, 0xC3, 0x83,
  0x87, 0x38, 0x70, 0xE0, 0xEE, 0x1C, 0x1C, 0x19, 0xC3, 0x83, 0x87, 0x38,
  0x70, 0xF0, 0xE7, 0x0E, 0x1C, 0x1C, 0xE3, 0x83, 0x83, 0x38, 0x70, 0x70,
  0xE7, 0x0E, 0x1E, 0x1C, 0xE1, 0xC3, 0xC7, 0x1C, 0x38, 0xF8, 0xE3, 0x87,
  0xBF, 0x38, 0x70, 0x7E, 0x7E, 0x0E, 0x0F, 0x8F, 0x81, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0E,
  0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xC7, 0xF0, 0x3C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x87,
  0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x87, 0x80, 0x7C, 0x3C, 0x07, 0xC1, 0xE0, 0x7E, 0x0F, 0x1F, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0x86, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x18, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x7C,
  0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x78,
  0x07, 0x81, 0xE0, 0x3E, 0x07, 0x83, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0x83, 0xC0, 0x7C, 0x01, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xC7, 0x80, 0x7F,
  0x8F, 0x01, 0xFF, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3E, 0x01, 0xC0, 0x7E,
  0x07, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x05, 0xFE, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x8F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xC1,
  0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x8F,
  0x80, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0x70, 0x01, 0xFC, 0x03, 0xB8, 0x01, 0xFE, 0x03,
  0xDC, 0x00, 0xEF, 0x01, 0xEE, 0x00, 0xF7, 0x80, 0xF7, 0x00, 0x77, 0x80,
  0x7B, 0x80, 0x7B, 0xC0, 0x39, 0xC0, 0x39, 0xE0, 0x3C, 0xE0, 0x3C, 0xF0,
  0x1E, 0x70, 0x1E, 0x70, 0x0F, 0x38, 0x1E, 0x78, 0x07, 0x1E, 0x0F, 0x3C,
  0x07, 0x8F, 0x07, 0x1E, 0x03, 0xC7, 0x87, 0x8F, 0x01, 0xE3, 0xC3, 0x87,
  0x00, 0xF1, 0xE3, 0xC7, 0x80, 0x70, 0xF1, 0xC3, 0xC0, 0x78, 0x79, 0xE1,
  0xE0, 0x3C, 0x3C, 0xE0, 0xF0, 0x1E, 0x1E, 0xF0, 0xF0, 0x0F, 0x0F, 0x78,
  0x78, 0x07, 0x07, 0xB8, 0x3C, 0x07, 0x83, 0xFC, 0x1E, 0x03, 0xC0, 0xFC,
  0x0F, 0x01, 0xE0, 0x7E, 0x0F, 0x00, 0xE0, 0x3E, 0x07, 0x80, 0x70, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xE0, 0x0F,
  0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x0E, 0xE0,
  0x1E, 0x03, 0xB8, 0x07, 0x01, 0xEF, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x1E,
  0xF0, 0x3C, 0x07, 0x1C, 0x0F, 0x01, 0xC7, 0x03, 0x80, 0xF1, 0xC1, 0xE0,
  0x3C, 0x78, 0x78, 0x0F, 0x1E, 0x1E, 0x03, 0x87, 0x87, 0x81, 0xE0, 0xE1,
  0xC0, 0x78, 0x38, 0xF0, 0x1E, 0x0E, 0x3C, 0x07, 0x83, 0xCF, 0x01, 0xC0,
  0xF3, 0x80, 0xF0, 0x3C, 0xE0, 0x3C, 0x07, 0x78, 0x0F, 0x01, 0xDE, 0x03,
  0xC0, 0x77, 0x80, 0xE0, 0x1F, 0xC0, 0x78, 0x07, 0xF0, 0x1E, 0x01, 0xFC,
  0x07, 0x80, 0x3F, 0x01, 0xE0, 0x0F, 0xC0, 0x70, 0x03, 0xE0, 0x3C, 0x00,
  0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFC, 0x7E, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0xCF,
  0x00, 0x1F, 0x3C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07,
  0x83, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x7C,
  0x0F, 0x07, 0xC0, 0x78, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFC,
  0x7E, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1F, 0x3C,
  0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x7B, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x3E,
  0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x0F, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x70, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xE0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF1, 0xE0, 0x3E, 0x01, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x83, 0x00, 0xFC, 0x1E, 0x1F, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01,
  0xE0, 0x3E, 0x1F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xBC, 0x00, 0xF0,
  0x07, 0x9E, 0x00, 0xF8, 0x03, 0xCF, 0x00, 0x7C, 0x03, 0xE7, 0x80, 0x3E,
  0x01, 0xE3, 0xC0, 0x3F, 0x00, 0xF1, 0xE0, 0x1F, 0x80, 0xF0, 0xF0, 0x1F,
  0xC0, 0x78, 0x78, 0x0F, 0xE0, 0x3C, 0x3C, 0x07, 0xF0, 0x3C, 0x1E, 0x07,
  0x78, 0x1E, 0x0F, 0x03, 0xB8, 0x1E, 0x07, 0x83, 0xDC, 0x0F, 0x03, 0xC1,
  0xCE, 0x07, 0x81, 0xE0, 0xE7, 0x07, 0x80, 0xF0, 0xF3, 0x83, 0xC0, 0x78,
  0x71, 0xC3, 0xC0, 0x3C, 0x78, 0xE1, 0xE0, 0x1E, 0x38, 0x70, 0xF0, 0x0F,
  0x1C, 0x38, 0xF0, 0x07, 0x9E, 0x1C, 0x78, 0x03, 0x8E, 0x0E, 0x78, 0x01,
  0xCF, 0x07, 0x3C, 0x00, 0xE7, 0x83, 0x9E, 0x00, 0x73, 0x81, 0xDE, 0x00,
  0x3B, 0xC0, 0xEF, 0x00, 0x1D, 0xC0, 0x77, 0x00, 0x0E, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1C,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0xF1, 0xC0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x79,
  0xE0, 0x0E, 0x78, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1E, 0xE0, 0x0F, 0x38, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x70,
  0x70, 0x3C, 0x1C, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x39, 0xE0, 0x0F,
  0x78, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0x83, 0x80, 0x00, 0x70, 0x00, 0x1F,
  0xCF, 0x03, 0xFE, 0xE0, 0x7F, 0xFE, 0x0F, 0x87, 0xE0, 0xF0, 0x3E, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7,
  0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E,
  0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x87, 0xE0, 0x7F, 0xDE, 0x07, 0xFD,
  0xC0, 0x3F, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x1C, 0x03, 0xCF, 0xE0, 0x7B, 0xFC, 0x0F,
  0xFF, 0xC1, 0xF8, 0x78, 0x7E, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0,
  0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0xC7,
  0xC3, 0xDF, 0xF0, 0x7B, 0xFC, 0x0E, 0x3F, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x82, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x20, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x0F, 0x00, 0x7F, 0x38, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xF8, 0x7E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1,
  0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xC0,
  0x1C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE1, 0xF8, 0x07,
  0xFD, 0xE0, 0x1F, 0xE7, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x9E, 0x07, 0xCF, 0x07, 0xC7, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x10, 0x7F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x04, 0x01, 0xFC, 0xE0, 0x0F, 0xFB, 0x80,
  0x7F, 0xEE, 0x03, 0xE1, 0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x38,
  0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x00, 0x70, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0x8F, 0xE0, 0x1F, 0xF7, 0x80,
  0x7F, 0xDC, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x0C, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x3C, 0x03, 0xCF, 0xE0, 0x7B, 0xFC, 0x0F, 0xFF,
  0xC1, 0xF0, 0xF8, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C,
  0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70,
  0x70, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC1,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x10, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0x78, 0x3C, 0x07, 0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0,
  0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x0E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xF7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0x83, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78,
  0x3C, 0x07, 0x83, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x3D, 0xFC, 0x7F, 0x81, 0xDF, 0xF7, 0xFC, 0x0E, 0xFF, 0xBF, 0xF0, 0x7C,
  0x3F, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x3E, 0x07, 0x81, 0xE1, 0xE0, 0x3C,
  0x0E, 0x0F, 0x03, 0xC0, 0x70, 0x78, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C,
  0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x38, 0x0E, 0x0F, 0x03, 0xC0, 0xF0, 0x70,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x01, 0xE1, 0xE0, 0x78,
  0x0E, 0x0F, 0x03, 0xC0, 0xF0, 0x70, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C,
  0x3C, 0x07, 0x01, 0xE1, 0xE0, 0x78, 0x0E, 0x0F, 0x03, 0xC0, 0xF0, 0xF0,
  0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0xF3, 0xF0, 0x1D, 0xFF, 0x03, 0xBF, 0xF0, 0x7E, 0x3E, 0x0F, 0x83,
  0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C, 0x1C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x83, 0xC1, 0xE1, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x3F, 0x80, 0x7B, 0xFC,
  0x03, 0xBF, 0xF0, 0x1F, 0x87, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0x7C,
  0x07, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x1E, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x83, 0xC0, 0x38, 0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x0F,
  0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xF1, 0xF0, 0x1D, 0xFF, 0x01, 0xEF, 0xF0,
  0x0F, 0x3F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x10, 0x1F,
  0xCE, 0x03, 0xFE, 0xE0, 0x7F, 0xFE, 0x0F, 0x87, 0xE0, 0xF0, 0x3E, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7,
  0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x70,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E,
  0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x87, 0xE0, 0x7F, 0xDE, 0x07, 0xFD,
  0xC0, 0x3F, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x07, 0x3F, 0x07, 0x3E, 0x07, 0x7E, 0x07, 0xF2, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0xF8, 0x10, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC2, 0x01, 0xE1, 0xC1, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x00, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x1F,
  0xF3, 0xFF, 0x3F, 0xF0, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xF0, 0x7F,
  0x07, 0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C, 0x1C, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x70, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3E, 0x3F, 0x07, 0xFE, 0xE0, 0x7F,
  0x9C, 0x07, 0xE7, 0x80, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xC0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0x80,
  0xF7, 0x80, 0xF7, 0x00, 0xEF, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xFC,
  0x0F, 0x81, 0xEF, 0x03, 0xE0, 0x7B, 0xC1, 0xF8, 0x1C, 0xF0, 0x7E, 0x0F,
  0x3C, 0x1F, 0x83, 0xCF, 0x0E, 0xE0, 0xE3, 0xC3, 0xB8, 0x78, 0xF1, 0xEE,
  0x1C, 0x3C, 0x73, 0x8F, 0x0E, 0x1C, 0xE3, 0xC3, 0x8E, 0x38, 0xE0, 0xE3,
  0x8E, 0x78, 0x39, 0xE7, 0x9C, 0x0E, 0x71, 0xEF, 0x03, 0x9C, 0x7B, 0xC0,
  0xEF, 0x1E, 0xE0, 0x3B, 0x87, 0x78, 0x0E, 0xE1, 0xDC, 0x03, 0xF0, 0x77,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xC0,
  0x00, 0xF3, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x77, 0x80, 0x00, 0x77, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xA0, 0x03,
  0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 35, 12, 0, -35 },
  { 54, 14, 13, 17, 5, -35 },
  { 77, 22, 35, 21, 0, -35 },
  { 174, 20, 40, 19, 0, -37 },
  { 274, 26, 35, 30, 2, -35 },
  { 388, 20, 35, 21, 0, -35 },
  { 476, 6, 13, 9, 5, -35 },
  { 486, 15, 43, 13, 1, -35 },
  { 567, 15, 43, 13, -4, -35 },
  { 648, 15, 16, 18, 5, -37 },
  { 678, 18, 23, 21, 2, -29 },
  { 730, 8, 11, 10, -2, -5 },
  { 741, 11, 4, 13, 1, -15 },
  { 747, 5, 6, 10, 1, -6 },
  { 751, 22, 35, 16, -2, -35 },
  { 848, 18, 35, 19, 1, -35 },
  { 927, 12, 35, 19, 5, -35 },
  { 980, 21, 35, 19, -2, -35 },
  { 1072, 20, 35, 19, -1, -35 },
  { 1160, 21, 35, 19, -1, -35 },
  { 1252, 21, 35, 19, -1, -35 },
  { 1344, 19, 35, 19, 1, -35 },
  { 1428, 19, 35, 19, 2, -35 },
  { 1512, 20, 35, 19, 0, -35 },
  { 1600, 19, 35, 19, 0, -35 },
  { 1684, 10, 26, 10, 0, -26 },
  { 1717, 12, 32, 10, -2, -26 },
  { 1765, 18, 22, 21, 2, -28 },
  { 1815, 18, 14, 21, 2, -24 },
  { 1847, 18, 22, 21, 2, -28 },
  { 1897, 15, 35, 14, 1, -35 },
  { 1963, 27, 39, 29, 1, -35 },
  { 2095, 20, 35, 20, -3, -35 },
  { 2183, 21, 35, 21, 0, -35 },
  { 2275, 21, 36, 19, 2, -36 },
  { 2370, 22, 35, 23, 0, -35 },
  { 2467, 20, 35, 18, 0, -35 },
  { 2555, 20, 35, 17, 0, -35 },
  { 2643, 23, 36, 24, 2, -36 },
  { 2747, 25, 35, 24, 0, -35 },
  { 2857, 19, 35, 13, -3, -35 },
  { 2941, 18, 44, 10, -7, -35 },
  { 3040, 24, 35, 20, 0, -35 },
  { 3145, 13, 35, 17, 0, -35 },
  { 3202, 33, 35, 32, 0, -35 },
  { 3347, 26, 35, 25, 0, -35 },
  { 3461, 22, 35, 24, 2, -35 },
  { 3558, 21, 35, 20, 0, -35 },
  { 3650, 22, 43, 24, 2, -35 },
  { 3769, 21, 35, 20, 0, -35 },
  { 3861, 21, 35, 18, -1, -35 },
  { 3953, 18, 35, 17, 3, -35 },
  { 4032, 22, 35, 23, 2, -35 },
  { 4129, 20, 35, 20, 4, -35 },
  { 4217, 33, 35, 32, 3, -35 },
  { 4362, 25, 35, 18, -3, -35 },
  { 4472, 18, 35, 17, 4, -35 },
  { 4551, 21, 35, 16, -2, -35 },
  { 4643, 18, 43, 14, -1, -35 },
  { 4740, 8, 35, 17, 5, -35 },
  { 4775, 18, 43, 14, -3, -35 },
  { 4872, 18, 19, 20, 1, -35 },
  { 4915, 15, 3, 15, -4, 4 },
  { 4921, 7, 7, 12, 7, -37 },
  { 4928, 20, 27, 21, 1, -27 },
  { 4996, 19, 37, 20, 0, -37 },
  { 5084, 16, 27, 16, 1, -27 },
  { 5138, 22, 37, 21, 1, -37 },
  { 5240, 17, 27, 19, 1, -27 },
  { 5298, 23, 49, 11, -6, -37 },
  { 5439, 22, 39, 21, -1, -27 },
  { 5547, 19, 37, 20, 0, -37 },
  { 5635, 11, 36, 9, 0, -36 },
  { 5685, 17, 48, 9, -6, -36 },
  { 5787, 20, 37, 18, 0, -37 },
  { 5880, 12, 37, 9, 0, -37 },
  { 5936, 29, 27, 30, 0, -27 },
  { 6034, 19, 27, 20, 0, -27 },
  { 6099, 18, 27, 20, 1, -27 },
  { 6160, 21, 38, 20, -2, -27 },
  { 6260, 20, 39, 21, 1, -27 },
  { 6358, 16, 27, 14, 0, -27 },
  { 6412, 17, 27, 15, -1, -27 },
  { 6470, 12, 32, 12, 1, -32 },
  { 6518, 19, 26, 20, 1, -26 },
  { 6580, 16, 26, 16, 3, -26 },
  { 6632, 26, 26, 27, 3, -26 },
  { 6717, 21, 26, 17, -2, -26 },
  { 6786, 24, 38, 17, -5, -26 },
  { 6900, 17, 26, 14, -2, -26 },
  { 6956, 18, 43, 16, 1, -35 },
  { 7053, 4, 49, 18, 7, -37 },
  { 7078, 18, 43, 16, -3, -35 },
  { 7175, 18, 6, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Italic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC49PT7B_H_
