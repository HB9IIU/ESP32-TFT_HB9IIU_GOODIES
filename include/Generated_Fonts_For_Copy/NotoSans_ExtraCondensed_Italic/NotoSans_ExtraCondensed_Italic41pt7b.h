#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x07, 0x83, 0xC0,
  0x70, 0x00, 0x38, 0xF7, 0x8E, 0x79, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x71,
  0xCE, 0x18, 0xE1, 0x8E, 0x38, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x0E, 0x18,
  0x03, 0x8E, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x0C, 0x30, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x4F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x30,
  0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3C, 0x8C, 0x1C, 0x40, 0x0E, 0x60, 0x06, 0x30, 0x07, 0x18, 0x01, 0xC8,
  0x00, 0xEC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x37, 0x00, 0x11, 0xC0, 0x08, 0xE0, 0x0C, 0x70,
  0x06, 0x38, 0x83, 0x38, 0x61, 0x3C, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x10, 0x3E, 0x01, 0x81, 0xFC, 0x0E, 0x06, 0x70, 0x30, 0x38, 0xC1, 0xC0,
  0xC3, 0x06, 0x07, 0x0C, 0x38, 0x1C, 0x71, 0xC0, 0x61, 0xC7, 0x03, 0x87,
  0x38, 0x0E, 0x18, 0xE0, 0x38, 0x67, 0x00, 0xE3, 0x9C, 0xF3, 0x0C, 0xE7,
  0xEC, 0x73, 0x3F, 0xB9, 0xDC, 0xC6, 0xFE, 0x67, 0x1D, 0xF3, 0x98, 0x73,
  0x8C, 0x61, 0x80, 0x73, 0x86, 0x01, 0x8E, 0x18, 0x0E, 0x30, 0xE0, 0x30,
  0xC3, 0x81, 0xC3, 0x0E, 0x06, 0x1C, 0x30, 0x38, 0x71, 0xC0, 0xC1, 0xC6,
  0x07, 0x03, 0x38, 0x18, 0x0F, 0xC0, 0xE0, 0x3E, 0x00, 0x00, 0x30, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x38,
  0x0E, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0xEF, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC3, 0x9E, 0xF3, 0xCE,
  0x39, 0xCE, 0x1C, 0xE7, 0x0E, 0xE7, 0x03, 0xF3, 0x81, 0xF1, 0xC0, 0xF8,
  0xE0, 0x78, 0x70, 0x3C, 0x38, 0x3F, 0x1F, 0x7B, 0x87, 0xF9, 0xE1, 0xF8,
  0xF0, 0x39, 0xDE, 0xE7, 0x39, 0xCC, 0xE7, 0x00, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x07, 0x06, 0x70,
  0xF7, 0x1F, 0xFF, 0x1F, 0xF0, 0xF0, 0x1F, 0x03, 0xB8, 0x71, 0xC7, 0x1C,
  0x21, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x1C, 0x78, 0xE3, 0xC7, 0x0E, 0x38, 0x71, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x33, 0xDF, 0xF7, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x0F, 0xF0, 0x3C, 0xF0,
  0x70, 0xE1, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x1C, 0xE0,
  0x39, 0xC0, 0xF7, 0x81, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1D,
  0xE0, 0x7B, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0xFE, 0x07, 0xF8, 0x07, 0xE0,
  0x00, 0x01, 0xE0, 0xF8, 0x3F, 0x0F, 0xE3, 0xFC, 0xF7, 0x3C, 0xE3, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xF9, 0xF0, 0x30, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0xFF, 0x01, 0xFF, 0xC0, 0x71, 0xF0, 0x20, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x20, 0x1E, 0x1F, 0x7E, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xDC, 0x00, 0xEE, 0x00, 0x6F, 0x00, 0x77, 0x00, 0x73,
  0x80, 0x31, 0xC0, 0x38, 0xE0, 0x18, 0xF0, 0x1C, 0x70, 0x1C, 0x38, 0x0C,
  0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0x06, 0x07, 0x07, 0x03, 0x83, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x80, 0xF0, 0xF7, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xE1, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3B, 0xF0, 0x77, 0xF8, 0x7F, 0x78, 0x7C, 0x38, 0x78,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xF1, 0xE0, 0xF0, 0x70, 0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x03, 0x83, 0x83, 0x81, 0xE3, 0xC0, 0x73, 0xC0, 0x3F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x1F, 0xF0, 0x1E, 0x3C, 0x1E, 0x0E, 0x0E, 0x07, 0x8F,
  0x03, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0x70, 0x1C,
  0x3C, 0x1E, 0x1F, 0x3E, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x01,
  0xFC, 0x03, 0xFE, 0x07, 0x9E, 0x0F, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1E, 0x3C, 0x1E, 0x1C, 0x3E, 0x1F, 0xEE, 0x1F, 0xFE, 0x0F, 0x9C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0xEF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0x0F, 0x0F,
  0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x70, 0xF0, 0xF0, 0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xF0, 0x01, 0x80, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x7F, 0x0F, 0xFC, 0x39, 0xE1, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0,
  0x07, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x07,
  0x00, 0x06, 0x0C, 0x04, 0x0E, 0x38, 0x3F, 0x1C, 0x60, 0xFE, 0x39, 0xC3,
  0x1C, 0x73, 0x0E, 0x38, 0xC6, 0x18, 0x61, 0x9C, 0x71, 0xC3, 0x30, 0xC3,
  0x86, 0x61, 0x87, 0x1C, 0xC7, 0x0C, 0x33, 0x8E, 0x38, 0x67, 0x18, 0x71,
  0xCE, 0x30, 0xE3, 0x18, 0x73, 0xCE, 0x30, 0xE5, 0x98, 0x61, 0xFB, 0xE0,
  0xC1, 0xE7, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x79, 0xC0,
  0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x07,
  0x03, 0x83, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xE0, 0x38, 0xF0,
  0x1C, 0x78, 0x0E, 0x38, 0x07, 0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x01, 0xEF,
  0x00, 0xFF, 0x00, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x1E,
  0x0F, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x1C, 0x0F, 0x0F, 0x03,
  0x83, 0x80, 0xE0, 0xE0, 0x78, 0x38, 0x3C, 0x1F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x70, 0xF8, 0x1C, 0x0E, 0x0F, 0x03, 0x83, 0xC0, 0xF0, 0xE0,
  0x3C, 0x38, 0x0F, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x78, 0x70, 0x3C,
  0x1C, 0x1F, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xCE, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x81, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1E, 0x1F, 0x07, 0x03, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07,
  0x0F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1E, 0x01, 0xC7,
  0x80, 0x71, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0xC0,
  0x78, 0xE0, 0x1E, 0x38, 0x0F, 0x0E, 0x03, 0xC7, 0x81, 0xE1, 0xC0, 0x70,
  0x70, 0x7C, 0x1C, 0x3E, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0x1E, 0x03, 0xC0, 0x20, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x01, 0xFC, 0x70, 0x3F, 0x87, 0x00,
  0x38, 0x70, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x80, 0xE0, 0x7C, 0x0E, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0x80, 0x78, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0F, 0x01, 0xE0, 0x70, 0x0F, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x8F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0xF0, 0x38, 0x1E, 0x03, 0x83, 0xC0, 0x78, 0x38, 0x07, 0x07,
  0x80, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x0F, 0x3C, 0x00, 0xE3,
  0x80, 0x0E, 0x78, 0x00, 0xEF, 0x00, 0x1E, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1E, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03,
  0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x78, 0x78, 0x07, 0x07, 0x80,
  0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x3C,
  0x00, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xEE, 0x0E, 0xE0, 0x1F, 0xC1,
  0xDC, 0x07, 0x70, 0x3B, 0x80, 0xEE, 0x07, 0x70, 0x39, 0xC1, 0xEE, 0x07,
  0x78, 0x39, 0xC1, 0xCF, 0x07, 0x38, 0x39, 0xC0, 0xE7, 0x0E, 0x38, 0x1C,
  0x61, 0xC7, 0x07, 0x8C, 0x79, 0xE0, 0xE1, 0x8E, 0x38, 0x1C, 0x31, 0xC7,
  0x03, 0x87, 0x70, 0xE0, 0x70, 0xEE, 0x1C, 0x1E, 0x1F, 0x87, 0x83, 0x83,
  0xF0, 0xE0, 0x70, 0x7C, 0x1C, 0x0E, 0x0F, 0x83, 0x81, 0xC1, 0xE0, 0xF0,
  0x70, 0x3C, 0x1E, 0x0E, 0x07, 0x83, 0x80, 0x03, 0xC0, 0x1C, 0x0F, 0x00,
  0xF0, 0x3E, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0,
  0x7E, 0x07, 0x81, 0xF8, 0x1C, 0x0E, 0x70, 0x70, 0x39, 0xC1, 0xC0, 0xE7,
  0x0F, 0x03, 0x9C, 0x38, 0x1E, 0x70, 0xE0, 0x71, 0xC3, 0x81, 0xC3, 0x8E,
  0x07, 0x0E, 0x78, 0x1C, 0x39, 0xC0, 0xF0, 0xE7, 0x03, 0x83, 0x9C, 0x0E,
  0x0E, 0x70, 0x38, 0x1B, 0xC0, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x1C, 0x07,
  0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x00, 0xF0, 0x38, 0x03, 0xC0,
  0xE0, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xF3,
  0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x78, 0x70, 0x0F, 0x1E, 0x01,
  0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1C, 0xF0, 0x03,
  0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x0E,
  0x38, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x70,
  0x70, 0x1E, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0xF0,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x03, 0x87, 0x01,
  0xC3, 0x81, 0xE1, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x73, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x01, 0xF3, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x78, 0x70, 0x0F,
  0x1E, 0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1C,
  0xF0, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x79,
  0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x0E, 0x07, 0x0F, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xE1, 0xC0, 0xE1, 0xE0,
  0xF0, 0xF1, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xE1, 0xE0, 0xE0, 0xF0,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1E, 0x07, 0x8E, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x0F, 0xDE, 0x07, 0x80, 0x81, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x0C, 0x07, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x1C, 0x1C, 0x03,
  0x83, 0x80, 0x70, 0xF0, 0x1E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x78, 0x07, 0x0F, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x0E, 0x0F, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0,
  0x70, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3,
  0xC0, 0xE3, 0x80, 0xE7, 0x80, 0xE7, 0x00, 0xE7, 0x00, 0xEF, 0x00, 0xEE,
  0x00, 0xEE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xD8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x01, 0xEE, 0x01, 0xC0, 0x3B,
  0xC0, 0x78, 0x07, 0x78, 0x0F, 0x01, 0xEF, 0x03, 0xE0, 0x39, 0xE0, 0x7C,
  0x0F, 0x3C, 0x0F, 0x81, 0xC7, 0x83, 0xF0, 0x38, 0xF0, 0x7E, 0x0F, 0x1E,
  0x1D, 0xC1, 0xC3, 0x83, 0xB8, 0x78, 0x70, 0x77, 0x0E, 0x0E, 0x1C, 0xE1,
  0xC1, 0xC3, 0x9C, 0x78, 0x38, 0x63, 0x8E, 0x07, 0x1C, 0x73, 0xC0, 0xE3,
  0x8E, 0x70, 0x1C, 0xE1, 0xCE, 0x03, 0x9C, 0x3B, 0xC0, 0x73, 0x07, 0x70,
  0x0E, 0xE0, 0xEE, 0x01, 0xDC, 0x1B, 0x80, 0x3F, 0x03, 0x70, 0x07, 0xE0,
  0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x1C, 0x0E,
  0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x00,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x3C, 0x3C, 0x03, 0x83, 0xC0,
  0x70, 0x3C, 0x0F, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0xF0, 0x1E, 0xE0, 0x39,
  0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x79,
  0xE0, 0x73, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xE1, 0xC3, 0x83, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0x9C, 0x03,
  0x9C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38,
  0x0E, 0x38, 0x07, 0xF0, 0x07, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xF1, 0xC7,
  0x0E, 0x38, 0x70, 0x03, 0xE7, 0x07, 0xF7, 0x0F, 0xB7, 0x1E, 0x1F, 0x1C,
  0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0,
  0x78, 0xE0, 0xF8, 0xF0, 0xF0, 0xFB, 0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x7E, 0x0E, 0xFE, 0x0F, 0xDF, 0x0F,
  0x87, 0x0F, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x38, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78,
  0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x78, 0xEC, 0xF0, 0xEF, 0xF0, 0xE7,
  0xC0, 0x03, 0xF8, 0x3F, 0xC3, 0xEC, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x10, 0xFB, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0xF9, 0xC0,
  0x7F, 0x70, 0x3E, 0xDC, 0x1E, 0x1E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x78, 0x78, 0x1E, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x1C,
  0x3C, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1E, 0x0E,
  0x0F, 0x83, 0xC3, 0xC0, 0xFB, 0xF0, 0x1F, 0xDC, 0x03, 0xE7, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0xF3, 0xC7, 0x87, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDE,
  0x0E, 0x70, 0x79, 0xCF, 0xCF, 0xFC, 0x3F, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x02, 0x1E, 0x38, 0x7F, 0xE0,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3D, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF9, 0xC0, 0x7F, 0x70, 0x3F, 0xDC, 0x1E,
  0x1F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07,
  0x07, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x1C, 0x3C, 0x0F, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x0F, 0x83, 0xC3, 0xC0, 0xFB,
  0xF0, 0x1F, 0xDC, 0x03, 0xE7, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x02, 0x03, 0xC0, 0xC1, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x7C,
  0x0E, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E,
  0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x1E, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x83, 0xC3,
  0xC3, 0xC1, 0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x39, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x1C, 0x3C, 0x0E,
  0x1E, 0x07, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x00, 0x06,
  0x7C, 0x7E, 0x0E, 0xFE, 0xFF, 0x0F, 0xDF, 0xFF, 0x0F, 0x0F, 0x87, 0x0F,
  0x0F, 0x07, 0x1E, 0x0F, 0x07, 0x1E, 0x0E, 0x07, 0x1C, 0x0E, 0x0E, 0x1C,
  0x0E, 0x0E, 0x1C, 0x1E, 0x0E, 0x3C, 0x1C, 0x0E, 0x38, 0x1C, 0x1E, 0x38,
  0x1C, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x3C, 0x1C, 0x78, 0x38, 0x1C, 0x70,
  0x38, 0x3C, 0x70, 0x38, 0x38, 0x70, 0x78, 0x38, 0xF0, 0x70, 0x38, 0xE0,
  0x70, 0x38, 0xE0, 0x70, 0x78, 0x06, 0x7C, 0x0E, 0xFE, 0x0F, 0xFF, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78,
  0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x78, 0xE0, 0x70, 0xE0,
  0x70, 0x03, 0xF0, 0x0F, 0xF0, 0x3D, 0xF0, 0xF0, 0xE1, 0xC1, 0xE7, 0x03,
  0xCE, 0x07, 0xBC, 0x0F, 0x70, 0x1E, 0xE0, 0x39, 0xC0, 0x77, 0x80, 0xEE,
  0x01, 0xDC, 0x07, 0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0xC3,
  0x83, 0xDF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0x9F, 0x80, 0xEF, 0xE0,
  0x3F, 0x3C, 0x0F, 0x87, 0x03, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x1C, 0x1C,
  0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x07, 0x07, 0x83, 0xC1,
  0xE1, 0xE0, 0x7C, 0xF0, 0x3B, 0xF8, 0x0E, 0x7C, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE7, 0x07, 0xF7, 0x0F,
  0xF7, 0x1E, 0x1F, 0x1C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xF8, 0xF0, 0xF0, 0xFB, 0xF0, 0x7F,
  0x70, 0x3E, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06,
  0x78, 0x77, 0xC3, 0xFC, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0xF8, 0x7F, 0xC7, 0x8E, 0x38, 0x13, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x20, 0x71, 0xDF, 0x8F, 0xF8, 0x7F, 0x80, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07, 0xF7, 0xFD, 0xFE, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x03, 0x80, 0xF4, 0x3F, 0x07, 0xC0, 0x1E, 0x0F, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70,
  0x38, 0xF0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xE1, 0xF0, 0xFF,
  0xF0, 0xFF, 0x60, 0x7E, 0x60, 0xF0, 0x3F, 0xC0, 0xEF, 0x03, 0xBC, 0x1C,
  0xF0, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x38,
  0x1C, 0xE0, 0x77, 0x01, 0x9C, 0x06, 0x70, 0x1B, 0x80, 0x6E, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x70, 0x78, 0x1D, 0xC1,
  0xE0, 0xF7, 0x07, 0x83, 0x9C, 0x3E, 0x0E, 0xF0, 0xF8, 0x73, 0xC7, 0xE1,
  0xCE, 0x1F, 0x87, 0x38, 0x6E, 0x38, 0xE3, 0xB8, 0xE3, 0x8E, 0xE7, 0x0E,
  0x73, 0x9C, 0x39, 0xCE, 0x70, 0xE6, 0x3B, 0x83, 0xB8, 0xEE, 0x0E, 0xE3,
  0xF0, 0x3B, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xC1,
  0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x3B,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x07,
  0x1C, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x1E, 0x01, 0xC1, 0xC0,
  0x1C, 0x3C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xDC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0xFC, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x70, 0x0F, 0xC0, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xE8, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 29, 10, 0, -29 },
  { 38, 12, 10, 14, 4, -29 },
  { 53, 18, 29, 17, 0, -29 },
  { 119, 17, 33, 16, 0, -31 },
  { 190, 22, 30, 25, 2, -30 },
  { 273, 17, 30, 18, 0, -30 },
  { 337, 5, 10, 8, 4, -29 },
  { 344, 12, 35, 11, 1, -29 },
  { 397, 12, 35, 11, -3, -29 },
  { 450, 12, 13, 15, 4, -31 },
  { 470, 15, 19, 18, 2, -24 },
  { 506, 7, 10, 8, -2, -5 },
  { 515, 9, 3, 11, 1, -13 },
  { 519, 5, 5, 8, 0, -5 },
  { 523, 19, 29, 14, -2, -29 },
  { 592, 15, 30, 16, 1, -30 },
  { 649, 11, 29, 16, 4, -29 },
  { 689, 17, 30, 16, -1, -30 },
  { 753, 17, 30, 16, -1, -30 },
  { 817, 17, 30, 16, -1, -30 },
  { 881, 16, 29, 16, 0, -29 },
  { 939, 16, 30, 16, 1, -30 },
  { 999, 17, 29, 16, 1, -29 },
  { 1061, 17, 30, 16, 0, -30 },
  { 1125, 16, 30, 16, 0, -30 },
  { 1185, 8, 22, 8, 0, -22 },
  { 1207, 10, 27, 8, -2, -22 },
  { 1241, 15, 19, 18, 2, -24 },
  { 1277, 15, 11, 18, 2, -20 },
  { 1298, 15, 19, 18, 2, -24 },
  { 1334, 13, 30, 12, 1, -30 },
  { 1383, 23, 33, 24, 1, -30 },
  { 1478, 17, 29, 17, -3, -29 },
  { 1540, 18, 29, 18, 0, -29 },
  { 1606, 18, 30, 16, 1, -30 },
  { 1674, 18, 29, 19, 0, -29 },
  { 1740, 17, 29, 15, 0, -29 },
  { 1802, 17, 29, 14, 0, -29 },
  { 1864, 20, 30, 20, 1, -30 },
  { 1939, 21, 29, 20, 0, -29 },
  { 2016, 16, 29, 11, -2, -29 },
  { 2074, 16, 37, 8, -6, -29 },
  { 2148, 20, 29, 17, 0, -29 },
  { 2221, 11, 29, 14, 0, -29 },
  { 2261, 27, 29, 27, 0, -29 },
  { 2359, 22, 29, 21, 0, -29 },
  { 2439, 19, 30, 20, 1, -30 },
  { 2511, 17, 29, 17, 0, -29 },
  { 2573, 19, 37, 20, 1, -30 },
  { 2661, 17, 29, 17, 0, -29 },
  { 2723, 18, 30, 15, -1, -30 },
  { 2791, 14, 29, 14, 3, -29 },
  { 2842, 19, 29, 19, 1, -29 },
  { 2911, 16, 29, 17, 4, -29 },
  { 2969, 27, 29, 27, 3, -29 },
  { 3067, 20, 29, 15, -2, -29 },
  { 3140, 15, 29, 15, 3, -29 },
  { 3195, 18, 29, 14, -2, -29 },
  { 3261, 15, 37, 12, -1, -30 },
  { 3331, 7, 29, 14, 4, -29 },
  { 3357, 16, 37, 12, -3, -30 },
  { 3431, 16, 15, 16, 0, -29 },
  { 3461, 13, 3, 12, -4, 3 },
  { 3466, 6, 6, 10, 6, -31 },
  { 3471, 16, 22, 17, 1, -22 },
  { 3515, 16, 31, 17, 0, -31 },
  { 3577, 13, 22, 13, 1, -22 },
  { 3613, 18, 31, 17, 1, -31 },
  { 3683, 14, 22, 16, 1, -22 },
  { 3722, 19, 41, 9, -5, -31 },
  { 3820, 18, 32, 17, -1, -22 },
  { 3892, 16, 31, 17, 0, -31 },
  { 3954, 9, 30, 8, 0, -30 },
  { 3988, 14, 40, 8, -5, -30 },
  { 4058, 17, 31, 15, 0, -31 },
  { 4124, 10, 31, 8, 0, -31 },
  { 4163, 24, 22, 25, 0, -22 },
  { 4229, 16, 22, 17, 0, -22 },
  { 4273, 15, 22, 17, 1, -22 },
  { 4315, 18, 32, 17, -2, -22 },
  { 4387, 16, 32, 17, 1, -22 },
  { 4451, 13, 22, 11, 0, -22 },
  { 4487, 13, 22, 13, 0, -22 },
  { 4523, 10, 27, 10, 1, -27 },
  { 4557, 16, 22, 17, 1, -22 },
  { 4601, 14, 22, 14, 2, -22 },
  { 4640, 22, 22, 22, 2, -22 },
  { 4701, 18, 22, 14, -2, -22 },
  { 4751, 20, 32, 14, -4, -22 },
  { 4831, 14, 22, 12, -1, -22 },
  { 4870, 15, 35, 13, 1, -29 },
  { 4936, 3, 41, 15, 6, -31 },
  { 4952, 14, 35, 13, -2, -29 },
  { 5014, 15, 5, 18, 2, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Italic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC41PT7B_H_
