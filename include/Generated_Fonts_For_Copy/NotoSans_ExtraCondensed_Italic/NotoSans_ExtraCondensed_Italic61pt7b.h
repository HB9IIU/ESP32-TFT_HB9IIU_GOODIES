#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0x87,
  0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0xF8, 0x3C, 0x7C,
  0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xE3,
  0xC0, 0xE1, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x78,
  0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFD, 0xC7, 0x80, 0xF8, 0xE0, 0x80, 0x78, 0x70, 0x00, 0x3C,
  0x30, 0x00, 0x3E, 0x18, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07,
  0xC6, 0x00, 0x03, 0xE3, 0x00, 0x00, 0xF9, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x7E,
  0x00, 0x03, 0x9F, 0x00, 0x01, 0xCF, 0x80, 0x00, 0xC3, 0xC0, 0x00, 0x61,
  0xE0, 0x00, 0x30, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0C,
  0x1E, 0x08, 0x06, 0x1F, 0x07, 0x03, 0x1F, 0x03, 0xE3, 0xBF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x78, 0x03, 0xFC, 0x00, 0x78, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0xBE,
  0x00, 0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x1E, 0x1E,
  0x03, 0xC0, 0x3C, 0x1E, 0x03, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0x38, 0x1E,
  0x07, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x0E, 0x00, 0x78, 0x1C,
  0x1E, 0x00, 0x78, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0xF0, 0x3C,
  0x78, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0x30, 0xF0, 0x78,
  0xF0, 0xFC, 0xF0, 0x79, 0xE1, 0xFE, 0xF0, 0xF1, 0xE3, 0xFF, 0xF0, 0xF3,
  0xC7, 0x8F, 0xF1, 0xE3, 0xC7, 0x0F, 0xFB, 0xE7, 0x8F, 0x0F, 0x7F, 0xC7,
  0x8E, 0x0F, 0x7F, 0x8F, 0x1E, 0x0F, 0x3E, 0x0F, 0x1E, 0x0F, 0x00, 0x1E,
  0x3C, 0x0F, 0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x3C,
  0x3C, 0x1E, 0x00, 0x78, 0x38, 0x1E, 0x00, 0x78, 0x78, 0x1E, 0x00, 0xF0,
  0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1C, 0x01, 0xE0, 0x78, 0x3C, 0x01, 0xC0,
  0x78, 0x3C, 0x03, 0xC0, 0x78, 0x78, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80,
  0x78, 0xF0, 0x0F, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x3F, 0xE0, 0x1E, 0x00,
  0x3F, 0xC0, 0x1E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x0F, 0x0F, 0x9E, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xC7, 0xC3,
  0xE3, 0xE7, 0xC0, 0xF9, 0xF3, 0xE0, 0x7C, 0xF1, 0xE0, 0x3E, 0xF9, 0xF0,
  0x0F, 0xF8, 0xF8, 0x07, 0xFC, 0x7C, 0x03, 0xFC, 0x3C, 0x00, 0xFE, 0x1E,
  0x00, 0x7E, 0x0F, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x3F, 0xC1,
  0xF8, 0x3F, 0xF0, 0xFF, 0xFE, 0xF8, 0x3F, 0xFE, 0x7C, 0x0F, 0xFE, 0x3F,
  0x03, 0xFC, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x18, 0x3C, 0x07,
  0x0F, 0x01, 0xF3, 0x83, 0xFF, 0xEF, 0xDF, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xF7, 0x80, 0xF8, 0xF0, 0x7E, 0x3C,
  0x0F, 0x0F, 0x81, 0x81, 0xF0, 0x20, 0x70, 0x00, 0x10, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF8, 0x39, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F,
  0x0F, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x1F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C,
  0x7E, 0x7C, 0xFC, 0x78, 0x78, 0xF8, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7E, 0x1F, 0x80, 0x1E, 0x03, 0xF0, 0x02, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0x00, 0xFC, 0x01, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x02, 0x00, 0x1F, 0x81, 0xC0,
  0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xDF, 0x00, 0x01,
  0xEF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00,
  0x71, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x38, 0x7C, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x0F, 0x80,
  0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0,
  0x07, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x03, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x82, 0x00,
  0x1F, 0x81, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x40,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x7C, 0xFF,
  0x00, 0xF3, 0xFF, 0x03, 0xEF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x7F, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0,
  0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0x83, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x01, 0xF0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xC7,
  0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F,
  0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0x81,
  0xFC, 0x0F, 0xEF, 0xFC, 0x0F, 0xFF, 0x7C, 0x07, 0xFE, 0x7C, 0x03, 0xFC,
  0x78, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0x78, 0xFE, 0x0C, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x3F, 0x83, 0xC1, 0xE0, 0x3F, 0xF0, 0x70,
  0x70, 0x1F, 0xFC, 0x1C, 0x3C, 0x0F, 0x8F, 0x0F, 0x0F, 0x03, 0x83, 0x83,
  0xC3, 0x81, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0x3C, 0x70, 0x3C, 0x1E,
  0x0F, 0x1C, 0x1E, 0x07, 0x03, 0x8F, 0x07, 0x83, 0xC0, 0xE3, 0xC1, 0xC0,
  0xF0, 0x38, 0xE0, 0xF0, 0x3C, 0x1E, 0x38, 0x3C, 0x0E, 0x07, 0x9E, 0x0F,
  0x07, 0x81, 0xC7, 0x83, 0x81, 0xE0, 0x71, 0xE0, 0xE0, 0x78, 0x3C, 0x70,
  0x78, 0x3C, 0x0E, 0x1C, 0x1E, 0x0F, 0x07, 0x87, 0x07, 0x83, 0xC1, 0xC1,
  0xC1, 0xE1, 0xF0, 0xF0, 0x70, 0x78, 0x7C, 0x38, 0x3C, 0x1F, 0x77, 0xBE,
  0x0F, 0x03, 0xFC, 0xFF, 0x03, 0xC0, 0xFE, 0x3F, 0x80, 0x70, 0x1F, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x10, 0x00, 0x03,
  0xF0, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x78, 0x07, 0xE0,
  0x1F, 0x01, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x03, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0xFE, 0x03, 0xE0,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x8F, 0x00, 0x3F, 0x80, 0x40,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x06, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xF0, 0x3F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xC0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xF8, 0x03, 0xE7, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x3F, 0x00, 0x7F, 0x00, 0x38, 0x07, 0xF0,
  0x00, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xE1, 0xF0, 0x07, 0xFF, 0x0F,
  0x80, 0x3F, 0xF0, 0x7C, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x0F,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1E,
  0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x01,
  0xF7, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x00, 0x7B, 0xE0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xCF,
  0x80, 0x3E, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x8F, 0x80,
  0x3C, 0x3C, 0x07, 0x8F, 0x80, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x1F, 0x0F,
  0x03, 0xE3, 0xE0, 0x0F, 0x87, 0x81, 0xE1, 0xF0, 0x07, 0xC3, 0xC1, 0xF0,
  0xF0, 0x03, 0xC1, 0xE0, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0xF8, 0x7C, 0x01,
  0xF0, 0x78, 0x78, 0x3E, 0x00, 0xF8, 0x3C, 0x7C, 0x1F, 0x00, 0x7C, 0x1E,
  0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0x9E, 0x07,
  0xC0, 0x1F, 0x03, 0xCF, 0x03, 0xE0, 0x0F, 0x81, 0xEF, 0x81, 0xF0, 0x07,
  0x80, 0xF7, 0x80, 0xF0, 0x03, 0xC0, 0x7F, 0xC0, 0xF8, 0x03, 0xE0, 0x3F,
  0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xE0, 0x1F,
  0x00, 0x78, 0x07, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F,
  0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x03,
  0xFC, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3D, 0xF0, 0x07, 0x80,
  0x1E, 0x78, 0x07, 0xC0, 0x1F, 0x3C, 0x03, 0xE0, 0x0F, 0x9E, 0x01, 0xF0,
  0x07, 0xCF, 0x00, 0xF8, 0x03, 0xC7, 0xC0, 0x78, 0x01, 0xE3, 0xE0, 0x7C,
  0x01, 0xF0, 0xF0, 0x3E, 0x00, 0xF8, 0x78, 0x1F, 0x00, 0x7C, 0x3C, 0x0F,
  0x00, 0x3C, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC3,
  0xE0, 0x0F, 0x81, 0xE1, 0xF0, 0x07, 0xC0, 0xF0, 0xF0, 0x03, 0xC0, 0x78,
  0xF8, 0x03, 0xE0, 0x3C, 0x7C, 0x01, 0xF0, 0x1F, 0x3E, 0x00, 0xF8, 0x0F,
  0x9F, 0x00, 0x7C, 0x03, 0xCF, 0x00, 0x3C, 0x01, 0xEF, 0x80, 0x3E, 0x00,
  0xF7, 0xC0, 0x1F, 0x00, 0x7B, 0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xC0,
  0x1F, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x03, 0xE0, 0x03, 0xFC, 0x01, 0xF0,
  0x01, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x3C,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3E, 0x0F, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x78, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF1, 0xFC,
  0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3E, 0x0F, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xFE, 0x01, 0xF1, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0x9F, 0x80, 0x7F, 0x00, 0xC0, 0x1F, 0x80, 0x10, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x20, 0x00, 0xF8,
  0x0C, 0x00, 0x7E, 0x03, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x80, 0x07,
  0xCF, 0x80, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0xFE, 0x00, 0xF8, 0x3E, 0x00, 0xFF, 0x00, 0x7C,
  0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x0F, 0x80, 0x7B, 0xC0, 0x3E, 0x07, 0xC0,
  0x3D, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0xF0, 0x0F, 0x81, 0xF0, 0x1E, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x9E, 0x07, 0xC0,
  0x3E, 0x07, 0x8F, 0x03, 0xE0, 0x1F, 0x03, 0xC7, 0x81, 0xF0, 0x0F, 0x83,
  0xE7, 0xC1, 0xF0, 0x07, 0x81, 0xE3, 0xE0, 0xF8, 0x03, 0xC0, 0xF1, 0xE0,
  0xF8, 0x01, 0xE0, 0xF0, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x78, 0x3E, 0x00,
  0x78, 0x7C, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x1E, 0x1F, 0x00, 0x1E, 0x1E,
  0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x07, 0x8F, 0x80, 0x07, 0x8F, 0x03, 0xC7,
  0xC0, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x00,
  0xF3, 0xC0, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x3D, 0xF0, 0x00, 0x3D, 0xE0,
  0x1E, 0xF8, 0x00, 0x3E, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03,
  0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xF1,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F, 0x07, 0x00, 0x7F,
  0x0F, 0x00, 0xFF, 0x9E, 0x01, 0xFF, 0x9E, 0x03, 0xFF, 0xDE, 0x07, 0xE1,
  0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0x80, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0xF8, 0x00,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07,
  0xE0, 0xF0, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0xC0, 0xF8, 0x3F,
  0xC0, 0xFF, 0xF7, 0x80, 0x7F, 0xF7, 0x80, 0x7F, 0xE7, 0x80, 0x3F, 0x87,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF1, 0xF8, 0x01, 0xE7,
  0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x3F, 0x03, 0xF8,
  0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01,
  0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7B, 0xDF,
  0xC0, 0xFB, 0xFF, 0x80, 0xF1, 0xFF, 0x00, 0xF1, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7E,
  0x0C, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x1F, 0x00, 0x1F, 0xF3,
  0xC0, 0x0F, 0xFE, 0x78, 0x01, 0xFF, 0xFF, 0x00, 0x7E, 0x1F, 0xE0, 0x1F,
  0x81, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x80,
  0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0x83, 0xFC, 0x01, 0xFF, 0xEF, 0x00, 0x1F,
  0xFD, 0xE0, 0x03, 0xFF, 0x3C, 0x00, 0x3F, 0x87, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3F, 0x0F, 0x83, 0xF0, 0x3C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80,
  0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F,
  0x03, 0xF1, 0xF3, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x10, 0x1F, 0xCF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xE0, 0x03, 0xFE, 0x78, 0x00,
  0xFF, 0xCF, 0x00, 0x3F, 0xFD, 0xE0, 0x0F, 0xC3, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1F, 0x00,
  0x1E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F,
  0x81, 0xFC, 0x01, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xBC,
  0x00, 0x7F, 0xEF, 0x80, 0x07, 0xF9, 0xF0, 0x00, 0x18, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x01,
  0xF0, 0x03, 0x00, 0xFE, 0x00, 0x7E, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x7F, 0x00, 0x79, 0xFF, 0x01, 0xF7, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00,
  0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xE0,
  0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xEF, 0x80, 0x01, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xE0,
  0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xE3, 0xF8, 0x1F, 0x80, 0x1E,
  0x7F, 0xC7, 0xFC, 0x03, 0xCF, 0xFC, 0xFF, 0xE0, 0x3D, 0xFF, 0xFF, 0xFE,
  0x03, 0xF8, 0x7F, 0xC3, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0xF0, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x80, 0x78,
  0x1E, 0x00, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x01,
  0xE3, 0xF8, 0x03, 0xCF, 0xF8, 0x0F, 0x3F, 0xF8, 0x1E, 0xFF, 0xF0, 0x3F,
  0xC3, 0xE0, 0x7F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78,
  0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x07,
  0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00,
  0x7C, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F,
  0xC3, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x07, 0x9F, 0xF0, 0x01,
  0xF7, 0xFF, 0x00, 0x3D, 0xFF, 0xE0, 0x07, 0xB8, 0x7E, 0x00, 0xFE, 0x07,
  0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1E, 0xFF, 0xF0, 0x03, 0xDF, 0xFC,
  0x00, 0xF9, 0xFF, 0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xE0, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x3F,
  0xE7, 0x80, 0x3F, 0xF3, 0xC0, 0x3F, 0xFD, 0xE0, 0x3F, 0x0F, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x7C, 0x00, 0x78,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0x7C, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xFC, 0x07, 0xC1,
  0xFE, 0x03, 0xFF, 0xDE, 0x00, 0xFF, 0xEF, 0x00, 0x7F, 0xEF, 0x80, 0x1F,
  0xC7, 0xC0, 0x01, 0x83, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE3, 0xF0, 0x1C, 0x7E, 0x03, 0xCF, 0xE0, 0x3D, 0xFE, 0x03,
  0xDF, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E,
  0x07, 0x03, 0xE0, 0x10, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC1, 0x00,
  0x3E, 0x0E, 0x03, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFC, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x04, 0x00, 0x07,
  0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xE0,
  0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0xC1, 0xE0,
  0x1F, 0x83, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xF8, 0x1F, 0xFE,
  0xF0, 0x3F, 0xFB, 0xE0, 0x3F, 0xE7, 0x80, 0x3F, 0x8F, 0x00, 0x18, 0x00,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0,
  0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0,
  0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xF0,
  0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xBC, 0x01, 0xF8, 0x07, 0xDE, 0x01, 0xFC, 0x07,
  0xCF, 0x00, 0xFC, 0x03, 0xE7, 0x80, 0x7E, 0x01, 0xE3, 0xC0, 0x7F, 0x01,
  0xF1, 0xE0, 0x3F, 0x80, 0xF8, 0xF0, 0x3D, 0xC0, 0x78, 0x78, 0x1F, 0xE0,
  0x7C, 0x3C, 0x0F, 0xF0, 0x3C, 0x1E, 0x0F, 0x78, 0x3E, 0x0F, 0x07, 0xBC,
  0x1F, 0x07, 0x87, 0x9E, 0x0F, 0x03, 0xC3, 0xCF, 0x0F, 0x81, 0xE1, 0xE7,
  0x87, 0x80, 0xF1, 0xE3, 0xC7, 0xC0, 0x78, 0xF1, 0xE3, 0xE0, 0x3C, 0x78,
  0xF1, 0xE0, 0x3E, 0x78, 0x79, 0xF0, 0x1F, 0x3C, 0x3C, 0xF0, 0x0F, 0xBC,
  0x1E, 0x78, 0x07, 0xDE, 0x0F, 0x7C, 0x03, 0xEF, 0x07, 0xBC, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7B, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x20, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x7F,
  0xE0, 0x0D, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xA0, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 44, 14, 1, -44 },
  { 78, 17, 16, 21, 6, -44 },
  { 112, 27, 44, 26, 0, -44 },
  { 261, 25, 50, 24, 0, -46 },
  { 418, 32, 45, 37, 3, -44 },
  { 598, 25, 45, 26, 0, -44 },
  { 739, 8, 16, 11, 6, -44 },
  { 755, 19, 54, 16, 1, -44 },
  { 884, 18, 54, 16, -4, -44 },
  { 1006, 18, 21, 22, 6, -47 },
  { 1054, 23, 29, 26, 2, -36 },
  { 1138, 11, 15, 12, -3, -7 },
  { 1159, 14, 5, 16, 1, -19 },
  { 1168, 6, 7, 12, 1, -7 },
  { 1174, 28, 44, 20, -3, -44 },
  { 1328, 23, 45, 24, 1, -44 },
  { 1458, 16, 44, 24, 6, -44 },
  { 1546, 26, 44, 24, -2, -44 },
  { 1689, 25, 45, 24, -1, -44 },
  { 1830, 25, 44, 24, -1, -44 },
  { 1968, 25, 45, 24, -1, -44 },
  { 2109, 23, 45, 24, 2, -44 },
  { 2239, 24, 44, 24, 2, -44 },
  { 2371, 25, 45, 24, 0, -44 },
  { 2512, 24, 45, 24, 0, -44 },
  { 2647, 12, 33, 12, 0, -33 },
  { 2697, 15, 41, 12, -3, -33 },
  { 2774, 23, 27, 26, 2, -35 },
  { 2852, 23, 17, 26, 2, -30 },
  { 2901, 23, 27, 26, 2, -35 },
  { 2979, 19, 44, 18, 1, -44 },
  { 3084, 34, 49, 36, 1, -44 },
  { 3293, 25, 44, 25, -4, -44 },
  { 3431, 27, 44, 26, 0, -44 },
  { 3580, 26, 45, 24, 2, -44 },
  { 3727, 27, 44, 28, 0, -44 },
  { 3876, 25, 44, 22, 0, -44 },
  { 4014, 25, 44, 21, 0, -44 },
  { 4152, 29, 45, 30, 2, -44 },
  { 4316, 31, 44, 29, 0, -44 },
  { 4487, 23, 44, 16, -3, -44 },
  { 4614, 23, 56, 12, -9, -44 },
  { 4775, 30, 44, 25, 0, -44 },
  { 4940, 16, 44, 21, 0, -44 },
  { 5028, 41, 44, 39, 0, -44 },
  { 5254, 33, 44, 31, 0, -44 },
  { 5436, 27, 45, 30, 2, -44 },
  { 5588, 26, 44, 25, 0, -44 },
  { 5731, 27, 54, 30, 2, -44 },
  { 5914, 26, 44, 26, 0, -44 },
  { 6057, 26, 45, 23, -1, -44 },
  { 6204, 22, 44, 21, 4, -44 },
  { 6325, 28, 45, 29, 2, -44 },
  { 6483, 25, 44, 25, 5, -44 },
  { 6621, 41, 44, 40, 4, -44 },
  { 6847, 31, 44, 23, -4, -44 },
  { 7018, 23, 44, 22, 4, -44 },
  { 7145, 27, 44, 20, -3, -44 },
  { 7294, 23, 54, 17, -2, -44 },
  { 7450, 10, 44, 21, 6, -44 },
  { 7505, 23, 54, 17, -4, -44 },
  { 7661, 23, 24, 24, 1, -44 },
  { 7730, 19, 4, 18, -5, 5 },
  { 7740, 8, 10, 15, 9, -47 },
  { 7750, 24, 34, 26, 2, -33 },
  { 7852, 24, 47, 25, 0, -46 },
  { 7993, 19, 34, 19, 2, -33 },
  { 8074, 27, 47, 26, 1, -46 },
  { 8233, 21, 34, 23, 1, -33 },
  { 8323, 29, 62, 14, -8, -47 },
  { 8548, 27, 48, 26, -1, -33 },
  { 8710, 23, 46, 25, 0, -46 },
  { 8843, 14, 45, 12, 0, -45 },
  { 8922, 22, 60, 12, -8, -45 },
  { 9087, 25, 46, 22, 0, -46 },
  { 9231, 15, 46, 12, 0, -46 },
  { 9318, 36, 33, 37, 0, -33 },
  { 9467, 23, 33, 25, 0, -33 },
  { 9562, 21, 34, 25, 2, -33 },
  { 9652, 27, 47, 25, -3, -33 },
  { 9811, 25, 48, 26, 1, -33 },
  { 9961, 20, 33, 17, 0, -33 },
  { 10044, 21, 34, 19, -1, -33 },
  { 10134, 15, 41, 15, 1, -40 },
  { 10211, 23, 34, 25, 2, -33 },
  { 10309, 20, 33, 21, 4, -33 },
  { 10392, 33, 33, 33, 3, -33 },
  { 10529, 26, 33, 21, -3, -33 },
  { 10637, 30, 48, 21, -6, -33 },
  { 10817, 21, 33, 17, -2, -33 },
  { 10904, 23, 54, 20, 1, -44 },
  { 11060, 4, 61, 22, 9, -47 },
  { 11091, 22, 54, 20, -4, -44 },
  { 11240, 23, 7, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Italic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC61PT7B_H_
