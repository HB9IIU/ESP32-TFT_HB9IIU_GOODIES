#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x7A, 0xAA, 0x19, 0x4A, 0xF5, 0x2F, 0x94,
  0xA0, 0x11, 0xD8, 0xC2, 0x18, 0xD6, 0x42, 0x00, 0x4A, 0xAB, 0x34, 0xEE,
  0xD5, 0x55, 0x98, 0x31, 0x94, 0xA2, 0x36, 0xD2, 0xF0, 0x5A, 0x12, 0x24,
  0x48, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11, 0x22, 0x24, 0x80, 0x2F, 0x6A,
  0x21, 0x3E, 0x42, 0x10, 0x6A, 0x00, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10,
  0x82, 0x10, 0xC0, 0x11, 0x52, 0x95, 0x4A, 0x52, 0x60, 0x2E, 0x94, 0x92,
  0xC0, 0x32, 0x42, 0x21, 0x11, 0x10, 0xF0, 0x32, 0x42, 0x26, 0x08, 0x42,
  0xE0, 0x08, 0xCC, 0x65, 0x4B, 0xC4, 0x20, 0x3A, 0x10, 0x87, 0x08, 0x42,
  0xE0, 0x19, 0x10, 0x87, 0x4A, 0x52, 0x60, 0x78, 0x44, 0x21, 0x10, 0x88,
  0xC0, 0x32, 0x52, 0xA2, 0x2A, 0x52, 0xE0, 0x32, 0x52, 0x95, 0x38, 0x44,
  0xE0, 0x40, 0x20, 0x20, 0x02, 0x94, 0x09, 0xB0, 0xC1, 0x80, 0xF8, 0x3E,
  0x83, 0x06, 0x6C, 0x00, 0x25, 0x12, 0x24, 0x40, 0x80, 0x1C, 0x45, 0x0A,
  0xD6, 0xB5, 0x6B, 0x5C, 0x80, 0xE0, 0x08, 0xC6, 0x52, 0x9D, 0x29, 0x88,
  0x31, 0x52, 0x97, 0x29, 0x32, 0xF0, 0x18, 0x94, 0x10, 0x42, 0x08, 0x10,
  0x70, 0x31, 0x52, 0x94, 0xA5, 0x32, 0xE0, 0x39, 0x10, 0x87, 0x21, 0x10,
  0xE0, 0x39, 0x10, 0x87, 0x22, 0x10, 0x80, 0x1C, 0x94, 0x10, 0x5A, 0x28,
  0x92, 0x78, 0x24, 0x94, 0x52, 0x79, 0x28, 0xA2, 0x90, 0x38, 0x84, 0x42,
  0x10, 0x84, 0xE0, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x30, 0x24, 0xA5,
  0x14, 0x61, 0x89, 0x24, 0x90, 0x25, 0x24, 0x94, 0xE0, 0x21, 0x23, 0x63,
  0x66, 0x66, 0x6A, 0xAA, 0x92, 0x94, 0x24, 0x96, 0x55, 0x55, 0x69, 0xA6,
  0x98, 0x18, 0x94, 0x51, 0x46, 0x28, 0xB2, 0x70, 0x31, 0x52, 0x95, 0x31,
  0x10, 0x80, 0x18, 0x94, 0x51, 0x46, 0x28, 0xB2, 0x70, 0x81, 0x00, 0x31,
  0x52, 0x95, 0x32, 0x52, 0x90, 0x32, 0x50, 0x82, 0x18, 0x42, 0xE0, 0xF4,
  0x44, 0x44, 0x88, 0x80, 0x24, 0x94, 0x52, 0x49, 0x28, 0xA4, 0x70, 0x8C,
  0xA5, 0x2A, 0x53, 0x18, 0x80, 0x91, 0x92, 0x92, 0xB2, 0xB4, 0xD4, 0xD8,
  0xD8, 0x98, 0x24, 0x91, 0x86, 0x10, 0xC3, 0x14, 0xD8, 0x99, 0xAA, 0xC4,
  0x88, 0x80, 0x78, 0x84, 0x42, 0x21, 0x10, 0xE0, 0x32, 0x44, 0x44, 0x48,
  0x88, 0xC0, 0xA9, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x84, 0x21, 0x38,
  0x11, 0x8C, 0xA8, 0x80, 0xF0, 0xC0, 0x22, 0xD3, 0x29, 0x49, 0xC0, 0x21,
  0x14, 0xD4, 0xA6, 0x52, 0xE0, 0x34, 0x48, 0x88, 0x60, 0x04, 0x22, 0x96,
  0x4A, 0x49, 0x24, 0x70, 0x35, 0x5F, 0x88, 0x60, 0x18, 0x8C, 0x42, 0x10,
  0x88, 0x42, 0x11, 0x00, 0x22, 0xD3, 0x29, 0x49, 0xC2, 0x26, 0x00, 0x21,
  0x14, 0xD4, 0xAA, 0x52, 0x90, 0x20, 0x24, 0xA4, 0x80, 0x08, 0x00, 0x21,
  0x08, 0x84, 0x21, 0x09, 0x80, 0x21, 0x12, 0xA6, 0x31, 0x94, 0x90, 0x25,
  0x24, 0xA4, 0x80, 0x14, 0xF5, 0x4A, 0x99, 0x32, 0xA5, 0x00, 0x13, 0x52,
  0xA9, 0x4A, 0x40, 0x32, 0x93, 0x19, 0x49, 0x80, 0x08, 0xD2, 0x49, 0x49,
  0x27, 0x10, 0x42, 0x00, 0x22, 0xD3, 0x29, 0x49, 0xC2, 0x21, 0x00, 0x17,
  0x44, 0x88, 0x80, 0x25, 0x44, 0x22, 0xE0, 0x2D, 0x25, 0x26, 0x4A, 0x55,
  0x29, 0x78, 0xBA, 0xCC, 0x88, 0xA6, 0xAE, 0xBA, 0xB2, 0xC0, 0x2C, 0xC3,
  0x0C, 0x53, 0x40, 0x2C, 0xA3, 0x0C, 0x30, 0x82, 0x10, 0xC0, 0x72, 0x44,
  0x8E, 0x09, 0x88, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF0, 0x20, 0x84,
  0x21, 0x0C, 0x84, 0x21, 0x30, 0x6C, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 4, 1, -9 },
  { 7, 5, 9, 5, 0, -9 },
  { 13, 5, 10, 5, 0, -9 },
  { 20, 6, 9, 7, 1, -9 },
  { 27, 5, 9, 5, 0, -9 },
  { 33, 2, 4, 2, 1, -9 },
  { 34, 4, 11, 3, 0, -9 },
  { 40, 4, 11, 3, -1, -9 },
  { 46, 4, 4, 4, 1, -9 },
  { 48, 5, 6, 5, 0, -7 },
  { 52, 3, 3, 2, -1, -1 },
  { 54, 3, 1, 3, 0, -4 },
  { 55, 1, 1, 2, 0, -1 },
  { 56, 6, 9, 4, -1, -9 },
  { 63, 5, 9, 5, 0, -9 },
  { 69, 3, 9, 5, 1, -9 },
  { 73, 5, 9, 5, 0, -9 },
  { 79, 5, 9, 5, 0, -9 },
  { 85, 5, 9, 5, 0, -9 },
  { 91, 5, 9, 5, 0, -9 },
  { 97, 5, 9, 5, 0, -9 },
  { 103, 5, 9, 5, 0, -9 },
  { 109, 5, 9, 5, 0, -9 },
  { 115, 5, 9, 5, 0, -9 },
  { 121, 2, 6, 2, 0, -6 },
  { 123, 3, 8, 2, -1, -6 },
  { 126, 5, 5, 5, 0, -7 },
  { 130, 5, 3, 5, 0, -6 },
  { 132, 5, 5, 5, 0, -7 },
  { 136, 4, 9, 3, 0, -9 },
  { 141, 7, 10, 7, 0, -9 },
  { 150, 5, 9, 5, -1, -9 },
  { 156, 5, 9, 5, 0, -9 },
  { 162, 6, 9, 5, 0, -9 },
  { 169, 5, 9, 6, 0, -9 },
  { 175, 5, 9, 4, 0, -9 },
  { 181, 5, 9, 4, 0, -9 },
  { 187, 6, 9, 6, 0, -9 },
  { 194, 6, 9, 6, 0, -9 },
  { 201, 5, 9, 3, -1, -9 },
  { 207, 5, 11, 2, -2, -9 },
  { 214, 6, 9, 5, 0, -9 },
  { 221, 3, 9, 4, 0, -9 },
  { 225, 8, 9, 8, 0, -9 },
  { 234, 6, 9, 6, 0, -9 },
  { 241, 6, 9, 6, 0, -9 },
  { 248, 5, 9, 5, 0, -9 },
  { 254, 6, 11, 6, 0, -9 },
  { 263, 5, 9, 5, 0, -9 },
  { 269, 5, 9, 5, 0, -9 },
  { 275, 4, 9, 4, 1, -9 },
  { 280, 6, 9, 6, 0, -9 },
  { 287, 5, 9, 5, 1, -9 },
  { 293, 8, 9, 8, 1, -9 },
  { 302, 6, 9, 4, -1, -9 },
  { 309, 4, 9, 4, 1, -9 },
  { 314, 5, 9, 4, 0, -9 },
  { 320, 4, 11, 3, 0, -9 },
  { 326, 2, 9, 4, 1, -9 },
  { 329, 5, 11, 3, -1, -9 },
  { 336, 5, 5, 5, 0, -9 },
  { 340, 4, 1, 4, -1, 1 },
  { 341, 1, 2, 3, 2, -9 },
  { 342, 5, 7, 5, 0, -7 },
  { 347, 5, 9, 5, 0, -9 },
  { 353, 4, 7, 4, 0, -7 },
  { 357, 6, 9, 5, 0, -9 },
  { 364, 4, 7, 5, 0, -7 },
  { 368, 5, 12, 3, -1, -9 },
  { 376, 5, 10, 5, 0, -7 },
  { 383, 5, 9, 5, 0, -9 },
  { 389, 3, 9, 2, 0, -9 },
  { 393, 5, 12, 2, -2, -9 },
  { 401, 5, 9, 4, 0, -9 },
  { 407, 3, 9, 2, 0, -9 },
  { 411, 7, 7, 7, 0, -7 },
  { 418, 5, 7, 5, 0, -7 },
  { 423, 5, 7, 5, 0, -7 },
  { 428, 6, 10, 5, -1, -7 },
  { 436, 5, 10, 5, 0, -7 },
  { 443, 4, 7, 3, 0, -7 },
  { 447, 4, 7, 4, 0, -7 },
  { 451, 3, 8, 3, 0, -8 },
  { 454, 5, 6, 5, 0, -6 },
  { 458, 4, 6, 4, 1, -6 },
  { 461, 6, 6, 7, 1, -6 },
  { 466, 6, 6, 4, -1, -6 },
  { 471, 6, 9, 4, -1, -6 },
  { 478, 4, 6, 3, 0, -6 },
  { 481, 5, 11, 4, 0, -9 },
  { 488, 1, 12, 4, 2, -9 },
  { 490, 5, 11, 4, -1, -9 },
  { 497, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Italic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC12PT7B_H_
