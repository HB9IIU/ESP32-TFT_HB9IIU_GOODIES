#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x63, 0x18, 0x84, 0x23, 0x00, 0x0C, 0x60, 0x6D, 0x2D,
  0xB6, 0x90, 0x0D, 0x84, 0x82, 0x43, 0x67, 0xF8, 0x90, 0xD8, 0x48, 0xFF,
  0x7F, 0x12, 0x09, 0x04, 0x84, 0x80, 0x04, 0x04, 0x1F, 0x34, 0x28, 0x28,
  0x38, 0x18, 0x0C, 0x16, 0x16, 0x16, 0xDC, 0xF8, 0x20, 0x20, 0x38, 0xC9,
  0x31, 0x24, 0x65, 0x89, 0xA1, 0x2D, 0xA5, 0x57, 0x7B, 0x0A, 0x42, 0x48,
  0x49, 0x11, 0x62, 0x28, 0x87, 0x00, 0x1E, 0x12, 0x12, 0x36, 0x14, 0x1C,
  0x18, 0x79, 0x4B, 0xCE, 0xCE, 0x84, 0xCE, 0x76, 0x6B, 0x68, 0x0C, 0x21,
  0x0C, 0x20, 0x86, 0x10, 0x41, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x60, 0x18,
  0x20, 0x83, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x30, 0x86, 0x10, 0x80,
  0x12, 0x4F, 0xCC, 0x53, 0x60, 0x10, 0x20, 0x40, 0x8F, 0xFF, 0xC4, 0x08,
  0x10, 0x20, 0x36, 0x44, 0x80, 0xF8, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x1E,
  0x13, 0x33, 0x23, 0x63, 0x63, 0x62, 0x42, 0x46, 0x46, 0xC4, 0xCC, 0x48,
  0x70, 0x19, 0xF5, 0x23, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x60, 0x0F, 0x08,
  0xC0, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04,
  0x07, 0xF0, 0x3E, 0x23, 0x03, 0x03, 0x02, 0x06, 0x38, 0x0C, 0x04, 0x06,
  0x04, 0x0C, 0x9C, 0xF8, 0x03, 0x07, 0x0E, 0x0A, 0x16, 0x16, 0x24, 0x64,
  0x44, 0xFE, 0xFE, 0x08, 0x08, 0x18, 0x1F, 0x10, 0x30, 0x20, 0x20, 0x78,
  0x7C, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x9C, 0xF8, 0x0F, 0x18, 0x10, 0x30,
  0x20, 0x7C, 0x76, 0x62, 0x42, 0x46, 0xC6, 0x44, 0x6C, 0x78, 0x7F, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0xC0,
  0x1F, 0x33, 0x21, 0x23, 0x32, 0x36, 0x18, 0x3C, 0x44, 0xC6, 0x86, 0x86,
  0xCC, 0x78, 0x1E, 0x33, 0x23, 0x63, 0x63, 0x63, 0x66, 0x7A, 0x36, 0x06,
  0x04, 0x0C, 0x18, 0xF0, 0x33, 0x20, 0x00, 0x00, 0x0C, 0xC0, 0x18, 0xC4,
  0x00, 0x00, 0x00, 0x11, 0x18, 0x8C, 0x40, 0x02, 0x0C, 0x73, 0x8C, 0x1C,
  0x0E, 0x07, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0x81, 0xC0,
  0xE0, 0x61, 0xCE, 0x70, 0x80, 0x3C, 0x4C, 0x18, 0x20, 0xC3, 0x04, 0x10,
  0x20, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x07, 0xC0, 0x82, 0x10, 0x23, 0x12,
  0x27, 0xB6, 0xDA, 0x49, 0x24, 0x92, 0x59, 0x25, 0xB4, 0xDD, 0x4C, 0xD8,
  0x40, 0x04, 0x00, 0x32, 0x01, 0xC0, 0x07, 0x07, 0x07, 0x0F, 0x0B, 0x1B,
  0x13, 0x33, 0x3F, 0x23, 0x63, 0x43, 0xC3, 0xC3, 0x1F, 0x08, 0xCC, 0x66,
  0x33, 0x11, 0x18, 0xF0, 0xCC, 0x63, 0x31, 0x90, 0x88, 0xCC, 0xE7, 0xC0,
  0x04, 0x1F, 0x31, 0x20, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0xC0, 0xC8, 0x78, 0x1F, 0x09, 0xCC, 0x66, 0x33, 0x19, 0x0C, 0x86, 0xC3,
  0x61, 0x31, 0x90, 0xC8, 0xCD, 0xC7, 0xC0, 0x1F, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x3E, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xF8, 0x1F, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x3E, 0x7C, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x02,
  0x0F, 0xCC, 0x24, 0x06, 0x02, 0x03, 0x01, 0x8E, 0xCF, 0x41, 0xA0, 0x90,
  0x4C, 0x67, 0x31, 0xF8, 0x18, 0xC4, 0x33, 0x0C, 0xC2, 0x31, 0x88, 0x63,
  0xF9, 0x84, 0x61, 0x18, 0xC4, 0x31, 0x0C, 0xC2, 0x31, 0x80, 0x1F, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0xF8,
  0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x10, 0xF0, 0xE0, 0x19, 0xC4, 0x43, 0x30, 0xD8, 0x34,
  0x0B, 0x03, 0x81, 0xE0, 0x6C, 0x1B, 0x04, 0xC1, 0x10, 0xC6, 0x31, 0x80,
  0x18, 0x8C, 0x63, 0x10, 0x8C, 0x63, 0x10, 0x8C, 0x7C, 0x18, 0x18, 0xC1,
  0xCE, 0x0E, 0x70, 0xF3, 0x85, 0x14, 0x68, 0xB2, 0xCD, 0xB6, 0x6D, 0x32,
  0x69, 0x13, 0xC8, 0x9C, 0xCC, 0xE6, 0x66, 0x20, 0x18, 0x63, 0x08, 0xE1,
  0x1E, 0x63, 0xCC, 0x59, 0x09, 0x23, 0x24, 0x65, 0x88, 0xF1, 0x1C, 0x23,
  0x8C, 0x31, 0x86, 0x00, 0x1F, 0x18, 0x98, 0x6C, 0x34, 0x1E, 0x0F, 0x05,
  0x82, 0x83, 0x41, 0xA1, 0x98, 0xCC, 0xC3, 0xC0, 0x1F, 0x13, 0x31, 0x31,
  0x31, 0x23, 0x26, 0x7E, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x1F, 0x18,
  0x98, 0x6C, 0x34, 0x1E, 0x0B, 0x05, 0x82, 0x83, 0x41, 0xA1, 0x98, 0xCC,
  0xC3, 0xC0, 0x60, 0x30, 0x1C, 0x00, 0x1F, 0x13, 0x31, 0x31, 0x31, 0x23,
  0x26, 0x7C, 0x6C, 0x6C, 0x4C, 0x44, 0xC4, 0xC6, 0x1F, 0x31, 0x20, 0x20,
  0x20, 0x30, 0x18, 0x0C, 0x0C, 0x04, 0x04, 0x0C, 0x9C, 0xF8, 0x7E, 0x30,
  0x40, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x00, 0x31,
  0x90, 0xD8, 0x4C, 0x26, 0x32, 0x1B, 0x09, 0x84, 0xC6, 0x43, 0x21, 0x90,
  0x8C, 0xC3, 0xC0, 0x83, 0x86, 0x86, 0x8C, 0x8C, 0x88, 0x98, 0x90, 0xB0,
  0xB0, 0xA0, 0xE0, 0xC0, 0xC0, 0x43, 0x0D, 0x0C, 0x64, 0x71, 0x91, 0x44,
  0x47, 0x31, 0x3C, 0x84, 0xB6, 0x16, 0xD8, 0x53, 0x41, 0x4F, 0x0F, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x0C, 0x00, 0x18, 0xC6, 0x60, 0x90, 0x2C, 0x0A,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x0D, 0x02, 0x41, 0x98, 0x46, 0x31, 0x80,
  0x43, 0x46, 0x64, 0x6C, 0x68, 0x78, 0x70, 0x30, 0x20, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0x1F, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x07, 0xE0, 0x0F, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x40, 0x48, 0xF0, 0xDB,
  0x64, 0x92, 0x6D, 0xB2, 0x40, 0x1E, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06,
  0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0xF0, 0x0C, 0x0C, 0x1E, 0x16,
  0x22, 0x62, 0xC3, 0xFE, 0xC9, 0x80, 0x1D, 0x3F, 0x33, 0x63, 0x63, 0x42,
  0x42, 0x46, 0xC6, 0x4C, 0x74, 0x18, 0x10, 0x10, 0x30, 0x36, 0x2B, 0x33,
  0x23, 0x63, 0x63, 0x42, 0x42, 0x46, 0xEC, 0xB8, 0x0E, 0x74, 0x83, 0x06,
  0x08, 0x10, 0x60, 0x40, 0xD1, 0xE0, 0x00, 0x80, 0xC0, 0x60, 0x31, 0xD1,
  0xF8, 0xCC, 0xC6, 0x63, 0x21, 0x10, 0x88, 0xCC, 0x62, 0x61, 0xD0, 0x0E,
  0x6C, 0x8B, 0x16, 0x6F, 0x10, 0x60, 0x40, 0xC9, 0xF0, 0x03, 0x83, 0x01,
  0x00, 0x80, 0xE0, 0xF0, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x38, 0x18, 0x00, 0x1D, 0x3F, 0x33, 0x63,
  0x63, 0x42, 0x42, 0x46, 0xC6, 0x4C, 0x74, 0x0C, 0x0C, 0x08, 0xF8, 0xE0,
  0x18, 0x10, 0x10, 0x30, 0x3E, 0x2F, 0x33, 0x22, 0x62, 0x62, 0x46, 0x46,
  0x44, 0xC4, 0xCC, 0x10, 0xC0, 0x03, 0x18, 0x84, 0x63, 0x10, 0x84, 0x63,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0xF0, 0xE0, 0x18, 0x10, 0x10,
  0x30, 0x33, 0x32, 0x24, 0x2C, 0x78, 0x78, 0x68, 0x48, 0x4C, 0xCC, 0xCC,
  0x18, 0x84, 0x63, 0x18, 0x84, 0x63, 0x18, 0x84, 0x63, 0x00, 0x3E, 0x63,
  0xFF, 0x33, 0x32, 0x23, 0x62, 0x26, 0x62, 0x46, 0x64, 0x66, 0x44, 0x4C,
  0x44, 0xCC, 0xC0, 0x3E, 0x2F, 0x33, 0x22, 0x62, 0x62, 0x46, 0x46, 0x44,
  0xC4, 0xCC, 0x0E, 0x36, 0x23, 0x63, 0x63, 0x42, 0x42, 0xC6, 0x46, 0x4C,
  0x78, 0x1B, 0x0A, 0xC6, 0x62, 0x33, 0x19, 0x8C, 0x84, 0x42, 0x23, 0x3B,
  0x1F, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x1D, 0x3F, 0x23, 0x63, 0x63,
  0x42, 0x42, 0x46, 0xC6, 0x4C, 0x74, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x2C,
  0xB3, 0x08, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x00, 0x3E, 0x69, 0x83, 0x06,
  0x06, 0x06, 0x04, 0x09, 0x33, 0xC0, 0x10, 0x8E, 0xF2, 0x11, 0x8C, 0x62,
  0x11, 0x87, 0x00, 0x31, 0x33, 0x23, 0x22, 0x62, 0x62, 0x46, 0x46, 0x44,
  0xCC, 0x74, 0xC7, 0x8B, 0x36, 0x4D, 0x9A, 0x34, 0x78, 0xE1, 0xC3, 0x00,
  0xC4, 0x79, 0x8B, 0x33, 0x6E, 0x6D, 0x49, 0xAB, 0x3D, 0x47, 0x28, 0xA7,
  0x18, 0xC3, 0x18, 0x00, 0x31, 0x89, 0x84, 0x83, 0xC1, 0xC0, 0xC0, 0x70,
  0x78, 0x2C, 0x32, 0x31, 0x00, 0x18, 0xC6, 0x21, 0x98, 0x64, 0x1B, 0x06,
  0xC1, 0xA0, 0x78, 0x1C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x0E, 0x03,
  0x00, 0x1E, 0x7C, 0x10, 0x60, 0x83, 0x0C, 0x18, 0x60, 0x83, 0xE0, 0x07,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x30, 0xC0, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x30, 0xFF, 0xFF, 0xF0, 0x1C, 0x18, 0x10, 0x60, 0xC1,
  0x82, 0x06, 0x06, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x30, 0xE0, 0xF3, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 9, 14, 8, 0, -14 },
  { 30, 8, 16, 8, 0, -15 },
  { 46, 11, 14, 12, 1, -14 },
  { 66, 8, 14, 9, 0, -14 },
  { 80, 3, 5, 4, 2, -14 },
  { 82, 6, 17, 5, 0, -14 },
  { 95, 6, 17, 5, -1, -14 },
  { 108, 6, 6, 7, 2, -15 },
  { 113, 7, 10, 9, 1, -12 },
  { 122, 4, 5, 4, -1, -2 },
  { 125, 5, 1, 5, 0, -6 },
  { 126, 2, 2, 4, 0, -2 },
  { 127, 9, 14, 7, -1, -14 },
  { 143, 8, 14, 8, 0, -14 },
  { 157, 5, 14, 8, 2, -14 },
  { 166, 9, 14, 8, -1, -14 },
  { 182, 8, 14, 8, 0, -14 },
  { 196, 8, 14, 8, 0, -14 },
  { 210, 8, 14, 8, 0, -14 },
  { 224, 8, 14, 8, 0, -14 },
  { 238, 8, 14, 8, 1, -14 },
  { 252, 8, 14, 8, 0, -14 },
  { 266, 8, 14, 8, 0, -14 },
  { 280, 4, 11, 4, 0, -11 },
  { 286, 5, 14, 4, -1, -11 },
  { 295, 7, 9, 9, 1, -12 },
  { 303, 7, 6, 9, 1, -10 },
  { 309, 7, 9, 9, 1, -12 },
  { 317, 7, 14, 6, 0, -14 },
  { 330, 12, 16, 12, 0, -14 },
  { 354, 8, 14, 8, -1, -14 },
  { 368, 9, 14, 9, 0, -14 },
  { 384, 8, 15, 8, 1, -15 },
  { 399, 9, 14, 9, 0, -14 },
  { 415, 8, 14, 7, 0, -14 },
  { 429, 8, 14, 7, 0, -14 },
  { 443, 9, 15, 10, 1, -15 },
  { 460, 10, 14, 10, 0, -14 },
  { 478, 8, 14, 5, -1, -14 },
  { 492, 8, 18, 4, -3, -14 },
  { 510, 10, 14, 8, 0, -14 },
  { 528, 5, 14, 7, 0, -14 },
  { 537, 13, 14, 13, 0, -14 },
  { 560, 11, 14, 10, 0, -14 },
  { 580, 9, 14, 10, 1, -14 },
  { 596, 8, 14, 8, 0, -14 },
  { 610, 9, 17, 10, 1, -14 },
  { 630, 8, 14, 8, 0, -14 },
  { 644, 8, 14, 8, 0, -14 },
  { 658, 7, 14, 7, 1, -14 },
  { 671, 9, 14, 9, 1, -14 },
  { 687, 8, 14, 8, 2, -14 },
  { 701, 14, 14, 13, 1, -14 },
  { 726, 10, 14, 7, -1, -14 },
  { 744, 8, 14, 7, 1, -14 },
  { 758, 9, 14, 7, -1, -14 },
  { 774, 8, 17, 6, -1, -14 },
  { 791, 3, 14, 7, 2, -14 },
  { 797, 7, 17, 6, -1, -14 },
  { 812, 8, 7, 8, 0, -14 },
  { 819, 7, 1, 6, -2, 2 },
  { 820, 3, 3, 5, 3, -15 },
  { 822, 8, 11, 8, 0, -11 },
  { 833, 8, 15, 8, 0, -15 },
  { 848, 7, 11, 6, 0, -11 },
  { 858, 9, 15, 8, 0, -15 },
  { 875, 7, 11, 8, 0, -11 },
  { 885, 9, 20, 5, -2, -15 },
  { 908, 8, 16, 8, 0, -11 },
  { 924, 8, 15, 8, 0, -15 },
  { 939, 5, 15, 4, 0, -15 },
  { 949, 8, 20, 4, -3, -15 },
  { 969, 8, 15, 7, 0, -15 },
  { 984, 5, 15, 4, 0, -15 },
  { 994, 12, 11, 12, 0, -11 },
  { 1011, 8, 11, 8, 0, -11 },
  { 1022, 8, 11, 8, 0, -11 },
  { 1033, 9, 16, 8, -1, -11 },
  { 1051, 8, 16, 8, 0, -11 },
  { 1067, 6, 11, 6, 0, -11 },
  { 1076, 7, 11, 6, 0, -11 },
  { 1086, 5, 13, 5, 0, -13 },
  { 1095, 8, 11, 8, 0, -11 },
  { 1106, 7, 11, 7, 1, -11 },
  { 1116, 11, 11, 11, 1, -11 },
  { 1132, 9, 11, 7, -1, -11 },
  { 1145, 10, 16, 7, -2, -11 },
  { 1165, 7, 11, 6, -1, -11 },
  { 1175, 8, 17, 7, 0, -14 },
  { 1192, 1, 20, 7, 3, -15 },
  { 1195, 7, 17, 7, -1, -14 },
  { 1210, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Italic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC20PT7B_H_
