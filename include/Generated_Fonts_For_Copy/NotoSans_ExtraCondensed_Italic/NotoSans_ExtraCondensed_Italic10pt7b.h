#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x20, 0xB8, 0x33, 0x56, 0xFA, 0xC0, 0x23, 0x64, 0x26,
  0xE4, 0x40, 0x69, 0xAB, 0x37, 0x34, 0xD5, 0x80, 0x75, 0x64, 0xBA, 0xD0,
  0xC0, 0x29, 0x49, 0x24, 0x80, 0x24, 0x92, 0x52, 0x80, 0x5D, 0x50, 0x22,
  0xF2, 0x20, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x35, 0x59, 0x9A,
  0xC0, 0x79, 0x25, 0x20, 0x71, 0x12, 0x48, 0xE0, 0x71, 0x16, 0x22, 0xE0,
  0x13, 0x56, 0xB6, 0x20, 0x74, 0x42, 0x22, 0xE0, 0x34, 0x6D, 0x9A, 0xE0,
  0x71, 0x22, 0x44, 0x80, 0x75, 0x56, 0xAA, 0xE0, 0x75, 0x97, 0x22, 0xC0,
  0x40, 0x80, 0x20, 0x05, 0x80, 0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16,
  0x80, 0x64, 0xA4, 0x20, 0x39, 0x17, 0xED, 0xBA, 0xE8, 0x1C, 0x13, 0x33,
  0x75, 0x90, 0x75, 0x56, 0x99, 0xE0, 0x3A, 0x11, 0x08, 0x41, 0x80, 0x72,
  0x52, 0xA9, 0x4B, 0x80, 0x74, 0x46, 0x88, 0xE0, 0x74, 0x46, 0x88, 0x80,
  0x3A, 0x11, 0x39, 0x49, 0xC0, 0x4A, 0x52, 0xE9, 0x4A, 0x40, 0x32, 0x22,
  0x24, 0xE0, 0x24, 0x94, 0x92, 0x80, 0x5A, 0x98, 0xCA, 0x52, 0x80, 0x49,
  0x29, 0x38, 0x66, 0xC9, 0xB3, 0x6B, 0x56, 0xAA, 0x00, 0x6B, 0x5A, 0xDB,
  0x4A, 0x40, 0x3A, 0x53, 0x19, 0x49, 0x80, 0x75, 0x57, 0x88, 0x80, 0x3A,
  0x53, 0x19, 0x49, 0x84, 0x20, 0x75, 0x56, 0xAA, 0xA0, 0x74, 0x42, 0x22,
  0xE0, 0xE9, 0x49, 0x20, 0x4A, 0x52, 0xA9, 0x49, 0x80, 0x9A, 0xAC, 0xC8,
  0x80, 0xA6, 0x9A, 0xBA, 0xEA, 0x49, 0x00, 0x29, 0x4C, 0x63, 0x2B, 0x40,
  0xB7, 0x69, 0x20, 0x72, 0x24, 0x48, 0xE0, 0x74, 0x44, 0x88, 0x88, 0xC0,
  0xAA, 0x94, 0x31, 0x12, 0x22, 0x22, 0xC0, 0x25, 0x59, 0xE0, 0x90, 0x79,
  0x9A, 0xE0, 0x44, 0x65, 0x59, 0x9E, 0x72, 0x4E, 0x08, 0x4C, 0xA9, 0x4A,
  0x9C, 0x79, 0xE8, 0xE0, 0x12, 0x36, 0x24, 0x44, 0x4C, 0x79, 0x9A, 0xE2,
  0xE0, 0x44, 0x65, 0x59, 0xAA, 0x45, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x44,
  0x47, 0x66, 0xAA, 0x55, 0x6A, 0x7D, 0x59, 0x6A, 0xA8, 0x75, 0x9A, 0xA0,
  0x79, 0x9A, 0xE0, 0x75, 0x99, 0xE8, 0x80, 0x79, 0x9A, 0xE2, 0x20, 0x6A,
  0x48, 0x69, 0x1C, 0x4D, 0x29, 0x30, 0x55, 0x9A, 0xE0, 0xBB, 0x48, 0xEF,
  0xAD, 0x4A, 0x00, 0x76, 0x4A, 0xA0, 0x29, 0x8C, 0x42, 0x23, 0x00, 0x69,
  0x4C, 0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x21, 0x22, 0x32, 0x24,
  0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 3, 2, 3, 1, -7 },
  { 5, 4, 7, 4, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 6, 7, 6, 0, -7 },
  { 20, 4, 7, 4, 0, -7 },
  { 24, 1, 2, 2, 1, -7 },
  { 25, 3, 9, 3, 0, -7 },
  { 29, 3, 9, 3, -1, -7 },
  { 33, 3, 4, 4, 1, -8 },
  { 35, 4, 5, 4, 0, -6 },
  { 38, 1, 2, 2, 0, -1 },
  { 39, 2, 1, 3, 0, -3 },
  { 40, 1, 1, 2, 0, -1 },
  { 41, 4, 7, 3, 0, -7 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 3, 7, 4, 1, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 4, 7, 4, 0, -7 },
  { 76, 4, 7, 4, 0, -7 },
  { 80, 4, 7, 4, 0, -7 },
  { 84, 2, 5, 2, 0, -5 },
  { 86, 3, 6, 2, -1, -5 },
  { 89, 4, 5, 4, 0, -6 },
  { 92, 4, 3, 4, 0, -5 },
  { 94, 4, 5, 4, 0, -6 },
  { 97, 3, 7, 3, 0, -7 },
  { 100, 6, 8, 6, 0, -7 },
  { 106, 4, 7, 4, -1, -7 },
  { 110, 4, 7, 4, 0, -7 },
  { 114, 5, 7, 4, 0, -7 },
  { 119, 5, 7, 5, 0, -7 },
  { 124, 4, 7, 4, 0, -7 },
  { 128, 4, 7, 3, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 4, 7, 3, -1, -7 },
  { 146, 3, 9, 2, -1, -7 },
  { 150, 5, 7, 4, 0, -7 },
  { 155, 3, 7, 3, 0, -7 },
  { 158, 7, 7, 6, 0, -7 },
  { 165, 5, 7, 5, 0, -7 },
  { 170, 5, 7, 5, 0, -7 },
  { 175, 4, 7, 4, 0, -7 },
  { 179, 5, 9, 5, 0, -7 },
  { 185, 4, 7, 4, 0, -7 },
  { 189, 4, 7, 4, 0, -7 },
  { 193, 3, 7, 3, 1, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 4, 7, 4, 1, -7 },
  { 205, 6, 7, 7, 1, -7 },
  { 211, 5, 7, 4, -1, -7 },
  { 216, 3, 7, 4, 1, -7 },
  { 219, 4, 7, 3, 0, -7 },
  { 223, 4, 9, 3, 0, -7 },
  { 228, 2, 7, 3, 1, -7 },
  { 230, 4, 9, 3, -1, -7 },
  { 235, 4, 4, 4, 0, -7 },
  { 237, 3, 1, 3, -1, 1 },
  { 238, 2, 2, 2, 1, -8 },
  { 239, 4, 5, 4, 0, -5 },
  { 242, 4, 8, 4, 0, -8 },
  { 246, 3, 5, 3, 0, -5 },
  { 248, 5, 8, 4, 0, -8 },
  { 253, 4, 5, 4, 0, -5 },
  { 256, 4, 10, 2, -1, -8 },
  { 261, 4, 7, 4, 0, -5 },
  { 265, 4, 8, 4, 0, -8 },
  { 269, 2, 7, 2, 0, -7 },
  { 271, 3, 9, 2, -1, -7 },
  { 275, 4, 8, 4, 0, -8 },
  { 279, 2, 8, 2, 0, -8 },
  { 281, 6, 5, 6, 0, -5 },
  { 285, 4, 5, 4, 0, -5 },
  { 288, 4, 5, 4, 0, -5 },
  { 291, 4, 7, 4, 0, -5 },
  { 295, 4, 7, 4, 0, -5 },
  { 299, 3, 5, 3, 0, -5 },
  { 301, 3, 5, 3, 0, -5 },
  { 303, 3, 7, 2, 0, -7 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 3, 5, 3, 1, -5 },
  { 311, 5, 5, 5, 1, -5 },
  { 315, 4, 5, 3, 0, -5 },
  { 318, 5, 7, 3, -1, -5 },
  { 323, 3, 5, 3, 0, -5 },
  { 325, 4, 9, 3, 0, -7 },
  { 330, 1, 10, 4, 1, -8 },
  { 332, 4, 9, 3, -1, -7 },
  { 337, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Italic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC10PT7B_H_
