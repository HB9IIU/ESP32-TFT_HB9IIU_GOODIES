#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83,
  0x06, 0x00, 0x00, 0x00, 0xC3, 0x87, 0x00, 0x67, 0x66, 0x66, 0xC6, 0xCC,
  0xCC, 0xCC, 0x03, 0x30, 0x19, 0x80, 0x88, 0x0C, 0xC0, 0x66, 0x02, 0x34,
  0xFF, 0xC1, 0x98, 0x08, 0xC0, 0xC4, 0x06, 0x60, 0x23, 0x0F, 0xFE, 0x7F,
  0xE0, 0xCC, 0x0C, 0x40, 0x66, 0x03, 0x30, 0x11, 0x01, 0x98, 0x00, 0x01,
  0x80, 0x20, 0x1F, 0x07, 0xF1, 0x92, 0x36, 0x0C, 0x81, 0x90, 0x1A, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x78, 0x0B, 0x03, 0x60, 0x4C, 0x09, 0x9D, 0x73,
  0xFC, 0x1E, 0x01, 0x00, 0x20, 0x04, 0x00, 0x1E, 0x0C, 0x6C, 0x30, 0xC8,
  0x43, 0x11, 0x86, 0x62, 0x0C, 0xCC, 0x11, 0x90, 0x63, 0x60, 0xCC, 0x9D,
  0x9B, 0x6F, 0xE4, 0x9B, 0x9B, 0x30, 0x66, 0x60, 0xC8, 0xC3, 0x31, 0x86,
  0x62, 0x18, 0xCC, 0x31, 0x98, 0xC3, 0x61, 0x83, 0x80, 0x07, 0x80, 0xFC,
  0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0xCC, 0x1D, 0x80, 0xF0, 0x0F, 0x00, 0xE0,
  0x3E, 0x13, 0x66, 0x67, 0x6E, 0x3E, 0xC3, 0xCC, 0x3C, 0xC3, 0x8C, 0x78,
  0xFF, 0xC7, 0xCC, 0x6D, 0xFD, 0xB0, 0x01, 0x81, 0x81, 0x81, 0xC0, 0xC0,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x06, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xE0, 0x1C, 0x18, 0xD8,
  0xFF, 0x1F, 0x38, 0x6C, 0xC6, 0x44, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x39,
  0x9C, 0xC6, 0x63, 0x00, 0x7E, 0xFB, 0xF0, 0x7F, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0x07, 0x83, 0xE1, 0x8C, 0xE3, 0x30, 0xDC, 0x36, 0x0D,
  0x83, 0x61, 0xF8, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0x0C, 0xC6,
  0x33, 0x8F, 0xC1, 0xE0, 0x0E, 0x3C, 0xF3, 0xEC, 0xC9, 0x87, 0x0C, 0x18,
  0x30, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x87, 0x00, 0x07, 0xE0,
  0xFE, 0x0C, 0x70, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xC3, 0xFC, 0x43, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x0E, 0x07, 0x83, 0xC0, 0x7C, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x90, 0xE3, 0xF8, 0x7E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0x60, 0x36, 0x02, 0x60, 0x6E, 0x0C, 0xC0, 0x8C, 0x18,
  0xC3, 0x0C, 0x31, 0x86, 0x18, 0x7F, 0xEF, 0xFE, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x0F, 0xE1, 0xFC, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0x80, 0x3F, 0x07, 0xF0, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x90, 0xE3, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x30, 0x7F, 0x1F, 0x73, 0x86, 0x70, 0xCC, 0x19,
  0x83, 0x30, 0xE6, 0x18, 0xC3, 0x18, 0xE3, 0xF8, 0x3E, 0x00, 0x3F, 0xE7,
  0xFC, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x00, 0x07, 0xC1, 0xFC, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x30,
  0xCE, 0x0F, 0x81, 0xC0, 0x7C, 0x19, 0xC6, 0x19, 0xC3, 0x30, 0x66, 0x0C,
  0xC1, 0x9C, 0x73, 0xFC, 0x3F, 0x00, 0x07, 0x81, 0xF8, 0x73, 0x9C, 0x33,
  0x06, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xE6, 0x38, 0xEF, 0x1F, 0x60, 0xDC,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC3, 0xF0, 0x7C, 0x00, 0x18, 0x71,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x00, 0x0E, 0x1C,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C, 0x30,
  0x61, 0x82, 0x00, 0x00, 0x40, 0x70, 0x7C, 0x3C, 0x3C, 0x3C, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x80, 0x60, 0x00, 0x1F, 0x1F, 0xC8,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x02, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x38, 0x1C, 0x00, 0x01, 0xF8, 0x0F, 0x38,
  0x30, 0x30, 0xC0, 0x31, 0x80, 0x66, 0x1E, 0xC8, 0xF9, 0xB1, 0x33, 0x66,
  0x66, 0x88, 0xCF, 0x31, 0x1E, 0x66, 0x2C, 0xCC, 0xD1, 0x19, 0xA2, 0x76,
  0x47, 0xF8, 0x86, 0x61, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x08, 0x07,
  0xF0, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x06, 0xC0, 0xD8,
  0x3B, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x31, 0xFE, 0x3F, 0xCE, 0x19, 0x83,
  0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x30, 0x0F, 0xC0, 0xFE, 0x0C, 0x71, 0xC3,
  0x1C, 0x31, 0x83, 0x18, 0x71, 0x86, 0x39, 0xC3, 0xF0, 0x3F, 0xC3, 0x0C,
  0x30, 0xE7, 0x0E, 0x60, 0xE6, 0x0C, 0x61, 0xC6, 0x38, 0xFF, 0x8F, 0xE0,
  0x03, 0xF0, 0xFE, 0x1C, 0x21, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0x1C, 0x38,
  0x61, 0xC3, 0x0C, 0x1C, 0x60, 0xE3, 0x07, 0x38, 0x31, 0x81, 0x8C, 0x0C,
  0x60, 0xE3, 0x07, 0x38, 0x31, 0x83, 0x8C, 0x18, 0x61, 0xC3, 0x1C, 0x3F,
  0xC1, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0xF0, 0xFE, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0xF8, 0x3F, 0x83,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0x03, 0xF8, 0x3F, 0xC3, 0x82, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x0F, 0xB8, 0x7D, 0x80, 0xCC, 0x06, 0x60, 0x33,
  0x03, 0x98, 0x1C, 0xE0, 0xC3, 0x06, 0x1F, 0xF0, 0x7F, 0x00, 0x0C, 0x0C,
  0x30, 0x30, 0xC1, 0xC7, 0x06, 0x1C, 0x18, 0x60, 0x61, 0x83, 0x86, 0x0E,
  0x38, 0x30, 0xFF, 0xC3, 0xFF, 0x0C, 0x1C, 0x30, 0x61, 0xC1, 0x86, 0x06,
  0x18, 0x18, 0x60, 0xE1, 0x83, 0x0E, 0x0C, 0x30, 0x30, 0x0F, 0xC1, 0xE0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x83, 0xF0, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x07, 0xC0, 0xF0, 0x00, 0x0C, 0x1C, 0x30,
  0xE0, 0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x67, 0x01, 0x98, 0x06, 0xC0, 0x3F,
  0x00, 0xD8, 0x03, 0xF0, 0x0E, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x18,
  0xE0, 0x63, 0x81, 0x86, 0x0E, 0x18, 0x30, 0x70, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0x60, 0xFF, 0xFE, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x0F,
  0x01, 0xE1, 0xB0, 0x6C, 0x36, 0x0F, 0x86, 0xC3, 0xE0, 0xD8, 0x6C, 0x3B,
  0x0D, 0x86, 0x63, 0x70, 0xCC, 0x6E, 0x19, 0x99, 0x83, 0x33, 0x30, 0xE6,
  0xC6, 0x18, 0xD9, 0xC3, 0x1E, 0x30, 0x63, 0xC6, 0x0C, 0x78, 0xC3, 0x0E,
  0x18, 0x61, 0xC7, 0x00, 0x0E, 0x06, 0x1C, 0x0C, 0x38, 0x30, 0xF0, 0x61,
  0xB0, 0xC3, 0x61, 0x86, 0xC7, 0x0D, 0x8C, 0x3B, 0x18, 0x66, 0x30, 0xC6,
  0x61, 0x8D, 0xC3, 0x1B, 0x0E, 0x36, 0x18, 0x6C, 0x30, 0xD8, 0x60, 0xF0,
  0xC1, 0xC3, 0x03, 0x86, 0x07, 0x00, 0x07, 0xE0, 0xFF, 0x1C, 0x31, 0x83,
  0x38, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x0C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0,
  0x0F, 0xC0, 0xFE, 0x0C, 0x61, 0xC7, 0x1C, 0x71, 0x87, 0x18, 0x71, 0x86,
  0x38, 0xE3, 0x1C, 0x3F, 0xC3, 0xF0, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0xE0, 0xFF, 0x1C, 0x31, 0x83,
  0x38, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x0C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x0F, 0xC0, 0xFE, 0x0C,
  0x71, 0xC7, 0x1C, 0x71, 0x87, 0x18, 0x71, 0x86, 0x38, 0xE3, 0x1C, 0x3F,
  0x83, 0xF0, 0x33, 0x07, 0x30, 0x63, 0x06, 0x38, 0x63, 0x86, 0x18, 0xE1,
  0x8C, 0x1C, 0x03, 0xF8, 0x7F, 0x83, 0x84, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC2, 0x1C, 0x3F, 0xE0, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0x18, 0x18, 0xC1, 0xC6, 0x0C, 0x70, 0x63, 0x03, 0x18, 0x18, 0xC1, 0xC6,
  0x0C, 0x70, 0x63, 0x03, 0x18, 0x38, 0xC1, 0x8E, 0x0C, 0x70, 0x63, 0x03,
  0x18, 0x38, 0xC1, 0x87, 0x1C, 0x3F, 0xC0, 0xFC, 0x00, 0xE0, 0x7E, 0x06,
  0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x18, 0xE1, 0x8E, 0x30, 0xE3, 0x0E, 0x70,
  0xE6, 0x0E, 0xE0, 0xEC, 0x0E, 0xC0, 0xF8, 0x0F, 0x80, 0xD8, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0xC0, 0xFC, 0x18, 0x1B, 0x87, 0x07, 0x70, 0xE0,
  0xCE, 0x1C, 0x39, 0x87, 0x86, 0x30, 0xF0, 0xC6, 0x36, 0x38, 0xC6, 0xC6,
  0x18, 0xD9, 0xC3, 0x33, 0x30, 0x66, 0x66, 0x0C, 0xCD, 0xC1, 0xB1, 0xB0,
  0x36, 0x36, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x00, 0x06, 0x0C, 0x18, 0x70, 0x71, 0x80, 0xCC, 0x03, 0x30,
  0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x36, 0x01, 0xDC, 0x06, 0x70, 0x38, 0xC0, 0xC3, 0x07, 0x0C,
  0x38, 0x30, 0xE0, 0xD8, 0x76, 0x19, 0x8E, 0x63, 0x19, 0xC6, 0x61, 0xB0,
  0x6C, 0x1E, 0x07, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xE0, 0xF8,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0xE0, 0xFC, 0x00, 0xCC, 0xCC, 0xC6, 0x66,
  0x66, 0x66, 0x67, 0x33, 0x33, 0x33, 0x07, 0xE0, 0xF8, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0xD8,
  0x39, 0x86, 0x31, 0x86, 0x30, 0xEC, 0x0F, 0x81, 0x80, 0xFF, 0xFF, 0xE6,
  0x63, 0x1F, 0x67, 0xF8, 0xC7, 0x38, 0x66, 0x0C, 0xC3, 0xB8, 0x66, 0x0C,
  0xC1, 0x98, 0x33, 0x0E, 0x61, 0x8C, 0x71, 0xFE, 0x1E, 0xC0, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0xF0, 0xFF, 0x1C, 0x67, 0x0C,
  0xE1, 0x98, 0x33, 0x06, 0x61, 0xD8, 0x33, 0x06, 0x60, 0xCC, 0x33, 0x8E,
  0x6F, 0x8D, 0xE0, 0x0F, 0x8F, 0x8C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xE1, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x1F, 0xE3, 0xFC, 0x31, 0xC7, 0x0C, 0x60,
  0xC6, 0x1C, 0xE1, 0x8C, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x8C, 0x30, 0xC7,
  0x0F, 0xF0, 0x7B, 0x00, 0x0F, 0x0F, 0xCC, 0x6C, 0x36, 0x1F, 0x1F, 0x7D,
  0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xF1, 0xF8, 0x00, 0xF8, 0x07,
  0x80, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x00, 0x07, 0xD8, 0x3F, 0x83, 0x1C,
  0x38, 0x61, 0x87, 0x0C, 0x38, 0xE1, 0x86, 0x0C, 0x30, 0x61, 0x87, 0x0C,
  0x38, 0x61, 0x83, 0x1C, 0x1F, 0xE0, 0x7B, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE1, 0x8E, 0x0F, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0xF0, 0xFF, 0x1C, 0xE7, 0x1C, 0xE3, 0x18, 0x63,
  0x0C, 0x61, 0x9C, 0x73, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x61, 0xCC, 0x30,
  0x04, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC7, 0x18,
  0x61, 0x8E, 0x30, 0xC0, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E,
  0x0F, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x18, 0xC6, 0x19, 0x87, 0x70, 0xCC, 0x1B, 0x03, 0xE0, 0x7C, 0x1D, 0x83,
  0x30, 0x67, 0x0C, 0x61, 0x8C, 0x61, 0x8C, 0x30, 0x0E, 0x18, 0x30, 0x60,
  0xC3, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1,
  0x86, 0x0C, 0x00, 0x1B, 0xCF, 0x1F, 0xDF, 0x1C, 0xE3, 0x38, 0xE3, 0x30,
  0xC3, 0x30, 0xC3, 0x30, 0xC3, 0x30, 0xC7, 0x71, 0xC6, 0x61, 0x86, 0x61,
  0x86, 0x61, 0x86, 0xE3, 0x8C, 0xC3, 0x0C, 0xC3, 0x0C, 0x1B, 0xC3, 0xFC,
  0x73, 0x9C, 0x73, 0x8C, 0x61, 0x8C, 0x31, 0x86, 0x71, 0xCC, 0x31, 0x86,
  0x30, 0xCE, 0x19, 0x87, 0x30, 0xC0, 0x0F, 0x07, 0xE3, 0x19, 0xC7, 0x61,
  0xF8, 0x7C, 0x1F, 0x06, 0xC1, 0xB0, 0x6C, 0x3B, 0x0C, 0xC7, 0x3F, 0x87,
  0xC0, 0x0D, 0xE0, 0xFF, 0x0E, 0x31, 0xC3, 0x1C, 0x31, 0x83, 0x18, 0x31,
  0x87, 0x30, 0x63, 0x06, 0x30, 0x63, 0x0C, 0x31, 0xC6, 0xF8, 0x6F, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0x63,
  0xF8, 0xC7, 0x38, 0x66, 0x1C, 0xC3, 0xB8, 0x66, 0x0C, 0xC1, 0x98, 0x33,
  0x0E, 0x61, 0x8C, 0x71, 0xFE, 0x1E, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x00, 0x1B, 0x8F, 0xC7, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x00, 0x1F, 0x9F,
  0xCC, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0x80, 0xC8,
  0xE7, 0xF3, 0xF0, 0x18, 0x30, 0x4B, 0xEF, 0xC6, 0x1C, 0x30, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x30, 0x60, 0xF1, 0xE0, 0x30, 0xCC, 0x33, 0x0D, 0xC3,
  0x61, 0x98, 0x66, 0x19, 0x86, 0xE3, 0xB0, 0xCC, 0x33, 0x1C, 0xC7, 0x3E,
  0xCF, 0x20, 0xC3, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB8, 0xD8,
  0x6C, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x00, 0x61, 0x87, 0x63, 0x86, 0x63,
  0x8E, 0x63, 0x8C, 0x67, 0x8C, 0x67, 0x98, 0x6D, 0x98, 0x6D, 0xB8, 0x69,
  0xB0, 0x79, 0xB0, 0x79, 0xE0, 0x51, 0xE0, 0x71, 0xE0, 0x71, 0xC0, 0xE1,
  0xC0, 0x18, 0x71, 0xCE, 0x0C, 0xC0, 0xDC, 0x0D, 0x80, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xF0, 0x3B, 0x03, 0x30, 0x73, 0x06, 0x30, 0xC3, 0x80,
  0x06, 0x0C, 0x18, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x19, 0xC0, 0x66,
  0x01, 0x98, 0x06, 0xC0, 0x1B, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x3F, 0x8F, 0xE0, 0x01, 0xC1,
  0xF0, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x83,
  0xC0, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x07, 0x80, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x01, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x07, 0x01, 0xC0, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x07, 0x83, 0xC0, 0x30, 0x3F, 0x8F, 0x3F, 0xC1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 20, 7, 0, -20 },
  { 19, 8, 7, 9, 3, -20 },
  { 26, 13, 20, 12, 0, -20 },
  { 59, 11, 23, 11, 0, -21 },
  { 91, 15, 20, 17, 1, -20 },
  { 129, 12, 20, 12, 0, -20 },
  { 159, 3, 7, 5, 3, -20 },
  { 162, 9, 24, 7, 0, -20 },
  { 189, 8, 24, 7, -2, -20 },
  { 213, 8, 9, 10, 3, -21 },
  { 222, 10, 13, 12, 1, -16 },
  { 239, 5, 7, 6, -1, -3 },
  { 244, 7, 3, 7, 0, -9 },
  { 247, 3, 3, 6, 0, -3 },
  { 249, 12, 20, 9, -1, -20 },
  { 279, 10, 20, 11, 1, -20 },
  { 304, 7, 20, 11, 3, -20 },
  { 322, 12, 20, 11, -1, -20 },
  { 352, 11, 20, 11, 0, -20 },
  { 380, 12, 20, 11, -1, -20 },
  { 410, 11, 20, 11, 0, -20 },
  { 438, 11, 20, 11, 1, -20 },
  { 466, 11, 20, 11, 1, -20 },
  { 494, 11, 20, 11, 0, -20 },
  { 522, 11, 20, 11, 0, -20 },
  { 550, 6, 15, 6, 0, -15 },
  { 562, 7, 19, 6, -1, -15 },
  { 579, 10, 12, 12, 1, -16 },
  { 594, 10, 8, 12, 1, -14 },
  { 604, 11, 12, 12, 1, -16 },
  { 621, 9, 20, 8, 0, -20 },
  { 644, 15, 22, 16, 1, -20 },
  { 686, 11, 20, 11, -2, -20 },
  { 714, 12, 20, 12, 0, -20 },
  { 744, 12, 20, 11, 1, -20 },
  { 774, 13, 20, 13, 0, -20 },
  { 807, 11, 20, 10, 0, -20 },
  { 835, 12, 20, 10, 0, -20 },
  { 865, 13, 20, 14, 1, -20 },
  { 898, 14, 20, 14, 0, -20 },
  { 933, 10, 20, 7, -1, -20 },
  { 958, 11, 25, 6, -4, -20 },
  { 993, 14, 20, 11, 0, -20 },
  { 1028, 8, 20, 9, 0, -20 },
  { 1048, 19, 20, 18, 0, -20 },
  { 1096, 15, 20, 14, 0, -20 },
  { 1134, 12, 20, 14, 1, -20 },
  { 1164, 12, 20, 11, 0, -20 },
  { 1194, 12, 25, 14, 1, -20 },
  { 1232, 12, 20, 12, 0, -20 },
  { 1262, 13, 20, 11, -1, -20 },
  { 1295, 10, 20, 10, 2, -20 },
  { 1320, 13, 20, 13, 1, -20 },
  { 1353, 12, 20, 11, 2, -20 },
  { 1383, 19, 20, 18, 2, -20 },
  { 1431, 14, 20, 10, -2, -20 },
  { 1466, 10, 20, 10, 2, -20 },
  { 1491, 12, 20, 9, -1, -20 },
  { 1521, 11, 25, 8, -1, -20 },
  { 1556, 4, 20, 10, 3, -20 },
  { 1566, 11, 25, 8, -2, -20 },
  { 1601, 11, 11, 11, 0, -20 },
  { 1617, 8, 2, 8, -2, 2 },
  { 1619, 4, 4, 7, 4, -21 },
  { 1621, 11, 15, 12, 1, -15 },
  { 1642, 11, 21, 12, 0, -21 },
  { 1671, 9, 15, 9, 1, -15 },
  { 1688, 12, 21, 12, 1, -21 },
  { 1720, 9, 15, 11, 1, -15 },
  { 1737, 13, 28, 6, -3, -21 },
  { 1783, 13, 22, 12, -1, -15 },
  { 1819, 11, 21, 12, 0, -21 },
  { 1848, 6, 21, 5, 0, -21 },
  { 1864, 10, 28, 5, -4, -21 },
  { 1899, 11, 21, 10, 0, -21 },
  { 1928, 7, 21, 5, 0, -21 },
  { 1947, 16, 15, 17, 0, -15 },
  { 1977, 11, 15, 12, 0, -15 },
  { 1998, 10, 15, 11, 1, -15 },
  { 2017, 12, 22, 12, -1, -15 },
  { 2050, 11, 22, 12, 1, -15 },
  { 2081, 9, 15, 8, 0, -15 },
  { 2098, 9, 15, 9, 0, -15 },
  { 2115, 7, 18, 7, 1, -18 },
  { 2131, 10, 15, 12, 1, -15 },
  { 2150, 9, 15, 9, 2, -15 },
  { 2167, 16, 15, 15, 1, -15 },
  { 2197, 12, 15, 10, -1, -15 },
  { 2220, 14, 22, 10, -3, -15 },
  { 2259, 10, 15, 8, -1, -15 },
  { 2278, 10, 24, 9, 1, -20 },
  { 2308, 2, 28, 10, 4, -21 },
  { 2315, 10, 24, 9, -2, -20 },
  { 2345, 11, 4, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Italic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC28PT7B_H_
