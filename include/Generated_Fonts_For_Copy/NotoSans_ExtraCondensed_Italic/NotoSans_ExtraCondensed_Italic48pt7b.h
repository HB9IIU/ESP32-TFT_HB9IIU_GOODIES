#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0x80, 0x7C, 0x07,
  0x80, 0xF8, 0x07, 0x00, 0x3C, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE7, 0x8F,
  0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0x71, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1,
  0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C,
  0x18, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0C, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x79, 0x8C, 0x07, 0x18, 0x00, 0xF1, 0x80, 0x0F,
  0x18, 0x00, 0xE1, 0x00, 0x0F, 0x30, 0x00, 0xF3, 0x00, 0x0F, 0xB0, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x0D, 0xE0, 0x00, 0xCF, 0x00, 0x0C, 0xF0, 0x00, 0xC7,
  0x00, 0x08, 0x70, 0x01, 0x87, 0x00, 0x18, 0xF0, 0x81, 0x8E, 0x0E, 0x19,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xF8, 0x03, 0x80, 0xFF, 0x01, 0xC0, 0x39, 0xC0,
  0x70, 0x1C, 0x70, 0x38, 0x07, 0x1C, 0x0E, 0x03, 0x87, 0x07, 0x00, 0xE1,
  0xC1, 0xC0, 0x70, 0x70, 0xE0, 0x1C, 0x1C, 0x38, 0x07, 0x07, 0x1C, 0x01,
  0xC3, 0xC7, 0x00, 0x70, 0xE3, 0x80, 0x38, 0x38, 0xE0, 0x0E, 0x0E, 0x70,
  0xF3, 0x87, 0x1C, 0xFE, 0xE1, 0xCE, 0x7F, 0xB8, 0xF3, 0x9C, 0xE7, 0x39,
  0xCE, 0x1D, 0xFC, 0xF3, 0x87, 0x7E, 0x39, 0xC1, 0xC7, 0x1E, 0x70, 0xE0,
  0x07, 0x1C, 0x38, 0x03, 0xCF, 0x0E, 0x00, 0xE3, 0x83, 0x80, 0x70, 0xE0,
  0xE0, 0x1C, 0x38, 0x38, 0x0E, 0x0E, 0x1C, 0x03, 0x83, 0x87, 0x01, 0xC0,
  0xE1, 0xC0, 0x70, 0x38, 0xE0, 0x38, 0x0E, 0x38, 0x0E, 0x03, 0xBC, 0x07,
  0x00, 0xFE, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0x80,
  0x3C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x78, 0x03, 0x87, 0x00, 0x3C, 0xF0,
  0x03, 0xCE, 0x00, 0x3D, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0x1E, 0x70, 0xE3, 0xC7,
  0x9E, 0x78, 0x79, 0xE7, 0x87, 0x9C, 0xF0, 0x3F, 0xCF, 0x03, 0xF8, 0xF0,
  0x3F, 0x8F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x3F, 0x0F,
  0x8F, 0xF0, 0xFF, 0xF7, 0x87, 0xFE, 0x78, 0x3F, 0x87, 0xC0, 0x3C, 0xF7,
  0x9E, 0x79, 0xE7, 0x1C, 0xF3, 0x8E, 0x38, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x43, 0x83, 0xCE, 0x0F, 0xFB, 0xDF, 0xFF, 0x0F, 0xFC,
  0x3E, 0x01, 0xF8, 0x0F, 0x70, 0x79, 0xE3, 0xE3, 0x83, 0x0F, 0x08, 0x30,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x27, 0xBF, 0xEF, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xC7, 0x81, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C,
  0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0,
  0x38, 0x3C, 0x1E, 0x0F, 0x0F, 0x01, 0xE7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xE3, 0xFE,
  0x79, 0xEF, 0x1C, 0x63, 0xC4, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x0E, 0x0F, 0x00, 0x40, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0x81, 0xF0, 0x10, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x80, 0x3E, 0x0C, 0x07, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0F, 0xE0,
  0x01, 0xDE, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x07, 0x3C,
  0x00, 0xE3, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87,
  0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0xF0, 0x1C, 0x0F, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x06, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x08, 0x03,
  0xE0, 0xE0, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x60, 0x0F, 0x7F, 0x01, 0xDF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xC3, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC3, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xF0, 0x7C, 0x1E,
  0x0F, 0x03, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x83, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x00, 0xF7, 0xC0,
  0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xDE, 0x01,
  0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x07, 0x87, 0xC1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7C, 0x3C,
  0x0F, 0x07, 0x83, 0xC0, 0x70, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xF0,
  0xE0, 0x1E, 0x1E, 0x07, 0xC3, 0xC1, 0xF8, 0x7C, 0x7F, 0x0F, 0xFD, 0xC0,
  0xFF, 0x78, 0x0F, 0xCF, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x04, 0x0F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x83, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x18, 0x38, 0x1F, 0xC3, 0x87, 0x07, 0xF8, 0x71, 0xC1, 0xE7, 0x0E, 0x38,
  0x70, 0xE1, 0xCE, 0x0E, 0x1C, 0x31, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1,
  0xC6, 0x1C, 0x1C, 0x39, 0xC3, 0x83, 0x87, 0x38, 0x70, 0xE0, 0xC7, 0x0C,
  0x1C, 0x38, 0xC3, 0x83, 0x87, 0x38, 0x70, 0xF0, 0xE7, 0x0E, 0x1C, 0x38,
  0xE1, 0xC3, 0x87, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0xB6, 0x38, 0x70, 0xFE,
  0xFE, 0x0E, 0x0F, 0x8F, 0x81, 0xC0, 0x40, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x00, 0x3C,
  0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x8E, 0x01, 0xE1,
  0xC0, 0x3C, 0x38, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x0F,
  0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E,
  0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3C,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0x83, 0xE0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x1E, 0x07, 0x81,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xF0,
  0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xE3, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xE0, 0x40, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC1, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0xFC, 0x03, 0xC0, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1E, 0x07, 0x80, 0x7C, 0x1E,
  0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0x80, 0x7C,
  0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x01,
  0x80, 0xFC, 0x01, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x1F, 0xE3, 0xC0, 0x3F, 0xC7, 0x80, 0xFF, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x3F, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E,
  0x03, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x3C, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1E, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0xE0,
  0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x38, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0x70, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0x3E, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01,
  0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0x73, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xC0,
  0x01, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xDC, 0x07, 0xB8, 0x03,
  0xFC, 0x07, 0xB8, 0x03, 0xFC, 0x07, 0xB8, 0x03, 0xBC, 0x07, 0x38, 0x07,
  0xBC, 0x07, 0x38, 0x07, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x38, 0x0E,
  0x78, 0x0F, 0x38, 0x1E, 0x78, 0x0E, 0x38, 0x1C, 0x78, 0x1E, 0x38, 0x3C,
  0x70, 0x1E, 0x38, 0x38, 0xF0, 0x1E, 0x38, 0x78, 0xF0, 0x1E, 0x38, 0x78,
  0xF0, 0x1C, 0x38, 0x70, 0xE0, 0x3C, 0x38, 0xF1, 0xE0, 0x3C, 0x38, 0xE1,
  0xE0, 0x3C, 0x3D, 0xE1, 0xE0, 0x38, 0x3D, 0xC1, 0xE0, 0x38, 0x3F, 0xC1,
  0xC0, 0x78, 0x3F, 0x83, 0xC0, 0x78, 0x3F, 0x83, 0xC0, 0x78, 0x3F, 0x03,
  0xC0, 0x70, 0x3F, 0x03, 0xC0, 0x70, 0x3F, 0x03, 0x80, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xE0,
  0x1F, 0x00, 0x78, 0x0F, 0xC0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01,
  0xE0, 0x3F, 0x80, 0x70, 0x0E, 0xE0, 0x3C, 0x07, 0xB8, 0x0F, 0x01, 0xEE,
  0x03, 0xC0, 0x7B, 0xC0, 0xE0, 0x1C, 0xF0, 0x78, 0x07, 0x3C, 0x1E, 0x03,
  0xC7, 0x07, 0x80, 0xF1, 0xC1, 0xE0, 0x3C, 0x70, 0x70, 0x0E, 0x1E, 0x3C,
  0x07, 0x87, 0x8F, 0x01, 0xE1, 0xE3, 0xC0, 0x78, 0x38, 0xF0, 0x1E, 0x0E,
  0x38, 0x07, 0x03, 0x9E, 0x03, 0xC0, 0xF7, 0x80, 0xF0, 0x3D, 0xE0, 0x3C,
  0x0F, 0x70, 0x0F, 0x01, 0xDC, 0x03, 0x80, 0x7F, 0x01, 0xE0, 0x1F, 0xC0,
  0x78, 0x07, 0xF0, 0x1E, 0x01, 0xF8, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x0F,
  0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x03, 0xE0, 0x7C,
  0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x07, 0x83, 0xE0, 0x78, 0x0F, 0x8F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3C, 0x3E, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x01,
  0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x03, 0xE0, 0x7C, 0x3E, 0x01, 0xE1,
  0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78,
  0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83,
  0xE0, 0x7C, 0x0F, 0x8F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3C, 0x3F, 0x03, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0x78, 0x0F, 0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0,
  0xF0, 0x7C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x07,
  0x01, 0xE0, 0x10, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x82, 0x00, 0xF8, 0x1E, 0x1F, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xE0, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x78, 0x03, 0xC0, 0x0E, 0x78,
  0x03, 0xC0, 0x1E, 0x78, 0x07, 0xC0, 0x1E, 0x78, 0x07, 0xC0, 0x3C, 0x78,
  0x07, 0xC0, 0x3C, 0x78, 0x0F, 0xC0, 0x38, 0x78, 0x0F, 0xC0, 0x78, 0x78,
  0x1F, 0xC0, 0x78, 0x78, 0x1D, 0xC0, 0xF0, 0x78, 0x1D, 0xC0, 0xF0, 0x78,
  0x3D, 0xC0, 0xE0, 0x78, 0x39, 0xC1, 0xE0, 0x78, 0x39, 0xC1, 0xE0, 0x78,
  0x71, 0xC3, 0xC0, 0x70, 0x71, 0xC3, 0xC0, 0x70, 0xF1, 0xC3, 0xC0, 0x70,
  0xE1, 0xC7, 0x80, 0x70, 0xE1, 0xC7, 0x80, 0x71, 0xE1, 0xCF, 0x00, 0x71,
  0xC3, 0xCF, 0x00, 0x73, 0xC3, 0xCF, 0x00, 0x73, 0x83, 0xDE, 0x00, 0x73,
  0x83, 0xDE, 0x00, 0x77, 0x83, 0xDC, 0x00, 0x77, 0x03, 0xBC, 0x00, 0x7F,
  0x03, 0xBC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x39,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x03, 0x8F, 0x00, 0x07, 0x8F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x07,
  0x80, 0x78, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x38, 0x0F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x78, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0x1D, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0xC0, 0xF0,
  0x70, 0x38, 0x1C, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x39, 0xE0, 0x0E,
  0xF0, 0x03, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1,
  0xF1, 0xE3, 0xC3, 0xC3, 0x87, 0x07, 0x00, 0xF8, 0xE0, 0x7F, 0x9C, 0x1F,
  0xFF, 0x87, 0xE7, 0xF0, 0xF0, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x1E, 0x1F,
  0x03, 0xFE, 0xE0, 0x7F, 0x9C, 0x07, 0xE3, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x7E, 0x03, 0xDF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xC7, 0xC3, 0xF0, 0x78, 0x7C, 0x0F, 0x0F, 0x81,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0E,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0xF0,
  0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0x9F, 0xE0, 0x71, 0xF8, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0x07, 0xFE, 0x07, 0xC4, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x20, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x3E, 0x78, 0x07, 0xFB, 0xC0, 0x7F, 0xFE,
  0x07, 0xC7, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xC1, 0xE0,
  0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xFE, 0xE0, 0x1F, 0xE7, 0x00, 0x7E, 0x38,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xE0, 0xF0, 0x70,
  0xF0, 0x3C, 0x78, 0x1C, 0x78, 0x0E, 0x3C, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F,
  0x8F, 0x7F, 0x87, 0xFF, 0x83, 0xFE, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x60, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x27, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E, 0x38, 0x07, 0xF9, 0xC0,
  0x7F, 0xFE, 0x03, 0xC7, 0xE0, 0x3C, 0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0xF8, 0x1E, 0x0F, 0xC0, 0xF8, 0xFE, 0x03, 0xFE, 0xE0, 0x1F, 0xEF, 0x00,
  0x7E, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x80, 0x3C, 0x06, 0x07, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x79, 0xF8, 0x1E,
  0xFF, 0x07, 0xFF, 0xC1, 0xF8, 0xF0, 0x7C, 0x3C, 0x3E, 0x07, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE1,
  0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0x70, 0xF0,
  0x3C, 0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x70, 0x1E,
  0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0E, 0x0F, 0x01, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x39, 0xE0, 0x07, 0x3C, 0x01,
  0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x70, 0x07,
  0xCF, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E,
  0x0E, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x1F, 0x07, 0xC0, 0x73, 0xF8, 0xFE, 0x07,
  0x7F, 0xDF, 0xF0, 0x7E, 0x7F, 0x9F, 0x07, 0xC3, 0xF0, 0xF0, 0xF8, 0x3E,
  0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0xF1,
  0xE0, 0x38, 0x0E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07,
  0x81, 0xE1, 0xC0, 0x78, 0x1E, 0x3C, 0x07, 0x01, 0xC3, 0xC0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x38, 0x0F, 0x03, 0x87, 0x80,
  0xE0, 0x38, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x70, 0x1E, 0x07,
  0x8F, 0x01, 0xC0, 0x70, 0xF0, 0x1C, 0x07, 0x0F, 0x03, 0xC0, 0xF0, 0x07,
  0x1F, 0x81, 0xCF, 0xF0, 0x77, 0xFC, 0x1F, 0x8F, 0x07, 0xC3, 0xC3, 0xE0,
  0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0E, 0x1E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C,
  0x07, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07,
  0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x78, 0x07, 0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x7B, 0x80, 0x3D, 0xC0, 0x1F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE1, 0xE1, 0xE0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xE7, 0xE0, 0x0E, 0x7F, 0x80,
  0x77, 0xFC, 0x03, 0xB1, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0x70, 0x07, 0x03, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xBF, 0xE0, 0x3D, 0xFE, 0x01,
  0xE7, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xE0, 0x7F,
  0x9C, 0x1F, 0xFF, 0x83, 0xC7, 0xE0, 0xF0, 0x7C, 0x3C, 0x07, 0x87, 0x80,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0xFC,
  0x3E, 0x3F, 0x03, 0xFE, 0xE0, 0x7F, 0xBC, 0x07, 0xE7, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x07, 0x1E, 0x0E, 0x7C, 0x1D, 0xF8, 0x3F, 0xF0, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF0, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x84, 0x03, 0xC3,
  0x03, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0xF3, 0xFF, 0x3F, 0xE0, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x0F, 0x01, 0xE1,
  0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x07,
  0x80, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C, 0x1E,
  0x07, 0x83, 0x80, 0xF0, 0x70, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x78,
  0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0,
  0xF8, 0x3E, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xB8, 0x07, 0xE7, 0x00, 0xF0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0,
  0x78, 0xF0, 0x70, 0xE0, 0xF0, 0xE0, 0xF0, 0xE1, 0xE0, 0xE1, 0xE0, 0xE1,
  0xC0, 0xE3, 0xC0, 0xE3, 0x80, 0xE7, 0x80, 0xE7, 0x00, 0xEF, 0x00, 0xEF,
  0x00, 0xEE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81,
  0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xE0, 0xF7, 0x03, 0xF0, 0x73, 0x83, 0xB8,
  0x79, 0xC1, 0xFC, 0x38, 0xE1, 0xDE, 0x3C, 0x70, 0xEE, 0x1E, 0x38, 0x77,
  0x0E, 0x1C, 0x73, 0x8F, 0x0E, 0x39, 0xC7, 0x07, 0x3C, 0xE3, 0x83, 0x9C,
  0x73, 0xC1, 0xCE, 0x39, 0xC0, 0xEE, 0x1D, 0xE0, 0x77, 0x0E, 0xE0, 0x3B,
  0x87, 0x70, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1E, 0xF0, 0x01, 0xEE, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xB8, 0x00, 0x7B, 0x80, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0xF3, 0xC0,
  0x00, 0xF3, 0xC0, 0x00, 0xF3, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x81, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x20, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x5F, 0xE0, 0x3F,
  0xFF, 0x1F, 0x9F, 0xFF, 0xC0, 0xFF, 0xA0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 34, 11, 0, -34 },
  { 52, 13, 12, 16, 5, -34 },
  { 72, 22, 34, 20, 0, -34 },
  { 166, 20, 39, 19, 0, -36 },
  { 264, 26, 35, 29, 2, -35 },
  { 378, 20, 35, 21, 0, -35 },
  { 466, 6, 12, 9, 5, -34 },
  { 475, 14, 43, 12, 1, -35 },
  { 551, 15, 43, 12, -4, -35 },
  { 632, 14, 16, 17, 5, -37 },
  { 660, 18, 22, 21, 2, -28 },
  { 710, 8, 11, 10, -2, -5 },
  { 721, 10, 4, 12, 1, -15 },
  { 726, 5, 6, 10, 1, -6 },
  { 730, 22, 34, 16, -2, -34 },
  { 824, 18, 35, 19, 1, -35 },
  { 903, 12, 34, 19, 5, -34 },
  { 954, 21, 35, 19, -2, -35 },
  { 1046, 20, 35, 19, -1, -35 },
  { 1134, 20, 35, 19, -1, -35 },
  { 1222, 20, 34, 19, -1, -34 },
  { 1307, 19, 35, 19, 1, -35 },
  { 1391, 20, 34, 19, 1, -34 },
  { 1476, 19, 35, 19, 0, -35 },
  { 1560, 19, 35, 19, 0, -35 },
  { 1644, 10, 26, 10, 0, -26 },
  { 1677, 12, 32, 10, -2, -26 },
  { 1725, 18, 22, 21, 2, -28 },
  { 1775, 18, 14, 21, 2, -24 },
  { 1807, 18, 22, 21, 2, -28 },
  { 1857, 15, 35, 14, 1, -35 },
  { 1923, 27, 39, 28, 1, -35 },
  { 2055, 19, 34, 19, -3, -34 },
  { 2136, 21, 34, 21, 0, -34 },
  { 2226, 20, 35, 19, 2, -35 },
  { 2314, 22, 34, 22, 0, -34 },
  { 2408, 20, 34, 18, 0, -34 },
  { 2493, 20, 34, 17, 0, -34 },
  { 2578, 23, 35, 24, 2, -35 },
  { 2679, 24, 34, 23, 0, -34 },
  { 2781, 18, 34, 12, -2, -34 },
  { 2858, 18, 43, 10, -7, -34 },
  { 2955, 23, 34, 19, 0, -34 },
  { 3053, 13, 34, 16, 0, -34 },
  { 3109, 32, 34, 31, 0, -34 },
  { 3245, 26, 34, 25, 0, -34 },
  { 3356, 21, 35, 24, 2, -35 },
  { 3448, 20, 34, 19, 0, -34 },
  { 3533, 21, 43, 24, 2, -35 },
  { 3646, 20, 34, 20, 0, -34 },
  { 3731, 21, 35, 18, -1, -35 },
  { 3823, 17, 34, 17, 3, -34 },
  { 3896, 22, 34, 23, 2, -34 },
  { 3990, 19, 34, 19, 4, -34 },
  { 4071, 32, 34, 31, 3, -34 },
  { 4207, 24, 34, 18, -3, -34 },
  { 4309, 18, 34, 17, 3, -34 },
  { 4386, 21, 34, 16, -2, -34 },
  { 4476, 18, 43, 14, -1, -35 },
  { 4573, 8, 34, 16, 5, -34 },
  { 4607, 18, 43, 14, -3, -35 },
  { 4704, 18, 18, 19, 1, -34 },
  { 4745, 15, 3, 15, -4, 4 },
  { 4751, 7, 8, 12, 7, -37 },
  { 4758, 19, 26, 20, 1, -26 },
  { 4820, 19, 36, 20, 0, -36 },
  { 4906, 16, 26, 15, 1, -26 },
  { 4958, 21, 36, 20, 1, -36 },
  { 5053, 17, 26, 18, 1, -26 },
  { 5109, 23, 49, 11, -6, -37 },
  { 5250, 21, 38, 20, -1, -26 },
  { 5350, 18, 36, 20, 0, -36 },
  { 5431, 11, 35, 9, 0, -35 },
  { 5480, 17, 47, 9, -6, -35 },
  { 5580, 19, 36, 17, 0, -36 },
  { 5666, 11, 36, 9, 0, -36 },
  { 5716, 28, 26, 29, 0, -26 },
  { 5807, 18, 26, 20, 0, -26 },
  { 5866, 17, 26, 20, 1, -26 },
  { 5922, 21, 37, 20, -2, -26 },
  { 6020, 19, 37, 20, 1, -26 },
  { 6108, 15, 26, 13, 0, -26 },
  { 6157, 17, 26, 15, -1, -26 },
  { 6213, 12, 32, 11, 1, -32 },
  { 6261, 19, 26, 20, 1, -26 },
  { 6323, 16, 26, 16, 3, -26 },
  { 6375, 25, 26, 26, 3, -26 },
  { 6457, 20, 26, 17, -2, -26 },
  { 6522, 24, 38, 16, -5, -26 },
  { 6636, 17, 26, 14, -2, -26 },
  { 6692, 18, 42, 16, 1, -34 },
  { 6787, 3, 48, 18, 7, -37 },
  { 6805, 17, 42, 16, -3, -34 },
  { 6895, 18, 6, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Italic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC48PT7B_H_
