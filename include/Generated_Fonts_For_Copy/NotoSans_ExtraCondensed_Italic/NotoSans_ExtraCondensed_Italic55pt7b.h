#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x3C,
  0x3E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x78,
  0x78, 0x78, 0x78, 0x70, 0x78, 0x70, 0x70, 0xF0, 0x70, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x38,
  0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x1E, 0x01, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00,
  0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x01, 0xC1, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFE,
  0xFC, 0x07, 0xCC, 0x30, 0x1F, 0x18, 0x00, 0x3C, 0x30, 0x00, 0x78, 0xE0,
  0x00, 0xF1, 0x80, 0x01, 0xE3, 0x00, 0x03, 0xC6, 0x00, 0x07, 0x8C, 0x00,
  0x0F, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x6F, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x1E, 0x00, 0x06, 0x3C, 0x00, 0x0C,
  0x78, 0x00, 0x18, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xC3, 0xC1, 0x01, 0x8F,
  0x83, 0x83, 0x3E, 0x07, 0xE7, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x1E, 0x03, 0xFE, 0x00, 0xE0, 0x1E, 0xF0, 0x0F, 0x01,
  0xE3, 0x80, 0x70, 0x0E, 0x1C, 0x07, 0x80, 0xF0, 0xE0, 0x38, 0x07, 0x07,
  0x03, 0xC0, 0x78, 0x38, 0x3C, 0x03, 0x81, 0xC1, 0xC0, 0x1C, 0x1E, 0x1E,
  0x00, 0xE0, 0xF0, 0xE0, 0x0F, 0x07, 0x8F, 0x00, 0x78, 0x38, 0x70, 0x03,
  0x81, 0xC7, 0x80, 0x1C, 0x1E, 0x38, 0x00, 0xE0, 0xF3, 0xC3, 0xC7, 0x07,
  0x1C, 0x7F, 0x38, 0x79, 0xE3, 0xFD, 0xC3, 0x8E, 0x3C, 0xEE, 0x3C, 0xF3,
  0xC7, 0xFB, 0xC7, 0x1C, 0x3F, 0xFE, 0x79, 0xE1, 0xEF, 0xE3, 0x8E, 0x0F,
  0x1C, 0x3C, 0x70, 0x70, 0x01, 0xC7, 0x83, 0x80, 0x1E, 0x38, 0x1C, 0x00,
  0xE1, 0xC0, 0xE0, 0x0F, 0x0E, 0x0F, 0x00, 0x70, 0xF0, 0x78, 0x07, 0x87,
  0x83, 0x80, 0x78, 0x3C, 0x1C, 0x03, 0xC1, 0xC1, 0xE0, 0x3C, 0x0E, 0x0E,
  0x01, 0xE0, 0x70, 0x70, 0x1E, 0x03, 0x87, 0x80, 0xE0, 0x1E, 0x78, 0x0F,
  0x00, 0xFF, 0x80, 0x70, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x83, 0xC3, 0xDF, 0x0F, 0x8F, 0x1E, 0x1E, 0x3E,
  0x3E, 0x3C, 0x78, 0x7C, 0xF1, 0xE0, 0x79, 0xE3, 0xC0, 0xFF, 0xCF, 0x81,
  0xFF, 0x1E, 0x01, 0xFE, 0x3C, 0x03, 0xF8, 0x78, 0x07, 0xF0, 0xF0, 0x07,
  0xC1, 0xE0, 0x1F, 0x83, 0xC0, 0x7F, 0x07, 0xC1, 0xFF, 0x0F, 0xC7, 0xFE,
  0x0F, 0xFF, 0x3C, 0x1F, 0xFC, 0x7C, 0x1F, 0xE0, 0xF8, 0x02, 0x00, 0x00,
  0x3E, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x02, 0x0E, 0x03, 0x87, 0x01, 0xF3, 0x87, 0xFF, 0xFF,
  0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0xF8, 0x00, 0xFC, 0x00, 0xF7, 0x00, 0xF3,
  0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x18, 0x3C, 0x00, 0x18, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C,
  0x1C, 0x1E, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xF9, 0xF0, 0x1E, 0x0F,
  0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x80,
  0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x7C,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E,
  0x07, 0x87, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF8, 0xFB, 0xCF, 0x9E, 0xF9, 0xF3, 0x8F, 0x18, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x7E, 0x00,
  0x60, 0x3E, 0x00, 0x40, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x0F, 0xC0, 0x18,
  0x0F, 0x80, 0x20, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x06, 0x00, 0xFC, 0x0F, 0x87, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x39, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0xF8, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x07, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x20, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x83, 0x00, 0x7E, 0x07, 0xC3, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7E, 0x08, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x3E, 0x7F, 0x00, 0xF3, 0xFE, 0x03, 0xDF, 0xFC,
  0x0F, 0xE1, 0xF0, 0x7F, 0x03, 0xC1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x3E, 0x00,
  0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0,
  0xF8, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x7E,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80,
  0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE7, 0xC0,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F,
  0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3E, 0x03, 0xE0, 0x7E, 0x1F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0,
  0x7F, 0x07, 0xEF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xBC, 0x03, 0xF1, 0xE0,
  0x06, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x0C, 0x3F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x7C, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00,
  0x00, 0x18, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0xF1, 0xF8, 0x40, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x3C, 0x07, 0xE0, 0xF0, 0x70, 0x1F, 0xF1, 0xE1, 0xE0,
  0x7F, 0xC3, 0xC3, 0x81, 0xE3, 0x87, 0x8F, 0x07, 0x0F, 0x0F, 0x1C, 0x1E,
  0x1E, 0x1C, 0x38, 0x38, 0x38, 0x38, 0xF0, 0xF0, 0x70, 0x71, 0xC1, 0xC1,
  0xE0, 0xE3, 0x83, 0x83, 0xC1, 0xCF, 0x0F, 0x07, 0x07, 0x9E, 0x1C, 0x0E,
  0x0E, 0x38, 0x38, 0x3C, 0x1C, 0x70, 0x70, 0x78, 0x38, 0xE1, 0xE0, 0xE0,
  0xE1, 0xC3, 0xC3, 0xC1, 0xC7, 0x87, 0x87, 0x87, 0x0F, 0x0F, 0x1F, 0x0E,
  0x1E, 0x1E, 0x3E, 0x38, 0x3C, 0x3C, 0xFC, 0xF0, 0x78, 0x3F, 0x9F, 0xC0,
  0xF0, 0x7E, 0x3F, 0x01, 0xE0, 0x38, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x00, 0x3F,
  0x8F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xF8, 0x00,
  0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x3F, 0x01,
  0xE0, 0x1F, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x87, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0x0F, 0xE0, 0x0F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x1E,
  0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C,
  0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x78, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xE1, 0xC0, 0x3F, 0x01, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x10,
  0x03, 0xFB, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8,
  0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xE0, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0x78, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07,
  0xE0, 0x1E, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0x80, 0x7E, 0x00, 0x60, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x78, 0x03, 0xFE, 0x3E,
  0x01, 0xFF, 0x8F, 0x80, 0x7F, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xF8, 0x07, 0xC0,
  0x3F, 0xCF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x78, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x37, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBC, 0x00, 0x07, 0xE7, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x01,
  0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3D,
  0xE0, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0x7B, 0xE0,
  0x1E, 0x78, 0x03, 0xDF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0xF3, 0xE0, 0x1E,
  0x3C, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x78, 0xF0, 0x07, 0x8F, 0x07, 0x87,
  0x80, 0x7C, 0x78, 0x3C, 0x3C, 0x03, 0xC3, 0xC3, 0xE3, 0xE0, 0x1E, 0x1E,
  0x1E, 0x1F, 0x00, 0xF0, 0x70, 0xF0, 0xF0, 0x07, 0x83, 0x8F, 0x07, 0x80,
  0x7C, 0x1C, 0x78, 0x3C, 0x03, 0xC0, 0xF7, 0x83, 0xE0, 0x1E, 0x07, 0xBC,
  0x1E, 0x00, 0xF0, 0x3F, 0xC0, 0xF0, 0x07, 0x81, 0xFE, 0x07, 0x80, 0x7C,
  0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x7F, 0x03, 0xE0, 0x1E, 0x03, 0xF8, 0x1E,
  0x00, 0xF0, 0x1F, 0x80, 0xF0, 0x07, 0x80, 0xFC, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x78,
  0x07, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x1E, 0x01, 0xF8, 0x01, 0xF0, 0x1F,
  0xC0, 0x0F, 0x00, 0xFE, 0x00, 0x78, 0x07, 0xF8, 0x03, 0xC0, 0x3F, 0xC0,
  0x1E, 0x03, 0xDE, 0x01, 0xF0, 0x1E, 0xF0, 0x0F, 0x00, 0xF7, 0x80, 0x78,
  0x07, 0x9C, 0x03, 0xC0, 0x3C, 0xF0, 0x3E, 0x03, 0xE7, 0x81, 0xF0, 0x1E,
  0x3C, 0x0F, 0x00, 0xF1, 0xE0, 0x78, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x38,
  0x3E, 0x03, 0xE1, 0xE1, 0xF0, 0x1E, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x78,
  0x07, 0x83, 0xC3, 0xC0, 0x7C, 0x1E, 0x3E, 0x03, 0xE0, 0x71, 0xE0, 0x1E,
  0x03, 0xCF, 0x00, 0xF0, 0x1E, 0x78, 0x07, 0x80, 0xF3, 0xC0, 0x7C, 0x07,
  0xBE, 0x03, 0xC0, 0x3D, 0xE0, 0x1E, 0x00, 0xEF, 0x00, 0xF0, 0x07, 0xF8,
  0x07, 0x80, 0x3F, 0xC0, 0x7C, 0x01, 0xFE, 0x03, 0xC0, 0x0F, 0xE0, 0x1E,
  0x00, 0x7F, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0x80, 0x0F, 0xC0, 0x7C, 0x00,
  0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F,
  0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0,
  0x78, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07,
  0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x01,
  0xF0, 0x3E, 0x0F, 0xC0, 0x7C, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07,
  0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3E,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F,
  0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xF0, 0x3E, 0x1F, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3C, 0x01, 0xF0,
  0x78, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3E,
  0x07, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0x3C, 0x01, 0xF0, 0x0C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x80, 0x0F, 0xC0, 0xE0, 0x1F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x05, 0x80,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0,
  0x07, 0x80, 0xF0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC,
  0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0,
  0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03,
  0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0x00, 0x1F,
  0x78, 0x01, 0xF0, 0x01, 0xE7, 0x80, 0x1F, 0x00, 0x3E, 0x78, 0x01, 0xF0,
  0x03, 0xC7, 0x80, 0x3F, 0x00, 0x7C, 0x78, 0x03, 0xF0, 0x07, 0xC7, 0x80,
  0x7F, 0x00, 0x78, 0x78, 0x07, 0xF0, 0x0F, 0x87, 0x80, 0x77, 0x00, 0xF0,
  0x78, 0x0F, 0x70, 0x0F, 0x0F, 0x80, 0xF7, 0x01, 0xF0, 0xF8, 0x0E, 0xF0,
  0x1E, 0x0F, 0x81, 0xEF, 0x03, 0xE0, 0xF8, 0x1E, 0xF0, 0x3C, 0x0F, 0x83,
  0xCF, 0x03, 0xC0, 0xF8, 0x3C, 0xF0, 0x7C, 0x0F, 0x83, 0x8F, 0x07, 0x80,
  0xF8, 0x78, 0xF0, 0xF8, 0x0F, 0x87, 0x8F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0,
  0xF0, 0x0F, 0x0F, 0x0F, 0x1F, 0x00, 0xF0, 0xE0, 0xF1, 0xE0, 0x0F, 0x1E,
  0x0F, 0x3E, 0x00, 0xF1, 0xE0, 0xF3, 0xC0, 0x0F, 0x3C, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0xF7, 0xC0, 0x0F, 0x38, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0xE7,
  0x80, 0x0F, 0x78, 0x0E, 0xF0, 0x00, 0xF7, 0x00, 0xEF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF9, 0xE0,
  0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0x78,
  0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7,
  0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0,
  0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0xF8,
  0x03, 0xCF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x07,
  0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x1E, 0x1E, 0x0E,
  0x07, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0xF0, 0x1F, 0xFB, 0xC0, 0xFF, 0xEF,
  0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01,
  0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x81, 0xE0, 0x7E,
  0x07, 0xC7, 0x78, 0x1F, 0xF9, 0xC0, 0x3F, 0xE7, 0x00, 0x7E, 0x3C, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC3, 0xE0, 0x0F, 0x3F, 0xC0, 0x3D, 0xFF, 0x80, 0xFF, 0xFE, 0x07,
  0xF0, 0xF8, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78,
  0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78,
  0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07,
  0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0xF1, 0xF8, 0x3D, 0xFF, 0xC0, 0xF3, 0xFE, 0x03, 0xC7, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07,
  0xC0, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x02,
  0x07, 0xE3, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x07, 0xC3, 0xC0, 0x07, 0xF9, 0xE0, 0x07, 0xFE, 0xF0, 0x07,
  0xFF, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0,
  0x78, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xC1, 0xFC, 0x01, 0xF1,
  0xDE, 0x00, 0xFF, 0xEE, 0x00, 0x3F, 0xE7, 0x00, 0x0F, 0xC7, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x7C, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01,
  0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x03, 0xE7, 0xC1, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x41, 0xF8, 0x38, 0x1F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xCF, 0x00, 0x7F,
  0xEF, 0x00, 0xFF, 0xEE, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x80,
  0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1E, 0x00,
  0xF0, 0x3E, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x1E, 0x0F, 0xE0, 0x1F, 0x1D,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFB, 0xC0, 0x07, 0xE3, 0xC0, 0x01, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x1F, 0x00, 0xC0, 0x3E,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x7C, 0x01,
  0xE7, 0xF8, 0x0F, 0x7F, 0xC0, 0x7F, 0xFF, 0x07, 0xF0, 0xF8, 0x3F, 0x03,
  0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C,
  0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0x80,
  0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x87,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF8, 0x0F,
  0x87, 0x80, 0x78, 0x00, 0x00, 0x20, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0x78, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC1,
  0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00,
  0x3E, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xBC, 0x00, 0x7C, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x03,
  0xCF, 0xF1, 0xFE, 0x03, 0x9F, 0xF3, 0xFF, 0x03, 0xBF, 0xFF, 0xFF, 0x07,
  0xF0, 0xFE, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x07, 0xC0, 0xFC, 0x0F, 0x07,
  0xC0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x1F, 0x0F,
  0x00, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0x1E, 0x1F,
  0x01, 0xE0, 0x1E, 0x1F, 0x01, 0xE0, 0x3E, 0x1E, 0x01, 0xE0, 0x3C, 0x1E,
  0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xE0, 0x3C, 0x3E, 0x03, 0xC0, 0x3C, 0x3C,
  0x03, 0xC0, 0x7C, 0x3C, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC0, 0x78, 0x3C,
  0x07, 0xC0, 0x78, 0x7C, 0x07, 0x80, 0x78, 0x78, 0x07, 0x80, 0xF8, 0x78,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0xF8,
  0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x7F,
  0x80, 0xE7, 0xFC, 0x07, 0x7F, 0xF0, 0x7F, 0x0F, 0x83, 0xF0, 0x3C, 0x1F,
  0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC3,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x78,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x78,
  0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F,
  0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x7E, 0x7E, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x3C, 0xFF, 0x00, 0x1E, 0xFF, 0xC0, 0x0E, 0xFF, 0xE0, 0x0F, 0x60, 0xF0,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x78,
  0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFF, 0xFC, 0x01,
  0xF7, 0xFC, 0x00, 0xF1, 0xFC, 0x00, 0x78, 0x20, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFC, 0xF0, 0x1F, 0xFB, 0xC0, 0xFF, 0xEE, 0x07, 0xC1,
  0xF8, 0x1E, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0,
  0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF1, 0xF0,
  0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F,
  0x87, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x81, 0xE0, 0xFE, 0x07, 0xC7,
  0x78, 0x1F, 0xFF, 0xC0, 0x3F, 0xEF, 0x00, 0x7E, 0x3C, 0x00, 0x40, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x47,
  0xC0, 0xE3, 0xE0, 0x39, 0xF8, 0x0E, 0xFE, 0x07, 0xFD, 0x81, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7C, 0x0C, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x10, 0x07, 0xC3, 0xC3, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0xFF, 0x3F, 0xF8,
  0xFF, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x0C,
  0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x3E, 0x1E,
  0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x3E,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC3, 0xE0,
  0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xE7, 0xF8, 0x1F, 0xFB, 0xC0,
  0xFF, 0x9E, 0x03, 0xF8, 0xE0, 0x03, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0xF0,
  0x07, 0x3C, 0x01, 0xDF, 0x00, 0x77, 0x80, 0x1D, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E, 0x03, 0xEF, 0x81, 0xF8,
  0x0F, 0x3C, 0x07, 0xE0, 0x3C, 0xF0, 0x1F, 0x81, 0xF3, 0xC0, 0xFE, 0x07,
  0x8F, 0x03, 0xB8, 0x1E, 0x3C, 0x1E, 0xE0, 0xF0, 0xF0, 0x7B, 0x83, 0xC3,
  0xC1, 0xDE, 0x1F, 0x0F, 0x0F, 0x78, 0x78, 0x3C, 0x39, 0xE1, 0xE0, 0xF1,
  0xE7, 0x8F, 0x03, 0xC7, 0x9E, 0x3C, 0x0F, 0x1C, 0x79, 0xF0, 0x3C, 0xF1,
  0xE7, 0x80, 0xF3, 0xC7, 0x9E, 0x03, 0xCE, 0x1E, 0xF0, 0x0F, 0x78, 0x7B,
  0xC0, 0x3D, 0xC1, 0xEF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0x77, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0xF0, 0x00, 0x79, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00,
  0x03, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x8F, 0x80,
  0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x09, 0xFE, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xF2, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 39, 13, 1, -39 },
  { 65, 16, 14, 19, 5, -39 },
  { 93, 25, 39, 23, 0, -39 },
  { 215, 23, 45, 22, 0, -42 },
  { 345, 29, 41, 33, 3, -40 },
  { 494, 23, 41, 24, 0, -40 },
  { 612, 7, 14, 10, 6, -39 },
  { 625, 17, 49, 14, 1, -40 },
  { 730, 17, 49, 14, -4, -40 },
  { 835, 17, 18, 20, 5, -42 },
  { 874, 20, 25, 24, 2, -32 },
  { 937, 9, 13, 11, -2, -6 },
  { 952, 12, 4, 14, 1, -17 },
  { 958, 5, 6, 11, 1, -6 },
  { 962, 26, 39, 18, -3, -39 },
  { 1089, 20, 41, 22, 1, -40 },
  { 1192, 13, 39, 22, 6, -39 },
  { 1256, 24, 40, 22, -2, -40 },
  { 1376, 23, 41, 22, -1, -40 },
  { 1494, 23, 40, 22, -1, -40 },
  { 1609, 23, 40, 22, -1, -39 },
  { 1724, 22, 41, 22, 1, -40 },
  { 1837, 22, 39, 22, 2, -39 },
  { 1945, 22, 41, 22, 0, -40 },
  { 2058, 21, 41, 22, 0, -40 },
  { 2166, 11, 30, 11, 0, -30 },
  { 2208, 14, 37, 11, -3, -30 },
  { 2273, 21, 25, 24, 2, -32 },
  { 2339, 20, 15, 24, 2, -27 },
  { 2377, 21, 25, 24, 2, -32 },
  { 2443, 17, 40, 16, 1, -40 },
  { 2528, 31, 45, 32, 1, -40 },
  { 2703, 23, 39, 22, -4, -39 },
  { 2816, 24, 39, 24, 0, -39 },
  { 2933, 23, 41, 21, 2, -40 },
  { 3051, 25, 39, 26, 0, -39 },
  { 3173, 23, 39, 20, 0, -39 },
  { 3286, 23, 39, 19, 0, -39 },
  { 3399, 26, 41, 27, 2, -40 },
  { 3533, 28, 39, 27, 0, -39 },
  { 3670, 21, 39, 14, -3, -39 },
  { 3773, 21, 50, 11, -8, -39 },
  { 3905, 27, 39, 22, 0, -39 },
  { 4037, 15, 39, 19, 0, -39 },
  { 4111, 37, 39, 36, 0, -39 },
  { 4292, 29, 39, 28, 0, -39 },
  { 4434, 24, 41, 27, 2, -40 },
  { 4557, 23, 39, 22, 0, -39 },
  { 4670, 24, 49, 27, 2, -40 },
  { 4817, 23, 39, 23, 0, -39 },
  { 4930, 24, 41, 21, -1, -40 },
  { 5053, 19, 39, 19, 4, -39 },
  { 5146, 25, 40, 26, 2, -39 },
  { 5271, 22, 39, 22, 5, -39 },
  { 5379, 36, 39, 36, 4, -39 },
  { 5555, 27, 39, 20, -3, -39 },
  { 5687, 20, 39, 20, 4, -39 },
  { 5785, 24, 39, 18, -2, -39 },
  { 5902, 20, 49, 16, -1, -40 },
  { 6025, 8, 39, 19, 6, -39 },
  { 6064, 21, 49, 16, -4, -40 },
  { 6193, 21, 21, 22, 1, -39 },
  { 6249, 18, 3, 17, -5, 5 },
  { 6256, 8, 9, 14, 8, -42 },
  { 6265, 22, 31, 23, 1, -30 },
  { 6351, 22, 43, 23, 0, -42 },
  { 6470, 18, 31, 17, 1, -30 },
  { 6540, 25, 43, 23, 1, -42 },
  { 6675, 19, 31, 21, 1, -30 },
  { 6749, 26, 55, 13, -7, -42 },
  { 6928, 24, 43, 23, -1, -30 },
  { 7057, 21, 42, 23, 0, -42 },
  { 7168, 13, 41, 11, 0, -41 },
  { 7235, 20, 54, 11, -7, -41 },
  { 7370, 22, 42, 20, 0, -42 },
  { 7486, 13, 42, 10, 0, -42 },
  { 7555, 32, 30, 34, 0, -30 },
  { 7675, 21, 30, 23, 0, -30 },
  { 7754, 20, 31, 22, 1, -30 },
  { 7832, 25, 43, 23, -3, -30 },
  { 7967, 22, 43, 23, 1, -30 },
  { 8086, 18, 30, 15, 0, -30 },
  { 8154, 19, 31, 17, -1, -30 },
  { 8228, 14, 37, 13, 1, -36 },
  { 8293, 21, 30, 23, 1, -29 },
  { 8372, 18, 29, 18, 3, -29 },
  { 8438, 30, 29, 30, 3, -29 },
  { 8547, 24, 29, 19, -3, -29 },
  { 8634, 27, 42, 19, -5, -29 },
  { 8776, 19, 29, 16, -2, -29 },
  { 8845, 20, 48, 18, 1, -39 },
  { 8965, 4, 55, 20, 8, -42 },
  { 8993, 20, 48, 18, -3, -39 },
  { 9113, 21, 7, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Italic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC55PT7B_H_
