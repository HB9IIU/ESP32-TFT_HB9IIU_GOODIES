#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x70, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x01, 0xC1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFB, 0x1E, 0x03, 0xE3, 0x04, 0x03,
  0xC3, 0x00, 0x07, 0xC7, 0x00, 0x07, 0x87, 0x00, 0x07, 0x86, 0x00, 0x07,
  0x86, 0x00, 0x07, 0x86, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xCE, 0x00, 0x03,
  0xEC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3B, 0xE0, 0x00, 0x31, 0xE0, 0x00, 0x31, 0xF0, 0x00, 0x31, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x61, 0xF0, 0x00, 0x61, 0xE0, 0x00,
  0x61, 0xE0, 0xC0, 0xE3, 0xE0, 0xF0, 0xEF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x1F, 0xF0,
  0x03, 0x80, 0x7F, 0xE0, 0x0F, 0x00, 0xF3, 0xC0, 0x3C, 0x03, 0xC3, 0x80,
  0x78, 0x07, 0x07, 0x01, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0x3C, 0x1C, 0x0F,
  0x00, 0x70, 0x38, 0x1E, 0x01, 0xE0, 0x70, 0x78, 0x03, 0xC1, 0xE0, 0xF0,
  0x07, 0x03, 0xC3, 0xC0, 0x0E, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x1E, 0x00,
  0x78, 0x1C, 0x3C, 0x00, 0xF0, 0x78, 0xF0, 0x01, 0xE0, 0xF1, 0xC1, 0xE3,
  0xC1, 0xC7, 0x87, 0xE7, 0x07, 0x8E, 0x1F, 0xEE, 0x0F, 0x3C, 0x7F, 0xDE,
  0x3C, 0x71, 0xE3, 0xFC, 0x79, 0xE3, 0x87, 0xFF, 0xE3, 0x8F, 0x0F, 0x7F,
  0x8F, 0x1C, 0x1E, 0xFE, 0x1C, 0x78, 0x3C, 0x30, 0x78, 0xF0, 0x78, 0x01,
  0xE1, 0xC0, 0xF0, 0x03, 0xC7, 0x81, 0xE0, 0x0F, 0x0F, 0x03, 0x80, 0x1E,
  0x1E, 0x0F, 0x00, 0x78, 0x38, 0x1E, 0x00, 0xF0, 0x70, 0x3C, 0x03, 0xC1,
  0xE0, 0x70, 0x07, 0x83, 0xC1, 0xE0, 0x1E, 0x07, 0x83, 0xC0, 0x3C, 0x0F,
  0x07, 0x00, 0xF0, 0x1E, 0x1E, 0x01, 0xE0, 0x3C, 0x38, 0x07, 0x80, 0x38,
  0xF0, 0x0F, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01,
  0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0x0F, 0xBE, 0x0F, 0x1F, 0x1E, 0x1F, 0x3E,
  0x1F, 0x1E, 0x3C, 0x1F, 0x1E, 0x7C, 0x0F, 0x3E, 0x78, 0x0F, 0xBC, 0xF8,
  0x0F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF8, 0xF0, 0x07, 0xF0, 0xF0,
  0x07, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF8, 0x0F, 0xF0, 0xF8,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0xF8, 0x3F, 0xF8, 0xF8, 0x1F,
  0xE0, 0xFC, 0x03, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40, 0xE0, 0x18, 0x38, 0x0F,
  0x9E, 0x07, 0xFF, 0xBE, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0x80, 0x0F, 0xF0, 0x07, 0xDC, 0x03, 0xE7, 0x81, 0xF1, 0xF0, 0x78, 0x3C,
  0x06, 0x0F, 0x81, 0x01, 0x80, 0x00, 0x40, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xE1,
  0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF0,
  0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00,
  0x78, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8,
  0x1F, 0x01, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xBC,
  0x7E, 0xF9, 0xF1, 0xF1, 0xC3, 0xE1, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0xFC, 0x01,
  0xC0, 0x3E, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0xFF, 0x00, 0xE0,
  0x3F, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x80, 0x07,
  0xC0, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xBE, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1C,
  0x7C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0xF8, 0x00, 0xF0,
  0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x81,
  0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x30, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x7C, 0x06, 0x00, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7D, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xCE, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x06, 0x00, 0x1E, 0x3F, 0x80, 0x1E, 0x7F,
  0xC0, 0x3E, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x01,
  0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x03,
  0xE0, 0x78, 0x07, 0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFC,
  0x7E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0,
  0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xC7,
  0xC0, 0x1F, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0,
  0x3F, 0x83, 0xE0, 0xFF, 0x07, 0xFF, 0xBC, 0x07, 0xFF, 0x78, 0x0F, 0xFD,
  0xF0, 0x0F, 0xE3, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x7C, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFD, 0xFC, 0x0C, 0x0F, 0x81, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0,
  0x70, 0x07, 0xE0, 0xF0, 0x78, 0x0F, 0xF8, 0x78, 0x38, 0x0F, 0xFC, 0x3C,
  0x3C, 0x0F, 0x1E, 0x1E, 0x1C, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x07, 0x07,
  0x8F, 0x07, 0x07, 0x83, 0xC7, 0x07, 0x83, 0xC1, 0xC7, 0x83, 0x81, 0xE0,
  0xE3, 0xC1, 0xC0, 0xE0, 0x71, 0xC1, 0xE0, 0xF0, 0x78, 0xE0, 0xE0, 0x78,
  0x3C, 0xF0, 0x70, 0x3C, 0x1C, 0x78, 0x78, 0x1C, 0x0E, 0x38, 0x3C, 0x1E,
  0x0F, 0x1C, 0x1E, 0x0F, 0x07, 0x0E, 0x0F, 0x07, 0x83, 0x87, 0x07, 0x87,
  0x83, 0xC3, 0x83, 0xC3, 0xC1, 0xC3, 0xC1, 0xE3, 0xE1, 0xE1, 0xE0, 0xF3,
  0xB9, 0xE0, 0xF0, 0x7F, 0x9F, 0xE0, 0x78, 0x1F, 0xCF, 0xE0, 0x3C, 0x07,
  0xC3, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x04, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xEF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xCF, 0x00, 0x07,
  0xCF, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x8F, 0x00, 0x0F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xF8, 0x3F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x1F,
  0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x03, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x03,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x10, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x04, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0x87, 0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0xFE, 0x00, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xE0, 0x0E, 0x01, 0xFC, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF8,
  0x7C, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xF8, 0x03, 0xFF, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xE0, 0x01,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xE0, 0x01,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x43, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00,
  0x78, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x78, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0x0F, 0xFC, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x1F, 0x78, 0x00, 0xFF,
  0xC0, 0x3E, 0xF0, 0x01, 0xEF, 0x80, 0x7D, 0xE0, 0x07, 0xDF, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x00, 0x79,
  0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x3C,
  0x7C, 0x03, 0xE3, 0xC0, 0xF8, 0xF8, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x0F,
  0x0F, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x3E,
  0x1F, 0x00, 0xF8, 0x78, 0x78, 0x3E, 0x01, 0xE0, 0xF9, 0xF0, 0x78, 0x03,
  0xC1, 0xF3, 0xC1, 0xF0, 0x0F, 0x83, 0xE7, 0x83, 0xE0, 0x1F, 0x03, 0xDE,
  0x07, 0xC0, 0x3E, 0x07, 0xBC, 0x0F, 0x80, 0x78, 0x0F, 0xF8, 0x1E, 0x00,
  0xF0, 0x1F, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0xC0, 0xF8, 0x07, 0xC0, 0x7F,
  0x01, 0xF0, 0x0F, 0x00, 0xFE, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0xFE, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x7C, 0x01,
  0xEF, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0x78, 0x03,
  0xEF, 0x00, 0x78, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xE7, 0x80, 0xF8, 0x03,
  0xC7, 0x80, 0xF8, 0x03, 0xC7, 0x80, 0xF0, 0x07, 0xC7, 0x81, 0xF0, 0x07,
  0xC7, 0x81, 0xF0, 0x07, 0x87, 0xC1, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x07,
  0x83, 0xC1, 0xE0, 0x0F, 0x83, 0xC3, 0xE0, 0x0F, 0x83, 0xC3, 0xE0, 0x0F,
  0x03, 0xC3, 0xE0, 0x0F, 0x03, 0xE3, 0xC0, 0x1F, 0x01, 0xE3, 0xC0, 0x1F,
  0x01, 0xE7, 0xC0, 0x1F, 0x01, 0xE7, 0xC0, 0x1E, 0x01, 0xE7, 0xC0, 0x1E,
  0x01, 0xE7, 0x80, 0x3E, 0x01, 0xF7, 0x80, 0x3E, 0x00, 0xFF, 0x80, 0x3E,
  0x00, 0xFF, 0x80, 0x3C, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0x87, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x80,
  0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x80, 0xF0, 0x1F, 0x80, 0x78, 0x1F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0x87, 0xF0, 0x07,
  0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x3F,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x3F, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xE0, 0x38, 0x07, 0xC0, 0x08, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x06, 0x00, 0x3F, 0x03, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xF7, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x07,
  0x8F, 0x80, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x7F, 0x00, 0x3E, 0x3E, 0x00,
  0xFE, 0x00, 0xF8, 0x7C, 0x01, 0xFC, 0x01, 0xF0, 0xF0, 0x07, 0xF8, 0x03,
  0xC1, 0xE0, 0x0F, 0xF0, 0x0F, 0x83, 0xC0, 0x3D, 0xE0, 0x1F, 0x07, 0x80,
  0x7B, 0xC0, 0x7C, 0x0F, 0x00, 0xF7, 0x80, 0xF8, 0x1E, 0x03, 0xCF, 0x01,
  0xE0, 0x3C, 0x07, 0x9E, 0x07, 0xC0, 0x78, 0x1F, 0x3C, 0x0F, 0x80, 0xF0,
  0x3C, 0x78, 0x3E, 0x01, 0xE0, 0x78, 0xF0, 0x7C, 0x03, 0xC1, 0xE1, 0xE0,
  0xF0, 0x07, 0x83, 0xC3, 0xC3, 0xE0, 0x0F, 0x07, 0x87, 0x87, 0xC0, 0x1E,
  0x1E, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x38,
  0x78, 0x00, 0xF1, 0xE0, 0xF1, 0xF0, 0x03, 0xE3, 0xC1, 0xE3, 0xE0, 0x07,
  0xCF, 0x03, 0xC7, 0x80, 0x0F, 0x9E, 0x07, 0x9F, 0x00, 0x1F, 0x7C, 0x0F,
  0x3C, 0x00, 0x3E, 0xF0, 0x1E, 0xF8, 0x00, 0x7D, 0xE0, 0x3D, 0xF0, 0x00,
  0xFF, 0x80, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0xF8,
  0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xE0,
  0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x00, 0x3F, 0x0F, 0x00, 0xFF,
  0x8F, 0x01, 0xFF, 0xDE, 0x03, 0xFF, 0xDE, 0x03, 0xF0, 0xFE, 0x07, 0xC0,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00,
  0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x78, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0x7C, 0x1F, 0xC0, 0x7F, 0xFB, 0xC0, 0x3F, 0xF3,
  0xC0, 0x3F, 0xE3, 0x80, 0x1F, 0xC7, 0x80, 0x07, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x7E, 0x00, 0xF9, 0xFE, 0x01, 0xF7, 0xFE, 0x03, 0xDF, 0xFE, 0x07,
  0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x01, 0xE0, 0xF8,
  0x03, 0xC1, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0xFF, 0x3F, 0x83, 0xEF,
  0xFE, 0x07, 0x9F, 0xF8, 0x0F, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0x04, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x02, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xE7, 0xC0, 0x0F, 0xFE, 0xF0,
  0x03, 0xFF, 0xDE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x03, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x03,
  0xE0, 0x1E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x1F,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3C,
  0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x7E, 0x00, 0x7C, 0x1F, 0xC0,
  0x0F, 0xEF, 0x78, 0x01, 0xFF, 0xCF, 0x00, 0x1F, 0xF1, 0xC0, 0x01, 0xFC,
  0x78, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x03, 0xE0, 0x78, 0x3E, 0x03,
  0xE1, 0xF0, 0x1E, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x7C, 0x7C,
  0x07, 0xC3, 0xE0, 0x7E, 0x1E, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x02, 0x03, 0xF1, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xC0, 0x0F, 0xF8, 0xF0,
  0x07, 0xFF, 0x78, 0x03, 0xFF, 0xDE, 0x00, 0xFC, 0x3F, 0x80, 0x7C, 0x0F,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03,
  0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3C,
  0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00,
  0x7C, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E,
  0x01, 0xF8, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0xC0,
  0x1F, 0xDF, 0xF0, 0x07, 0xFF, 0x7C, 0x00, 0xFF, 0x9E, 0x00, 0x1F, 0xC7,
  0x80, 0x00, 0x83, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x80, 0x1F, 0x00, 0x38, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x7E, 0x00, 0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xDF, 0xFC,
  0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xC0,
  0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xC1, 0xF0, 0x07,
  0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x07,
  0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xDE, 0x00, 0x1F,
  0x9E, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x01, 0xC3, 0xF0, 0x3F, 0x00, 0x79, 0xFF, 0x1F, 0xF0, 0x0F, 0x7F, 0xF7,
  0xFF, 0x01, 0xEF, 0xFE, 0xFF, 0xE0, 0x3F, 0x87, 0xF8, 0x7C, 0x07, 0xE0,
  0xFE, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x1E, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0x78, 0x1E, 0x01, 0xF0, 0x1F,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0,
  0x0F, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x1F, 0x00,
  0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x3C, 0x0F,
  0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x3E,
  0x0F, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x1F, 0x00, 0xF0, 0x3C, 0x03, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0xF8, 0x3E, 0x01,
  0xE0, 0x1E, 0x07, 0x80, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x3E,
  0x01, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x01, 0xC3, 0xF0, 0x07,
  0x9F, 0xF0, 0x0F, 0x7F, 0xF0, 0x1E, 0xFF, 0xE0, 0x3F, 0x87, 0xE0, 0x7E,
  0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x80,
  0x78, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F,
  0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0x83,
  0xE0, 0x1E, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80,
  0x1E, 0x3E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x78,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x78, 0x07,
  0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7F, 0x7F, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x7E, 0x00, 0x1E, 0x3F, 0xC0, 0x07, 0x9F, 0xF8, 0x01, 0xEF, 0xFF,
  0x00, 0x7F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x3C, 0x03, 0xF0,
  0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07,
  0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x7C,
  0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x3C, 0x00,
  0xF8, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3F, 0x83, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xDF, 0xFC,
  0x01, 0xF7, 0xFE, 0x00, 0x7C, 0xFF, 0x00, 0x1E, 0x04, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0x00, 0xFF, 0x8F, 0x01,
  0xFF, 0xDE, 0x03, 0xFF, 0xDE, 0x03, 0xF0, 0xFE, 0x07, 0xC0, 0xFE, 0x0F,
  0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C,
  0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0x7C, 0x1F, 0xC0, 0x7F, 0x7F, 0xC0, 0x7F, 0xF7, 0xC0, 0x3F,
  0xE7, 0x80, 0x1F, 0xC7, 0x80, 0x02, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xC3, 0xE0, 0x79, 0xFC, 0x0F, 0x3F, 0x01, 0xEF, 0xE0, 0x3F, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x07, 0xE0, 0x60, 0x7C, 0x02, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x80, 0x1F, 0x0C, 0x03,
  0xE0, 0xFD, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xFF, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x06, 0x00, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x3C,
  0x03, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x7F, 0x03, 0xE1,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFE, 0xF0, 0x0F, 0xF9, 0xE0, 0x1F, 0xE3,
  0xC0, 0x06, 0x00, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0xF8,
  0x78, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3E,
  0x07, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F,
  0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7B,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x3E,
  0x78, 0x0F, 0xE0, 0x3E, 0x78, 0x0F, 0xE0, 0x3C, 0x78, 0x0F, 0xE0, 0x7C,
  0x78, 0x1F, 0xE0, 0x78, 0x78, 0x1F, 0xE0, 0x78, 0x78, 0x3D, 0xE0, 0xF8,
  0x78, 0x3D, 0xE0, 0xF0, 0x78, 0x3D, 0xE1, 0xF0, 0x78, 0x79, 0xC1, 0xE0,
  0xF8, 0x79, 0xC1, 0xE0, 0xF8, 0x71, 0xC3, 0xE0, 0xF8, 0xF1, 0xC3, 0xC0,
  0xF8, 0xF1, 0xC7, 0xC0, 0xF9, 0xE3, 0xC7, 0x80, 0xF9, 0xE3, 0xC7, 0x80,
  0xF9, 0xE3, 0xCF, 0x80, 0xFB, 0xC3, 0xCF, 0x00, 0xFB, 0xC3, 0xCF, 0x00,
  0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x83, 0xDE, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x3C, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x7C,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x7C, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x07,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x04, 0xFF, 0x00, 0x17, 0xFF, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xA0, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 42, 14, 1, -42 },
  { 75, 16, 15, 20, 6, -42 },
  { 105, 26, 42, 25, 0, -42 },
  { 242, 24, 48, 23, 0, -45 },
  { 386, 31, 44, 36, 3, -43 },
  { 557, 24, 44, 25, 0, -43 },
  { 689, 8, 15, 11, 6, -42 },
  { 704, 18, 51, 15, 1, -42 },
  { 819, 18, 51, 15, -4, -42 },
  { 934, 18, 20, 21, 6, -45 },
  { 979, 22, 28, 25, 2, -35 },
  { 1056, 11, 15, 12, -3, -7 },
  { 1077, 13, 4, 15, 1, -18 },
  { 1084, 6, 7, 12, 1, -7 },
  { 1090, 27, 42, 20, -3, -42 },
  { 1232, 22, 44, 23, 1, -43 },
  { 1353, 15, 42, 23, 6, -42 },
  { 1432, 25, 43, 23, -2, -43 },
  { 1567, 24, 44, 23, -1, -43 },
  { 1699, 24, 42, 23, -1, -42 },
  { 1825, 25, 43, 23, -1, -42 },
  { 1960, 24, 44, 23, 1, -43 },
  { 2092, 24, 42, 23, 2, -42 },
  { 2218, 24, 44, 23, 0, -43 },
  { 2350, 23, 44, 23, 0, -43 },
  { 2477, 12, 32, 12, 0, -32 },
  { 2525, 15, 40, 12, -3, -32 },
  { 2600, 22, 26, 25, 2, -34 },
  { 2672, 22, 17, 25, 2, -29 },
  { 2719, 22, 26, 25, 2, -34 },
  { 2791, 19, 43, 17, 1, -43 },
  { 2894, 33, 47, 35, 1, -42 },
  { 3088, 24, 42, 24, -4, -42 },
  { 3214, 26, 42, 25, 0, -42 },
  { 3351, 25, 44, 23, 2, -43 },
  { 3489, 27, 42, 27, 0, -42 },
  { 3631, 24, 42, 22, 0, -42 },
  { 3757, 24, 42, 20, 0, -42 },
  { 3883, 28, 44, 29, 2, -43 },
  { 4037, 30, 42, 29, 0, -42 },
  { 4195, 23, 42, 15, -3, -42 },
  { 4316, 23, 53, 12, -9, -42 },
  { 4469, 29, 42, 24, 0, -42 },
  { 4622, 16, 42, 20, 0, -42 },
  { 4706, 39, 42, 38, 0, -42 },
  { 4911, 32, 42, 30, 0, -42 },
  { 5079, 26, 44, 29, 2, -43 },
  { 5222, 25, 42, 24, 0, -42 },
  { 5354, 26, 53, 29, 2, -43 },
  { 5527, 25, 42, 25, 0, -42 },
  { 5659, 25, 44, 22, -1, -43 },
  { 5797, 21, 42, 20, 4, -42 },
  { 5908, 27, 43, 28, 2, -42 },
  { 6054, 24, 42, 24, 5, -42 },
  { 6180, 39, 42, 39, 4, -42 },
  { 6385, 29, 42, 22, -3, -42 },
  { 6538, 22, 42, 21, 4, -42 },
  { 6654, 25, 42, 20, -2, -42 },
  { 6786, 23, 52, 17, -2, -42 },
  { 6936, 9, 42, 20, 6, -42 },
  { 6984, 22, 52, 17, -4, -42 },
  { 7127, 22, 22, 23, 1, -42 },
  { 7188, 19, 4, 18, -5, 5 },
  { 7198, 8, 9, 15, 9, -45 },
  { 7207, 24, 33, 25, 1, -32 },
  { 7306, 23, 46, 25, 0, -45 },
  { 7439, 19, 33, 19, 1, -32 },
  { 7518, 27, 46, 25, 1, -45 },
  { 7674, 21, 33, 23, 1, -32 },
  { 7761, 27, 59, 14, -7, -45 },
  { 7961, 26, 46, 25, -1, -32 },
  { 8111, 23, 45, 24, 0, -45 },
  { 8241, 14, 43, 11, 0, -43 },
  { 8317, 22, 57, 11, -8, -43 },
  { 8474, 24, 45, 21, 0, -45 },
  { 8609, 14, 45, 11, 0, -45 },
  { 8688, 35, 32, 36, 0, -32 },
  { 8828, 23, 32, 24, 0, -32 },
  { 8920, 22, 33, 24, 1, -32 },
  { 9011, 26, 46, 25, -3, -32 },
  { 9161, 24, 46, 25, 1, -32 },
  { 9299, 19, 32, 16, 0, -32 },
  { 9375, 20, 33, 19, -1, -32 },
  { 9458, 15, 40, 14, 1, -39 },
  { 9533, 23, 33, 24, 1, -32 },
  { 9628, 20, 32, 20, 3, -32 },
  { 9708, 32, 32, 32, 3, -32 },
  { 9836, 26, 32, 20, -3, -32 },
  { 9940, 29, 46, 20, -6, -32 },
  { 10107, 20, 32, 17, -2, -32 },
  { 10187, 22, 51, 19, 1, -42 },
  { 10328, 4, 59, 22, 9, -45 },
  { 10358, 22, 51, 19, -4, -42 },
  { 10499, 22, 8, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Italic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC59PT7B_H_
