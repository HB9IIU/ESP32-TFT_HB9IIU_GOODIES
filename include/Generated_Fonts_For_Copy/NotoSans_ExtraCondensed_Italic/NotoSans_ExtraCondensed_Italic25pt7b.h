#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x20, 0x00,
  0x18, 0xE3, 0x80, 0x76, 0xCD, 0x9B, 0x36, 0x49, 0xB3, 0x00, 0x02, 0x60,
  0xCC, 0x11, 0x02, 0x60, 0xCC, 0x7F, 0xCF, 0xF8, 0xCC, 0x19, 0x02, 0x60,
  0xCC, 0x7F, 0xCF, 0xF8, 0xCC, 0x19, 0x02, 0x20, 0x4C, 0x19, 0x80, 0x01,
  0x00, 0xC0, 0x78, 0x7F, 0x3A, 0x4C, 0x83, 0x40, 0xD0, 0x1C, 0x07, 0x00,
  0x60, 0x2C, 0x0B, 0x02, 0x40, 0xB2, 0x2C, 0xFE, 0x1E, 0x01, 0x00, 0xC0,
  0x1C, 0x31, 0xE1, 0x19, 0x18, 0xC8, 0x84, 0x4C, 0x62, 0x43, 0x36, 0x19,
  0xA7, 0xCB, 0x7E, 0xD6, 0x5D, 0xB2, 0x09, 0x10, 0xD9, 0x84, 0xCC, 0x66,
  0x62, 0x32, 0x31, 0xB3, 0x07, 0x00, 0x07, 0x03, 0x61, 0x98, 0x66, 0x19,
  0x86, 0x41, 0xB0, 0x78, 0x1C, 0x0F, 0x06, 0xCD, 0x9B, 0xC7, 0xB1, 0xEC,
  0x33, 0x1C, 0xFF, 0x9E, 0x60, 0x7B, 0x6D, 0x20, 0x03, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x20, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x60, 0xC0, 0x0C, 0x08, 0x48, 0xFF, 0x1F, 0x3C, 0x64, 0x26,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFF, 0xFE, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x33, 0x66, 0x4C, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x00, 0x0F, 0x0F,
  0x8C, 0x66, 0x36, 0x1B, 0x0D, 0x87, 0x86, 0xC3, 0x61, 0xB0, 0xD8, 0x6C,
  0x64, 0x32, 0x19, 0x98, 0xF8, 0x78, 0x00, 0x0C, 0xF7, 0xBE, 0xD8, 0x61,
  0x8C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x00, 0x07, 0x81, 0xF8,
  0x23, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0x87,
  0xE1, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x1C, 0x07, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0xFE, 0x3F, 0x00, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x05, 0x83, 0x60, 0x98, 0x6C, 0x33, 0x08, 0xC6, 0x31, 0x0C,
  0xFF, 0xBF, 0xE0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x0F, 0xC7, 0xF1, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xF8, 0x3F, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0xFE, 0x3F, 0x00, 0x07, 0x87, 0xC6, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xBC, 0xF7, 0x71, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x19,
  0x8C, 0xFC, 0x3C, 0x00, 0x3F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x00, 0x0F, 0x87, 0xF1, 0x8C, 0xC3, 0x30, 0xCC, 0x31, 0x98,
  0x6C, 0x0E, 0x0F, 0x87, 0x31, 0x8C, 0xC3, 0x30, 0x4C, 0x33, 0x0C, 0xEE,
  0x1F, 0x00, 0x0F, 0x07, 0xE1, 0x98, 0xC3, 0x30, 0xCC, 0x36, 0x1D, 0x86,
  0x61, 0x8C, 0xE3, 0xD8, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0xFC, 0x3E,
  0x00, 0x10, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x8E, 0x60, 0x04, 0x31,
  0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x31, 0x86, 0x10, 0xC0, 0x01,
  0x81, 0xC3, 0x87, 0x0E, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x20,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x38, 0x1C, 0x3C, 0x78, 0xF0, 0x60, 0x20, 0x00, 0x1E, 0x3F, 0x23,
  0x03, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0x00, 0x00,
  0x60, 0xE0, 0xE0, 0x03, 0xE0, 0x39, 0x83, 0x06, 0x20, 0x13, 0x00, 0x91,
  0xE5, 0x9B, 0x29, 0x99, 0xCC, 0x8E, 0x44, 0xE6, 0x67, 0x33, 0x29, 0x93,
  0x4D, 0xD2, 0x33, 0x10, 0x00, 0x80, 0x06, 0x00, 0x18, 0xC0, 0x7C, 0x00,
  0x00, 0xC0, 0x70, 0x1C, 0x0D, 0x03, 0x40, 0x90, 0x64, 0x19, 0x0C, 0x43,
  0x31, 0xFC, 0x7F, 0x18, 0xCC, 0x33, 0x0D, 0xC3, 0x60, 0xF8, 0x30, 0x0F,
  0x83, 0xF8, 0x63, 0x8C, 0x31, 0x86, 0x30, 0xCC, 0x31, 0x8E, 0x3F, 0x07,
  0xF0, 0xC6, 0x30, 0xE6, 0x18, 0xC3, 0x18, 0x63, 0x1C, 0xFF, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0x83, 0xF8, 0x63, 0x8C, 0x31, 0x86, 0x30, 0xCC, 0x19, 0x83,
  0x30, 0x66, 0x0C, 0xC3, 0xB0, 0x66, 0x0C, 0xC3, 0x18, 0x63, 0x38, 0xFE,
  0x1F, 0x80, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x3F, 0x0F, 0xC3, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xFE, 0x3F,
  0x80, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x3F,
  0x0F, 0xC3, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x00,
  0x07, 0xE0, 0xFF, 0x1C, 0x23, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x3C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8E, 0x18,
  0x7F, 0x83, 0xF0, 0x0C, 0x18, 0xE1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x0C,
  0x30, 0xC1, 0x86, 0x0C, 0x3F, 0xE1, 0xFF, 0x0C, 0x30, 0xC1, 0x86, 0x0C,
  0x30, 0x61, 0x83, 0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0x1F, 0x87, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x7E, 0x00, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x1E, 0x0E, 0x00, 0x0C,
  0x31, 0xC6, 0x18, 0xE1, 0x8C, 0x19, 0x81, 0xB0, 0x33, 0x03, 0x60, 0x3E,
  0x03, 0xE0, 0x36, 0x06, 0x60, 0x66, 0x06, 0x30, 0x63, 0x06, 0x30, 0xC3,
  0x0C, 0x38, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0xFF, 0xFC, 0x0E, 0x03, 0x8F, 0x03, 0x87, 0x81,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xD8, 0xD8, 0x78, 0x6C, 0x6C, 0x36,
  0x36, 0x1B, 0x33, 0x0D, 0x99, 0x8C, 0xC9, 0x86, 0x6C, 0xC3, 0x36, 0x61,
  0x9E, 0x30, 0x8F, 0x30, 0xC7, 0x18, 0x63, 0x8C, 0x00, 0x0C, 0x18, 0xE0,
  0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x0F, 0x18, 0xD8, 0xC6, 0x46, 0x33, 0x31,
  0x9B, 0x0C, 0xD8, 0xC6, 0xC6, 0x36, 0x30, 0xB1, 0x87, 0x08, 0x38, 0xC1,
  0xC6, 0x0E, 0x00, 0x07, 0x81, 0xF8, 0x63, 0x98, 0x33, 0x06, 0xC0, 0xD8,
  0x1B, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0x60, 0x6C, 0x0D, 0x83, 0x30, 0x66,
  0x18, 0x7E, 0x0F, 0x80, 0x0F, 0x03, 0xF8, 0x63, 0x0C, 0x71, 0x8E, 0x31,
  0x8C, 0x31, 0x86, 0x31, 0x87, 0xF0, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x81, 0xF8, 0x63, 0x98, 0x33, 0x06,
  0xC0, 0xD8, 0x1B, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0x60, 0x6C, 0x0D, 0x83,
  0x30, 0x66, 0x18, 0x7E, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0x0F, 0x03, 0xF8, 0x63, 0x0C, 0x71, 0x8E, 0x31, 0x8C, 0x31, 0x86, 0x33,
  0x87, 0xE0, 0xF8, 0x33, 0x06, 0x60, 0xC6, 0x18, 0xC3, 0x18, 0xC3, 0x18,
  0x70, 0x07, 0xE1, 0xFC, 0x70, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x64, 0x1C, 0x7F,
  0x1F, 0xC0, 0xFF, 0xFF, 0x86, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x18,
  0x66, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0x98, 0x33, 0x06, 0x60, 0xCC,
  0x33, 0x06, 0x60, 0xCC, 0x19, 0x87, 0x30, 0xC6, 0x18, 0xFE, 0x0F, 0x80,
  0xC0, 0xF0, 0x7C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xC6, 0x33,
  0x0C, 0xC3, 0x60, 0xD8, 0x34, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0xC1,
  0x83, 0xC1, 0x83, 0xC3, 0x86, 0xC3, 0x86, 0xC3, 0x86, 0xC7, 0x8C, 0xC7,
  0x8C, 0xCD, 0x98, 0xCD, 0x98, 0xC9, 0x98, 0xD9, 0xB0, 0xD9, 0xB0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0xC1, 0x80, 0x0C,
  0x30, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x05, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x01, 0xB0, 0x1B, 0x03, 0x30, 0x33, 0x06, 0x30, 0xC3,
  0x0C, 0x30, 0xC1, 0xE1, 0xB0, 0xD8, 0xC6, 0x63, 0x61, 0xB0, 0xF0, 0x78,
  0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x00, 0x0F,
  0xE3, 0xFC, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xFF, 0x1F, 0xC0,
  0x07, 0xC1, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x78, 0x3E, 0x00, 0x88, 0xCC, 0xCC, 0xCC, 0x44, 0x66, 0x66, 0x66,
  0x23, 0x07, 0xC1, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x78, 0x3E, 0x00, 0x02, 0x01, 0xC0, 0x70, 0x3C, 0x19, 0x86,
  0x63, 0x18, 0xC6, 0x60, 0xF0, 0x30, 0xFF, 0xFE, 0xD9, 0x90, 0x0C, 0x4F,
  0xA3, 0x39, 0x86, 0x61, 0xB0, 0x6C, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x63,
  0x18, 0xFE, 0x3D, 0x80, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x41,
  0xF8, 0xE3, 0x38, 0xCC, 0x33, 0x0C, 0x83, 0x61, 0xD8, 0x66, 0x19, 0x86,
  0xE3, 0x3D, 0xCD, 0xE0, 0x0E, 0x1F, 0x32, 0x60, 0x60, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE8, 0x78, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x19, 0x8F, 0xE1, 0x9C, 0x61, 0x8C, 0x33, 0x0C, 0x61, 0x8C, 0x31,
  0x86, 0x30, 0xC6, 0x30, 0xC6, 0x1F, 0xC3, 0xD8, 0x00, 0x0C, 0x1F, 0x33,
  0x63, 0x63, 0xC7, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xEC, 0x7C, 0x00,
  0xF0, 0x1E, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x0F, 0xC0, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x0F, 0x00, 0xE0,
  0x00, 0x03, 0x10, 0x7A, 0x0C, 0xE1, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x83, 0x18, 0x3F, 0x83, 0xD8, 0x01, 0x80,
  0x30, 0x03, 0x08, 0x70, 0xFE, 0x07, 0xC0, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0xC1, 0xF8, 0xE7, 0x38, 0xCC, 0x63, 0x18, 0xC6, 0x61, 0x98,
  0x66, 0x31, 0x8C, 0x43, 0x30, 0xCC, 0x70, 0x0C, 0x70, 0x00, 0x00, 0x63,
  0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x83, 0xC1, 0xC0,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x9C, 0xC6, 0x33, 0x0D,
  0x83, 0xE0, 0xB0, 0x7C, 0x1D, 0x86, 0x61, 0x98, 0x46, 0x31, 0x8C, 0x70,
  0x0C, 0x30, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18,
  0x43, 0x0C, 0x00, 0x03, 0x18, 0x2F, 0x78, 0xE7, 0xB9, 0x8E, 0x33, 0x18,
  0x46, 0x31, 0x8C, 0x63, 0x30, 0xC6, 0x63, 0x0C, 0xC6, 0x31, 0x8C, 0x66,
  0x18, 0xCC, 0x31, 0x98, 0xC3, 0x00, 0x03, 0x05, 0xE3, 0x9C, 0xE3, 0x31,
  0x8C, 0x63, 0x19, 0x86, 0x61, 0x98, 0xC6, 0x33, 0x0C, 0xC3, 0x31, 0xC0,
  0x0C, 0x0F, 0x8C, 0xCC, 0x66, 0x1E, 0x0F, 0x0D, 0x86, 0xC3, 0x61, 0xB1,
  0x98, 0xCF, 0xC3, 0xC0, 0x00, 0x81, 0x78, 0x71, 0x8E, 0x31, 0x86, 0x30,
  0xC4, 0x19, 0x87, 0x30, 0xC6, 0x18, 0xC3, 0x18, 0xC7, 0xF8, 0xDE, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x47, 0xA3, 0x39,
  0x8E, 0x61, 0xB0, 0x4C, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xFE,
  0x3D, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x03, 0x17, 0x3D,
  0x38, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x0C,
  0x3F, 0x31, 0x60, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0xFC,
  0xF8, 0x10, 0xC3, 0x3F, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0E,
  0x38, 0x31, 0xB0, 0xD8, 0x6C, 0x66, 0x32, 0x1B, 0x0D, 0x86, 0xC6, 0x63,
  0x33, 0x9F, 0xCF, 0x40, 0xC3, 0xA1, 0x91, 0x88, 0xC4, 0x62, 0x61, 0x30,
  0xB0, 0x58, 0x28, 0x1C, 0x0C, 0x06, 0x00, 0x43, 0x1D, 0x1C, 0x64, 0x71,
  0xB1, 0x4C, 0xCF, 0x33, 0x2C, 0x8D, 0xB6, 0x36, 0xD8, 0xD3, 0xC3, 0xCF,
  0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x80, 0x18, 0xE3, 0x30, 0x66, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x00, 0xF0, 0x1E, 0x06, 0xC1, 0x98, 0x31, 0x8C, 0x30,
  0x0C, 0x70, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x0D, 0x80, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x1F, 0xCF, 0xC0, 0x03, 0x83, 0x83, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x38, 0x1C, 0x06, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0xC0, 0x3C, 0x0E, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x70, 0x38, 0x00, 0xF8, 0xEF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 18, 6, 0, -18 },
  { 15, 7, 7, 8, 2, -18 },
  { 22, 11, 18, 11, 0, -18 },
  { 47, 10, 20, 10, 0, -19 },
  { 72, 13, 18, 15, 1, -18 },
  { 102, 10, 18, 11, 0, -18 },
  { 125, 3, 7, 5, 3, -18 },
  { 128, 8, 22, 6, 0, -18 },
  { 150, 8, 22, 6, -2, -18 },
  { 172, 8, 8, 9, 2, -19 },
  { 180, 9, 12, 11, 1, -15 },
  { 194, 4, 6, 5, -1, -3 },
  { 197, 6, 2, 6, 0, -8 },
  { 199, 3, 3, 5, 0, -3 },
  { 201, 11, 18, 8, -1, -18 },
  { 226, 9, 18, 10, 1, -18 },
  { 247, 6, 18, 10, 3, -18 },
  { 261, 11, 18, 10, -1, -18 },
  { 286, 10, 18, 10, 0, -18 },
  { 309, 10, 18, 10, 0, -18 },
  { 332, 10, 18, 10, 0, -18 },
  { 355, 9, 18, 10, 1, -18 },
  { 376, 10, 18, 10, 1, -18 },
  { 399, 10, 18, 10, 0, -18 },
  { 422, 10, 18, 10, 0, -18 },
  { 445, 5, 14, 5, 0, -14 },
  { 454, 6, 17, 5, -1, -14 },
  { 467, 9, 11, 11, 1, -14 },
  { 480, 9, 7, 11, 1, -12 },
  { 488, 9, 11, 11, 1, -14 },
  { 501, 8, 18, 7, 0, -18 },
  { 519, 13, 20, 15, 1, -18 },
  { 552, 10, 18, 10, -2, -18 },
  { 575, 11, 18, 11, 0, -18 },
  { 600, 11, 18, 10, 1, -18 },
  { 625, 11, 18, 12, 0, -18 },
  { 650, 10, 18, 9, 0, -18 },
  { 673, 10, 18, 9, 0, -18 },
  { 696, 12, 18, 12, 1, -18 },
  { 723, 13, 18, 12, 0, -18 },
  { 753, 9, 18, 7, -1, -18 },
  { 774, 10, 23, 5, -4, -18 },
  { 803, 12, 18, 10, 0, -18 },
  { 830, 7, 18, 8, 0, -18 },
  { 846, 17, 18, 16, 0, -18 },
  { 885, 13, 18, 13, 0, -18 },
  { 915, 11, 18, 12, 1, -18 },
  { 940, 11, 18, 10, 0, -18 },
  { 965, 11, 22, 12, 1, -18 },
  { 996, 11, 18, 10, 0, -18 },
  { 1021, 11, 18, 9, -1, -18 },
  { 1046, 9, 18, 9, 2, -18 },
  { 1067, 11, 18, 12, 1, -18 },
  { 1092, 10, 18, 10, 2, -18 },
  { 1115, 16, 18, 16, 2, -18 },
  { 1151, 12, 18, 9, -1, -18 },
  { 1178, 9, 18, 9, 2, -18 },
  { 1199, 11, 18, 8, -1, -18 },
  { 1224, 10, 22, 7, -1, -18 },
  { 1252, 4, 18, 9, 3, -18 },
  { 1261, 10, 22, 7, -2, -18 },
  { 1289, 10, 10, 10, 0, -18 },
  { 1302, 8, 2, 8, -2, 2 },
  { 1304, 3, 4, 6, 4, -19 },
  { 1306, 10, 14, 11, 1, -14 },
  { 1324, 10, 19, 10, 0, -19 },
  { 1348, 8, 14, 8, 1, -14 },
  { 1362, 11, 19, 11, 1, -19 },
  { 1389, 8, 14, 10, 1, -14 },
  { 1403, 12, 25, 6, -3, -19 },
  { 1441, 12, 20, 11, -1, -14 },
  { 1471, 10, 19, 10, 0, -19 },
  { 1495, 6, 18, 5, 0, -18 },
  { 1509, 9, 24, 5, -3, -18 },
  { 1536, 10, 19, 9, 0, -19 },
  { 1560, 6, 19, 5, 0, -19 },
  { 1575, 15, 14, 15, 0, -14 },
  { 1602, 10, 14, 10, 0, -14 },
  { 1620, 9, 14, 10, 1, -14 },
  { 1636, 11, 20, 10, -1, -14 },
  { 1664, 10, 20, 11, 1, -14 },
  { 1689, 8, 14, 7, 0, -14 },
  { 1703, 8, 14, 8, 0, -14 },
  { 1717, 6, 16, 6, 1, -16 },
  { 1729, 9, 13, 10, 1, -13 },
  { 1744, 9, 13, 8, 1, -13 },
  { 1759, 14, 13, 14, 1, -13 },
  { 1782, 11, 13, 9, -1, -13 },
  { 1800, 12, 19, 9, -2, -13 },
  { 1829, 9, 13, 7, -1, -13 },
  { 1844, 9, 22, 8, 1, -18 },
  { 1869, 1, 25, 9, 4, -19 },
  { 1873, 10, 22, 8, -2, -18 },
  { 1901, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Italic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC25PT7B_H_
