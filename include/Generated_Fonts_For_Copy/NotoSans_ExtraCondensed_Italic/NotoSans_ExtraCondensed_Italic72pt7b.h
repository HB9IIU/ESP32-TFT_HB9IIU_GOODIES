#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0xE3, 0xE0, 0x0F, 0xC7, 0x06,
  0x00, 0xFC, 0x38, 0x10, 0x07, 0xC1, 0x80, 0x00, 0x7E, 0x1C, 0x00, 0x03,
  0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x07, 0xC1,
  0x80, 0x00, 0x3E, 0x1C, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x07, 0xE7, 0x00,
  0x00, 0x3F, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x33, 0xF0, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0x1C, 0x7E, 0x00,
  0x00, 0xE1, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x70, 0x7C, 0x00, 0x03,
  0x83, 0xE0, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x07, 0x0F,
  0xC1, 0x00, 0x70, 0x7C, 0x04, 0x03, 0x87, 0xE0, 0x78, 0x1C, 0x7E, 0x03,
  0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00,
  0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x80, 0x1F,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0xF8,
  0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x78, 0x00, 0x7C, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x1E, 0x0F, 0x00,
  0x07, 0x80, 0xF8, 0x7C, 0x00, 0x1E, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x0F,
  0x0F, 0x80, 0x81, 0xE0, 0x7C, 0x3C, 0x1F, 0xCF, 0x81, 0xF1, 0xF0, 0xFF,
  0xBE, 0x07, 0x8F, 0x87, 0xFE, 0xF8, 0x3E, 0x3E, 0x3F, 0xFD, 0xE0, 0xF1,
  0xF1, 0xF1, 0xF7, 0x87, 0xC7, 0xC7, 0x83, 0xDF, 0x3E, 0x3E, 0x3E, 0x0F,
  0x7F, 0xF8, 0xF0, 0xF0, 0x3C, 0xFF, 0xC7, 0xC7, 0xC0, 0xF3, 0xFE, 0x1E,
  0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x3C,
  0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x3C, 0x07, 0xC0, 0x03, 0xE0,
  0xF0, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x1F, 0x01, 0xE0,
  0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x3E, 0x00, 0x3C, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x1F, 0x00,
  0x3E, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0x1E,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x01, 0xE1, 0xF0, 0x07,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0xFC,
  0x3F, 0x1F, 0x03, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F,
  0x03, 0xE1, 0xF0, 0xF8, 0x0F, 0xCF, 0xC7, 0xE0, 0x3F, 0x3F, 0x1F, 0x80,
  0xFC, 0xF8, 0x7C, 0x01, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x0F, 0xC0, 0x1F,
  0xFC, 0x3E, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x03, 0xFC,
  0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFF, 0x03,
  0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC7, 0xF7, 0xE0, 0x7F,
  0xFF, 0x9F, 0x81, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xE0, 0xFC, 0x03, 0xFE,
  0x03, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0x00,
  0xF0, 0x07, 0x03, 0xC0, 0x1F, 0x1F, 0x00, 0x7F, 0x78, 0x1B, 0xFF, 0xEF,
  0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x0F, 0xDE, 0x00, 0x7E, 0x7C, 0x03, 0xF0,
  0xF8, 0x1F, 0xC3, 0xE0, 0x3E, 0x0F, 0xC0, 0x70, 0x1F, 0x00, 0x80, 0x78,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC7, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0,
  0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xDF,
  0x8F, 0xE7, 0xCF, 0xF1, 0xF1, 0xF8, 0xFC, 0x3C, 0x3F, 0x0C, 0x0F, 0xC1,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xE0,
  0x1F, 0xC0, 0x07, 0x00, 0x3F, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xFC,
  0x00, 0xE0, 0x0F, 0xE0, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0xFE,
  0x03, 0x80, 0x1F, 0xE0, 0x1F, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0xF8, 0x1F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xF3, 0xFF, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x80, 0x01, 0xFC, 0x03, 0x80, 0x1F, 0xE0, 0x0F, 0xC3,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFE, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x03, 0xF3,
  0xFF, 0x80, 0x3F, 0x7F, 0xFC, 0x03, 0xEF, 0xFF, 0xC0, 0x3E, 0xFF, 0xFE,
  0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x03, 0xFE, 0x0F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xFC,
  0x03, 0xFF, 0xCF, 0x80, 0x1F, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0E,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x78, 0x3F, 0x80, 0xC0, 0x3F, 0x81, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0xF8, 0x01, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0xFE, 0x0F,
  0x07, 0xC0, 0x3F, 0xFC, 0x1E, 0x0F, 0x00, 0xFF, 0xF8, 0x3C, 0x3E, 0x03,
  0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x83, 0xC0, 0xF1, 0xF0, 0x1E, 0x0F, 0x81,
  0xE3, 0xC0, 0x78, 0x1F, 0x03, 0xC7, 0x81, 0xF0, 0x3C, 0x07, 0x9F, 0x03,
  0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x78, 0x1F, 0x03, 0xE0,
  0x78, 0xF0, 0x3C, 0x07, 0x80, 0xF3, 0xE0, 0x78, 0x0F, 0x01, 0xE7, 0x81,
  0xF0, 0x3E, 0x03, 0xCF, 0x03, 0xC0, 0x7C, 0x0F, 0x9E, 0x07, 0x80, 0xF8,
  0x1E, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0xF8, 0x3E, 0x07, 0xC0, 0xF9, 0xE0,
  0x7C, 0x0F, 0x81, 0xE3, 0xC0, 0xF8, 0x1F, 0x03, 0xC7, 0x81, 0xE0, 0x7C,
  0x0F, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x1E, 0x07, 0xC3, 0xF0, 0x78, 0x3C,
  0x0F, 0x87, 0xE0, 0xF0, 0x78, 0x1F, 0x1D, 0xE7, 0xC0, 0xF0, 0x1F, 0xF3,
  0xFF, 0x01, 0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xC0, 0x3F, 0x87, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x00,
  0x03, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xFC,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0x83, 0xC0, 0x07, 0xF8, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x06, 0x00,
  0x0F, 0xFD, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7E,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x40, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xE0, 0x07, 0xFC, 0x00, 0x70, 0x03, 0xFC, 0x00, 0x08, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0xC3, 0xF0, 0x01, 0xFF, 0xE0, 0xFC, 0x00,
  0x7F, 0xF8, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xBF, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x00,
  0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x00,
  0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x01,
  0xF3, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xF1, 0xF0, 0x03,
  0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x07,
  0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x1F,
  0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x3F,
  0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x80, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0xF8,
  0x1F, 0x80, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF1, 0xF0,
  0x1F, 0x00, 0x1F, 0x01, 0xF3, 0xF0, 0x3F, 0x00, 0x1F, 0x01, 0xF3, 0xE0,
  0x3F, 0x00, 0x3F, 0x01, 0xF3, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF7, 0xC0,
  0x3E, 0x00, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x80,
  0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x00, 0xF8,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xEF, 0x80, 0x1F,
  0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x00, 0x3E,
  0x7C, 0x00, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF0, 0x01, 0xF9, 0xF0, 0x07,
  0xE0, 0x03, 0xF1, 0xF0, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0x0F,
  0x87, 0xC0, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x1F, 0x01,
  0xF8, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xF0,
  0x7E, 0x00, 0x3F, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x0F, 0x8F, 0xC0, 0x07, 0xE0, 0x1F,
  0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x00,
  0x7E, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0x01,
  0xF7, 0xE0, 0x03, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xF8, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x87, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x1F, 0xE0, 0x07, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7C,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xE1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0xFC, 0x00,
  0x7F, 0x80, 0x1C, 0x00, 0x7F, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x60,
  0x00, 0xFE, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xFB,
  0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF3,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE3,
  0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE3, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE3,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC3, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC3,
  0xC0, 0x7E, 0x00, 0x7C, 0x07, 0x83, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x87,
  0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x07,
  0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x07,
  0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x07,
  0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xF8, 0x07,
  0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x07,
  0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x07, 0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x07,
  0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x07,
  0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F,
  0x87, 0xC1, 0xE0, 0x00, 0x1F, 0xE0, 0xF0, 0x03, 0xFF, 0x1F, 0x00, 0x7F,
  0xF9, 0xF0, 0x0F, 0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x1E, 0xF8, 0x07, 0xFF, 0xEF, 0x80, 0x7F, 0xFC, 0xF8,
  0x03, 0xFF, 0x8F, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xC7, 0xFE, 0x00, 0x3E, 0x7F, 0xF8, 0x03, 0xF7, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x03, 0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7E, 0x03, 0xFC, 0x07, 0xE0,
  0x1F, 0xF8, 0xFF, 0x00, 0xFB, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0x00, 0x7C,
  0x7F, 0xF0, 0x03, 0xE1, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0x01, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x02, 0x01,
  0xFE, 0x3C, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x7F, 0xFB, 0xF0, 0x00, 0xFF, 0xFB,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x1E, 0xF8, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x7F, 0xFC, 0xF8,
  0x00, 0x3F, 0xF8, 0xF0, 0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFE, 0xFF, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFE, 0x7E, 0x01,
  0xFC, 0x7E, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x60, 0x7F, 0x01, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x00,
  0x03, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0x9F, 0x00, 0x0F, 0xFF, 0x9F, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x3F, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0x80, 0x0F,
  0xF1, 0xEF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0x80, 0x03,
  0xFF, 0x9F, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0,
  0x03, 0xF8, 0x00, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x0F, 0x8F, 0xFC, 0x00, 0xFB, 0xFF, 0xC0, 0x0F, 0xBF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7E, 0x01, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3E, 0x03, 0xF0,
  0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0xFE, 0x00, 0x3E, 0x7F, 0xF0, 0xFF,
  0xC0, 0x0F, 0x3F, 0xFC, 0x7F, 0xF8, 0x07, 0xDF, 0xFF, 0xBF, 0xFF, 0x01,
  0xF7, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x87, 0xF0, 0x1F, 0xC0,
  0x7F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x0F, 0x8F, 0xFC, 0x00, 0xF3,
  0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x01, 0xF7, 0xFF, 0xE0, 0x1F, 0xF0, 0x7E,
  0x01, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F,
  0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xF1,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x1F,
  0x1F, 0xF8, 0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x1E, 0x7F, 0xFC, 0x00, 0x3E,
  0xFF, 0xFE, 0x00, 0x3E, 0xE0, 0x7E, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xBC,
  0x7F, 0x80, 0x0F, 0xBF, 0xFF, 0x00, 0x0F, 0xBF, 0xFE, 0x00, 0x1F, 0x9F,
  0xFC, 0x00, 0x1F, 0x8F, 0xF8, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF0, 0x03, 0xFF, 0x1F, 0x00, 0x7F, 0xF9,
  0xF0, 0x0F, 0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x83, 0xFE, 0x03,
  0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0xFF,
  0x80, 0xFF, 0x1E, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0xF8, 0x03,
  0xFF, 0x9F, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x78, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x7E, 0x01, 0xE3, 0xFC,
  0x03, 0xCF, 0xF8, 0x0F, 0x9F, 0xE0, 0x1F, 0x7F, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xF7, 0xE0, 0x1F, 0xC0, 0x70, 0x0F, 0xC0, 0x08, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x80, 0x07, 0xE0, 0x60, 0x07, 0xF0, 0x3E, 0x0F, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0x87,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x18, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1C, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07,
  0xF8, 0x1F, 0x81, 0xFE, 0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0xFE, 0xF8, 0x07,
  0xFF, 0x9F, 0x00, 0xFF, 0xE3, 0xE0, 0x0F, 0xF8, 0x78, 0x00, 0x38, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0x7B, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0x80, 0x3F, 0x3F, 0x00, 0xFF, 0x00, 0x7C, 0x7E, 0x01, 0xFE, 0x01,
  0xF8, 0xFC, 0x07, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0x78, 0x0F, 0xC3, 0xF0,
  0x3E, 0xF0, 0x1F, 0x87, 0xE0, 0x7D, 0xE0, 0x3E, 0x0F, 0xC0, 0xF3, 0xC0,
  0xFC, 0x1F, 0x83, 0xE7, 0x81, 0xF0, 0x3F, 0x07, 0xCF, 0x03, 0xE0, 0x7E,
  0x1F, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0xF8,
  0x7E, 0x03, 0xE1, 0xF1, 0xF0, 0xF8, 0x07, 0xC3, 0xE3, 0xE1, 0xF0, 0x0F,
  0x87, 0x87, 0xC7, 0xE0, 0x1F, 0x1F, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x1F,
  0x3F, 0x00, 0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x7C, 0xF8, 0x01,
  0xF3, 0xC0, 0xFB, 0xF0, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0x07, 0xDF, 0x03,
  0xEF, 0x80, 0x0F, 0xBC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x27, 0xFF, 0x00, 0x0D, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF4, 0x00, 0x1F,
  0xFC, 0x80, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 52, 17, 1, -51 },
  { 112, 20, 18, 24, 7, -51 },
  { 157, 32, 51, 30, 0, -51 },
  { 361, 29, 59, 28, 0, -55 },
  { 575, 38, 53, 44, 3, -52 },
  { 827, 30, 53, 31, 0, -52 },
  { 1026, 10, 18, 13, 7, -51 },
  { 1049, 22, 63, 19, 1, -52 },
  { 1223, 21, 63, 19, -5, -52 },
  { 1389, 22, 24, 26, 7, -55 },
  { 1455, 26, 33, 31, 3, -42 },
  { 1563, 12, 18, 15, -3, -8 },
  { 1590, 16, 5, 19, 1, -22 },
  { 1600, 7, 9, 15, 1, -8 },
  { 1608, 33, 52, 24, -4, -52 },
  { 1823, 26, 53, 28, 2, -52 },
  { 1996, 18, 51, 28, 7, -51 },
  { 2111, 30, 52, 28, -2, -52 },
  { 2306, 29, 53, 28, -1, -52 },
  { 2499, 30, 52, 28, -1, -52 },
  { 2694, 30, 52, 28, -1, -51 },
  { 2889, 28, 53, 28, 2, -52 },
  { 3075, 29, 51, 28, 2, -51 },
  { 3260, 30, 53, 28, -1, -52 },
  { 3459, 28, 53, 28, 0, -52 },
  { 3645, 14, 40, 15, 0, -39 },
  { 3715, 19, 49, 15, -4, -39 },
  { 3832, 27, 33, 31, 3, -42 },
  { 3944, 26, 21, 31, 3, -36 },
  { 4013, 27, 33, 31, 3, -42 },
  { 4125, 23, 53, 21, 1, -52 },
  { 4278, 39, 58, 42, 2, -52 },
  { 4561, 29, 52, 29, -5, -52 },
  { 4750, 31, 51, 31, 0, -51 },
  { 4948, 30, 53, 28, 3, -52 },
  { 5147, 32, 51, 33, 0, -51 },
  { 5351, 30, 51, 26, 0, -51 },
  { 5543, 30, 51, 25, 0, -51 },
  { 5735, 34, 53, 35, 3, -52 },
  { 5961, 36, 51, 35, 0, -51 },
  { 6191, 28, 51, 19, -4, -51 },
  { 6370, 28, 65, 15, -11, -51 },
  { 6598, 35, 51, 29, 0, -51 },
  { 6822, 19, 51, 24, 0, -51 },
  { 6944, 48, 51, 47, 0, -51 },
  { 7250, 39, 51, 37, 0, -51 },
  { 7499, 32, 53, 36, 3, -52 },
  { 7711, 30, 51, 29, 0, -51 },
  { 7903, 32, 64, 36, 3, -52 },
  { 8159, 30, 51, 30, 0, -51 },
  { 8351, 32, 53, 27, -2, -52 },
  { 8563, 25, 51, 25, 5, -51 },
  { 8723, 34, 52, 34, 2, -51 },
  { 8944, 29, 51, 29, 6, -51 },
  { 9129, 48, 51, 47, 5, -51 },
  { 9435, 36, 51, 27, -4, -51 },
  { 9665, 27, 51, 26, 5, -51 },
  { 9838, 32, 51, 24, -3, -51 },
  { 10042, 27, 64, 20, -2, -52 },
  { 10258, 12, 52, 24, 7, -52 },
  { 10336, 27, 64, 20, -5, -52 },
  { 10552, 28, 27, 29, 1, -51 },
  { 10647, 22, 4, 22, -6, 6 },
  { 10658, 9, 11, 18, 11, -55 },
  { 10671, 28, 40, 30, 2, -39 },
  { 10811, 29, 56, 30, 0, -55 },
  { 11014, 23, 40, 23, 2, -39 },
  { 11129, 32, 56, 30, 2, -55 },
  { 11353, 24, 40, 28, 2, -39 },
  { 11473, 34, 72, 17, -9, -55 },
  { 11779, 32, 56, 30, -2, -39 },
  { 12003, 28, 55, 30, 0, -55 },
  { 12196, 17, 53, 14, 0, -53 },
  { 12309, 26, 70, 14, -9, -53 },
  { 12537, 29, 55, 26, 0, -55 },
  { 12737, 17, 55, 14, 0, -55 },
  { 12854, 42, 39, 44, 0, -39 },
  { 13059, 28, 39, 30, 0, -39 },
  { 13196, 26, 40, 29, 2, -39 },
  { 13326, 32, 56, 30, -3, -39 },
  { 13550, 28, 56, 30, 2, -39 },
  { 13746, 23, 39, 20, 0, -39 },
  { 13859, 25, 40, 23, -1, -39 },
  { 13984, 17, 48, 17, 2, -47 },
  { 14086, 27, 40, 30, 2, -39 },
  { 14221, 24, 39, 24, 4, -39 },
  { 14338, 39, 39, 39, 4, -39 },
  { 14529, 31, 39, 25, -3, -39 },
  { 14681, 35, 56, 24, -7, -39 },
  { 14926, 26, 39, 20, -3, -39 },
  { 15053, 26, 62, 24, 2, -51 },
  { 15255, 5, 72, 26, 11, -55 },
  { 15300, 26, 62, 24, -4, -51 },
  { 15502, 27, 9, 31, 3, -30 },
};

const GFXfont NotoSans_ExtraCondensed_Italic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC72PT7B_H_
