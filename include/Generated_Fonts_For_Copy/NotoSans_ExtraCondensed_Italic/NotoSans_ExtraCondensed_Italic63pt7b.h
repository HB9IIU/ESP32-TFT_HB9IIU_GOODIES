#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x04, 0x00, 0x00, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0xC3, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x38, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0x98, 0x70, 0x0F, 0x86, 0x04, 0x03, 0xE1, 0x80,
  0x00, 0xF0, 0xE0, 0x00, 0x7C, 0x38, 0x00, 0x1F, 0x0C, 0x00, 0x07, 0xC3,
  0x00, 0x01, 0xF1, 0xC0, 0x00, 0x7C, 0x70, 0x00, 0x0F, 0x9C, 0x00, 0x03,
  0xF6, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x06, 0x7C, 0x00, 0x01, 0x8F, 0x80, 0x00,
  0xE3, 0xE0, 0x00, 0x38, 0xF8, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x07, 0x80,
  0x00, 0xC3, 0xE0, 0x00, 0x70, 0xF8, 0x00, 0x1C, 0x3E, 0x08, 0x07, 0x1F,
  0x03, 0x81, 0x8F, 0xC0, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x0F, 0x00,
  0xF9, 0xE0, 0x0F, 0x00, 0x78, 0x70, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x80,
  0x3C, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x81, 0xE0,
  0x0F, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x3C,
  0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x3C, 0x0F, 0x1E,
  0x02, 0x1E, 0x07, 0x8F, 0x0F, 0xCF, 0x07, 0x8F, 0x0F, 0xF7, 0x83, 0xC7,
  0x8F, 0xFF, 0xC3, 0xC7, 0x8F, 0x1F, 0xE1, 0xE3, 0xCF, 0x0F, 0xF9, 0xE3,
  0xC7, 0x87, 0xBF, 0xF3, 0xE7, 0x83, 0xDF, 0xF1, 0xE3, 0xC1, 0xE7, 0xF1,
  0xE1, 0xE0, 0xF0, 0x40, 0xF1, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x3C, 0x00,
  0x78, 0x78, 0x1E, 0x00, 0x78, 0x38, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00,
  0x3C, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x81, 0xE0,
  0x0F, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x78,
  0x07, 0x80, 0x70, 0x78, 0x03, 0xC0, 0x38, 0x3C, 0x03, 0xC0, 0x1E, 0x3C,
  0x01, 0xE0, 0x0F, 0x3E, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC1, 0xF0, 0xF9, 0xF0,
  0x7C, 0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xE3, 0xE7, 0xC0,
  0xF9, 0xF1, 0xF0, 0x1F, 0x7C, 0xF8, 0x07, 0xDE, 0x3E, 0x01, 0xFF, 0x8F,
  0x80, 0x3F, 0xC3, 0xE0, 0x0F, 0xF0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0xE0, 0xF8, 0x0F, 0xF8, 0x3F, 0x07,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0x3F, 0xF8, 0x7E, 0x07,
  0xFC, 0x1F, 0x80, 0x30, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0xC1, 0xE0, 0x1E, 0x3C,
  0x03, 0xF7, 0x87, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xEF, 0x01, 0xF9, 0xE0, 0x7E, 0x1E,
  0x07, 0x83, 0xC0, 0x70, 0x7C, 0x04, 0x07, 0x00, 0x00, 0x80, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0x88, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7E, 0x3F,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xBE, 0x7E, 0x7D, 0xF9, 0xF3, 0xE3,
  0xE3, 0x87, 0xC6, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x0E, 0x01, 0xF0, 0x01, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x07,
  0xE0, 0x06, 0x00, 0xFC, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x80, 0x07, 0xE0, 0x38, 0x07, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x3D, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x03,
  0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x20, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x02,
  0x00, 0x1F, 0x80, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x3E, 0x7F, 0xC0, 0x3C,
  0xFF, 0xE0, 0x7D, 0xFF, 0xF0, 0x7F, 0xC3, 0xF0, 0x7F, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0xFE, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0x7C, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xF3, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x03,
  0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFC, 0x3E, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x7F, 0x0F, 0x80, 0xFE, 0x0F, 0x81, 0xFE, 0x0F, 0xC3, 0xFE, 0x0F,
  0xFF, 0xBE, 0x07, 0xFF, 0x3C, 0x03, 0xFE, 0x7C, 0x01, 0xFC, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x80,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x20, 0x00, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x70, 0x7F, 0x04, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x3F, 0x81, 0xC1, 0xC0, 0x3F, 0xF0, 0x70, 0xF0, 0x1F, 0xFC,
  0x1C, 0x38, 0x0F, 0x8F, 0x07, 0x1E, 0x07, 0x87, 0x83, 0xC7, 0x83, 0xC1,
  0xE0, 0xF3, 0xC0, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x1E, 0x0F, 0x38, 0x1E,
  0x0F, 0x03, 0xDE, 0x07, 0x03, 0xC0, 0xE7, 0x83, 0xC0, 0xF0, 0x39, 0xE0,
  0xF0, 0x3C, 0x1E, 0x70, 0x38, 0x1E, 0x07, 0xBC, 0x1E, 0x07, 0x81, 0xEF,
  0x07, 0x81, 0xE0, 0x73, 0xC1, 0xE0, 0x78, 0x3C, 0xF0, 0x78, 0x3C, 0x0F,
  0x3C, 0x1C, 0x0F, 0x03, 0x8E, 0x07, 0x07, 0xC1, 0xE3, 0x81, 0xC1, 0xF0,
  0x70, 0xE0, 0x78, 0x7C, 0x3C, 0x38, 0x1E, 0x37, 0x1E, 0x0E, 0x07, 0xFD,
  0xFF, 0x03, 0x81, 0xFE, 0x7F, 0xC0, 0xE0, 0x3F, 0x0F, 0xE0, 0x38, 0x07,
  0x80, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00,
  0x01, 0xF8, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7C, 0x7F, 0xE0, 0x0F, 0x80, 0x7E,
  0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0x7C,
  0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0x07, 0x00, 0x3F, 0x80, 0x20, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x30, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x7C, 0x03, 0xF8,
  0x07, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x03, 0x00, 0x3F, 0x00, 0x04, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x1F, 0x00, 0x3F, 0xF8, 0x7C, 0x00,
  0xFF, 0xC1, 0xF0, 0x03, 0xFF, 0x07, 0xC0, 0x1F, 0xFC, 0x3F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x6F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x03,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x07, 0xDE, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x79,
  0xE0, 0x01, 0xEF, 0x80, 0x3E, 0x78, 0x00, 0xFB, 0xE0, 0x0F, 0x9E, 0x00,
  0x3C, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0x9F,
  0x00, 0x3C, 0x78, 0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF1, 0xF0, 0x07,
  0xC7, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x78,
  0x0F, 0x8F, 0x80, 0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x0F, 0x87, 0x80, 0xF0,
  0xF8, 0x03, 0xE1, 0xE0, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x1E, 0x0F, 0x80,
  0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC3, 0xC1, 0xF0, 0x07, 0xC1,
  0xF1, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x3E,
  0x0F, 0x80, 0x1E, 0x07, 0xCF, 0x83, 0xE0, 0x0F, 0x81, 0xF7, 0xC0, 0xF8,
  0x03, 0xE0, 0x7D, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x78, 0x0F, 0x80, 0x3E,
  0x07, 0xFE, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0xF8,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x03,
  0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x80,
  0x1F, 0x00, 0x7D, 0xE0, 0x07, 0xC0, 0x1F, 0x78, 0x01, 0xF0, 0x07, 0xDE,
  0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x79, 0xF0, 0x0F, 0x80, 0x3E,
  0x7C, 0x03, 0xE0, 0x0F, 0x8F, 0x00, 0xF0, 0x03, 0xE3, 0xC0, 0x7C, 0x00,
  0xF8, 0xF0, 0x1F, 0x00, 0x3C, 0x3E, 0x07, 0xC0, 0x1F, 0x0F, 0x81, 0xF0,
  0x07, 0xC3, 0xE0, 0x78, 0x01, 0xF0, 0x78, 0x3E, 0x00, 0x7C, 0x1E, 0x0F,
  0x80, 0x1E, 0x07, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0xF8, 0x03, 0xE0, 0x7C,
  0x7C, 0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x3E, 0x03, 0xC7, 0xC0, 0x1F, 0x00,
  0xF1, 0xF0, 0x07, 0xC0, 0x3C, 0x78, 0x01, 0xF0, 0x0F, 0x3E, 0x00, 0x7C,
  0x03, 0xEF, 0x80, 0x1E, 0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0xF8, 0x03,
  0xE0, 0x07, 0xBC, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x3E, 0x00, 0x7F, 0xC0,
  0x0F, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x07, 0xFC, 0x01, 0xF0, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x03,
  0xF8, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xCF, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0,
  0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xF0, 0x0F,
  0x83, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFE, 0x0F, 0x80, 0x7F, 0x00, 0x60, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x1F, 0x80, 0xC0,
  0x07, 0xE0, 0x1F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x0F,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x80,
  0x78, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0,
  0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xF0, 0x00, 0x78, 0xFC, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80,
  0x01, 0xE7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x03, 0xF7, 0xC0, 0x01,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xF0, 0x03, 0xF1,
  0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xFF, 0x00, 0x3E, 0x1F, 0x00,
  0x3F, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xBC,
  0x03, 0xF0, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0x1F, 0x00, 0xF3, 0xC0, 0x3E,
  0x07, 0xC0, 0x3D, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x9F, 0x03, 0xF0, 0x1F, 0x01, 0xE7, 0xC0, 0xF8, 0x07, 0xC0, 0xF9,
  0xE0, 0x3E, 0x01, 0xF0, 0x3C, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x1E, 0x07,
  0xC0, 0x1F, 0x07, 0x87, 0x81, 0xF0, 0x07, 0xC1, 0xE1, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x78, 0x3E, 0x00, 0x7C, 0x3C, 0x1E, 0x1F, 0x00, 0x1F, 0x0F,
  0x07, 0x87, 0xC0, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0x01, 0xF1, 0xE0, 0x78,
  0xF8, 0x00, 0x7C, 0xF8, 0x1E, 0x3E, 0x00, 0x1F, 0x3C, 0x07, 0x9F, 0x00,
  0x07, 0xCF, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x00, 0x79,
  0xE0, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x07, 0xBE, 0x00, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0xF8,
  0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80,
  0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x78, 0x07, 0xC0,
  0x78, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x3C, 0x1F, 0x00,
  0x3C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xC0, 0x00, 0x7F, 0x0F, 0x80, 0x7F, 0xC7, 0x80, 0x7F, 0xF3, 0xC0,
  0x7F, 0xFB, 0xE0, 0x7F, 0x0F, 0xF0, 0x3E, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xE0, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xE1, 0xFE, 0x03,
  0xFF, 0xEF, 0x00, 0xFF, 0xE7, 0x80, 0x7F, 0xE3, 0xC0, 0x0F, 0xE3, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC7, 0xF0, 0x03, 0xE7, 0xFC, 0x01, 0xE7, 0xFF, 0x01, 0xF7, 0xFF,
  0x80, 0xFF, 0x8F, 0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xF0, 0xFC, 0x07, 0xBF, 0xFE,
  0x07, 0xDF, 0xFE, 0x03, 0xC7, 0xFE, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF0, 0x40, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC3, 0xC0, 0x07, 0xFC, 0xF8,
  0x01, 0xFF, 0xDF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1E,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0x7E, 0x1F, 0xE0, 0x0F, 0xFF,
  0xBC, 0x00, 0xFF, 0xE7, 0x80, 0x1F, 0xF9, 0xF0, 0x01, 0xFE, 0x3C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0,
  0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE7,
  0xC0, 0x3F, 0x3E, 0x03, 0xF1, 0xF0, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0x81, 0xFE,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xE8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x08, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1,
  0xE0, 0x03, 0xFF, 0x3C, 0x00, 0xFF, 0xE7, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xE1, 0xFE, 0x01, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x3F, 0xC0, 0x3F,
  0x0F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xC0, 0x0F, 0xFC, 0xF8,
  0x00, 0xFF, 0x1E, 0x00, 0x03, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x02, 0x00, 0x3F, 0x00, 0x40, 0x0F,
  0xC0, 0x0F, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF1, 0xFC, 0x01, 0xF7, 0xFE, 0x01, 0xEF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFC, 0x3F, 0x03, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0,
  0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x78, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x8F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x79, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xE1, 0xFC, 0x1F, 0xE0, 0x0F,
  0x3F, 0xF1, 0xFF, 0x80, 0x7B, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3D, 0xC3, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0xE0, 0x7C, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x78, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x07, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE1, 0xFC, 0x01,
  0xE7, 0xFE, 0x01, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0x3F, 0x03,
  0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xF0, 0x7E,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x03, 0xC7, 0xFC, 0x00, 0x3C,
  0xFF, 0xE0, 0x07, 0xDF, 0xFE, 0x00, 0x7F, 0x83, 0xE0, 0x07, 0xF0, 0x3F,
  0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x01,
  0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0x0F, 0xC0,
  0x0F, 0x7F, 0xFC, 0x00, 0xF7, 0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x01, 0xF1,
  0xFE, 0x00, 0x1F, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0x00, 0xFF,
  0xCF, 0x01, 0xFF, 0xCF, 0x03, 0xFF, 0xFF, 0x07, 0xF1, 0xFF, 0x07, 0xC0,
  0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xC0, 0x7F, 0xE7, 0xC0, 0x3F, 0xC7,
  0x80, 0x06, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE3,
  0xF0, 0x1E, 0x7F, 0x01, 0xEF, 0xF0, 0x3E, 0xFE, 0x03, 0xDF, 0xE0, 0x3D,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0,
  0x30, 0x1F, 0x00, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x80, 0x1F, 0x83, 0x80, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF2, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x18, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0xC0, 0xF8, 0x3F,
  0xC0, 0xFF, 0xF7, 0x80, 0xFF, 0xF7, 0x80, 0x7F, 0xE7, 0x80, 0x3F, 0x87,
  0x80, 0x0E, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF0, 0x3E,
  0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x0F,
  0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x3E, 0x00, 0xF3,
  0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0xFC,
  0x01, 0xF7, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC0, 0x3E, 0x7C, 0x07,
  0xF0, 0x0F, 0x9F, 0x01, 0xFC, 0x07, 0xC7, 0xC0, 0xFF, 0x01, 0xF1, 0xE0,
  0x3F, 0xC0, 0x78, 0x78, 0x0F, 0xF0, 0x3E, 0x1E, 0x07, 0xBC, 0x0F, 0x87,
  0x81, 0xEF, 0x07, 0xC1, 0xE0, 0xFB, 0xC1, 0xF0, 0x78, 0x3C, 0xF0, 0x78,
  0x1E, 0x0F, 0x3C, 0x3E, 0x07, 0x87, 0x8F, 0x0F, 0x81, 0xE1, 0xE3, 0xC7,
  0xC0, 0x78, 0xF8, 0xF1, 0xF0, 0x1E, 0x3C, 0x3C, 0x78, 0x07, 0x8F, 0x0F,
  0x3E, 0x01, 0xE7, 0x83, 0xCF, 0x80, 0x79, 0xE0, 0xF3, 0xC0, 0x1E, 0x78,
  0x7D, 0xF0, 0x07, 0xBC, 0x1F, 0x78, 0x01, 0xEF, 0x07, 0xBE, 0x00, 0x7F,
  0xC1, 0xEF, 0x80, 0x3F, 0xE0, 0x7B, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0x9F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x04, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0x3F, 0xF0, 0x03, 0x7F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xC0, 0x07, 0xFC, 0x80, 0x00,
  0x60,
};

const GFXglyph NotoSans_ExtraCondensed_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 46, 15, 1, -45 },
  { 88, 18, 16, 21, 6, -45 },
  { 124, 28, 45, 27, 0, -45 },
  { 282, 26, 52, 25, 0, -48 },
  { 451, 33, 47, 38, 3, -46 },
  { 645, 26, 47, 27, 0, -46 },
  { 798, 8, 16, 12, 6, -45 },
  { 814, 19, 55, 16, 1, -45 },
  { 945, 19, 55, 16, -5, -45 },
  { 1076, 19, 21, 23, 6, -48 },
  { 1126, 23, 30, 27, 3, -37 },
  { 1213, 11, 15, 13, -3, -7 },
  { 1234, 14, 4, 16, 1, -19 },
  { 1241, 6, 8, 13, 1, -7 },
  { 1247, 29, 45, 21, -3, -45 },
  { 1411, 24, 47, 25, 1, -46 },
  { 1552, 15, 45, 25, 7, -45 },
  { 1637, 27, 46, 25, -2, -46 },
  { 1793, 26, 47, 25, -1, -46 },
  { 1946, 26, 45, 25, -1, -45 },
  { 2093, 26, 46, 25, -1, -45 },
  { 2243, 24, 47, 25, 2, -46 },
  { 2384, 25, 45, 25, 2, -45 },
  { 2525, 25, 47, 25, 0, -46 },
  { 2672, 24, 47, 25, 0, -46 },
  { 2813, 12, 35, 13, 0, -34 },
  { 2866, 16, 42, 13, -3, -34 },
  { 2950, 24, 28, 27, 2, -36 },
  { 3034, 23, 18, 27, 3, -31 },
  { 3086, 23, 28, 27, 3, -36 },
  { 3167, 20, 47, 18, 1, -46 },
  { 3285, 34, 50, 37, 2, -45 },
  { 3498, 25, 45, 25, -4, -45 },
  { 3639, 28, 45, 27, 0, -45 },
  { 3797, 27, 47, 24, 2, -46 },
  { 3956, 28, 45, 29, 0, -45 },
  { 4114, 26, 45, 23, 0, -45 },
  { 4261, 26, 45, 22, 0, -45 },
  { 4408, 30, 47, 31, 2, -46 },
  { 4585, 32, 45, 30, 0, -45 },
  { 4765, 24, 45, 16, -3, -45 },
  { 4900, 24, 57, 13, -9, -45 },
  { 5071, 31, 45, 26, 0, -45 },
  { 5246, 17, 45, 21, 0, -45 },
  { 5342, 42, 45, 41, 0, -45 },
  { 5579, 34, 45, 32, 0, -45 },
  { 5771, 28, 47, 31, 2, -46 },
  { 5936, 27, 45, 25, 0, -45 },
  { 6088, 28, 57, 31, 2, -46 },
  { 6288, 27, 45, 26, 0, -45 },
  { 6440, 27, 47, 24, -1, -46 },
  { 6599, 23, 45, 22, 4, -45 },
  { 6729, 29, 46, 30, 2, -45 },
  { 6896, 26, 45, 25, 5, -45 },
  { 7043, 42, 45, 41, 4, -45 },
  { 7280, 32, 45, 23, -4, -45 },
  { 7460, 23, 45, 22, 5, -45 },
  { 7590, 28, 45, 21, -3, -45 },
  { 7748, 24, 55, 18, -2, -45 },
  { 7913, 11, 45, 21, 6, -45 },
  { 7975, 24, 55, 18, -4, -45 },
  { 8140, 24, 24, 25, 1, -45 },
  { 8212, 19, 4, 19, -5, 5 },
  { 8222, 9, 10, 16, 9, -48 },
  { 8234, 25, 35, 27, 2, -34 },
  { 8344, 25, 49, 26, 0, -48 },
  { 8498, 20, 35, 20, 2, -34 },
  { 8586, 27, 49, 27, 2, -48 },
  { 8752, 21, 35, 24, 2, -34 },
  { 8844, 30, 63, 14, -8, -48 },
  { 9081, 27, 49, 27, -1, -34 },
  { 9247, 24, 48, 26, 0, -48 },
  { 9391, 14, 46, 12, 0, -46 },
  { 9472, 23, 61, 12, -8, -46 },
  { 9648, 26, 48, 23, 0, -48 },
  { 9804, 15, 48, 12, 0, -48 },
  { 9894, 37, 34, 39, 0, -34 },
  { 10052, 24, 34, 26, 0, -34 },
  { 10154, 22, 35, 26, 2, -34 },
  { 10251, 28, 49, 26, -3, -34 },
  { 10423, 24, 49, 27, 2, -34 },
  { 10570, 20, 34, 17, 0, -34 },
  { 10655, 22, 35, 20, -1, -34 },
  { 10752, 15, 42, 15, 2, -41 },
  { 10831, 24, 35, 26, 2, -34 },
  { 10936, 20, 34, 21, 4, -34 },
  { 11021, 34, 34, 34, 3, -34 },
  { 11166, 27, 34, 22, -3, -34 },
  { 11281, 31, 49, 21, -6, -34 },
  { 11471, 22, 34, 18, -2, -34 },
  { 11565, 24, 55, 21, 1, -45 },
  { 11730, 5, 63, 23, 9, -48 },
  { 11770, 23, 55, 21, -4, -45 },
  { 11929, 24, 8, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Italic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC63PT7B_H_
