#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x07, 0xC7, 0xC3, 0xF1, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C,
  0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x83, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x81, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xDC, 0x78, 0x07, 0xC7, 0x04, 0x03,
  0xE1, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x3C, 0x38, 0x00, 0x1F, 0x0E, 0x00,
  0x07, 0xC3, 0x80, 0x01, 0xF0, 0xC0, 0x00, 0x7C, 0x30, 0x00, 0x0F, 0x9C,
  0x00, 0x03, 0xF7, 0x00, 0x00, 0xFD, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x7C, 0x00, 0x01, 0xDF,
  0x80, 0x00, 0x63, 0xE0, 0x00, 0x18, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03,
  0x87, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x0C, 0x3E, 0x00,
  0x07, 0x0F, 0x81, 0x01, 0xC7, 0xC0, 0xF0, 0x63, 0xF0, 0x3F, 0xDF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x3F, 0xE0,
  0x03, 0xC0, 0x1F, 0x7C, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x03, 0xC3,
  0xC0, 0x3C, 0x01, 0xE0, 0xF0, 0x1F, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x3C,
  0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x78, 0x01,
  0xE0, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x83, 0xC0,
  0x07, 0x81, 0xE1, 0xE0, 0x01, 0xE0, 0x78, 0x78, 0x00, 0xF0, 0x1E, 0x3C,
  0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x0F, 0x03, 0xC7, 0x83, 0xE3, 0xC0, 0xF1,
  0xE1, 0xFC, 0xF0, 0x78, 0xF0, 0xFF, 0xBC, 0x1E, 0x3C, 0x7F, 0xEF, 0x0F,
  0x1E, 0x3C, 0x7F, 0xC3, 0xC7, 0x8F, 0x0F, 0xFF, 0xE3, 0xC7, 0x83, 0xDF,
  0xF0, 0xF1, 0xE0, 0xF7, 0xFC, 0x78, 0xF0, 0x3C, 0xFC, 0x1E, 0x3C, 0x0F,
  0x00, 0x0F, 0x0F, 0x03, 0xC0, 0x07, 0xC7, 0x81, 0xE0, 0x01, 0xE1, 0xE0,
  0x78, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x07, 0x80, 0x1F, 0x0F,
  0x01, 0xE0, 0x07, 0x83, 0xC0, 0xF8, 0x03, 0xE0, 0xF0, 0x3C, 0x00, 0xF0,
  0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC1, 0xE0, 0x0F,
  0x00, 0xF0, 0x78, 0x03, 0xC0, 0x3C, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x03, 0xE7, 0x80, 0x3C, 0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x1F, 0xF0,
  0x07, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xE1, 0xFB, 0xE0,
  0xF8, 0x3E, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C,
  0x1F, 0x1F, 0x1F, 0x01, 0xF3, 0xC3, 0xE0, 0x3E, 0xF8, 0xF8, 0x07, 0xDF,
  0x1F, 0x00, 0x7F, 0xC3, 0xE0, 0x0F, 0xF8, 0x7C, 0x01, 0xFE, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFE, 0x07, 0xC0, 0x3F, 0xC0,
  0xF8, 0x0F, 0xF8, 0x1F, 0x83, 0xFF, 0x83, 0xFF, 0xFD, 0xF0, 0x3F, 0xFF,
  0x3F, 0x03, 0xFF, 0x87, 0xE0, 0x3F, 0xE0, 0x7C, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x02, 0x07, 0x80,
  0x78, 0x70, 0x07, 0xE7, 0x02, 0x7F, 0xF7, 0xEF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xBC, 0x01, 0xF3,
  0xC0, 0x3F, 0x1E, 0x07, 0xE1, 0xF0, 0x1C, 0x1F, 0x00, 0x80, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0x3E, 0x01, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x7E, 0x7C, 0xFC, 0xFC, 0xF0,
  0xF8, 0x60, 0xF8, 0x20, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0x78, 0x0F, 0xC0, 0x0C, 0x01, 0xF8, 0x01, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFC,
  0x3F, 0xC0, 0x1C, 0x03, 0xF0, 0x04, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x80, 0x07, 0xE0, 0x38, 0x07,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xEF, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x9F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE1, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x01, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x01, 0xE0,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x80, 0x07, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x30, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x0F,
  0x8F, 0xF0, 0x07, 0xDF, 0xFC, 0x03, 0xDF, 0xFF, 0x03, 0xEF, 0xFF, 0x81,
  0xFE, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x3F,
  0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x80,
  0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF8, 0x3E, 0x03, 0xFC, 0x1F, 0x83, 0xFC,
  0x0F, 0xF7, 0xFE, 0x03, 0xFF, 0xDF, 0x01, 0xFF, 0xCF, 0x80, 0x7F, 0xC7,
  0x80, 0x1F, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x20, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x87, 0xF0,
  0x60, 0x3F, 0x04, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0xE0, 0x1E, 0x0F, 0x00, 0xFF, 0xC3, 0xC3, 0xC0,
  0x3F, 0xF0, 0x78, 0x78, 0x0F, 0xFE, 0x0F, 0x1E, 0x03, 0xC3, 0xC1, 0xE3,
  0xC0, 0xF0, 0x78, 0x3C, 0x70, 0x3C, 0x1E, 0x07, 0x9E, 0x07, 0x83, 0xC0,
  0xE3, 0xC1, 0xE0, 0x78, 0x1C, 0x70, 0x3C, 0x0F, 0x07, 0x9E, 0x07, 0x03,
  0xC0, 0xF3, 0xC1, 0xE0, 0x78, 0x1E, 0x78, 0x3C, 0x0F, 0x03, 0xCE, 0x07,
  0x81, 0xE0, 0x73, 0xC1, 0xE0, 0x78, 0x1E, 0x78, 0x3C, 0x0F, 0x03, 0xCF,
  0x07, 0x81, 0xE0, 0x71, 0xE0, 0xF0, 0x7C, 0x1E, 0x3C, 0x1E, 0x0F, 0x03,
  0xC7, 0x83, 0xC1, 0xE0, 0x70, 0xE0, 0x78, 0x7C, 0x1E, 0x1C, 0x0F, 0x0F,
  0x87, 0x83, 0x81, 0xE3, 0xF8, 0xE0, 0x70, 0x3F, 0xEF, 0xFC, 0x0E, 0x03,
  0xF8, 0xFF, 0x01, 0xC0, 0x7E, 0x1F, 0xC0, 0x38, 0x03, 0x80, 0x40, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x07, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xC1, 0xFE, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x7C, 0x00, 0xFE, 0x01,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x07, 0xF0,
  0x38, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3E, 0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x7F,
  0x00, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x0F, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x00, 0x3F, 0x80, 0x02, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x3E,
  0x00, 0x7F, 0xF0, 0x7C, 0x00, 0xFF, 0xE0, 0xF8, 0x01, 0xFF, 0x81, 0xF0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x07,
  0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x47, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x1E, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xDE, 0x00, 0x07,
  0xBE, 0x00, 0xFB, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x00, 0x3D, 0xF0,
  0x03, 0xEF, 0x00, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x1F,
  0x3C, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0xF8,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x07,
  0x87, 0xC0, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x1E, 0x1F, 0x00, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC7, 0x81, 0xF0, 0x03,
  0xE0, 0x79, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x3C, 0x0F, 0xC0, 0x1F, 0x01,
  0xEF, 0x81, 0xF0, 0x03, 0xE0, 0x3D, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xFC,
  0x07, 0xC0, 0x0F, 0x00, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x3E,
  0x00, 0x7C, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x7C, 0x01,
  0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x03, 0xE0,
  0x0F, 0xF8, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x0F,
  0x80, 0x3D, 0xE0, 0x07, 0xC0, 0x1F, 0x78, 0x01, 0xF0, 0x07, 0xDF, 0x00,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x00, 0x7D, 0xF0, 0x07, 0xC0, 0x1E, 0x3C,
  0x03, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x03, 0xE3, 0xC0, 0x3E, 0x00, 0xF8,
  0xF8, 0x0F, 0x80, 0x3E, 0x3E, 0x07, 0xC0, 0x0F, 0x8F, 0x81, 0xF0, 0x07,
  0xC1, 0xE0, 0x7C, 0x01, 0xF0, 0x78, 0x1F, 0x00, 0x7C, 0x1E, 0x07, 0xC0,
  0x1F, 0x07, 0xC3, 0xE0, 0x07, 0x81, 0xF0, 0xF8, 0x03, 0xE0, 0x7C, 0x3E,
  0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x3E, 0x03, 0xC3, 0xE0, 0x0F, 0x80, 0xF1,
  0xF0, 0x07, 0xC0, 0x3E, 0x7C, 0x01, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0x03,
  0xE7, 0xC0, 0x1F, 0x00, 0xF9, 0xE0, 0x07, 0xC0, 0x1E, 0xF8, 0x03, 0xE0,
  0x07, 0xBE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x0F,
  0x80, 0x1F, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x7C, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xF8,
  0x01, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0x7E,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xF8,
  0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x3F, 0x80, 0x3E,
  0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0xFE, 0x00,
  0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x3E, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0xFE, 0x01, 0xF1,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFD,
  0xFC, 0x01, 0xFC, 0x03, 0x80, 0x7E, 0x00, 0x20, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x04, 0x00, 0x1F, 0x80, 0xE0,
  0x07, 0xF0, 0x1F, 0x83, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x8F,
  0x80, 0x01, 0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07,
  0x9F, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE7, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xDE, 0x01, 0xF8, 0x1F, 0x00, 0xFB, 0xC0, 0x3E, 0x03,
  0xE0, 0x1E, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xCF, 0x01, 0xF0, 0x0F, 0x80,
  0xF9, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x3C, 0x0F, 0xC0, 0x3E, 0x07, 0xC7,
  0x81, 0xF0, 0x07, 0xC0, 0xF0, 0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x1E, 0x0F,
  0x80, 0x1F, 0x07, 0xC3, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0xF8, 0x3E, 0x00,
  0x7C, 0x3E, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0x83, 0xE1, 0xF0, 0x01, 0xF0,
  0xF0, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0x81,
  0xF1, 0xF0, 0x00, 0xF9, 0xF0, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x07, 0x8F,
  0x80, 0x03, 0xE7, 0x80, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x1E, 0x7C, 0x00,
  0x0F, 0xBC, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x00, 0x3D,
  0xF0, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3,
  0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E,
  0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0,
  0x01, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x7F, 0xF3,
  0xE0, 0x3F, 0xFD, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x01,
  0xFC, 0x1F, 0x00, 0xFE, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0,
  0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x7F,
  0x03, 0xF0, 0x7F, 0x81, 0xFF, 0xF7, 0x80, 0x7F, 0xF3, 0xC0, 0x1F, 0xF1,
  0xE0, 0x07, 0xF0, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xFC, 0x01, 0xF7,
  0xFF, 0x00, 0xF7, 0xFF, 0x80, 0xFB, 0xDF, 0xE0, 0x7F, 0x83, 0xF0, 0x3F,
  0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x3E, 0x07, 0xF8, 0x7F, 0x03, 0xDF, 0xFF, 0x03, 0xEF, 0xFF, 0x01, 0xE3,
  0xFF, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFD, 0xE0, 0x7E, 0x02,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x20,
  0xFC, 0x0C, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xF8, 0xF8, 0x01,
  0xFF, 0xCF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x0F,
  0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0xFE,
  0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xBC, 0x00, 0x7F, 0xF3, 0xC0, 0x07,
  0xFE, 0x3C, 0x00, 0x3F, 0xC3, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0x1F, 0x83,
  0xF0, 0x7C, 0x3F, 0x01, 0xE1, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0,
  0x3F, 0x8F, 0x8F, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x43, 0xF0, 0x0C, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0x98, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x21, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0x1F, 0x00, 0x1F, 0xF9, 0xF0, 0x03, 0xFF, 0xDE, 0x00,
  0x7F, 0xFD, 0xE0, 0x0F, 0xC1, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0,
  0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7E,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x1F,
  0x01, 0xFC, 0x01, 0xF0, 0x3F, 0xC0, 0x1F, 0x87, 0xFC, 0x01, 0xFF, 0xF7,
  0x80, 0x0F, 0xFE, 0xF8, 0x00, 0xFF, 0xCF, 0x80, 0x07, 0xF8, 0xF8, 0x00,
  0x0E, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x0F, 0xC0, 0x0F, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xFC, 0x01, 0xF7, 0xFF, 0x00, 0xF7, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x01, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x7C,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x07,
  0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x07,
  0x8F, 0xF8, 0x7F, 0xC0, 0x1E, 0x7F, 0xE3, 0xFF, 0x80, 0x7B, 0xFF, 0xDF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x83, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF1, 0xFF, 0x00,
  0x79, 0xFF, 0x80, 0x3D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xF8,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F,
  0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xE0,
  0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF9, 0xF8, 0x1F, 0x83, 0xF0,
  0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x01, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xC7, 0xFC, 0x00, 0x3C, 0xFF, 0xE0, 0x03, 0xDF, 0xFE,
  0x00, 0x7D, 0xE7, 0xF0, 0x07, 0xF8, 0x3F, 0x00, 0x7F, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x3F, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0x7F, 0xF8, 0x01, 0xF3, 0xFF, 0x00, 0x1F, 0x1F, 0xE0,
  0x01, 0xF0, 0x60, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC7, 0xC0,
  0x3F, 0xF3, 0xE0, 0x3F, 0xFD, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x07, 0xF8,
  0x3F, 0x01, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFE, 0x07,
  0xC0, 0xFF, 0x03, 0xF0, 0xFF, 0x81, 0xFF, 0xF7, 0x80, 0x7F, 0xF7, 0xC0,
  0x3F, 0xF3, 0xE0, 0x0F, 0xF1, 0xF0, 0x00, 0xE0, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x1F, 0x80,
  0x79, 0xFC, 0x03, 0xDF, 0xE0, 0x3F, 0xFE, 0x01, 0xEF, 0x10, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0xF8, 0x1F, 0x80, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x82, 0x00, 0x7E,
  0x0E, 0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFB, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x30, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF7, 0x80, 0x7F, 0xE7, 0x80, 0x3F, 0x87, 0x80, 0x0E, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1E,
  0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x7F,
  0x00, 0xF9, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x01, 0xFC, 0x07, 0xC7, 0xC0,
  0x7F, 0x80, 0xF8, 0xF8, 0x0F, 0xF0, 0x1F, 0x1F, 0x03, 0xFC, 0x07, 0xC3,
  0xE0, 0x7F, 0x80, 0xF8, 0x7C, 0x0F, 0xF0, 0x3E, 0x0F, 0x83, 0xDE, 0x07,
  0xC1, 0xF0, 0x7B, 0xC0, 0xF8, 0x3C, 0x1F, 0x78, 0x3E, 0x07, 0x83, 0xCF,
  0x07, 0xC0, 0xF0, 0x79, 0xE0, 0xF0, 0x1E, 0x1F, 0x3C, 0x3E, 0x03, 0xC3,
  0xC7, 0x87, 0xC0, 0x78, 0x78, 0xF1, 0xF0, 0x0F, 0x1E, 0x1E, 0x3E, 0x01,
  0xE3, 0xC3, 0xC7, 0x80, 0x3C, 0xF8, 0x79, 0xF0, 0x07, 0x9E, 0x0F, 0x3E,
  0x00, 0xF3, 0xC1, 0xEF, 0x80, 0x1E, 0xF0, 0x3D, 0xF0, 0x03, 0xDE, 0x07,
  0xBC, 0x00, 0x7B, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x9F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x00,
  0x01, 0x1F, 0xE0, 0x01, 0x3F, 0xF8, 0x03, 0x7F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFE, 0x80, 0x03, 0xFC, 0x80, 0x00,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 47, 15, 1, -46 },
  { 90, 18, 17, 22, 6, -46 },
  { 129, 29, 46, 27, 0, -46 },
  { 296, 26, 53, 25, 0, -49 },
  { 469, 34, 47, 39, 3, -46 },
  { 669, 27, 47, 27, 0, -46 },
  { 828, 8, 17, 12, 7, -46 },
  { 845, 20, 56, 16, 1, -46 },
  { 985, 20, 56, 16, -5, -46 },
  { 1125, 20, 21, 23, 6, -49 },
  { 1178, 23, 30, 28, 3, -38 },
  { 1265, 11, 15, 13, -3, -7 },
  { 1286, 14, 5, 17, 1, -20 },
  { 1295, 6, 8, 13, 1, -7 },
  { 1301, 29, 46, 21, -3, -46 },
  { 1468, 24, 47, 25, 1, -46 },
  { 1609, 16, 46, 25, 7, -46 },
  { 1701, 27, 46, 25, -2, -46 },
  { 1857, 26, 47, 25, -1, -46 },
  { 2010, 26, 46, 25, -1, -46 },
  { 2160, 27, 47, 25, -1, -46 },
  { 2319, 25, 47, 25, 2, -46 },
  { 2466, 26, 46, 25, 2, -46 },
  { 2616, 26, 47, 25, 0, -46 },
  { 2769, 25, 47, 25, 0, -46 },
  { 2916, 13, 36, 13, 0, -35 },
  { 2975, 16, 43, 13, -3, -35 },
  { 3061, 24, 29, 28, 2, -37 },
  { 3148, 23, 19, 28, 3, -32 },
  { 3203, 23, 29, 28, 3, -37 },
  { 3287, 20, 47, 19, 1, -46 },
  { 3405, 35, 51, 38, 2, -46 },
  { 3629, 26, 46, 26, -4, -46 },
  { 3779, 28, 46, 28, 0, -46 },
  { 3940, 27, 47, 25, 2, -46 },
  { 4099, 29, 46, 30, 0, -46 },
  { 4266, 26, 46, 23, 0, -46 },
  { 4416, 26, 46, 22, 0, -46 },
  { 4566, 31, 47, 31, 2, -46 },
  { 4749, 32, 46, 31, 0, -46 },
  { 4933, 24, 46, 17, -3, -46 },
  { 5071, 24, 58, 13, -9, -46 },
  { 5245, 31, 46, 26, 0, -46 },
  { 5424, 17, 46, 22, 0, -46 },
  { 5522, 43, 46, 41, 0, -46 },
  { 5770, 34, 46, 33, 0, -46 },
  { 5966, 29, 47, 32, 2, -46 },
  { 6137, 27, 46, 26, 0, -46 },
  { 6293, 29, 57, 32, 2, -46 },
  { 6500, 27, 46, 27, 0, -46 },
  { 6656, 27, 47, 24, -1, -46 },
  { 6815, 23, 46, 22, 4, -46 },
  { 6948, 30, 47, 30, 2, -46 },
  { 7125, 26, 46, 26, 5, -46 },
  { 7275, 43, 46, 42, 4, -46 },
  { 7523, 32, 46, 24, -4, -46 },
  { 7707, 23, 46, 23, 5, -46 },
  { 7840, 28, 46, 21, -3, -46 },
  { 8001, 24, 56, 18, -2, -46 },
  { 8169, 11, 46, 22, 6, -46 },
  { 8233, 24, 56, 18, -4, -46 },
  { 8401, 24, 25, 25, 1, -46 },
  { 8476, 21, 4, 19, -6, 5 },
  { 8487, 9, 10, 16, 9, -49 },
  { 8499, 25, 36, 27, 2, -35 },
  { 8612, 25, 50, 27, 0, -49 },
  { 8769, 20, 36, 20, 2, -35 },
  { 8859, 28, 50, 27, 2, -49 },
  { 9034, 21, 36, 24, 2, -35 },
  { 9129, 30, 64, 15, -8, -49 },
  { 9369, 28, 50, 27, -1, -35 },
  { 9544, 25, 49, 26, 0, -49 },
  { 9698, 15, 47, 12, 0, -47 },
  { 9787, 23, 62, 12, -8, -47 },
  { 9966, 26, 49, 23, 0, -49 },
  { 10126, 15, 49, 12, 0, -49 },
  { 10218, 38, 35, 39, 0, -35 },
  { 10385, 25, 35, 26, 0, -35 },
  { 10495, 22, 36, 26, 2, -35 },
  { 10594, 28, 50, 27, -3, -35 },
  { 10769, 25, 50, 27, 2, -35 },
  { 10926, 21, 35, 18, 0, -35 },
  { 11018, 22, 36, 20, -1, -35 },
  { 11117, 15, 43, 15, 2, -42 },
  { 11198, 24, 35, 26, 2, -34 },
  { 11303, 21, 34, 22, 4, -34 },
  { 11393, 35, 34, 35, 3, -34 },
  { 11542, 27, 34, 22, -3, -34 },
  { 11657, 31, 49, 22, -6, -34 },
  { 11847, 22, 34, 18, -2, -34 },
  { 11941, 24, 56, 21, 1, -46 },
  { 12109, 5, 64, 23, 9, -49 },
  { 12149, 23, 56, 21, -4, -46 },
  { 12310, 24, 9, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Italic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC64PT7B_H_
