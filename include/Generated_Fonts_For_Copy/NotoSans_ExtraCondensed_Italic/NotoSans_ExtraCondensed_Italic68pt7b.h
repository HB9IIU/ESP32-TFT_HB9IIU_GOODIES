#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x20, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x1F,
  0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xE1,
  0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0xF0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x81, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xCE, 0x1C, 0x01, 0xF0,
  0xE0, 0x40, 0x3F, 0x0C, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3E, 0x1C, 0x00,
  0x03, 0xE1, 0xC0, 0x00, 0x3E, 0x1C, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x3E,
  0x38, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x3F, 0x38, 0x00, 0x01, 0xFB, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x0C, 0xFC, 0x00,
  0x01, 0xC7, 0xC0, 0x00, 0x1C, 0x3E, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x1C,
  0x3E, 0x00, 0x01, 0x83, 0xE0, 0x00, 0x38, 0x3E, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x38, 0x7C, 0x08, 0x03, 0x07, 0xC0, 0xE0, 0x30, 0xF8, 0x0F, 0x87,
  0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x1F, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0xF8,
  0x01, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xC0, 0x0F,
  0x07, 0x80, 0x7C, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x1E, 0x07, 0x80, 0xF8,
  0x01, 0xE0, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0x78,
  0x0F, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x0F, 0x80,
  0x07, 0x81, 0xF0, 0xF0, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x0F, 0x81, 0xE1,
  0xE0, 0x70, 0xF8, 0x1E, 0x3C, 0x1F, 0xCF, 0x03, 0xC3, 0xC3, 0xFE, 0xF0,
  0x3C, 0x78, 0x7F, 0xEF, 0x07, 0xC7, 0x8F, 0x9F, 0xF8, 0x78, 0xF1, 0xF0,
  0xF7, 0x8F, 0x9F, 0x1E, 0x0F, 0x7F, 0xF1, 0xE3, 0xE0, 0xF7, 0xFE, 0x3E,
  0x3C, 0x0F, 0x3F, 0xC3, 0xC3, 0xC0, 0xF1, 0xF8, 0x7C, 0x7C, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0xF0, 0x00, 0xF8, 0x78, 0x1F, 0x00, 0x0F, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0xF0, 0x1E, 0x00, 0x1E, 0x0F, 0x01, 0xE0, 0x03, 0xE0,
  0xF0, 0x1E, 0x00, 0x3C, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x3E, 0x00,
  0x78, 0x1F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x07,
  0xC0, 0x1F, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x3E, 0x01,
  0xE0, 0xF0, 0x03, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x00, 0xFB, 0xE0, 0x07,
  0x80, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7D, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x81, 0xF0, 0xFC, 0xF8, 0x1F, 0x0F, 0x8F, 0xC3, 0xF1, 0xF0,
  0xFC, 0x3E, 0x3F, 0x07, 0xC3, 0xE3, 0xE0, 0x7E, 0x7C, 0x7E, 0x07, 0xE7,
  0xC7, 0xC0, 0x3E, 0xFC, 0xFC, 0x03, 0xEF, 0x8F, 0x80, 0x3F, 0xF8, 0xF8,
  0x01, 0xFF, 0x0F, 0x80, 0x1F, 0xF0, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x03, 0xFE, 0x0F,
  0xC0, 0x7F, 0xE0, 0xFE, 0x1F, 0xBE, 0x07, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE,
  0x3F, 0x03, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x1F, 0x80, 0x38, 0x00, 0x00,
  0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F,
  0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x04, 0x07, 0x80, 0x70, 0x78, 0x0F, 0xC7, 0x00, 0xFF, 0x70, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFB, 0xC0, 0x1F, 0x3E, 0x03, 0xE1, 0xE0, 0x7E, 0x1F,
  0x03, 0xC1, 0xF0, 0x18, 0x0F, 0x80, 0x80, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7C, 0x20, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7C,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xDF, 0x1F, 0x8F, 0x9F, 0x8F, 0xC7, 0x87, 0xE1, 0x83, 0xE0, 0x81, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0x03, 0xF8, 0x00,
  0xF0, 0x0F, 0xC0, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0x60, 0x07, 0xF0,
  0x04, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x87, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x80, 0x03, 0xF8, 0x0C, 0x00, 0x7F, 0x00, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x1F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xF0, 0x00,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x80, 0x01, 0xF8, 0x0C, 0x00, 0x7F, 0x80, 0xF8, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0xFC, 0x7F, 0x80, 0x3E, 0x7F,
  0xF0, 0x0F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xF0, 0x7F,
  0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0,
  0xFE, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0,
  0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F,
  0xC0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x7C,
  0x03, 0xFF, 0x9F, 0x00, 0x7F, 0xC7, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xC0,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x07, 0xE0, 0x20, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0x3C, 0x1E, 0x00, 0xFF, 0xC1, 0xE0, 0xF0, 0x0F, 0xFE, 0x0F, 0x0F,
  0x00, 0xFF, 0xF0, 0x78, 0x78, 0x0F, 0x8F, 0x83, 0xC7, 0xC0, 0xF0, 0x78,
  0x1E, 0x3C, 0x0F, 0x83, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x07, 0x9E, 0x07,
  0x81, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x01, 0xC7, 0x81, 0xE0, 0x78, 0x1E,
  0x78, 0x1E, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x3E, 0x07, 0x9E, 0x07, 0x81,
  0xE0, 0x3C, 0xF0, 0x78, 0x0F, 0x03, 0xC7, 0x83, 0xC0, 0x78, 0x1E, 0x78,
  0x1E, 0x07, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0x07, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0xF0, 0x7C, 0x1F, 0x03, 0xC7, 0x83, 0xE0, 0xF8, 0x3C, 0x3C, 0x1F,
  0x07, 0xC1, 0xE1, 0xE0, 0xF8, 0x7E, 0x1E, 0x0F, 0x03, 0xC7, 0x70, 0xF0,
  0x78, 0x1F, 0x7B, 0xDF, 0x03, 0xC0, 0xFF, 0x9F, 0xF0, 0x1E, 0x03, 0xF8,
  0xFF, 0x00, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0xE0, 0x07, 0xC0, 0x3F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7C, 0x07, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x30,
  0x01, 0xFC, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x40, 0x03, 0xFE, 0x3E, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xC3, 0xFE, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x7C, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xFC, 0x01, 0xF8,
  0x0F, 0xF0, 0x03, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xF0, 0x7E, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x3F, 0xFC, 0x1F, 0x80, 0x1F,
  0xFC, 0x0F, 0xC0, 0x0F, 0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x41, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0xFD, 0xE0, 0x00, 0xFB, 0xF0, 0x07, 0xCF, 0x00, 0x07, 0xDF, 0x80, 0x3E,
  0x78, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0x9E,
  0x00, 0x1F, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x03, 0xE3,
  0xF0, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x00,
  0xFC, 0x3E, 0x07, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x3E, 0x0F, 0xC0, 0x1F, 0x83,
  0xE1, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x7C,
  0x0F, 0xC0, 0x1F, 0x81, 0xF3, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xBE, 0x03,
  0xE0, 0x07, 0xC0, 0x3D, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x07, 0xFC, 0x00,
  0x3E, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x7F,
  0xC0, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xFB, 0xC0, 0x07, 0xC0,
  0x0F, 0xBE, 0x00, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xC0, 0x1F, 0xBE, 0x00,
  0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x01, 0xF1,
  0xE0, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x03, 0xF1, 0xF0, 0x1F, 0x80,
  0x3E, 0x1F, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x3E, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x3E, 0x00,
  0x7C, 0x0F, 0x87, 0xE0, 0x0F, 0xC0, 0xF8, 0x7C, 0x00, 0xF8, 0x07, 0x87,
  0xC0, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x80,
  0x7C, 0xFC, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x01,
  0xF0, 0x03, 0xCF, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x03, 0xF0, 0x03, 0xEF,
  0x80, 0x3E, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07,
  0xC0, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0x1F, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x1F, 0xF8, 0x01, 0xF0,
  0x1F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x00,
  0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x3F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xC0, 0x07, 0xF0, 0x03,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x04,
  0x00, 0x1F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF2, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0,
  0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x80,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0xE0,
  0xF8, 0x01, 0xEF, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x78, 0x03, 0xF0, 0x3E,
  0x00, 0xFB, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xBE, 0x00, 0xF8, 0x0F, 0x80,
  0x7D, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF3, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x9F,
  0x01, 0xF0, 0x0F, 0xC0, 0x78, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC7, 0xC0,
  0xF8, 0x03, 0xF0, 0x3C, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE1, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF0, 0x78, 0x3F, 0x00,
  0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x01, 0xF0, 0x78, 0x1E, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x07, 0x87, 0xC0, 0x03, 0xE1,
  0xE0, 0x3C, 0x7E, 0x00, 0x1F, 0x1F, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x0F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x79, 0xF8, 0x00, 0x3E, 0x7C, 0x03,
  0xCF, 0x80, 0x01, 0xF3, 0xC0, 0x1E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0xF7,
  0xE0, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03,
  0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07,
  0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC0,
  0xE0, 0x00, 0x1F, 0x80, 0x20, 0x0F, 0xFC, 0x78, 0x03, 0xFF, 0x9F, 0x00,
  0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x7C, 0x07, 0xE0, 0xFF, 0x81, 0xF8, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F,
  0x80, 0x3F, 0x81, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7F,
  0x80, 0xFE, 0x1D, 0xF0, 0x0F, 0xFF, 0xBE, 0x01, 0xFF, 0xE7, 0x80, 0x1F,
  0xF8, 0xF0, 0x01, 0xFE, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF9, 0xFF, 0x00, 0x3E, 0x7F, 0xF0, 0x07,
  0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x0F,
  0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x7E,
  0x03, 0xFE, 0x1F, 0xC0, 0x7B, 0xFF, 0xF0, 0x1F, 0x3F, 0xFC, 0x03, 0xE7,
  0xFF, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xC0, 0x40, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x80, 0x7E, 0x0E, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0xE7, 0xC0, 0x03, 0xFF,
  0x9F, 0x00, 0x1F, 0xFF, 0x7C, 0x00, 0xFF, 0xFD, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3E,
  0x00, 0xFE, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0xFF, 0x00, 0x3F, 0x87, 0x7C, 0x00, 0x7F, 0xFD, 0xF0, 0x01, 0xFF, 0xE7,
  0x80, 0x03, 0xFF, 0x1E, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xCF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F,
  0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x03, 0xF8, 0x7D,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x7E, 0x01, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x8F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x02, 0x00, 0x0F, 0xFC, 0x78, 0x00, 0x3F, 0xF9, 0xF0, 0x00,
  0xFF, 0xFB, 0xE0, 0x03, 0xFF, 0xF7, 0xC0, 0x07, 0xE0, 0xFF, 0x80, 0x1F,
  0x80, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0x07,
  0xE0, 0x7F, 0x80, 0x0F, 0xE1, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0xF8, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x20, 0x00, 0xFC,
  0x00, 0x70, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0xF9, 0xFF, 0x00, 0x7C, 0xFF, 0xE0,
  0x1F, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0x03,
  0xF0, 0x3F, 0x80, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x06, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xE0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xF1, 0xFF, 0x07, 0xFC, 0x01, 0xF3, 0xFF, 0x9F, 0xFE, 0x01, 0xF7,
  0xFF, 0xBF, 0xFE, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF8,
  0x3F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x7C, 0x7F, 0xC0, 0x1F, 0x3F, 0xF8, 0x07, 0xDF,
  0xFE, 0x01, 0xEF, 0xFF, 0xC0, 0x7F, 0x83, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC,
  0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F,
  0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFD, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0,
  0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0xFF, 0x80, 0x03, 0xE7, 0xFF, 0x00, 0x0F, 0xBF, 0xFE, 0x00, 0x3F,
  0xF3, 0xF8, 0x00, 0xF7, 0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xF8, 0x7F, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xC0, 0x07, 0xE7, 0xFE, 0x00, 0x1F, 0x0F,
  0xF0, 0x00, 0x7C, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x0F, 0xFC, 0x78, 0x03, 0xFF, 0x9F,
  0x00, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x7C, 0x07, 0xE0, 0xFF, 0x81, 0xF8,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xFC, 0x07, 0xE0,
  0x7F, 0x80, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0x80,
  0x1F, 0xF9, 0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x07, 0xC7, 0xF0, 0x1F, 0x3F, 0x80, 0x79, 0xFE,
  0x01, 0xEF, 0xF8, 0x07, 0xBE, 0x40, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xC7, 0xC0, 0x7E, 0x01,
  0x81, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x60, 0x07, 0xE0, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x40, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0E, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x0F, 0xC1, 0xFE, 0x03, 0xF0, 0xFF,
  0x80, 0xFF, 0xFB, 0xE0, 0x3F, 0xFC, 0xF8, 0x07, 0xFF, 0x3C, 0x00, 0xFF,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x3E, 0xF8, 0x03, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0x80, 0x7E, 0xF8, 0x07, 0xF8, 0x07, 0xCF, 0x80, 0x7F, 0x80, 0x7C,
  0xF8, 0x07, 0xF8, 0x0F, 0x8F, 0x80, 0xF7, 0x80, 0xF8, 0xF8, 0x0F, 0x78,
  0x1F, 0x8F, 0x81, 0xF7, 0x81, 0xF0, 0xF8, 0x1E, 0xF8, 0x1F, 0x0F, 0x81,
  0xEF, 0x83, 0xE0, 0xF8, 0x3E, 0xF8, 0x3E, 0x0F, 0x83, 0xCF, 0x83, 0xE0,
  0xF8, 0x7C, 0xF8, 0x7C, 0x0F, 0x87, 0x8F, 0x87, 0xC0, 0xF8, 0x78, 0xF8,
  0xF8, 0x0F, 0x8F, 0x8F, 0x8F, 0x80, 0xF8, 0xF0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0xF1, 0xF0, 0x0F, 0x9E, 0x0F, 0x3E, 0x00,
  0xFB, 0xE0, 0xF3, 0xE0, 0x0F, 0xBC, 0x0F, 0x3E, 0x00, 0xFB, 0xC0, 0xF7,
  0xC0, 0x0F, 0x7C, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x0F, 0x78,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x07,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB,
  0xFF, 0xBF, 0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0x00, 0x3F, 0xF9, 0x00, 0x07,
  0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 16, 50, 16, 1, -49 },
  { 101, 19, 18, 23, 7, -49 },
  { 144, 30, 49, 29, 0, -49 },
  { 328, 28, 56, 27, 0, -52 },
  { 524, 36, 50, 41, 3, -49 },
  { 749, 28, 50, 29, 0, -49 },
  { 924, 9, 18, 13, 7, -49 },
  { 945, 21, 60, 17, 1, -49 },
  { 1103, 21, 60, 17, -5, -49 },
  { 1261, 20, 23, 25, 7, -52 },
  { 1319, 25, 32, 29, 3, -40 },
  { 1419, 12, 17, 14, -3, -8 },
  { 1445, 15, 5, 18, 1, -21 },
  { 1455, 7, 9, 14, 1, -8 },
  { 1463, 31, 49, 23, -3, -49 },
  { 1653, 26, 50, 27, 1, -49 },
  { 1816, 17, 49, 27, 7, -49 },
  { 1921, 29, 49, 27, -2, -49 },
  { 2099, 28, 50, 27, -1, -49 },
  { 2274, 28, 49, 27, -1, -49 },
  { 2446, 28, 50, 27, -1, -49 },
  { 2621, 26, 50, 27, 2, -49 },
  { 2784, 28, 49, 27, 2, -49 },
  { 2956, 27, 50, 27, 0, -49 },
  { 3125, 26, 50, 27, 0, -49 },
  { 3288, 13, 38, 14, 0, -37 },
  { 3350, 17, 46, 14, -3, -37 },
  { 3448, 25, 30, 29, 3, -39 },
  { 3542, 25, 20, 29, 3, -34 },
  { 3605, 25, 30, 29, 3, -39 },
  { 3699, 22, 50, 20, 1, -49 },
  { 3837, 37, 55, 40, 2, -49 },
  { 4092, 27, 49, 27, -4, -49 },
  { 4258, 30, 49, 29, 0, -49 },
  { 4442, 29, 50, 26, 2, -49 },
  { 4624, 31, 49, 32, 0, -49 },
  { 4814, 28, 49, 25, 0, -49 },
  { 4986, 28, 49, 23, 0, -49 },
  { 5158, 33, 50, 33, 2, -49 },
  { 5365, 34, 49, 33, 0, -49 },
  { 5574, 26, 49, 18, -3, -49 },
  { 5734, 26, 62, 14, -10, -49 },
  { 5936, 33, 49, 28, 0, -49 },
  { 6139, 18, 49, 23, 0, -49 },
  { 6250, 45, 49, 44, 0, -49 },
  { 6526, 36, 49, 35, 0, -49 },
  { 6747, 31, 50, 34, 2, -49 },
  { 6941, 29, 49, 27, 0, -49 },
  { 7119, 31, 61, 34, 2, -49 },
  { 7356, 29, 49, 28, 0, -49 },
  { 7534, 30, 50, 26, -2, -49 },
  { 7722, 25, 49, 23, 4, -49 },
  { 7876, 32, 50, 32, 2, -49 },
  { 8076, 27, 49, 27, 6, -49 },
  { 8242, 45, 49, 44, 5, -49 },
  { 8518, 34, 49, 25, -4, -49 },
  { 8727, 25, 49, 24, 5, -49 },
  { 8881, 30, 49, 23, -3, -49 },
  { 9065, 26, 60, 19, -2, -49 },
  { 9260, 11, 49, 23, 7, -49 },
  { 9328, 25, 60, 19, -4, -49 },
  { 9516, 26, 26, 27, 1, -49 },
  { 9601, 22, 4, 21, -6, 6 },
  { 9612, 9, 11, 17, 10, -52 },
  { 9625, 27, 38, 29, 2, -37 },
  { 9754, 27, 53, 28, 0, -52 },
  { 9933, 22, 38, 22, 2, -37 },
  { 10038, 30, 53, 29, 2, -52 },
  { 10237, 23, 38, 26, 2, -37 },
  { 10347, 32, 68, 16, -8, -52 },
  { 10619, 31, 53, 29, -2, -37 },
  { 10825, 26, 52, 28, 0, -52 },
  { 10994, 16, 50, 13, 0, -50 },
  { 11094, 25, 66, 13, -9, -50 },
  { 11301, 28, 52, 25, 0, -52 },
  { 11483, 16, 52, 13, 0, -52 },
  { 11587, 40, 37, 42, 0, -37 },
  { 11772, 26, 37, 28, 0, -37 },
  { 11893, 24, 38, 28, 2, -37 },
  { 12007, 30, 53, 28, -3, -37 },
  { 12206, 27, 53, 29, 2, -37 },
  { 12385, 22, 37, 19, 0, -37 },
  { 12487, 23, 38, 21, -1, -37 },
  { 12597, 16, 46, 16, 2, -45 },
  { 12689, 26, 37, 28, 2, -36 },
  { 12810, 22, 36, 23, 4, -36 },
  { 12909, 36, 36, 37, 4, -36 },
  { 13071, 29, 36, 23, -3, -36 },
  { 13202, 33, 52, 23, -6, -36 },
  { 13417, 23, 36, 19, -2, -36 },
  { 13521, 25, 60, 22, 2, -49 },
  { 13709, 5, 68, 25, 10, -52 },
  { 13752, 24, 60, 22, -4, -49 },
  { 13932, 25, 8, 29, 3, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Italic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC68PT7B_H_
