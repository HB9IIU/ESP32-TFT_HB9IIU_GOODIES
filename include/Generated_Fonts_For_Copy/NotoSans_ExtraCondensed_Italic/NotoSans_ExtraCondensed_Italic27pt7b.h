#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x04, 0x00, 0x00, 0x61, 0xC3, 0x80, 0x67, 0xCF, 0x36, 0x6C, 0xD9, 0xA2,
  0x00, 0x03, 0x30, 0x22, 0x06, 0x60, 0x66, 0x04, 0x43, 0xFF, 0x3F, 0xF0,
  0x88, 0x19, 0x81, 0x98, 0x11, 0x0F, 0xFC, 0xFF, 0xC2, 0x20, 0x62, 0x06,
  0x60, 0x66, 0x04, 0x40, 0xCC, 0x00, 0x01, 0x00, 0x20, 0x04, 0x07, 0xF1,
  0xFE, 0x34, 0x0C, 0x81, 0x90, 0x3A, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0B, 0x02, 0x60, 0x4C, 0x09, 0x99, 0x63, 0xF8, 0x1E, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x08, 0x00, 0x3C, 0x30, 0xD8, 0x41, 0x31, 0x86, 0x62, 0x0C,
  0xCC, 0x11, 0x90, 0x62, 0x60, 0xCD, 0x99, 0x9B, 0x7B, 0x6D, 0x93, 0xDB,
  0x32, 0x64, 0x40, 0xD8, 0x83, 0x33, 0x06, 0x66, 0x18, 0x8C, 0x31, 0x30,
  0xC3, 0x63, 0x87, 0x80, 0x01, 0x00, 0xF0, 0x33, 0x06, 0x61, 0x8C, 0x33,
  0x06, 0x60, 0xF8, 0x0F, 0x01, 0xC0, 0x78, 0x1B, 0x36, 0x67, 0xCF, 0xB0,
  0xF6, 0x1C, 0xC3, 0x98, 0xF3, 0xFE, 0x3E, 0xE0, 0x6F, 0x6D, 0xA0, 0x03,
  0x83, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xE0,
  0x10, 0x18, 0x98, 0xD9, 0xFF, 0x38, 0x68, 0xEC, 0x4E, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x39, 0x9C, 0xC6, 0x62, 0x00, 0x7F, 0xF0, 0x7F, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x00, 0x02, 0x03, 0xE1, 0xD8, 0xE6, 0x31, 0xCC, 0x76,
  0x19, 0x86, 0x61, 0xB8, 0x6C, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x33, 0x1C,
  0xC6, 0x33, 0x8F, 0xC1, 0xE0, 0x0E, 0x39, 0xF7, 0x6D, 0xC3, 0x06, 0x0C,
  0x18, 0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x80, 0x01, 0x00,
  0x7E, 0x0E, 0xE0, 0x87, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xFF, 0x8F, 0xF8, 0x02, 0x03, 0xF8, 0x77, 0x08, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x03, 0x83, 0xE0, 0x78, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x10, 0xE3, 0xF8, 0x7E, 0x00, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x6C, 0x0B, 0x03, 0x60, 0xCC, 0x11, 0x86, 0x31, 0x8C, 0x31,
  0x8C, 0x31, 0xFF, 0xBF, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x0F,
  0xE1, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xF0, 0x3F, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x87, 0x1F, 0xC3,
  0xF0, 0x00, 0x00, 0x81, 0xF0, 0xE4, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80,
  0x6F, 0x3F, 0xCE, 0x3B, 0x8E, 0xC3, 0xB0, 0xEC, 0x33, 0x0C, 0xC3, 0x31,
  0x8F, 0xE1, 0xF0, 0x3F, 0xE7, 0xF8, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x01, 0xF8, 0x73, 0x8C, 0x31,
  0x86, 0x70, 0xC6, 0x30, 0xC6, 0x1F, 0x81, 0xE0, 0x78, 0x19, 0x86, 0x39,
  0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0xFC, 0x3F, 0x00, 0x03, 0x03,
  0xE1, 0xDC, 0x63, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x70, 0xCC, 0x73, 0x3C,
  0xFB, 0x1D, 0x80, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x8F, 0xC3, 0xE0, 0x08,
  0xC6, 0x20, 0x00, 0x00, 0x00, 0x00, 0x06, 0x73, 0x00, 0x04, 0x30, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC6, 0x18, 0x43, 0x08, 0x00,
  0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C, 0x3C, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x80, 0x30, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1C, 0x0E, 0x0E, 0x0F,
  0x0F, 0x03, 0x00, 0x04, 0x0F, 0x8E, 0xE0, 0x30, 0x18, 0x0C, 0x0C, 0x0E,
  0x06, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0x80, 0x00, 0x00, 0x30, 0x38,
  0x1C, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x30, 0x30, 0xC0, 0x23, 0x00, 0x44,
  0x3C, 0xD8, 0xD9, 0xB3, 0x32, 0x44, 0x45, 0x99, 0x9B, 0x33, 0x34, 0x46,
  0x68, 0x98, 0x91, 0x33, 0x23, 0xFC, 0x47, 0x30, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x0C, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x36, 0x06, 0xC1, 0xD8, 0x33, 0x06, 0x61, 0x8C, 0x31, 0x8F, 0xF1, 0xFE,
  0x30, 0xCC, 0x19, 0x83, 0x70, 0x6C, 0x0F, 0x81, 0x80, 0x0F, 0xC0, 0xFE,
  0x1C, 0x71, 0x87, 0x18, 0x71, 0x87, 0x18, 0x63, 0x8C, 0x3F, 0x83, 0xF8,
  0x31, 0xC3, 0x0C, 0x70, 0xC6, 0x0C, 0x60, 0xC6, 0x1C, 0x63, 0x8F, 0xF0,
  0xFE, 0x00, 0x00, 0x80, 0xFC, 0x3D, 0x8E, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xFE, 0x1C, 0x71, 0x83,
  0x18, 0x31, 0x83, 0x18, 0x33, 0x83, 0x30, 0x33, 0x07, 0x30, 0x73, 0x06,
  0x70, 0x66, 0x0E, 0x60, 0xC6, 0x18, 0x63, 0x8F, 0xF0, 0xFC, 0x00, 0x0F,
  0xE1, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x3F, 0x87,
  0xF0, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x07, 0xF0, 0xFE, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xC3, 0xDC, 0x38, 0x23,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x79, 0x87,
  0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x18, 0xE0, 0xC3, 0x06, 0x1F, 0xF0,
  0x7F, 0x00, 0x0C, 0x1C, 0x30, 0x61, 0xC1, 0x86, 0x06, 0x18, 0x38, 0x60,
  0xC1, 0x83, 0x0E, 0x0C, 0x3F, 0xF0, 0xFF, 0xC3, 0x06, 0x0C, 0x18, 0x70,
  0x61, 0x81, 0x86, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x03, 0x0C, 0x1C, 0x00,
  0x1F, 0xC1, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1E, 0x0F, 0xC0,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x06, 0x0F, 0x83, 0xC0, 0x0C, 0x38, 0x61, 0x87, 0x18, 0x31,
  0xC1, 0x9C, 0x0C, 0xC0, 0x6C, 0x07, 0xE0, 0x36, 0x01, 0xF0, 0x0F, 0x80,
  0x6E, 0x07, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x70, 0x63, 0x86, 0x0C, 0x30,
  0x60, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x87,
  0x0C, 0x18, 0x30, 0x61, 0xFF, 0xF8, 0x0E, 0x03, 0xC3, 0x80, 0xF1, 0xE0,
  0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0x61, 0xE0, 0xF8, 0xF8, 0x6C,
  0x32, 0x1B, 0x0C, 0x8C, 0xC3, 0x23, 0x30, 0xCD, 0xDC, 0x63, 0x66, 0x18,
  0xD9, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0x63, 0x8C, 0x30, 0xE3, 0x0C, 0x30,
  0xC0, 0x0E, 0x0C, 0x38, 0x31, 0xE0, 0xC7, 0x83, 0x1A, 0x18, 0x6C, 0x61,
  0xB1, 0x8E, 0xC6, 0x33, 0x38, 0xCC, 0xC3, 0x33, 0x0C, 0x6C, 0x61, 0xB1,
  0x87, 0xC6, 0x1E, 0x18, 0x78, 0x61, 0xE3, 0x03, 0x8C, 0x0C, 0x00, 0x01,
  0x80, 0x7E, 0x0E, 0xE1, 0x87, 0x38, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60,
  0x3E, 0x07, 0xE0, 0x7C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC, 0x0C, 0xC1,
  0x8E, 0x38, 0x7F, 0x03, 0xE0, 0x0F, 0xC1, 0xFC, 0x71, 0x8C, 0x31, 0x86,
  0x30, 0xC6, 0x19, 0xC7, 0x30, 0xC6, 0xF8, 0xFC, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x00, 0x01, 0x80, 0x7E, 0x0E,
  0xE1, 0x87, 0x38, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x07, 0xE0,
  0x7C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC, 0x0C, 0xC1, 0x8E, 0x38, 0x7F,
  0x03, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xC1,
  0xFC, 0x71, 0x8C, 0x31, 0x86, 0x30, 0xC6, 0x19, 0xC7, 0x31, 0xC7, 0xF0,
  0xF8, 0x1B, 0x87, 0x30, 0xC6, 0x18, 0xC3, 0x18, 0x63, 0x98, 0x33, 0x06,
  0x00, 0x00, 0x80, 0x7F, 0x0F, 0xF0, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x88, 0x38, 0xFF, 0x07, 0xE0, 0xFF, 0xFF, 0xC6, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x00, 0x18, 0x31, 0x83, 0x38, 0x33, 0x07, 0x30,
  0x63, 0x06, 0x30, 0x66, 0x06, 0x60, 0xE6, 0x0C, 0x60, 0xCE, 0x0C, 0xC0,
  0xCC, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x0F, 0xF0, 0x7E, 0x00, 0xE0, 0xFC,
  0x1B, 0x83, 0x70, 0xEE, 0x19, 0xC7, 0x30, 0xC6, 0x18, 0xC6, 0x18, 0xC3,
  0x38, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x00, 0xC0, 0xC1, 0xF0, 0x70, 0x6C, 0x1C, 0x3B, 0x07, 0x0C, 0xC3, 0xC3,
  0x30, 0xF1, 0x8C, 0x6C, 0x63, 0x1B, 0x38, 0xC6, 0xCC, 0x33, 0x33, 0x0C,
  0xCD, 0xC3, 0x63, 0x60, 0xD8, 0xD8, 0x36, 0x3C, 0x0F, 0x0B, 0x03, 0xC3,
  0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0C, 0x00, 0x06, 0x1C, 0x18, 0x60,
  0x63, 0x01, 0xCC, 0x03, 0x60, 0x0D, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0D, 0x80, 0x36, 0x01, 0x98, 0x0E, 0x70,
  0x31, 0xC1, 0xC3, 0x0E, 0x0C, 0x00, 0xE1, 0xF8, 0x66, 0x31, 0x8C, 0x66,
  0x19, 0x86, 0xC1, 0xB0, 0x78, 0x1E, 0x07, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xC1, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0F, 0xC0, 0xCC, 0xCC, 0xCC, 0x66, 0x66, 0x66, 0x66, 0x33,
  0x33, 0x30, 0x07, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0x80, 0x03, 0x00, 0xE0, 0x1E, 0x06,
  0xC0, 0xD8, 0x31, 0x0C, 0x31, 0x86, 0x60, 0xDC, 0x0C, 0xFF, 0xFF, 0xCE,
  0x66, 0x30, 0x0E, 0x07, 0xF3, 0x9D, 0xC7, 0x61, 0xD8, 0x6E, 0x1B, 0x06,
  0xC1, 0xB0, 0xCC, 0x33, 0x0C, 0xC7, 0x3E, 0xC7, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x60, 0xFE, 0x1C, 0xC7, 0x1C, 0xE1,
  0x98, 0x73, 0x0E, 0x61, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x33, 0x8E, 0x7F,
  0x8D, 0xE0, 0x07, 0x1F, 0x39, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x0E, 0xC1, 0xFC, 0x39, 0xC7, 0x1C, 0x61, 0xC6, 0x18, 0xE1,
  0x8C, 0x18, 0xC1, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x0F, 0xB0, 0x72,
  0x00, 0x06, 0x0F, 0x8C, 0x6E, 0x36, 0x1F, 0x1B, 0x1D, 0xF8, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xF1, 0xF8, 0x00, 0x30, 0x0F, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0xFC, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x0F, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x7F, 0x0E, 0x71, 0xC7, 0x18, 0x71, 0x86, 0x38, 0x63, 0x06, 0x30,
  0x63, 0x0C, 0x30, 0xC3, 0x1C, 0x31, 0xC3, 0xEC, 0x1D, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x0C, 0xF0, 0xFE, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x98, 0x7F, 0x1C, 0xCE, 0x33, 0x0C, 0xC3, 0x30, 0xCC,
  0x76, 0x19, 0x86, 0x61, 0x98, 0x66, 0x3B, 0x0C, 0xC3, 0x00, 0x0C, 0x30,
  0xC0, 0x00, 0x01, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x63, 0x8C,
  0x30, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0xF0, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x08, 0xC6, 0x19, 0x87, 0x70, 0xCC, 0x1B, 0x03,
  0xE0, 0x7C, 0x1D, 0x83, 0xB0, 0x66, 0x0C, 0xC1, 0x8C, 0x61, 0x8C, 0x30,
  0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC6, 0x18,
  0x61, 0x86, 0x30, 0xC0, 0x01, 0x8E, 0x1F, 0xDF, 0x1C, 0xE7, 0x38, 0xE3,
  0x30, 0xC3, 0x30, 0xC6, 0x30, 0xC6, 0x31, 0x86, 0x61, 0x86, 0x61, 0x86,
  0x61, 0x8C, 0x63, 0x8C, 0xE3, 0x0C, 0xC3, 0x0C, 0xC3, 0x1C, 0x01, 0x87,
  0xF1, 0xCC, 0xE3, 0x38, 0xCC, 0x33, 0x0C, 0xC7, 0x61, 0x98, 0x66, 0x19,
  0x86, 0xE3, 0xB0, 0xCC, 0x30, 0x0E, 0x0F, 0x8C, 0x6E, 0x36, 0x1B, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xD8, 0x6C, 0x67, 0xF1, 0xF0, 0x00, 0xC0,
  0xFE, 0x0E, 0x61, 0xC7, 0x1C, 0x31, 0x87, 0x18, 0x71, 0x86, 0x30, 0x63,
  0x06, 0x30, 0xE3, 0x0C, 0x31, 0xC6, 0xF8, 0x6F, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x07, 0xF3, 0x9D, 0xC7, 0x61,
  0xD8, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0x1C, 0xC7, 0x3E, 0xC7,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x01, 0x8F, 0x85,
  0xC7, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x00, 0x0E, 0x0F, 0xCC, 0x46, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xC8, 0xE7, 0xE3, 0xE0, 0x18, 0x61, 0x0C, 0x7E, 0xC7,
  0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0xF3, 0xC0, 0x30, 0xCC, 0x36,
  0x19, 0x86, 0x61, 0x98, 0x66, 0x3B, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0x1C,
  0xFE, 0x3D, 0x80, 0xC3, 0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0xD8,
  0xF0, 0xF0, 0xE0, 0xE0, 0xC0, 0x63, 0x8E, 0xC7, 0x19, 0x9E, 0x33, 0x3C,
  0xC6, 0x59, 0x8D, 0xB3, 0x1B, 0x6C, 0x34, 0xD8, 0x59, 0xE0, 0xB3, 0xC3,
  0xC7, 0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x30, 0x00, 0x18, 0xE3, 0x98, 0x36,
  0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xCC, 0x31,
  0x86, 0x31, 0x86, 0x00, 0x06, 0x1C, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x06,
  0x60, 0x19, 0x80, 0x6E, 0x01, 0xB0, 0x06, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x0B,
  0x80, 0x1C, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0F, 0xE7, 0xF0, 0x03, 0xC1, 0xE0,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x07, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x03,
  0x03, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x3E,
  0x0F, 0x00, 0x78, 0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 6, 0, -19 },
  { 18, 7, 7, 9, 3, -19 },
  { 25, 12, 19, 11, 0, -19 },
  { 54, 11, 23, 11, 0, -21 },
  { 86, 15, 20, 16, 1, -20 },
  { 124, 11, 20, 12, 0, -20 },
  { 152, 3, 7, 5, 3, -19 },
  { 155, 9, 23, 7, 0, -19 },
  { 181, 8, 23, 7, -2, -19 },
  { 204, 8, 9, 10, 3, -21 },
  { 213, 10, 13, 12, 1, -16 },
  { 230, 5, 7, 5, -1, -3 },
  { 235, 6, 2, 7, 0, -8 },
  { 237, 3, 3, 5, 0, -3 },
  { 239, 12, 19, 9, -1, -19 },
  { 268, 10, 20, 11, 1, -20 },
  { 293, 7, 19, 11, 3, -19 },
  { 310, 12, 20, 11, -1, -20 },
  { 340, 11, 20, 11, 0, -20 },
  { 368, 11, 19, 11, 0, -19 },
  { 395, 11, 19, 11, 0, -19 },
  { 422, 10, 20, 11, 1, -20 },
  { 447, 11, 19, 11, 1, -19 },
  { 474, 11, 20, 11, 0, -20 },
  { 502, 10, 20, 11, 0, -20 },
  { 527, 5, 15, 6, 0, -15 },
  { 537, 6, 19, 6, -1, -15 },
  { 552, 10, 12, 12, 1, -16 },
  { 567, 10, 7, 12, 1, -13 },
  { 576, 10, 12, 12, 1, -16 },
  { 591, 9, 20, 8, 0, -20 },
  { 614, 15, 21, 16, 1, -19 },
  { 654, 11, 19, 11, -2, -19 },
  { 681, 12, 19, 12, 0, -19 },
  { 710, 11, 20, 10, 1, -20 },
  { 738, 12, 19, 13, 0, -19 },
  { 767, 11, 19, 10, 0, -19 },
  { 794, 11, 19, 9, 0, -19 },
  { 821, 13, 20, 13, 1, -20 },
  { 854, 14, 19, 13, 0, -19 },
  { 888, 10, 19, 7, -1, -19 },
  { 912, 10, 24, 5, -4, -19 },
  { 942, 13, 19, 11, 0, -19 },
  { 973, 7, 19, 9, 0, -19 },
  { 990, 18, 19, 17, 0, -19 },
  { 1033, 14, 19, 14, 0, -19 },
  { 1067, 12, 20, 13, 1, -20 },
  { 1097, 11, 19, 11, 0, -19 },
  { 1124, 12, 25, 13, 1, -20 },
  { 1162, 11, 19, 11, 0, -19 },
  { 1189, 12, 20, 10, -1, -20 },
  { 1219, 9, 19, 9, 2, -19 },
  { 1241, 12, 19, 13, 1, -19 },
  { 1270, 11, 19, 11, 2, -19 },
  { 1297, 18, 19, 18, 2, -19 },
  { 1340, 14, 19, 10, -2, -19 },
  { 1374, 10, 19, 10, 2, -19 },
  { 1398, 12, 19, 9, -1, -19 },
  { 1427, 10, 23, 8, -1, -19 },
  { 1456, 4, 19, 9, 3, -19 },
  { 1466, 10, 23, 8, -2, -19 },
  { 1495, 11, 10, 11, 0, -19 },
  { 1509, 8, 2, 8, -2, 2 },
  { 1511, 4, 5, 7, 4, -21 },
  { 1514, 10, 15, 11, 1, -15 },
  { 1533, 11, 21, 11, 0, -21 },
  { 1562, 8, 15, 9, 1, -15 },
  { 1577, 12, 21, 11, 1, -21 },
  { 1609, 9, 15, 10, 1, -15 },
  { 1626, 12, 27, 6, -3, -21 },
  { 1667, 12, 21, 11, -1, -15 },
  { 1699, 10, 21, 11, 0, -21 },
  { 1726, 6, 20, 5, 0, -20 },
  { 1741, 9, 26, 5, -3, -20 },
  { 1771, 11, 21, 10, 0, -21 },
  { 1800, 6, 21, 5, 0, -21 },
  { 1816, 16, 15, 17, 0, -15 },
  { 1846, 10, 15, 11, 0, -15 },
  { 1865, 9, 15, 11, 1, -15 },
  { 1882, 12, 21, 11, -1, -15 },
  { 1914, 10, 21, 11, 1, -15 },
  { 1941, 9, 15, 7, 0, -15 },
  { 1958, 9, 15, 9, 0, -15 },
  { 1975, 6, 18, 6, 1, -18 },
  { 1989, 10, 14, 11, 1, -14 },
  { 2007, 8, 14, 9, 2, -14 },
  { 2021, 15, 14, 15, 1, -14 },
  { 2048, 11, 14, 9, -1, -14 },
  { 2068, 14, 21, 9, -3, -14 },
  { 2105, 9, 14, 8, -1, -14 },
  { 2121, 10, 23, 9, 1, -19 },
  { 2150, 2, 27, 10, 4, -21 },
  { 2157, 10, 23, 9, -2, -19 },
  { 2186, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Italic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC27PT7B_H_
