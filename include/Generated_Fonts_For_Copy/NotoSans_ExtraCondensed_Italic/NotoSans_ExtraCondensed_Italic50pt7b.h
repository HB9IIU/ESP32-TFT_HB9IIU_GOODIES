#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x00,
  0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x1C, 0x3C, 0x70, 0xF1, 0xC3, 0x8F, 0x0E, 0x38, 0x38, 0xE1, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x47,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C,
  0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x70, 0x70, 0x01, 0xC1,
  0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xCC,
  0x60, 0x78, 0xC0, 0x07, 0x18, 0x00, 0xF1, 0x80, 0x0F, 0x18, 0x00, 0xF1,
  0x80, 0x0F, 0x18, 0x00, 0x7B, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x06, 0xF0, 0x00, 0xC7, 0x80, 0x0C, 0x78, 0x00, 0xC7, 0x80, 0x0C, 0x78,
  0x00, 0xC7, 0x80, 0x18, 0x70, 0x81, 0x8F, 0x0E, 0x19, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x07,
  0x00, 0xFE, 0x00, 0xE0, 0x3F, 0xC0, 0x38, 0x07, 0x3C, 0x07, 0x01, 0xC3,
  0x81, 0xC0, 0x38, 0x70, 0x78, 0x0E, 0x0E, 0x0E, 0x01, 0xC1, 0xC3, 0xC0,
  0x38, 0x78, 0x70, 0x0E, 0x0E, 0x1E, 0x01, 0xC1, 0xC3, 0x80, 0x38, 0x38,
  0xF0, 0x07, 0x07, 0x1C, 0x00, 0xE1, 0xE7, 0x80, 0x3C, 0x38, 0xE1, 0xC7,
  0x07, 0x38, 0xFE, 0xE1, 0xE7, 0x3F, 0xDE, 0x39, 0xC7, 0x3D, 0xCF, 0x39,
  0xC3, 0xBF, 0xCE, 0x38, 0x77, 0xF1, 0xCE, 0x0E, 0x7C, 0x71, 0xC1, 0xC0,
  0x0E, 0x38, 0x78, 0x03, 0x8E, 0x0E, 0x00, 0x71, 0xC1, 0xC0, 0x1C, 0x38,
  0x38, 0x03, 0x87, 0x07, 0x00, 0xE0, 0xE1, 0xE0, 0x3C, 0x3C, 0x38, 0x07,
  0x07, 0x07, 0x01, 0xE0, 0xE1, 0xE0, 0x38, 0x1C, 0x38, 0x0F, 0x03, 0xCF,
  0x01, 0xC0, 0x3F, 0xC0, 0x78, 0x07, 0xF0, 0x0E, 0x00, 0x7C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xF0,
  0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0xF1, 0xE7, 0x87, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xCF, 0x07, 0xBC, 0x78, 0x3D, 0xE7, 0x81, 0xEE, 0x3C, 0x07,
  0xF1, 0xE0, 0x3F, 0x0F, 0x01, 0xF8, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x1E,
  0x07, 0xF0, 0xF8, 0x7F, 0x87, 0xFF, 0xBC, 0x1F, 0xF9, 0xF0, 0x7F, 0x87,
  0x80, 0x40, 0x00, 0x00, 0x3E, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x3C, 0x70,
  0xE1, 0xC7, 0x8E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x06, 0x38, 0x1F,
  0x70, 0x7F, 0xFF, 0x9F, 0xFF, 0x07, 0xFE, 0x1F, 0x80, 0x7F, 0x01, 0xE7,
  0x07, 0xCE, 0x0F, 0x1E, 0x0C, 0x1E, 0x08, 0x30, 0x00, 0x40, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x37, 0xFF,
  0xFF, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFB, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0x70, 0x78, 0x0E,
  0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x79, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x7C, 0x0F, 0xE0, 0xFF, 0x0F, 0xF8, 0xFB, 0x8F, 0xBC, 0xF9, 0xE3,
  0x0F, 0x08, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xE0, 0x78, 0x02, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xE7, 0xE0, 0x18, 0x0F,
  0x80, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x04, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x10, 0x03, 0xE0, 0xE0,
  0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x1D,
  0xE0, 0x00, 0xEF, 0x00, 0x0E, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00,
  0x71, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x3C,
  0x01, 0xC1, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x70, 0x0F, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x10, 0x03, 0xE0,
  0xE0, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xE2,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC1,
  0x00, 0x3C, 0xFE, 0x03, 0xDF, 0xF0, 0x3B, 0xFF, 0x07, 0xF0, 0xF0, 0x7E,
  0x0F, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x7C, 0x7C,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3E, 0x3F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70,
  0x0F, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xCF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFB, 0xE0, 0x1F, 0x1E, 0x03, 0xE0, 0xF0,
  0x7C, 0x0F, 0x07, 0x80, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0xF8, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFB, 0xF0,
  0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0xFC, 0x7C, 0x3F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xBC, 0x0F, 0xE7, 0x80, 0xF1, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x81, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x01, 0x80, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x0E, 0x3E, 0x08, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x03, 0xF8, 0x70, 0xE0, 0x7F, 0x87,
  0x1C, 0x0F, 0x78, 0x71, 0xC1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0x73, 0x83,
  0x87, 0x06, 0x38, 0x70, 0x70, 0xE3, 0x87, 0x07, 0x0E, 0x70, 0x70, 0xE0,
  0xE7, 0x0E, 0x0E, 0x0E, 0x70, 0xE0, 0xE0, 0xC7, 0x0E, 0x1E, 0x1C, 0x70,
  0xE1, 0xC1, 0xCE, 0x1E, 0x1C, 0x18, 0xE1, 0xC3, 0xC3, 0x8E, 0x1C, 0x3C,
  0x30, 0xE1, 0xE6, 0xC7, 0x0E, 0x0F, 0xEE, 0xE0, 0xE0, 0xFC, 0xFC, 0x0E,
  0x07, 0x87, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x01, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F,
  0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00,
  0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xE0, 0xF8, 0x0F, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xF0,
  0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC3, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00,
  0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x07, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFD, 0xE0, 0x3F, 0x02,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7E,
  0x18, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1E, 0x1F, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x7C,
  0x0F, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x3C, 0x1F, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFE, 0xFE, 0x03, 0xF0, 0x0C, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x0F,
  0xF8, 0xF8, 0x0F, 0xF8, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF8, 0x03,
  0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x10, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x03,
  0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x80, 0x07,
  0x9F, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xBC, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xEF, 0x01, 0xDC, 0x00, 0xF7, 0x81, 0xEF, 0x00, 0x7F, 0x80,
  0xF7, 0x80, 0x7B, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3C, 0xF0,
  0x1C, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0x3C, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0x1E, 0x03, 0xCF, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0x8F,
  0x01, 0xE3, 0xC3, 0xC7, 0x80, 0xF1, 0xE1, 0xE3, 0xC0, 0x78, 0xF1, 0xE1,
  0xE0, 0x38, 0x78, 0xF0, 0xF0, 0x3C, 0x1C, 0x70, 0xF0, 0x1E, 0x0E, 0x78,
  0x78, 0x0F, 0x07, 0x38, 0x3C, 0x07, 0x83, 0xBC, 0x1E, 0x03, 0x81, 0xDC,
  0x1E, 0x03, 0xC0, 0xFE, 0x0F, 0x01, 0xE0, 0x7E, 0x07, 0x80, 0xF0, 0x3F,
  0x03, 0xC0, 0x78, 0x1F, 0x81, 0xE0, 0x38, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x3E,
  0x00, 0x3C, 0x07, 0xE0, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x1F, 0x80, 0x3C,
  0x07, 0xF0, 0x07, 0x80, 0xFE, 0x00, 0xE0, 0x1F, 0xC0, 0x3C, 0x03, 0xBC,
  0x07, 0x80, 0x77, 0x80, 0xF0, 0x1E, 0xF0, 0x1E, 0x03, 0xCE, 0x03, 0x80,
  0x79, 0xC0, 0xF0, 0x0F, 0x38, 0x1E, 0x01, 0xC7, 0x83, 0xC0, 0x78, 0xF0,
  0x78, 0x0F, 0x1E, 0x1E, 0x01, 0xE1, 0xC3, 0xC0, 0x3C, 0x38, 0x78, 0x0F,
  0x07, 0x0F, 0x01, 0xE0, 0xF1, 0xE0, 0x3C, 0x1E, 0x78, 0x07, 0x83, 0xCF,
  0x00, 0xE0, 0x39, 0xE0, 0x3C, 0x07, 0x3C, 0x07, 0x80, 0xE7, 0x00, 0xF0,
  0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0xF0, 0x07, 0xF0,
  0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x0E, 0x00,
  0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7E, 0xFE, 0x03, 0xE0, 0x78, 0x1F,
  0x01, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF7,
  0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x07,
  0xC0, 0x7C, 0x3E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xE0, 0x1E, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78,
  0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x03, 0xE0,
  0x78, 0x3E, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7E,
  0xFE, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00,
  0x7D, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E,
  0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1E, 0x1F, 0x81, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC1, 0xE0, 0x3C,
  0x0F, 0x03, 0xE0, 0x78, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3C,
  0x03, 0xE1, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE0, 0x30, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x30, 0x07, 0xC0, 0xF8, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xFC, 0x7E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07,
  0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0xDE, 0x00, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x00, 0x79, 0xE0, 0x0F, 0x80, 0x3C, 0x78, 0x03, 0xE0, 0x0F, 0x1E, 0x00,
  0xF8, 0x07, 0xC7, 0x80, 0x7E, 0x01, 0xE1, 0xE0, 0x1F, 0x80, 0x78, 0x78,
  0x0F, 0xE0, 0x3C, 0x1E, 0x03, 0xB8, 0x0F, 0x07, 0x80, 0xEE, 0x03, 0xC1,
  0xE0, 0x7B, 0x81, 0xE0, 0x78, 0x1C, 0xE0, 0x78, 0x1E, 0x0F, 0x38, 0x3C,
  0x07, 0x83, 0xDE, 0x0F, 0x01, 0xE0, 0xE7, 0x83, 0xC0, 0x78, 0x79, 0xE1,
  0xE0, 0x1E, 0x1C, 0x78, 0x78, 0x07, 0x87, 0x1E, 0x3C, 0x01, 0xE3, 0xC7,
  0x8F, 0x00, 0x78, 0xE1, 0xE3, 0xC0, 0x1E, 0x78, 0x79, 0xE0, 0x07, 0x9C,
  0x1E, 0x78, 0x01, 0xE7, 0x07, 0xBC, 0x00, 0x7B, 0xC1, 0xCF, 0x00, 0x1C,
  0xE0, 0x73, 0xC0, 0x07, 0x78, 0x1D, 0xE0, 0x01, 0xDE, 0x07, 0x78, 0x00,
  0x77, 0x01, 0xDC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0x38, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0x9E,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x7B, 0x80, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x3B, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0xF1, 0xF1, 0xE3, 0xC3, 0x83, 0x87, 0x00, 0xFC, 0x70, 0x1F,
  0xEF, 0x03, 0xFE, 0xF0, 0x7C, 0x6E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x1E,
  0x03, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F,
  0x0F, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x86, 0xE0, 0x7F, 0xFE, 0x03, 0xFD,
  0xE0, 0x3F, 0x9C, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0xF8,
  0x07, 0xBF, 0xC0, 0x7B, 0xFE, 0x07, 0xF1, 0xE0, 0x7C, 0x1F, 0x0F, 0xC0,
  0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x87,
  0xC0, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7E, 0x1E, 0x0F, 0x7F, 0xE0,
  0xF7, 0xFC, 0x0E, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xC2, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x30, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3F,
  0x3C, 0x03, 0xFE, 0xF0, 0x0F, 0xFB, 0x80, 0x7C, 0x7E, 0x03, 0xE0, 0xF8,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xE0,
  0xF8, 0x07, 0x87, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xDE, 0x00, 0xFE, 0x70,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xF8,
  0xF0, 0xF0, 0x78, 0xF8, 0x1C, 0x78, 0x0E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E,
  0x07, 0x9E, 0x07, 0xCF, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xFE, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x10, 0x7F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFC, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x20, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x2F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x1C, 0x01, 0xFE, 0xF0, 0x0F, 0xFB,
  0xC0, 0x7C, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x81,
  0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78,
  0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x07, 0xC0, 0xF0, 0x3F, 0x03, 0xE0, 0xF8, 0x07, 0x87, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xDE, 0x00, 0xFE, 0x70, 0x00, 0x43, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x08, 0x07, 0xC0, 0x3E, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xCF, 0xC0, 0x7B, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFC, 0xF8, 0x3E, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x00,
  0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x07, 0x83, 0xC0,
  0x78, 0x78, 0x07, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0,
  0x0F, 0x78, 0x00, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC3,
  0xC0, 0x38, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78,
  0x3C, 0x07, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x9F, 0x83, 0xF0, 0x3D, 0xFE,
  0x7F, 0x81, 0xDF, 0xFF, 0xFE, 0x0E, 0xC7, 0xF9, 0xF0, 0x7C, 0x1F, 0x07,
  0x83, 0xC0, 0xF8, 0x3C, 0x3E, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F,
  0x01, 0xC0, 0x78, 0x78, 0x1E, 0x03, 0xC7, 0x80, 0xF0, 0x1C, 0x3C, 0x07,
  0x81, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0x78, 0x78, 0x1E, 0x03,
  0xC7, 0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F,
  0x03, 0xC0, 0x78, 0x70, 0x1E, 0x03, 0xC7, 0x80, 0xF0, 0x3C, 0x3C, 0x07,
  0x81, 0xE1, 0xE0, 0x38, 0x0F, 0x0F, 0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x03,
  0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x07, 0x81, 0xE0, 0x03, 0x9F, 0x80, 0xF7,
  0xF8, 0x1D, 0xFF, 0x83, 0xB9, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC3, 0xE0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0x1E, 0x0F, 0x03,
  0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x79, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E,
  0x3C, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x08, 0x00, 0x00, 0xE3, 0xE0, 0x07, 0x9F, 0xC0, 0x1E, 0xFF,
  0x80, 0x7F, 0x1E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xC0,
  0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x38, 0x03, 0xC1, 0xE0,
  0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x70, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x1F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xE3, 0xE0, 0x1D, 0xFF,
  0x80, 0xF7, 0xFC, 0x03, 0xCF, 0xC0, 0x0F, 0x08, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x70, 0x1F, 0xEF, 0x03, 0xFE, 0xF0,
  0x7C, 0x7E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF8,
  0x3E, 0x07, 0x87, 0xE0, 0x7F, 0xFE, 0x07, 0xFD, 0xE0, 0x3F, 0x9C, 0x00,
  0x43, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x9F, 0x07, 0xBF, 0x07, 0x7E,
  0x07, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x60, 0xF0, 0x10, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE2, 0x01,
  0xE1, 0xC1, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x0F, 0xF3, 0xFF,
  0x3F, 0xF3, 0xFF, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x07, 0xF0,
  0x7F, 0x00, 0x80, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F,
  0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C,
  0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x1F, 0x87, 0xC7, 0xF0,
  0x7F, 0xDC, 0x0F, 0xF3, 0x80, 0xFC, 0x70, 0x02, 0x00, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xF7, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xC0, 0x7B, 0xC0,
  0xF8, 0x0F, 0x78, 0x1F, 0x03, 0xCF, 0x07, 0xE0, 0x79, 0xE0, 0xFC, 0x0E,
  0x3C, 0x1F, 0x83, 0xC7, 0x87, 0x70, 0x78, 0xF0, 0xEE, 0x1E, 0x1E, 0x1D,
  0xC3, 0xC3, 0xC7, 0x38, 0x70, 0x78, 0xE7, 0x1E, 0x0F, 0x3C, 0xE3, 0xC1,
  0xE7, 0x1C, 0x70, 0x38, 0xE3, 0x9E, 0x07, 0x38, 0x73, 0x80, 0xE7, 0x0E,
  0xF0, 0x1D, 0xE1, 0xDE, 0x03, 0xB8, 0x3B, 0x80, 0x77, 0x07, 0xF0, 0x0F,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xC0, 0xFC,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x1C,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x01,
  0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xC0, 0x0F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x73, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x2F, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFD, 0x00, 0x7F, 0x20, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 36, 12, 0, -36 },
  { 60, 14, 13, 17, 5, -36 },
  { 83, 22, 36, 21, 0, -36 },
  { 182, 20, 41, 20, 0, -38 },
  { 285, 27, 37, 30, 2, -36 },
  { 410, 21, 37, 21, 0, -36 },
  { 508, 7, 13, 9, 5, -36 },
  { 520, 15, 44, 13, 1, -36 },
  { 603, 15, 44, 13, -4, -36 },
  { 686, 15, 17, 18, 5, -38 },
  { 718, 18, 23, 22, 2, -29 },
  { 770, 9, 13, 10, -2, -6 },
  { 785, 11, 3, 13, 1, -15 },
  { 790, 5, 6, 10, 1, -6 },
  { 794, 22, 36, 17, -2, -36 },
  { 893, 19, 37, 20, 1, -36 },
  { 981, 13, 36, 20, 5, -36 },
  { 1040, 22, 36, 20, -2, -36 },
  { 1139, 21, 37, 20, -1, -36 },
  { 1237, 21, 36, 20, -1, -36 },
  { 1332, 21, 37, 20, -1, -36 },
  { 1430, 20, 37, 20, 1, -36 },
  { 1523, 20, 36, 20, 2, -36 },
  { 1613, 20, 37, 20, 0, -36 },
  { 1706, 19, 37, 20, 0, -36 },
  { 1794, 10, 27, 10, 0, -27 },
  { 1828, 13, 34, 10, -3, -27 },
  { 1884, 19, 22, 22, 2, -29 },
  { 1937, 18, 14, 22, 2, -25 },
  { 1969, 19, 22, 22, 2, -29 },
  { 2022, 16, 36, 14, 1, -36 },
  { 2094, 28, 40, 29, 1, -36 },
  { 2234, 20, 36, 20, -3, -36 },
  { 2324, 22, 36, 22, 0, -36 },
  { 2423, 21, 37, 19, 2, -36 },
  { 2521, 23, 36, 23, 0, -36 },
  { 2625, 21, 36, 18, 0, -36 },
  { 2720, 21, 36, 17, 0, -36 },
  { 2815, 24, 37, 25, 2, -36 },
  { 2926, 25, 36, 24, 0, -36 },
  { 3039, 20, 36, 13, -3, -36 },
  { 3129, 19, 46, 10, -7, -36 },
  { 3239, 24, 36, 20, 0, -36 },
  { 3347, 14, 36, 17, 0, -36 },
  { 3410, 33, 36, 32, 0, -36 },
  { 3559, 27, 36, 26, 0, -36 },
  { 3681, 22, 37, 25, 2, -36 },
  { 3783, 21, 36, 20, 0, -36 },
  { 3878, 22, 45, 25, 2, -36 },
  { 4002, 21, 36, 21, 0, -36 },
  { 4097, 22, 37, 19, -1, -36 },
  { 4199, 18, 36, 17, 3, -36 },
  { 4280, 23, 37, 24, 2, -36 },
  { 4387, 20, 36, 20, 4, -36 },
  { 4477, 34, 36, 33, 3, -36 },
  { 4630, 25, 36, 19, -3, -36 },
  { 4743, 18, 36, 18, 4, -36 },
  { 4824, 22, 36, 17, -2, -36 },
  { 4923, 19, 44, 14, -1, -36 },
  { 5028, 8, 36, 17, 5, -36 },
  { 5064, 19, 44, 14, -3, -36 },
  { 5169, 19, 19, 20, 1, -36 },
  { 5215, 15, 3, 15, -4, 4 },
  { 5221, 7, 8, 12, 7, -38 },
  { 5228, 20, 28, 21, 1, -27 },
  { 5298, 20, 39, 21, 0, -38 },
  { 5396, 16, 28, 16, 1, -27 },
  { 5452, 22, 39, 21, 1, -38 },
  { 5560, 17, 28, 19, 1, -27 },
  { 5620, 23, 50, 12, -6, -38 },
  { 5764, 22, 39, 21, -1, -27 },
  { 5872, 19, 38, 21, 0, -38 },
  { 5963, 12, 37, 10, 0, -37 },
  { 6019, 18, 49, 10, -6, -37 },
  { 6130, 20, 38, 18, 0, -38 },
  { 6225, 12, 38, 10, 0, -38 },
  { 6282, 29, 27, 31, 0, -27 },
  { 6380, 19, 27, 21, 0, -27 },
  { 6445, 18, 28, 20, 1, -27 },
  { 6508, 22, 39, 21, -2, -27 },
  { 6616, 20, 39, 21, 1, -27 },
  { 6714, 16, 27, 14, 0, -27 },
  { 6768, 17, 28, 16, -1, -27 },
  { 6828, 12, 34, 12, 1, -33 },
  { 6879, 19, 28, 21, 1, -27 },
  { 6946, 16, 27, 17, 3, -27 },
  { 7000, 27, 27, 27, 3, -27 },
  { 7092, 21, 27, 17, -2, -27 },
  { 7163, 25, 39, 17, -5, -27 },
  { 7285, 18, 27, 14, -2, -27 },
  { 7346, 19, 44, 16, 1, -36 },
  { 7451, 4, 50, 18, 7, -38 },
  { 7476, 18, 44, 16, -3, -36 },
  { 7575, 19, 7, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Italic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC50PT7B_H_
