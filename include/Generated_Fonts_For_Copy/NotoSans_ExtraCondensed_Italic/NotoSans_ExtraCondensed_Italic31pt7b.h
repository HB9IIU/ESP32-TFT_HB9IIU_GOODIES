#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x00, 0x00, 0x20, 0x70, 0xE0, 0xE0, 0x73,
  0xB9, 0x98, 0xCC, 0xE6, 0x67, 0x33, 0x19, 0x8C, 0x01, 0x9C, 0x04, 0x60,
  0x31, 0x80, 0xC4, 0x02, 0x30, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x0C, 0x60,
  0x31, 0x80, 0xCC, 0x06, 0x30, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x0C, 0x60,
  0x33, 0x00, 0x8C, 0x06, 0x30, 0x18, 0x80, 0x46, 0x03, 0x18, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x07, 0xC0, 0xFF, 0x8E, 0xD8, 0x64, 0x03, 0x20,
  0x19, 0x00, 0xC8, 0x07, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1F, 0x00,
  0x98, 0x04, 0xC0, 0x26, 0x01, 0x31, 0x1B, 0x8F, 0xF8, 0x7F, 0x80, 0x20,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0F, 0x06, 0x0D, 0x83, 0x0C, 0xC3,
  0x06, 0x63, 0x06, 0x31, 0x83, 0x19, 0x81, 0x8C, 0xC0, 0xC6, 0xC0, 0x46,
  0x62, 0x63, 0x67, 0xB1, 0xB6, 0xED, 0xB3, 0x37, 0x9B, 0x18, 0x19, 0x8C,
  0x0C, 0xC6, 0x0C, 0xC6, 0x06, 0x63, 0x06, 0x31, 0x83, 0x18, 0xC3, 0x0C,
  0xC1, 0x87, 0xE1, 0x81, 0xE0, 0x03, 0xE0, 0x3F, 0x03, 0x98, 0x18, 0xC0,
  0xC6, 0x06, 0x30, 0x33, 0x01, 0xB8, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x3E,
  0x03, 0x73, 0xB9, 0x99, 0x8F, 0xDC, 0x7C, 0xC1, 0xE6, 0x0E, 0x30, 0x71,
  0xC7, 0x8F, 0xEE, 0x3E, 0x70, 0x77, 0x66, 0x66, 0xCC, 0x03, 0x83, 0x81,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x00, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x00, 0x0E,
  0x06, 0x03, 0x1D, 0x8F, 0xF8, 0xFC, 0x70, 0x6C, 0xE6, 0x33, 0x80, 0x80,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0x9C, 0xC6,
  0x63, 0x00, 0x7E, 0xFF, 0xF8, 0x27, 0xFE, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xC1, 0xFC, 0x73, 0x8C, 0x33, 0x86, 0x60, 0xDC, 0x1B, 0x87,
  0x60, 0xEC, 0x1F, 0x83, 0xF0, 0x6E, 0x0D, 0x83, 0xB0, 0x76, 0x0C, 0xC3,
  0x98, 0x63, 0x1C, 0x73, 0x0F, 0xE0, 0xF8, 0x00, 0x07, 0x0F, 0x1E, 0x3E,
  0xE6, 0x4E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38,
  0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x03, 0xF0, 0x7F, 0xC1, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xF0, 0x7F, 0xC1, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x3F, 0x01, 0xC0,
  0x1F, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x31, 0x07, 0x8F, 0xF8, 0x3F, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x01,
  0xF0, 0x0B, 0x00, 0xD8, 0x0C, 0xC0, 0x6E, 0x06, 0x60, 0x63, 0x03, 0x18,
  0x31, 0xC1, 0x8E, 0x18, 0x61, 0x83, 0x0F, 0xFE, 0x7F, 0xF4, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x07, 0xF0, 0xFF, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3E, 0x03, 0xF8, 0x3F, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC8, 0x38,
  0xFF, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x67, 0x86, 0xF8, 0xF9, 0xCF, 0x1C, 0xE0, 0xCE, 0x0C,
  0xC1, 0xCC, 0x1C, 0xC1, 0xCC, 0x18, 0xC3, 0x8E, 0x70, 0x7F, 0x07, 0xE0,
  0x3F, 0xF3, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xE0, 0x7F,
  0x87, 0x0C, 0x30, 0x71, 0x83, 0x0C, 0x18, 0x61, 0xC3, 0x8C, 0x0C, 0xE0,
  0x7C, 0x03, 0xC0, 0x3F, 0x03, 0x9C, 0x38, 0xE3, 0x83, 0x18, 0x18, 0xC0,
  0xC6, 0x06, 0x30, 0x31, 0xC3, 0x87, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFE,
  0x1C, 0x71, 0x87, 0x38, 0x33, 0x83, 0x30, 0x33, 0x07, 0x30, 0x73, 0x07,
  0x30, 0xE3, 0x9E, 0x3F, 0x60, 0xEE, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0xFE, 0x0F, 0xC0, 0x08, 0x71, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x8E, 0x38, 0xE0, 0x03, 0x07, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x38,
  0x30, 0x30, 0x60, 0xE0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x87,
  0xF1, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x01, 0xC0, 0xF0,
  0x18, 0x00, 0x00, 0xFC, 0x01, 0xE7, 0x01, 0x80, 0xC1, 0x80, 0x61, 0x80,
  0x18, 0xC0, 0x0C, 0xC3, 0xE6, 0x63, 0x33, 0x63, 0x31, 0xB1, 0x18, 0xD9,
  0x8C, 0x58, 0xC6, 0x6C, 0x46, 0x36, 0x63, 0x1B, 0x31, 0x99, 0x99, 0xCC,
  0xCE, 0xEC, 0x63, 0x9C, 0x30, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC1, 0x00, 0x7F, 0x80, 0x06, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xD8, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x39,
  0x81, 0x8C, 0x1C, 0x60, 0xE3, 0x07, 0xF8, 0x7F, 0xC3, 0x06, 0x38, 0x31,
  0xC1, 0x9C, 0x0C, 0xE0, 0x76, 0x03, 0xF0, 0x1C, 0x07, 0xF0, 0x3F, 0xE0,
  0xE3, 0x83, 0x07, 0x0C, 0x1C, 0x70, 0x61, 0xC1, 0x87, 0x0E, 0x18, 0x70,
  0x7F, 0x83, 0xF8, 0x0E, 0x78, 0x38, 0x60, 0xC1, 0xC3, 0x07, 0x1C, 0x1C,
  0x70, 0x71, 0x81, 0x86, 0x0E, 0x18, 0x70, 0xFF, 0x83, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0xC3, 0x84, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE1, 0x07, 0xF8, 0x1F, 0xC0, 0x07,
  0xE0, 0x3F, 0xC0, 0xE3, 0x83, 0x07, 0x0C, 0x1C, 0x70, 0x71, 0xC1, 0xC7,
  0x07, 0x18, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x06, 0x38, 0x18, 0xC0, 0xE3,
  0x03, 0x9C, 0x1C, 0x70, 0x71, 0x83, 0x86, 0x1C, 0x18, 0xF0, 0xFF, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC1, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x83, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0F, 0xF0, 0x7F, 0x83, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3C, 0x10, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x83, 0xE7, 0x07,
  0xCE, 0x1F, 0x9C, 0x06, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xE1,
  0x81, 0x83, 0x83, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x06, 0x07, 0x0E, 0x06,
  0x0E, 0x06, 0x0C, 0x0E, 0x0C, 0x0E, 0x1C, 0x0C, 0x1C, 0x0C, 0x1C, 0x0C,
  0x18, 0x1C, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x38, 0x30, 0x38,
  0x30, 0x38, 0x70, 0x30, 0x70, 0x30, 0x60, 0x70, 0x60, 0x70, 0x60, 0x60,
  0xE0, 0x60, 0xE0, 0xE0, 0x07, 0xF0, 0x3E, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x7E, 0x0F,
  0xF0, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x05, 0xC0, 0x7C, 0x0F, 0x80, 0x06, 0x0E, 0x1C, 0x38, 0x38,
  0x60, 0x61, 0xC0, 0xC7, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x1B, 0x80,
  0x36, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x06, 0x70, 0x0C, 0xE0, 0x38,
  0xC0, 0x71, 0x80, 0xC3, 0x81, 0x87, 0x03, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x00, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xFF, 0xFF, 0x07,
  0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F,
  0x0F, 0x81, 0xF8, 0x7C, 0x0D, 0x83, 0x60, 0x6C, 0x1B, 0x06, 0xE0, 0xD8,
  0x37, 0x0E, 0xE3, 0xB0, 0x77, 0x19, 0x83, 0x39, 0xCC, 0x19, 0xCC, 0xE0,
  0xC6, 0xE7, 0x0E, 0x36, 0x30, 0x71, 0xB1, 0x83, 0x0F, 0x0C, 0x18, 0x78,
  0xE0, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xE1, 0x80, 0x07, 0x03, 0x87,
  0x81, 0x83, 0xC0, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0xFC, 0x30, 0x76, 0x18,
  0x33, 0x0C, 0x19, 0x8E, 0x0C, 0xC7, 0x0E, 0x63, 0x07, 0x39, 0x83, 0x1C,
  0xC1, 0x86, 0xE0, 0xC3, 0x70, 0xE1, 0xB0, 0x70, 0xD8, 0x30, 0x7C, 0x18,
  0x3E, 0x0C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x03, 0xF0, 0x1F, 0xE0,
  0xE1, 0x87, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0x01, 0xDC, 0x07, 0x70, 0x1D,
  0x80, 0x76, 0x01, 0xB8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x0C,
  0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x1C, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x7F, 0x83, 0x9E, 0x18, 0x70, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87,
  0x18, 0x30, 0xC3, 0x8E, 0x38, 0x7F, 0xC3, 0xF8, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0xE1, 0x87, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0x01, 0xDC,
  0x07, 0x70, 0x1D, 0x80, 0x76, 0x01, 0xB8, 0x06, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0xB8, 0x0C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x1C, 0x70, 0x7F, 0x80,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07,
  0xE0, 0x7F, 0x83, 0x9E, 0x18, 0x70, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87,
  0x18, 0x30, 0xC3, 0x8E, 0x78, 0x7F, 0x83, 0xF8, 0x19, 0xC0, 0xCE, 0x0E,
  0x30, 0x71, 0x83, 0x0E, 0x18, 0x70, 0xC3, 0x8E, 0x0C, 0x70, 0x70, 0x03,
  0xFC, 0x1F, 0xE0, 0xE0, 0x83, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x10, 0xF0, 0xFF, 0x81,
  0xFC, 0x00, 0x7F, 0xEF, 0xFE, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x0C, 0x70,
  0x31, 0x81, 0xC6, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x81, 0x8C, 0x0E, 0x30,
  0x38, 0xC0, 0xC7, 0x03, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0xCE, 0x06, 0x38,
  0x18, 0xE0, 0xE3, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0x7F, 0x80, 0xFC, 0x00,
  0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x0E, 0xC1, 0xCC, 0x1C, 0xC1, 0x8C, 0x38,
  0xC3, 0x0C, 0x70, 0xC7, 0x0C, 0x60, 0xCE, 0x0C, 0xC0, 0xDC, 0x0D, 0x80,
  0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x70, 0x3B,
  0x03, 0x81, 0x98, 0x1C, 0x1C, 0xC1, 0xE0, 0xC6, 0x0F, 0x0E, 0x30, 0xD8,
  0x61, 0x86, 0xC3, 0x0C, 0x36, 0x38, 0xE3, 0x71, 0x87, 0x1B, 0x9C, 0x39,
  0xD8, 0xC1, 0xCC, 0xC6, 0x0E, 0x66, 0x70, 0x76, 0x33, 0x03, 0xB1, 0xB8,
  0x1F, 0x8D, 0xC0, 0xF8, 0x6C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x70, 0x38, 0x00, 0x07, 0x07, 0x03, 0x0E, 0x03,
  0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0xB8, 0x03, 0xB0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x70,
  0xE0, 0xE0, 0x60, 0x60, 0x76, 0x0E, 0x60, 0xC6, 0x1C, 0x71, 0x87, 0x38,
  0x73, 0x07, 0x70, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x03, 0xF0, 0x3E, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0F, 0xC0, 0xFC, 0x00, 0xC7, 0x38, 0xC6, 0x31, 0x8C, 0x63, 0x9C,
  0x63, 0x18, 0xC6, 0x31, 0xCE, 0x31, 0x8C, 0x03, 0xF0, 0x7E, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0x80, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xC0, 0xCE, 0x1C, 0x61, 0x86,
  0x38, 0x63, 0x07, 0x60, 0x3E, 0x03, 0xFF, 0xC0, 0xCE, 0xE6, 0x30, 0x07,
  0x31, 0xFB, 0x1C, 0xF3, 0x8E, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE0,
  0xCE, 0x0C, 0xC1, 0xCC, 0x1C, 0xC1, 0x8C, 0x38, 0xE7, 0x8F, 0xD8, 0x79,
  0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xDE, 0x1F, 0xF1, 0xE7, 0x1C, 0x31, 0x83, 0x38, 0x33, 0x83, 0x30, 0x33,
  0x07, 0x30, 0x77, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xCF, 0x1C, 0xDF, 0x8C,
  0xF0, 0x07, 0xC7, 0xE1, 0xC8, 0xE0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x23, 0xF8, 0x7E, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0xE6,
  0x1F, 0xF1, 0xE7, 0x8E, 0x38, 0xE1, 0xC7, 0x0E, 0x30, 0x73, 0x83, 0x9C,
  0x18, 0xE0, 0xC6, 0x0E, 0x30, 0x71, 0x83, 0x0C, 0x38, 0x73, 0xC3, 0xF6,
  0x0F, 0x30, 0x07, 0x87, 0xF1, 0x8C, 0xC3, 0x70, 0xD8, 0x36, 0x1F, 0x9E,
  0xFE, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x11, 0xFC, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xD0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xCC, 0x1F, 0xB0, 0x73, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x8E,
  0x0E, 0x38, 0x30, 0xE0, 0xC3, 0x07, 0x0C, 0x1C, 0x30, 0x60, 0xC3, 0x83,
  0x9E, 0x0F, 0xF8, 0x1E, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC2,
  0x0E, 0x0F, 0xF0, 0x3F, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xDE, 0x1F, 0xF1, 0xE7, 0x1C, 0x71, 0x87, 0x38,
  0x73, 0x86, 0x30, 0x63, 0x06, 0x30, 0xE7, 0x0E, 0x70, 0xC6, 0x0C, 0x60,
  0xC6, 0x1C, 0xE1, 0xCE, 0x18, 0x06, 0x1C, 0x38, 0x20, 0x00, 0x07, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x1C,
  0x30, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x0F, 0x81, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x87, 0x1C, 0x70, 0xC7,
  0x06, 0x30, 0x33, 0x83, 0xB8, 0x1F, 0x80, 0xDC, 0x07, 0xE0, 0x3B, 0x03,
  0x98, 0x1C, 0xC0, 0xC7, 0x06, 0x38, 0x31, 0xC3, 0x86, 0x1C, 0x30, 0x06,
  0x0C, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C,
  0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0x19, 0xE3, 0x86, 0xFB,
  0xF1, 0xE7, 0xDC, 0x71, 0xC3, 0x18, 0x70, 0xCE, 0x1C, 0x73, 0x86, 0x1C,
  0xC1, 0x86, 0x30, 0xE1, 0x8C, 0x38, 0x67, 0x0C, 0x39, 0xC3, 0x0E, 0x60,
  0xC3, 0x18, 0x70, 0xCE, 0x1C, 0x33, 0x86, 0x1C, 0xE1, 0x87, 0x00, 0x19,
  0xE1, 0xBF, 0x1E, 0x71, 0xC7, 0x18, 0x73, 0x87, 0x38, 0x63, 0x06, 0x30,
  0x63, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1,
  0x80, 0x07, 0x83, 0xF8, 0x63, 0x18, 0x77, 0x0E, 0xC1, 0xD8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1B, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x38, 0xC7, 0xF8, 0x7C,
  0x00, 0x0E, 0xF0, 0x6F, 0xC3, 0xCE, 0x1C, 0x30, 0xE1, 0x8E, 0x0C, 0x70,
  0x63, 0x03, 0x18, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x87, 0x1C, 0x30,
  0xE3, 0x8F, 0xF8, 0x77, 0x83, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x07, 0x31, 0xFB, 0x1C, 0xF3, 0x8E, 0x70, 0xE7,
  0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xCE, 0x0C, 0xC1, 0xCC, 0x1C, 0xC1, 0x8C,
  0x38, 0xE7, 0x8F, 0xF8, 0x7B, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x19, 0xC6, 0xF1, 0xF8, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x00, 0x0F, 0x87, 0xF3, 0x88, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC8, 0x73, 0xF8, 0xFC, 0x00,
  0x0C, 0x30, 0x61, 0xF7, 0xE7, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C,
  0x38, 0x60, 0xC1, 0x83, 0xC7, 0x80, 0x38, 0x73, 0x86, 0x30, 0x63, 0x06,
  0x30, 0xE7, 0x0E, 0x70, 0xC6, 0x0C, 0x60, 0xCE, 0x1C, 0xE1, 0xCE, 0x18,
  0xC3, 0x8C, 0x38, 0xC7, 0x8F, 0xF0, 0x7B, 0x00, 0xC1, 0xF0, 0x7C, 0x1B,
  0x0E, 0xC3, 0x31, 0xCC, 0x63, 0x38, 0xCC, 0x33, 0x0D, 0xC3, 0x60, 0xF8,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x00, 0xC1, 0x83, 0xC3, 0x87, 0xC3, 0x86,
  0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8C, 0xCD, 0x8C, 0xCD, 0x98, 0xCD, 0x98,
  0xD9, 0xB8, 0xD9, 0xB0, 0xF9, 0xB0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0,
  0xE1, 0xC0, 0xE1, 0xC0, 0x1C, 0x38, 0x61, 0x83, 0x1C, 0x19, 0xC0, 0xEC,
  0x07, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x36, 0x03,
  0xB8, 0x19, 0xC1, 0xC6, 0x1C, 0x30, 0xC1, 0xC0, 0x06, 0x06, 0x0C, 0x1C,
  0x18, 0x30, 0x30, 0xE0, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x70, 0x0C, 0xC0, 0x1B, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x3E, 0x00, 0x78, 0x00, 0x0F, 0xE3, 0xF8, 0x03, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x0F, 0x81, 0xC0,
  0x3C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xF8, 0x07, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0xF0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x38, 0x1F, 0x03, 0x80, 0x00, 0x38, 0x1F, 0xE3, 0xCF, 0xF8, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 22, 7, 0, -22 },
  { 23, 9, 8, 10, 3, -22 },
  { 32, 14, 22, 13, 0, -22 },
  { 71, 13, 26, 12, 0, -24 },
  { 114, 17, 22, 19, 1, -22 },
  { 161, 13, 22, 13, 0, -22 },
  { 197, 4, 8, 6, 3, -22 },
  { 201, 9, 27, 8, 1, -22 },
  { 232, 9, 27, 8, -2, -22 },
  { 263, 9, 11, 11, 3, -24 },
  { 276, 12, 14, 13, 1, -18 },
  { 297, 5, 7, 6, -1, -3 },
  { 302, 7, 3, 8, 0, -10 },
  { 305, 4, 4, 6, 0, -4 },
  { 307, 15, 22, 10, -2, -22 },
  { 349, 11, 22, 12, 1, -22 },
  { 380, 8, 22, 12, 3, -22 },
  { 402, 13, 22, 12, -1, -22 },
  { 438, 13, 22, 12, -1, -22 },
  { 474, 13, 22, 12, -1, -22 },
  { 510, 12, 22, 12, 0, -22 },
  { 543, 12, 22, 12, 1, -22 },
  { 576, 12, 22, 12, 1, -22 },
  { 609, 13, 22, 12, 0, -22 },
  { 645, 12, 22, 12, 0, -22 },
  { 678, 6, 17, 6, 0, -17 },
  { 691, 8, 21, 6, -2, -17 },
  { 712, 12, 14, 13, 1, -18 },
  { 733, 12, 8, 13, 1, -15 },
  { 745, 12, 14, 13, 1, -18 },
  { 766, 10, 22, 9, 0, -22 },
  { 794, 17, 25, 18, 1, -22 },
  { 848, 13, 22, 13, -2, -22 },
  { 884, 14, 22, 13, 0, -22 },
  { 923, 13, 22, 12, 1, -22 },
  { 959, 14, 22, 14, 0, -22 },
  { 998, 13, 22, 11, 0, -22 },
  { 1034, 13, 22, 11, 0, -22 },
  { 1070, 15, 22, 15, 1, -22 },
  { 1112, 16, 22, 15, 0, -22 },
  { 1156, 12, 22, 8, -2, -22 },
  { 1189, 12, 28, 6, -5, -22 },
  { 1231, 15, 22, 13, 0, -22 },
  { 1273, 8, 22, 10, 0, -22 },
  { 1295, 21, 22, 20, 0, -22 },
  { 1353, 17, 22, 16, 0, -22 },
  { 1400, 14, 22, 15, 1, -22 },
  { 1439, 13, 22, 13, 0, -22 },
  { 1475, 14, 27, 15, 1, -22 },
  { 1523, 13, 22, 13, 0, -22 },
  { 1559, 14, 22, 12, -1, -22 },
  { 1598, 11, 22, 11, 2, -22 },
  { 1629, 14, 22, 15, 1, -22 },
  { 1668, 12, 22, 13, 3, -22 },
  { 1701, 21, 22, 20, 2, -22 },
  { 1759, 16, 22, 12, -2, -22 },
  { 1803, 12, 22, 11, 2, -22 },
  { 1836, 13, 22, 10, -1, -22 },
  { 1872, 12, 27, 9, -1, -22 },
  { 1913, 5, 22, 11, 3, -22 },
  { 1927, 12, 27, 9, -2, -22 },
  { 1968, 12, 12, 12, 0, -22 },
  { 1986, 10, 1, 9, -3, 3 },
  { 1988, 4, 5, 8, 5, -24 },
  { 1991, 12, 17, 13, 1, -17 },
  { 2017, 12, 24, 13, 0, -24 },
  { 2053, 10, 17, 10, 1, -17 },
  { 2075, 13, 24, 13, 1, -24 },
  { 2114, 10, 17, 12, 1, -17 },
  { 2136, 15, 31, 7, -4, -24 },
  { 2195, 14, 24, 13, -1, -17 },
  { 2237, 12, 24, 13, 0, -24 },
  { 2273, 7, 23, 6, 0, -23 },
  { 2294, 11, 30, 6, -4, -23 },
  { 2336, 13, 24, 11, 0, -24 },
  { 2375, 7, 24, 6, 0, -24 },
  { 2396, 18, 17, 19, 0, -17 },
  { 2435, 12, 17, 13, 0, -17 },
  { 2461, 11, 17, 13, 1, -17 },
  { 2485, 13, 24, 13, -1, -17 },
  { 2524, 12, 24, 13, 1, -17 },
  { 2560, 10, 17, 9, 0, -17 },
  { 2582, 10, 17, 10, 0, -17 },
  { 2604, 7, 20, 7, 1, -20 },
  { 2622, 12, 17, 13, 1, -17 },
  { 2648, 10, 17, 10, 2, -17 },
  { 2670, 16, 17, 17, 2, -17 },
  { 2704, 13, 17, 11, -1, -17 },
  { 2732, 15, 24, 11, -3, -17 },
  { 2777, 11, 17, 9, -1, -17 },
  { 2801, 11, 27, 10, 1, -22 },
  { 2839, 2, 31, 11, 5, -24 },
  { 2847, 11, 27, 10, -2, -22 },
  { 2885, 12, 4, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Italic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC31PT7B_H_
