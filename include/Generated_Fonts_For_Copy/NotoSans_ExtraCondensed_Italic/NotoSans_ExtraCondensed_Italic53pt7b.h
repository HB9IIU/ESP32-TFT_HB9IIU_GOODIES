#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xC3, 0x83, 0x8F, 0x0F, 0x1C, 0x1C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x78, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0xE1, 0xE0, 0x01, 0xC1,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x83,
  0x80, 0x03, 0x83, 0x80, 0x07, 0x87, 0x00, 0x07, 0x07, 0x00, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0E, 0x0E, 0x00, 0x1E, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xE6, 0x30, 0x1E, 0x30, 0x00, 0x78,
  0xC0, 0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x3C, 0x70, 0x00, 0x71, 0x80,
  0x01, 0xE6, 0x00, 0x07, 0xD8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1B,
  0xE0, 0x00, 0x67, 0x80, 0x01, 0x9E, 0x00, 0x06, 0x3C, 0x00, 0x18, 0xF0,
  0x00, 0xC3, 0xC0, 0x03, 0x0F, 0x00, 0x0C, 0x38, 0x00, 0x31, 0xE0, 0xC1,
  0xCF, 0x83, 0xE6, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x81, 0xFE, 0x00,
  0xE0, 0x3F, 0xC0, 0x3C, 0x0E, 0x38, 0x07, 0x03, 0xC7, 0x81, 0xE0, 0x70,
  0xF0, 0x38, 0x0E, 0x1E, 0x0F, 0x03, 0xC3, 0xC1, 0xC0, 0x70, 0x70, 0x78,
  0x0E, 0x0E, 0x0E, 0x03, 0xC1, 0xC3, 0xC0, 0x78, 0x38, 0x70, 0x0E, 0x0F,
  0x1E, 0x01, 0xC1, 0xE3, 0x80, 0x38, 0x38, 0xF0, 0x07, 0x07, 0x1C, 0x3E,
  0xE1, 0xE7, 0x1F, 0xDC, 0x38, 0xE3, 0xFF, 0x8F, 0x38, 0xE3, 0xF1, 0xC7,
  0x3C, 0x7F, 0xF9, 0xC7, 0x0F, 0xFE, 0x79, 0xE1, 0xDF, 0x8E, 0x38, 0x38,
  0x03, 0xC7, 0x07, 0x00, 0x71, 0xE0, 0xE0, 0x1E, 0x38, 0x1C, 0x03, 0x87,
  0x07, 0x80, 0xF0, 0xE0, 0xF0, 0x1C, 0x1C, 0x1C, 0x07, 0x87, 0x83, 0x80,
  0xE0, 0xF0, 0xF0, 0x3C, 0x1E, 0x1C, 0x07, 0x03, 0xC3, 0x81, 0xE0, 0x78,
  0xF0, 0x38, 0x0F, 0x1C, 0x0F, 0x00, 0xFF, 0x01, 0xC0, 0x1F, 0xE0, 0x78,
  0x01, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x3C,
  0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x3C, 0x7D, 0xF0, 0xF3, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x78, 0x3C, 0x79, 0xE0, 0x7B, 0xCF, 0x81, 0xEF, 0x3C, 0x07, 0xF8, 0xF0,
  0x1F, 0xE3, 0xC0, 0x3F, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x1F,
  0x83, 0xE0, 0xFF, 0x0F, 0xC7, 0xFC, 0x1F, 0xFE, 0xF8, 0x7F, 0xF3, 0xE0,
  0xFF, 0x07, 0x80, 0x20, 0x00, 0x00, 0x1E, 0x7C, 0xF9, 0xE3, 0xC7, 0x8F,
  0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xE0, 0x61, 0xC0, 0x79, 0xC1, 0xFF,
  0xDF, 0x7F, 0xFF, 0x07, 0xFF, 0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3E,
  0x70, 0x7C, 0x78, 0x38, 0x78, 0x10, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C,
  0x1E, 0x0E, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xE1,
  0xE0, 0x3C, 0x1E, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C,
  0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x07, 0x87,
  0xC0, 0x7D, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF8,
  0xFF, 0x8F, 0xBC, 0xF9, 0xE7, 0x0F, 0x10, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0x03, 0xC0, 0x08, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7C, 0x7E, 0x01, 0xC0, 0x7C, 0x04, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x82, 0x00, 0x7C, 0x0F, 0x07, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x77, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xCF,
  0x00, 0x0E, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00,
  0x38, 0x78, 0x01, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x01, 0xE0,
  0xF0, 0x0F, 0x03, 0xC0, 0x38, 0x1F, 0x01, 0xE0, 0x78, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7B, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x82, 0x00, 0x7C,
  0x0F, 0x07, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFE, 0x60, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0xF8, 0x07, 0x9F, 0xE0, 0x3D, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0x3C, 0x3E, 0x01,
  0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C,
  0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC1, 0xF0, 0x1F, 0x9F, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xE3,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0x80,
  0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x78, 0x3F, 0x0F, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x3E, 0x1F, 0x03, 0xE0,
  0x78, 0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3,
  0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x3E,
  0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xFE, 0xF0, 0x1F, 0xE7, 0x80, 0x7C, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x20, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x78, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x00, 0x00, 0x10, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC1, 0xE7, 0xE0, 0xC0, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x38, 0x03, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x3E, 0x0E, 0x1E, 0x07, 0xFC, 0x70, 0xE0, 0x7F, 0xC3, 0x87, 0x07, 0x8E,
  0x1C, 0x70, 0x78, 0x70, 0xE3, 0x83, 0x87, 0x87, 0x3C, 0x38, 0x38, 0x39,
  0xC1, 0xC1, 0xC1, 0xCE, 0x1E, 0x0E, 0x0E, 0x70, 0xE0, 0xF0, 0xF7, 0x07,
  0x07, 0x07, 0x38, 0x38, 0x38, 0x39, 0xC3, 0xC3, 0xC1, 0xCE, 0x1C, 0x1E,
  0x1C, 0x70, 0xE0, 0xE0, 0xE7, 0x87, 0x0F, 0x07, 0x3C, 0x38, 0x78, 0x71,
  0xC1, 0xC3, 0xC3, 0x8E, 0x0F, 0x36, 0x38, 0x70, 0x7F, 0xBF, 0x83, 0x81,
  0xF9, 0xF8, 0x1C, 0x07, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F,
  0x80, 0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B, 0xE0, 0x03,
  0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3C, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1E,
  0x07, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x7C, 0x03,
  0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xF0, 0x7E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x1F,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xDE,
  0x01, 0xF8, 0x08, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x08, 0x07, 0xF1,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xE0, 0xFC, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80,
  0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0xC0, 0x78, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xE7, 0xE0, 0x1F, 0x80, 0x70, 0x1F, 0x80, 0x08, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0xFF,
  0x1F, 0x00, 0xFF, 0x8F, 0x80, 0x7F, 0xC7, 0xC0, 0x3F, 0xC3, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x0F,
  0xE1, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0xC0,
  0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80,
  0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x03,
  0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x1F, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3,
  0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x7B, 0x80, 0x0F, 0xF0, 0x0F,
  0x70, 0x03, 0xDE, 0x01, 0xEE, 0x00, 0x7B, 0xC0, 0x79, 0xC0, 0x0E, 0x78,
  0x0F, 0x38, 0x03, 0xDF, 0x01, 0xE7, 0x00, 0x7B, 0xC0, 0x3C, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78,
  0x1E, 0x7C, 0x07, 0x8F, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0xF1, 0xE0, 0x3E,
  0x3C, 0x3C, 0x3C, 0x07, 0x87, 0x87, 0x87, 0x80, 0xF0, 0xF0, 0xE1, 0xF0,
  0x1E, 0x1E, 0x3C, 0x3C, 0x03, 0xC3, 0xC7, 0x87, 0x80, 0xF0, 0x79, 0xE0,
  0xF0, 0x1E, 0x0F, 0x3C, 0x3E, 0x03, 0xC1, 0xEF, 0x07, 0x80, 0x78, 0x3D,
  0xE0, 0xF0, 0x0F, 0x07, 0xF8, 0x1E, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x78,
  0x1F, 0xC0, 0xF8, 0x0F, 0x03, 0xF8, 0x1E, 0x01, 0xE0, 0x7E, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xF8, 0x00,
  0xF0, 0x1F, 0xC0, 0x0F, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0xC0, 0x1E, 0x01,
  0xFC, 0x01, 0xE0, 0x3F, 0xC0, 0x1E, 0x03, 0xDC, 0x01, 0xE0, 0x3D, 0xE0,
  0x3C, 0x03, 0xDE, 0x03, 0xC0, 0x3D, 0xE0, 0x3C, 0x07, 0x9E, 0x03, 0xC0,
  0x79, 0xE0, 0x7C, 0x07, 0x8E, 0x07, 0x80, 0x78, 0xF0, 0x78, 0x07, 0x8F,
  0x07, 0x80, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0xF0,
  0x0F, 0x07, 0x0F, 0x01, 0xF0, 0x78, 0xF0, 0x1E, 0x07, 0x8F, 0x01, 0xE0,
  0x79, 0xE0, 0x1E, 0x07, 0x9E, 0x01, 0xE0, 0x79, 0xE0, 0x3E, 0x03, 0x9E,
  0x03, 0xC0, 0x3D, 0xE0, 0x3C, 0x03, 0xFC, 0x03, 0xC0, 0x3F, 0xC0, 0x3C,
  0x03, 0xFC, 0x07, 0x80, 0x3F, 0xC0, 0x78, 0x01, 0xFC, 0x07, 0x80, 0x1F,
  0x80, 0x78, 0x01, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0xF0, 0x01, 0xF8, 0x0F,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1E,
  0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1F,
  0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0,
  0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7E, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xE0, 0xFC, 0x07, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C,
  0x1E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x7E, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xE0, 0xFC, 0x07, 0x81, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0x81,
  0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF1, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xC0, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0x01, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x80,
  0x0F, 0x81, 0xC0, 0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F,
  0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00,
  0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87,
  0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0x00,
  0x79, 0xE0, 0x07, 0xC0, 0x0F, 0x3C, 0x01, 0xF8, 0x03, 0xCF, 0x80, 0x3F,
  0x00, 0x79, 0xF0, 0x07, 0xC0, 0x1F, 0x3E, 0x01, 0xF8, 0x03, 0xC7, 0xC0,
  0x3F, 0x00, 0x78, 0xF8, 0x0F, 0xE0, 0x1F, 0x1E, 0x01, 0xFC, 0x03, 0xC3,
  0xC0, 0x3B, 0x80, 0xF8, 0x78, 0x0F, 0x70, 0x1E, 0x0F, 0x01, 0xEE, 0x03,
  0xC1, 0xE0, 0x39, 0xC0, 0xF8, 0x3C, 0x0F, 0x38, 0x1E, 0x07, 0x81, 0xC7,
  0x07, 0xC0, 0xF0, 0x78, 0xE0, 0xF0, 0x1E, 0x0F, 0x1C, 0x1E, 0x03, 0xC1,
  0xC7, 0x87, 0xC0, 0x78, 0x78, 0xF0, 0xF0, 0x0F, 0x0E, 0x1E, 0x3E, 0x01,
  0xE3, 0xC3, 0xC7, 0x80, 0x3C, 0x78, 0x78, 0xF0, 0x07, 0x8E, 0x0F, 0x3E,
  0x00, 0xF3, 0xC1, 0xE7, 0x80, 0x1E, 0x78, 0x3C, 0xF0, 0x03, 0xDE, 0x07,
  0xBC, 0x00, 0x7B, 0xC0, 0xF7, 0x80, 0x0F, 0x70, 0x1F, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x77, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7,
  0x80, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x7D,
  0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC3, 0x80, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x01, 0xC1, 0xE0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0xEF, 0x00, 0x0F, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xF3, 0xE3, 0xC7, 0xC7, 0x87,
  0x0F, 0x0E, 0x00, 0x7C, 0x00, 0x07, 0xF1, 0xC0, 0xFF, 0xDE, 0x07, 0xFE,
  0xF0, 0x7C, 0x3F, 0x87, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E,
  0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x78, 0x3F, 0x03, 0xE3, 0xF8, 0x1F, 0xFB,
  0xC0, 0x7F, 0x9E, 0x01, 0xF8, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x8F, 0x80, 0x3C, 0xFE, 0x01, 0xEF, 0xF8, 0x1E, 0xFF,
  0xC0, 0xFE, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x03, 0xC3, 0xE0, 0x1E, 0x1F,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0,
  0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xFC, 0x1F, 0x07, 0xF1, 0xF0, 0x7B, 0xFF,
  0x03, 0xCF, 0xF0, 0x1C, 0x7F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7C, 0x10, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x08, 0x3E, 0x18, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x78, 0x01, 0xFE, 0x78, 0x03, 0xFF, 0x78, 0x03, 0xFF, 0x78, 0x07, 0xC3,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01,
  0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0x80, 0xF8, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F,
  0x00, 0x7C, 0x7F, 0x00, 0x7F, 0xEF, 0x00, 0x3F, 0xCF, 0x00, 0x1F, 0x8E,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x3E, 0x7C, 0x3F, 0x1F, 0xFF, 0x87,
  0xFF, 0x81, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x02,
  0x1F, 0x03, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x3C, 0x03, 0xFF, 0x78, 0x07, 0xFE,
  0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0,
  0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x3F, 0x80, 0x7F, 0xEF, 0x00, 0x7F, 0x9E, 0x00, 0x7E, 0x78,
  0x00, 0x20, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x08, 0x03, 0xE0, 0x1C,
  0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x7C, 0x03, 0xDF, 0xE0, 0x3F,
  0xFF, 0x07, 0xBF, 0xF0, 0x7F, 0x1F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE1,
  0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C,
  0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07,
  0x80, 0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3E, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xDF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0x78, 0x03, 0xF3,
  0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x83, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x07, 0x3F, 0xC7, 0xF8, 0x0E, 0xFF, 0xDF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7E, 0x1F, 0xC3, 0xE0, 0xF8, 0x1F, 0x03, 0xC1, 0xF0,
  0x3E, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0x1E, 0x1E, 0x03,
  0xE0, 0x7C, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x01, 0xE1, 0xF0, 0x1E,
  0x03, 0xC3, 0xC0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x7C, 0x07, 0x80, 0xF0, 0xF0, 0x1F, 0x01,
  0xE1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x1E,
  0x1E, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x0F, 0x0F,
  0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x39, 0xFE, 0x03, 0xBF, 0xF0,
  0x7F, 0xFF, 0x07, 0xF0, 0xF0, 0x7E, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F,
  0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x1F, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0x7B,
  0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xC3,
  0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0x8F, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x71, 0xFC, 0x00,
  0x73, 0xFE, 0x00, 0xF7, 0xFE, 0x00, 0xFE, 0x1F, 0x00, 0xFC, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x03,
  0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE3, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1E, 0x7F, 0x80, 0x1E, 0x3F, 0x00, 0x1E, 0x08, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xF3, 0xC0, 0xFF, 0xDE, 0x07, 0xFE, 0xF0, 0x7C, 0x3F, 0x07, 0xC0, 0xF8,
  0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x01, 0xE1, 0xF0, 0x0F,
  0x0F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8,
  0x3F, 0x03, 0xE3, 0xF8, 0x1F, 0xFB, 0xC0, 0x7F, 0x9E, 0x01, 0xF9, 0xE0,
  0x02, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x81, 0xCF, 0xC0, 0xEF, 0xC0, 0xF7, 0xE0, 0x7F, 0x90, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0x80,
  0x83, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x80, 0x7C, 0x3C, 0x3F, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x03, 0xFF, 0x3F, 0xF9,
  0xFF, 0xC3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1F,
  0x10, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x10, 0x00, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0,
  0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80,
  0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xFC,
  0xEE, 0x03, 0xFF, 0x70, 0x1F, 0xF7, 0x80, 0x7F, 0x3C, 0x00, 0x40, 0x00,
  0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0xFF, 0x01, 0xF8, 0x1F, 0xF0,
  0x1F, 0x81, 0xEF, 0x03, 0xF0, 0x1E, 0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0,
  0x3C, 0xF0, 0x7F, 0x03, 0xCF, 0x07, 0x70, 0x78, 0xF0, 0xF7, 0x07, 0x8F,
  0x0F, 0x70, 0xF0, 0xF0, 0xE7, 0x0F, 0x0F, 0x1E, 0x70, 0xF0, 0xF1, 0xC7,
  0x1E, 0x0F, 0x1C, 0x71, 0xE0, 0xF3, 0xC7, 0x3C, 0x0F, 0x38, 0x73, 0xC0,
  0xF7, 0x87, 0x3C, 0x0F, 0x78, 0x77, 0x80, 0xF7, 0x07, 0x78, 0x0F, 0xF0,
  0xF7, 0x00, 0xFE, 0x0F, 0xF0, 0x0E, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8,
  0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xE0,
  0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E,
  0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xE7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xE0, 0x00,
  0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x3C,
  0x00, 0x70, 0x1F, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE8, 0x03, 0xFC, 0x80, 0x02, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 38, 12, 1, -38 },
  { 58, 15, 14, 18, 5, -38 },
  { 85, 24, 38, 22, 0, -38 },
  { 199, 22, 43, 21, 0, -40 },
  { 318, 27, 39, 32, 3, -38 },
  { 450, 22, 39, 23, 0, -38 },
  { 558, 7, 14, 10, 5, -38 },
  { 571, 16, 46, 14, 1, -38 },
  { 663, 16, 46, 14, -4, -38 },
  { 755, 16, 17, 19, 5, -40 },
  { 789, 20, 25, 23, 2, -31 },
  { 852, 9, 13, 11, -2, -6 },
  { 867, 12, 4, 14, 1, -16 },
  { 873, 5, 6, 11, 1, -6 },
  { 877, 25, 38, 18, -3, -38 },
  { 996, 20, 39, 21, 1, -38 },
  { 1094, 13, 38, 21, 6, -38 },
  { 1156, 23, 38, 21, -2, -38 },
  { 1266, 22, 39, 21, -1, -38 },
  { 1374, 22, 38, 21, -1, -38 },
  { 1479, 22, 39, 21, -1, -38 },
  { 1587, 21, 39, 21, 1, -38 },
  { 1690, 21, 38, 21, 2, -38 },
  { 1790, 21, 39, 21, 0, -38 },
  { 1893, 21, 39, 21, 0, -38 },
  { 1996, 11, 29, 11, 0, -29 },
  { 2036, 14, 36, 11, -3, -29 },
  { 2099, 20, 24, 23, 2, -31 },
  { 2159, 20, 15, 23, 2, -26 },
  { 2197, 20, 24, 23, 2, -31 },
  { 2257, 17, 38, 15, 1, -38 },
  { 2338, 29, 42, 31, 1, -38 },
  { 2491, 21, 38, 21, -3, -38 },
  { 2591, 23, 38, 23, 0, -38 },
  { 2701, 22, 39, 20, 2, -38 },
  { 2809, 24, 38, 25, 0, -38 },
  { 2923, 22, 38, 19, 0, -38 },
  { 3028, 22, 38, 18, 0, -38 },
  { 3133, 25, 39, 26, 2, -38 },
  { 3255, 27, 38, 26, 0, -38 },
  { 3384, 21, 38, 14, -3, -38 },
  { 3484, 20, 48, 11, -8, -38 },
  { 3604, 26, 38, 21, 0, -38 },
  { 3728, 14, 38, 18, 0, -38 },
  { 3795, 35, 38, 34, 0, -38 },
  { 3962, 28, 38, 27, 0, -38 },
  { 4095, 24, 39, 26, 2, -38 },
  { 4212, 22, 38, 21, 0, -38 },
  { 4317, 24, 47, 26, 2, -38 },
  { 4458, 22, 38, 22, 0, -38 },
  { 4563, 23, 39, 20, -1, -38 },
  { 4676, 19, 38, 18, 3, -38 },
  { 4767, 24, 39, 25, 2, -38 },
  { 4884, 21, 38, 21, 5, -38 },
  { 4984, 35, 38, 35, 4, -38 },
  { 5151, 26, 38, 20, -3, -38 },
  { 5275, 19, 38, 19, 4, -38 },
  { 5366, 23, 38, 18, -2, -38 },
  { 5476, 20, 47, 15, -1, -38 },
  { 5594, 9, 38, 18, 5, -38 },
  { 5637, 20, 47, 15, -4, -38 },
  { 5755, 20, 20, 21, 1, -38 },
  { 5805, 17, 4, 16, -5, 4 },
  { 5814, 7, 9, 13, 8, -41 },
  { 5822, 21, 30, 22, 1, -29 },
  { 5901, 21, 41, 22, 0, -40 },
  { 6009, 17, 30, 17, 1, -29 },
  { 6073, 24, 41, 22, 1, -40 },
  { 6196, 18, 30, 20, 1, -29 },
  { 6264, 25, 54, 12, -7, -41 },
  { 6433, 23, 42, 22, -1, -29 },
  { 6554, 20, 40, 22, 0, -40 },
  { 6654, 12, 39, 10, 0, -39 },
  { 6713, 19, 52, 10, -7, -39 },
  { 6837, 21, 40, 19, 0, -40 },
  { 6942, 13, 40, 10, 0, -40 },
  { 7007, 31, 29, 32, 0, -29 },
  { 7120, 20, 29, 22, 0, -29 },
  { 7193, 19, 30, 22, 1, -29 },
  { 7265, 24, 41, 22, -3, -29 },
  { 7388, 21, 42, 22, 1, -29 },
  { 7499, 17, 29, 15, 0, -29 },
  { 7561, 18, 30, 17, -1, -29 },
  { 7629, 13, 36, 13, 1, -35 },
  { 7688, 21, 29, 22, 1, -28 },
  { 7765, 18, 28, 18, 3, -28 },
  { 7828, 28, 28, 29, 3, -28 },
  { 7926, 22, 28, 18, -2, -28 },
  { 8003, 26, 41, 18, -5, -28 },
  { 8137, 19, 28, 15, -2, -28 },
  { 8204, 20, 46, 17, 1, -38 },
  { 8319, 3, 53, 19, 8, -40 },
  { 8339, 19, 46, 17, -3, -38 },
  { 8449, 20, 7, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Italic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC53PT7B_H_
