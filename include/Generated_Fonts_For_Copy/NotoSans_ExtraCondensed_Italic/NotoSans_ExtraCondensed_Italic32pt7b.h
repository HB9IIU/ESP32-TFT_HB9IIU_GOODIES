#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xE0,
  0x73, 0xB9, 0xDC, 0xCC, 0x66, 0x33, 0x3B, 0x99, 0x8C, 0x01, 0x8C, 0x06,
  0x30, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0xC0, 0x63, 0x0F, 0xFF, 0x3F,
  0xFC, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x18, 0xC0, 0x63, 0x0F, 0xFF, 0x3F,
  0xFC, 0x31, 0x80, 0xC6, 0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x98, 0x0C,
  0x60, 0x00, 0x00, 0x40, 0x06, 0x00, 0x70, 0x0F, 0xF0, 0xFF, 0x8E, 0xC8,
  0x66, 0x03, 0x20, 0x19, 0x00, 0xE8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0xDC, 0x04, 0xE0, 0x27, 0x01, 0x31, 0x0B, 0x8F, 0xF8,
  0x7F, 0x80, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1E, 0x06, 0x3E,
  0x0C, 0x66, 0x0C, 0x66, 0x18, 0x66, 0x18, 0xC6, 0x30, 0xC6, 0x30, 0xC6,
  0x60, 0xC6, 0xE0, 0xCC, 0xCE, 0x8D, 0xDF, 0xDD, 0xB3, 0xFB, 0x33, 0xF3,
  0x33, 0x06, 0x63, 0x06, 0x63, 0x0C, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x18,
  0xC6, 0x30, 0xCE, 0x30, 0x7C, 0x60, 0x78, 0x03, 0xE0, 0x3F, 0x01, 0x9C,
  0x1C, 0xE0, 0xC7, 0x06, 0x30, 0x31, 0x81, 0x98, 0x0F, 0xC0, 0x7C, 0x01,
  0xC0, 0x3E, 0x03, 0xF1, 0x99, 0x9D, 0xCE, 0xFC, 0x76, 0xE1, 0xF6, 0x0F,
  0x30, 0x71, 0x83, 0x8E, 0x3E, 0x7F, 0xF1, 0xF1, 0xC0, 0x37, 0x76, 0x66,
  0x6C, 0x01, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x38, 0x18, 0x18, 0x00, 0x0E, 0x03, 0x84, 0xC3, 0xF3, 0x7F, 0xC7,
  0x03, 0xE1, 0xD8, 0x63, 0x08, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x39, 0xCC, 0xE7, 0x33, 0x18, 0x7F, 0x7E,
  0xFE, 0x27, 0xFE, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC1, 0xFC, 0x3B, 0x8E, 0x31, 0x86, 0x70, 0xCC, 0x1B, 0x83, 0x70, 0x6C,
  0x0D, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xB0, 0x36, 0x0E, 0xC1, 0xD8, 0x33,
  0x0E, 0x61, 0x8E, 0x71, 0xFC, 0x1F, 0x00, 0x03, 0x0F, 0x1F, 0x3F, 0x76,
  0xE6, 0x4E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x03, 0xF0, 0x3F, 0xE0, 0x63, 0x81,
  0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0xE0, 0x63, 0x81, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0xC1, 0xC3,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x16, 0x00,
  0xF8, 0x06, 0xE0, 0x1B, 0x00, 0xCC, 0x03, 0x70, 0x19, 0xC0, 0xC7, 0x03,
  0x18, 0x18, 0x60, 0xE3, 0x83, 0x0E, 0x18, 0x32, 0x7F, 0xF3, 0xFF, 0xC0,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x7F,
  0xC3, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xFC, 0x0F, 0xF0, 0x23, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x88, 0x38, 0x7F, 0x83, 0xF8, 0x00, 0x01,
  0xF0, 0x3F, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x06, 0xF8, 0x7F, 0xCF, 0x1C, 0xE0, 0xCE, 0x0C, 0xE0, 0xCC, 0x0C, 0xC0,
  0xCC, 0x1C, 0xC1, 0xCC, 0x38, 0xE3, 0x87, 0xF0, 0x7E, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x03, 0xE0, 0x7F, 0x83, 0x8E, 0x38, 0x71, 0x83, 0x8C, 0x1C, 0x60, 0xC3,
  0x8E, 0x1C, 0x60, 0x7E, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x1C, 0xE1, 0xC3,
  0x1C, 0x1C, 0xC0, 0xE6, 0x07, 0x30, 0x39, 0x81, 0x8E, 0x1C, 0x3F, 0xC0,
  0xFC, 0x00, 0x03, 0xE0, 0x7F, 0x0E, 0x71, 0xC3, 0x18, 0x33, 0x83, 0x38,
  0x33, 0x03, 0x30, 0x33, 0x07, 0x30, 0x73, 0x8F, 0x3F, 0xF1, 0xF6, 0x04,
  0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x0F, 0xE0, 0xFC,
  0x00, 0x1C, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8E,
  0x38, 0xE0, 0x03, 0x03, 0xC1, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0C,
  0x0E, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x0E, 0x00,
  0x80, 0x00, 0x0F, 0x83, 0xF8, 0x67, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x18, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x61,
  0xE2, 0x61, 0xF1, 0x31, 0x99, 0xB1, 0x8C, 0xD8, 0xCC, 0x6C, 0xC6, 0x3C,
  0x63, 0x1E, 0x31, 0x8B, 0x31, 0x8D, 0x98, 0xC6, 0xCC, 0xE6, 0x67, 0xDF,
  0x31, 0xCF, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x80, 0x3F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x06, 0xE0, 0x77, 0x03, 0x38, 0x19, 0xC1, 0xCE,
  0x0C, 0x70, 0xE3, 0x87, 0xFC, 0x7F, 0xE3, 0xFF, 0x18, 0x39, 0xC1, 0xCE,
  0x0E, 0xE0, 0x77, 0x03, 0xB0, 0x1F, 0x80, 0xE0, 0x07, 0xE0, 0x1F, 0xE0,
  0xE7, 0xC3, 0x87, 0x0C, 0x1C, 0x30, 0x71, 0xC1, 0xC7, 0x06, 0x1C, 0x38,
  0x61, 0xC1, 0xFE, 0x0F, 0xF8, 0x38, 0xE0, 0xE1, 0xC3, 0x07, 0x0C, 0x1C,
  0x70, 0x71, 0xC1, 0xC7, 0x07, 0x18, 0x38, 0x61, 0xE3, 0xFF, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x70, 0x83, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0xEF, 0x83,
  0x87, 0x0C, 0x1C, 0x30, 0x31, 0xC0, 0xC7, 0x03, 0x1C, 0x0C, 0x60, 0x31,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x03, 0x8C, 0x0E, 0x70, 0x39,
  0xC1, 0xC7, 0x0E, 0x18, 0x78, 0x67, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x07, 0xF8, 0x7F, 0x83, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x08, 0x7F, 0x83, 0xFC, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x1E, 0x38, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x07, 0xEE, 0x0F, 0x9C, 0x03, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x31, 0xC0,
  0x63, 0x81, 0xC3, 0x83, 0x87, 0x07, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x06,
  0x03, 0x06, 0x07, 0x0E, 0x07, 0x0E, 0x06, 0x0C, 0x06, 0x0C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x0C, 0x18, 0x0C, 0x1F, 0xFC, 0x3F, 0xFC, 0x38,
  0x1C, 0x38, 0x18, 0x30, 0x18, 0x30, 0x38, 0x70, 0x38, 0x70, 0x30, 0x70,
  0x30, 0x60, 0x70, 0x60, 0x70, 0xE0, 0x70, 0xE0, 0x60, 0x07, 0xF8, 0x3F,
  0x80, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x9C, 0x07, 0xC0, 0xF8, 0x00, 0x06, 0x07, 0x06, 0x0E, 0x0E,
  0x1C, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1D,
  0xC0, 0x1B, 0x80, 0x1B, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3B, 0x80, 0x31,
  0x80, 0x31, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x61, 0xC0, 0x60,
  0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0xFF, 0xFC, 0x07, 0x00, 0x78, 0x38, 0x03,
  0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x7E,
  0x06, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0x70, 0xDC, 0x3B, 0x06, 0x61, 0x98,
  0x73, 0x1D, 0xC3, 0x98, 0xCE, 0x18, 0xC6, 0x70, 0xC6, 0x63, 0x06, 0x33,
  0x18, 0x71, 0xB9, 0xC3, 0x8D, 0x8E, 0x18, 0x7C, 0x70, 0xC3, 0xC3, 0x06,
  0x1E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x07, 0x01, 0x83, 0x81,
  0xC3, 0xC0, 0xE1, 0xE0, 0x60, 0xF8, 0x30, 0x7C, 0x18, 0x76, 0x1C, 0x3B,
  0x0E, 0x1D, 0x86, 0x0C, 0xC3, 0x06, 0x73, 0x87, 0x39, 0xC3, 0x8C, 0xE1,
  0x86, 0x60, 0xC3, 0x30, 0x61, 0xB8, 0x70, 0xFC, 0x38, 0x7C, 0x18, 0x1E,
  0x0C, 0x0F, 0x06, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xC0, 0x01, 0xF0, 0x1F,
  0xE0, 0xF3, 0xC3, 0x87, 0x1C, 0x0C, 0xE0, 0x33, 0x80, 0xCC, 0x03, 0x70,
  0x0D, 0xC0, 0x37, 0x01, 0xD8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xB8,
  0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x38, 0x71, 0xC1, 0xFE, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0xEF, 0x83, 0x8E, 0x0C, 0x18, 0x30,
  0x71, 0xC1, 0x87, 0x06, 0x1C, 0x38, 0x60, 0xE1, 0x87, 0x0E, 0x3C, 0x3F,
  0xE0, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xF3,
  0xC3, 0x87, 0x1C, 0x0C, 0xE0, 0x33, 0x80, 0xCC, 0x03, 0x70, 0x0D, 0xC0,
  0x37, 0x01, 0xD8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x0E, 0xE0,
  0x3B, 0x81, 0xCE, 0x07, 0x38, 0x38, 0x71, 0xC1, 0xFE, 0x03, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0xEF, 0x83, 0x8E, 0x0C, 0x18, 0x30, 0x71, 0xC1, 0x87, 0x06, 0x1C, 0x38,
  0x60, 0xE1, 0x87, 0x0F, 0xF8, 0x3F, 0xC0, 0xEE, 0x03, 0x18, 0x0C, 0x60,
  0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x18, 0x70, 0x60, 0xC3, 0x83, 0x8E, 0x0E,
  0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xF1, 0x83, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0xC3, 0xC3, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x00, 0x0C, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0xE0, 0x61, 0x81, 0xC3,
  0x03, 0x8E, 0x07, 0x1C, 0x0C, 0x38, 0x18, 0x60, 0x71, 0xC0, 0xE3, 0x81,
  0x87, 0x03, 0x0C, 0x0E, 0x18, 0x1C, 0x70, 0x38, 0xE0, 0x61, 0xC0, 0xC3,
  0x83, 0x87, 0x06, 0x0E, 0x1C, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0xC0, 0x3E,
  0x03, 0xB0, 0x1D, 0x81, 0xCC, 0x0E, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3,
  0x86, 0x1C, 0x30, 0xC1, 0x8E, 0x0C, 0x60, 0x67, 0x03, 0x30, 0x1B, 0x80,
  0xDC, 0x06, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x60, 0x30, 0x1B, 0x03, 0x81, 0xD8, 0x1C, 0x0E, 0xC0, 0xE0, 0xE6, 0x0F,
  0x07, 0x30, 0x78, 0x31, 0x87, 0xC3, 0x8C, 0x36, 0x1C, 0x61, 0xB0, 0xC3,
  0x19, 0x8E, 0x18, 0xCC, 0x61, 0xCE, 0x67, 0x0E, 0x63, 0x38, 0x73, 0x19,
  0x83, 0xB8, 0xDC, 0x1D, 0x86, 0xC0, 0xEC, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0x81, 0xE0,
  0x00, 0x07, 0x07, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x9C, 0x03,
  0x98, 0x03, 0xB8, 0x03, 0xB0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C,
  0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x30, 0x60, 0x70, 0x60, 0xE0, 0x70, 0x60,
  0x76, 0x06, 0x70, 0xE7, 0x0C, 0x71, 0xC7, 0x18, 0x73, 0x87, 0x30, 0x37,
  0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x43, 0xFE,
  0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFE, 0x0F, 0xC0, 0xE7, 0x18, 0xC6,
  0x31, 0x8C, 0x73, 0x8C, 0x63, 0x18, 0xC6, 0x39, 0xC6, 0x31, 0x8C, 0x60,
  0x03, 0xF0, 0x7F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x6E, 0x03, 0x30, 0x31, 0x83, 0x8C, 0x18, 0x71, 0xC1, 0x9C, 0x0D,
  0xC0, 0x70, 0xFF, 0xFF, 0xF0, 0xEE, 0x63, 0x30, 0x0F, 0xB1, 0xFB, 0x38,
  0xF3, 0x87, 0x70, 0x67, 0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xEE, 0x0C, 0xC0,
  0xCC, 0x1C, 0xC1, 0xCC, 0x3C, 0xE3, 0x8F, 0xD8, 0x79, 0x80, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0xBE, 0x1F,
  0xF0, 0xF1, 0xC7, 0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0xC6, 0x06,
  0x30, 0x73, 0x83, 0x9C, 0x18, 0xE1, 0xC7, 0x0E, 0x78, 0xE3, 0xFE, 0x19,
  0xE0, 0x0F, 0xC7, 0xF3, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x23, 0xF8, 0x7E, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83,
  0xEC, 0x1F, 0xB0, 0xE3, 0xC3, 0x87, 0x1C, 0x18, 0x70, 0x61, 0x81, 0x8E,
  0x0E, 0x38, 0x38, 0xE0, 0xC3, 0x03, 0x0C, 0x1C, 0x30, 0x70, 0xC3, 0xC3,
  0x8E, 0x0F, 0xD8, 0x1E, 0x60, 0x0F, 0xC3, 0xF8, 0xE3, 0x98, 0x77, 0x0E,
  0xC1, 0x98, 0x77, 0xFC, 0xFE, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x43, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xEC, 0x1F, 0xB0, 0xE3, 0xC3, 0x87,
  0x1C, 0x18, 0x70, 0x61, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xC3, 0x03,
  0x0C, 0x1C, 0x30, 0x70, 0xC3, 0xC3, 0x9E, 0x0F, 0xD8, 0x1E, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC2, 0x06, 0x0F, 0xF8, 0x3F, 0xC0, 0x1C,
  0x00, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xDF, 0x1F, 0xF1, 0xE3, 0x1C, 0x31, 0x83, 0x38, 0x73, 0x87, 0x38, 0x73,
  0x06, 0x30, 0x67, 0x0E, 0x70, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE1, 0xCE,
  0x1C, 0x02, 0x0C, 0x38, 0x30, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC3,
  0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x70, 0x00, 0x20,
  0x0C, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x87, 0x1C, 0x70, 0xE7, 0x06, 0x30,
  0x33, 0x83, 0xB8, 0x1F, 0x80, 0xDC, 0x07, 0xE0, 0x3B, 0x03, 0x98, 0x1C,
  0xE0, 0xC7, 0x06, 0x38, 0x30, 0xC3, 0x86, 0x1C, 0x38, 0x07, 0x06, 0x06,
  0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x1D, 0xF7, 0xC3,
  0x7F, 0xFC, 0x71, 0xE3, 0x8E, 0x1C, 0x71, 0x87, 0x0E, 0x70, 0xE1, 0x8E,
  0x1C, 0x31, 0x83, 0x0E, 0x30, 0x61, 0xC6, 0x1C, 0x39, 0xC3, 0x86, 0x38,
  0x60, 0xC6, 0x0C, 0x38, 0xC1, 0x87, 0x38, 0x70, 0xC7, 0x0E, 0x18, 0xE1,
  0x87, 0x00, 0x1D, 0xF1, 0xBF, 0x1E, 0x31, 0xC3, 0x18, 0x33, 0x87, 0x38,
  0x73, 0x07, 0x30, 0x63, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x0C, 0xE0,
  0xCE, 0x1C, 0xE1, 0xC0, 0x0F, 0xC3, 0xFC, 0xE3, 0x98, 0x37, 0x06, 0xC0,
  0xD8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0x60, 0xEC, 0x1D, 0x87, 0x38,
  0xE3, 0xF8, 0x7E, 0x00, 0x07, 0x7C, 0x0D, 0xF8, 0x1E, 0x38, 0x38, 0x70,
  0x60, 0xE1, 0xC1, 0xC3, 0x83, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x70,
  0x70, 0xE0, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x1C, 0x1F, 0xF0, 0x3B, 0xC0,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x0F, 0xB1, 0xFB, 0x38, 0xF3, 0x07, 0x70, 0x67, 0x06, 0x60, 0x6E,
  0x0E, 0xE0, 0xEE, 0x0C, 0xC0, 0xCC, 0x1C, 0xC1, 0xCC, 0x3C, 0xE7, 0x8F,
  0xD8, 0x7B, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x1D, 0xC6, 0xF1, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x00, 0x0F, 0xE3, 0xF8, 0xE1, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x0E, 0x21, 0xC7, 0xF0, 0xFC,
  0x00, 0x0C, 0x0C, 0x18, 0x18, 0x7F, 0x7E, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xF8, 0xF8, 0x38, 0x73,
  0x87, 0x30, 0x73, 0x06, 0x30, 0x67, 0x0E, 0x70, 0xE6, 0x0C, 0x60, 0xC6,
  0x0C, 0xE1, 0xCE, 0x1C, 0xC1, 0x8C, 0x38, 0xE7, 0x8F, 0xD8, 0x7B, 0x80,
  0xC0, 0xF0, 0x7C, 0x1B, 0x0E, 0xC3, 0x31, 0xCC, 0x63, 0x18, 0xCE, 0x33,
  0x0D, 0xC3, 0x60, 0xD8, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0xC1, 0xC3,
  0xE1, 0xE1, 0xB0, 0xF1, 0xD8, 0x78, 0xCC, 0x6C, 0x66, 0x36, 0x73, 0x3B,
  0x31, 0x99, 0xB8, 0xCD, 0xD8, 0x6C, 0xEC, 0x36, 0x6E, 0x1B, 0x36, 0x0F,
  0x1B, 0x07, 0x8F, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x00, 0x1C,
  0x38, 0x61, 0x83, 0x1C, 0x1D, 0xC0, 0xEC, 0x03, 0xE0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x37, 0x03, 0xB8, 0x18, 0xC1, 0xC6, 0x1C,
  0x30, 0xE1, 0xC0, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x60, 0x07,
  0xE0, 0x07, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x07, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x60, 0x3C, 0x0E, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x81, 0xE0,
  0x38, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x3C, 0x05, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0F, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0x7C, 0x1F,
  0xFF, 0xC7, 0xF8, 0x0C,
};

const GFXglyph NotoSans_ExtraCondensed_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 23, 8, 0, -23 },
  { 24, 9, 8, 11, 3, -23 },
  { 33, 14, 23, 14, 0, -23 },
  { 74, 13, 26, 13, 0, -24 },
  { 117, 16, 23, 19, 2, -23 },
  { 163, 13, 23, 14, 0, -23 },
  { 201, 4, 8, 6, 3, -23 },
  { 205, 9, 28, 8, 1, -23 },
  { 237, 9, 28, 8, -2, -23 },
  { 269, 10, 10, 12, 3, -24 },
  { 282, 12, 15, 14, 1, -19 },
  { 305, 5, 8, 6, -1, -4 },
  { 310, 8, 3, 8, 0, -10 },
  { 313, 4, 4, 6, 0, -4 },
  { 315, 15, 23, 11, -2, -23 },
  { 359, 11, 23, 13, 1, -23 },
  { 391, 8, 23, 13, 3, -23 },
  { 414, 14, 23, 13, -1, -23 },
  { 455, 14, 23, 13, -1, -23 },
  { 496, 14, 23, 13, -1, -23 },
  { 537, 13, 23, 13, 0, -23 },
  { 575, 12, 23, 13, 1, -23 },
  { 610, 13, 23, 13, 1, -23 },
  { 648, 13, 23, 13, 0, -23 },
  { 686, 12, 23, 13, 0, -23 },
  { 721, 6, 17, 7, 0, -17 },
  { 734, 9, 21, 7, -2, -17 },
  { 758, 12, 15, 14, 1, -19 },
  { 781, 12, 9, 14, 1, -16 },
  { 795, 12, 15, 14, 1, -19 },
  { 818, 11, 23, 9, 0, -23 },
  { 850, 17, 26, 19, 1, -23 },
  { 906, 13, 23, 13, -2, -23 },
  { 944, 14, 23, 14, 0, -23 },
  { 985, 14, 23, 12, 1, -23 },
  { 1026, 14, 23, 15, 0, -23 },
  { 1067, 13, 23, 12, 0, -23 },
  { 1105, 13, 23, 11, 0, -23 },
  { 1143, 15, 23, 16, 1, -23 },
  { 1187, 16, 23, 15, 0, -23 },
  { 1233, 13, 23, 8, -2, -23 },
  { 1271, 12, 29, 6, -5, -23 },
  { 1315, 16, 23, 13, 0, -23 },
  { 1361, 9, 23, 11, 0, -23 },
  { 1387, 21, 23, 21, 0, -23 },
  { 1448, 17, 23, 16, 0, -23 },
  { 1497, 14, 23, 16, 1, -23 },
  { 1538, 14, 23, 13, 0, -23 },
  { 1579, 14, 28, 16, 1, -23 },
  { 1628, 14, 23, 13, 0, -23 },
  { 1669, 14, 23, 12, -1, -23 },
  { 1710, 11, 23, 11, 2, -23 },
  { 1742, 15, 23, 15, 1, -23 },
  { 1786, 13, 23, 13, 3, -23 },
  { 1824, 21, 23, 21, 2, -23 },
  { 1885, 16, 23, 12, -2, -23 },
  { 1931, 12, 23, 11, 2, -23 },
  { 1966, 14, 23, 11, -1, -23 },
  { 2007, 12, 28, 9, -1, -23 },
  { 2049, 5, 23, 11, 3, -23 },
  { 2064, 12, 28, 9, -2, -23 },
  { 2106, 13, 12, 13, 0, -23 },
  { 2126, 10, 2, 10, -3, 3 },
  { 2129, 4, 5, 8, 5, -24 },
  { 2132, 12, 17, 14, 1, -17 },
  { 2158, 13, 24, 13, 0, -24 },
  { 2197, 10, 17, 10, 1, -17 },
  { 2219, 14, 24, 14, 1, -24 },
  { 2261, 11, 17, 12, 1, -17 },
  { 2285, 15, 32, 7, -4, -24 },
  { 2345, 14, 25, 14, -1, -17 },
  { 2389, 12, 24, 13, 0, -24 },
  { 2425, 7, 24, 6, 0, -24 },
  { 2446, 11, 32, 6, -4, -24 },
  { 2490, 13, 24, 12, 0, -24 },
  { 2529, 8, 24, 6, 0, -24 },
  { 2553, 19, 17, 20, 0, -17 },
  { 2594, 12, 17, 13, 0, -17 },
  { 2620, 11, 17, 13, 1, -17 },
  { 2644, 15, 24, 13, -2, -17 },
  { 2689, 12, 25, 14, 1, -17 },
  { 2727, 10, 17, 9, 0, -17 },
  { 2749, 11, 17, 10, 0, -17 },
  { 2773, 8, 21, 8, 1, -21 },
  { 2794, 12, 17, 13, 1, -17 },
  { 2820, 10, 17, 11, 2, -17 },
  { 2842, 17, 17, 17, 2, -17 },
  { 2879, 13, 17, 11, -1, -17 },
  { 2907, 16, 25, 11, -3, -17 },
  { 2957, 11, 17, 9, -1, -17 },
  { 2981, 11, 28, 11, 1, -23 },
  { 3020, 2, 32, 12, 5, -24 },
  { 3028, 12, 28, 10, -2, -23 },
  { 3070, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Italic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC32PT7B_H_
