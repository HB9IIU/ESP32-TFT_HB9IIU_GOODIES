#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x0F, 0x01, 0xC0,
  0x79, 0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x38, 0xE7, 0x1C, 0xE3,
  0x98, 0x60, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x18, 0x60, 0x0C,
  0x70, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0,
  0xC7, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x38, 0xE0, 0x18, 0x60,
  0x0C, 0x30, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x83, 0x8E, 0x01, 0xC6,
  0x00, 0xC3, 0x00, 0x63, 0x80, 0x71, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x1C,
  0x70, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFE,
  0x07, 0xFF, 0x0F, 0x6E, 0x0E, 0x62, 0x0C, 0x40, 0x1C, 0x40, 0x1C, 0xC0,
  0x1C, 0xC0, 0x0E, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0x78, 0x01, 0x38, 0x03, 0x38, 0x03, 0x38, 0x02, 0x38,
  0x02, 0x38, 0xC6, 0x70, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0xE1, 0xF8, 0x1C, 0x39,
  0x81, 0x83, 0x1C, 0x38, 0x71, 0xC3, 0x07, 0x1C, 0x70, 0x61, 0x86, 0x06,
  0x18, 0xE0, 0xE1, 0x8C, 0x0E, 0x39, 0xC0, 0xC3, 0x98, 0x0C, 0x33, 0x9E,
  0xC7, 0x33, 0xFC, 0x67, 0x73, 0xEE, 0x66, 0x3F, 0xCE, 0xE3, 0x78, 0xCC,
  0x30, 0x1C, 0xC3, 0x01, 0x9C, 0x30, 0x39, 0xC7, 0x07, 0x1C, 0x70, 0x71,
  0x86, 0x0E, 0x18, 0x60, 0xC1, 0x8E, 0x1C, 0x18, 0xC1, 0x81, 0x9C, 0x38,
  0x1F, 0x83, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0x9C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x30,
  0x07, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x1D, 0xC7,
  0x39, 0xC7, 0x71, 0xCE, 0x70, 0xEE, 0xE0, 0xEC, 0xE0, 0xFC, 0xE0, 0x78,
  0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xF8, 0xFB, 0xF8, 0x7F, 0xBC, 0x3F, 0x1C,
  0x3B, 0xDC, 0xE7, 0x39, 0x9C, 0xE7, 0x00, 0x00, 0xF0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0x70, 0x07, 0x04, 0x60, 0xE6, 0x0F, 0xFE, 0x3F, 0xF0,
  0xE0, 0x1F, 0x03, 0xB0, 0xF3, 0x86, 0x1C, 0x21, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x38,
  0xE0, 0xFF, 0xFF, 0xFF, 0x73, 0xFC, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0,
  0x0F, 0xE0, 0x7F, 0xC3, 0xC7, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xE7, 0x03,
  0xBC, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83,
  0x8E, 0x0E, 0x38, 0x70, 0xE3, 0xC3, 0xDE, 0x07, 0xF0, 0x0F, 0x80, 0x01,
  0xC1, 0xF0, 0xF8, 0x7E, 0x3F, 0x9E, 0xEF, 0x71, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0x03, 0x07, 0x02, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF,
  0x02, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x03, 0xF8, 0x03, 0xC0, 0x07, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x80, 0xF0, 0xF3, 0xF0, 0xFF, 0xE0,
  0x7F, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0x70, 0x01, 0xF0, 0x01, 0xB8, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE6, 0x00,
  0xE7, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x30, 0xE0, 0x30, 0xE0, 0x38, 0x70,
  0x18, 0x38, 0x1C, 0x1C, 0x1C, 0x0E, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF,
  0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x80, 0xE0, 0xE3, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7E,
  0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE2, 0x03, 0x9F, 0x87, 0x7F, 0x0F, 0x8F,
  0x1E, 0x1E, 0x78, 0x1C, 0xF0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE,
  0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xF1, 0xE0, 0xF7, 0x81, 0xFE,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x07, 0x9E, 0x0F, 0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x0E,
  0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x3C, 0x07, 0x78, 0x07,
  0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x1E, 0xF0, 0x38, 0x70, 0x70, 0x78, 0x70,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x70, 0xF9, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xF8, 0x1F,
  0xF0, 0x78, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x0E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xE7, 0x87, 0x8F, 0x1F, 0x0F,
  0xFE, 0x1F, 0xDC, 0x0E, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC1, 0x1F, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x06, 0x0F, 0x0F, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x01, 0xC0, 0xF0,
  0x3C, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0xC3, 0xFE, 0x1F, 0xF1, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x38, 0x3C, 0x07, 0x80, 0x60, 0x30,
  0x03, 0x83, 0x00, 0x0C, 0x38, 0x00, 0x61, 0x80, 0x03, 0x18, 0x3F, 0x18,
  0xC3, 0xF8, 0xCC, 0x39, 0xC6, 0x61, 0x8E, 0x37, 0x1C, 0x61, 0xB0, 0xC3,
  0x0D, 0x8E, 0x38, 0xEC, 0x61, 0xC6, 0xE3, 0x0C, 0x37, 0x18, 0x61, 0xB0,
  0xC7, 0x19, 0x86, 0x38, 0xCC, 0x33, 0xCC, 0x61, 0xF7, 0xE3, 0x0F, 0xBE,
  0x18, 0x10, 0x40, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x77,
  0x00, 0x77, 0x00, 0x77, 0x00, 0xE7, 0x00, 0xE7, 0x01, 0xC7, 0x01, 0xC7,
  0x03, 0xC7, 0x03, 0x87, 0x03, 0x87, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07,
  0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E,
  0x07, 0x87, 0x03, 0x83, 0x83, 0xC3, 0xC3, 0xC1, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xE0, 0x38, 0x78, 0x3C, 0x1E, 0x1C, 0x0F, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x78, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xF8, 0x20, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x70, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x1C, 0x3E, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x0F,
  0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x3C, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0xF0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x87, 0x03, 0xC1, 0xC1, 0xE0,
  0x70, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x60, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x7F, 0x1C, 0x0F,
  0xE3, 0x81, 0xF8, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x07,
  0x8F, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x78, 0x1C,
  0x07, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0xF0, 0x38,
  0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07,
  0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x03, 0x81,
  0xE0, 0x38, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xC0, 0x70,
  0x3C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x38, 0x0E,
  0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x01,
  0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x4F,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x0E,
  0x03, 0x83, 0xC0, 0x70, 0x70, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x71, 0xE0,
  0x0E, 0x38, 0x01, 0xCF, 0x00, 0x3B, 0xC0, 0x0F, 0x70, 0x01, 0xDC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x78, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1C, 0x1C, 0x03,
  0x83, 0x80, 0x70, 0x78, 0x0E, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF,
  0xFF, 0x7F, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x6C,
  0x01, 0xB8, 0x3B, 0x80, 0xFE, 0x0E, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x07, 0x38, 0x73,
  0x81, 0xCE, 0x1C, 0xE0, 0x73, 0x8E, 0x38, 0x38, 0xE3, 0x8E, 0x0E, 0x38,
  0xC7, 0x03, 0x8E, 0x71, 0xC0, 0xE3, 0x9C, 0x70, 0x38, 0xEE, 0x1C, 0x1C,
  0x3B, 0x8F, 0x07, 0x0F, 0xC3, 0x81, 0xC3, 0xF0, 0xE0, 0x70, 0xF8, 0x38,
  0x1C, 0x3E, 0x0E, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x03, 0xC0,
  0x38, 0x1E, 0x01, 0xC1, 0xF0, 0x1C, 0x0F, 0x80, 0xE0, 0x7C, 0x07, 0x03,
  0xE0, 0x38, 0x1B, 0x83, 0xC1, 0xDC, 0x1C, 0x0E, 0xE0, 0xE0, 0x77, 0x07,
  0x03, 0x98, 0x38, 0x38, 0xC3, 0x81, 0xC7, 0x1C, 0x0E, 0x38, 0xE0, 0x71,
  0xC7, 0x03, 0x8E, 0x38, 0x38, 0x73, 0x81, 0xC1, 0x9C, 0x0E, 0x0E, 0xE0,
  0x70, 0x77, 0x03, 0x83, 0xB8, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x03,
  0xE0, 0x70, 0x1F, 0x03, 0x80, 0xF8, 0x38, 0x07, 0x81, 0xC0, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F, 0x03, 0x83,
  0x80, 0xF1, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xF3, 0x80,
  0x3C, 0xE0, 0x0F, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0x70, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C,
  0x07, 0x8F, 0x01, 0xC1, 0xC0, 0xF0, 0x78, 0x78, 0x1F, 0x7C, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0x0F, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E,
  0x07, 0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F, 0x03, 0x83, 0x80,
  0xF1, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C,
  0xE0, 0x0F, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07,
  0x8F, 0x01, 0xC1, 0xC0, 0xF0, 0x78, 0x78, 0x1F, 0x7C, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xE1, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x1C, 0x0E, 0x0E,
  0x07, 0x07, 0x03, 0x83, 0x83, 0xC3, 0xC1, 0xC1, 0xC1, 0xE0, 0xE3, 0xE0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1E,
  0x03, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x78, 0x38,
  0x3C, 0x38, 0x0E, 0x1C, 0x07, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xF0, 0x20, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0xC0, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x07,
  0x87, 0x01, 0xC1, 0xC0, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0xC3,
  0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0,
  0x70, 0xF0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x78,
  0x1F, 0x7C, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE1,
  0xC0, 0xE3, 0x80, 0xE3, 0x80, 0xE7, 0x80, 0xE7, 0x00, 0xE7, 0x00, 0xEE,
  0x00, 0xEE, 0x00, 0xEC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x00, 0xEE, 0x01, 0xC0,
  0x7B, 0x80, 0xF0, 0x1C, 0xE0, 0x3C, 0x07, 0x38, 0x1F, 0x03, 0x8E, 0x07,
  0xC0, 0xE3, 0x81, 0xB0, 0x78, 0xE0, 0xEC, 0x1C, 0x38, 0x3F, 0x07, 0x0E,
  0x1D, 0xC3, 0x83, 0x87, 0x70, 0xE0, 0xE1, 0x9C, 0x38, 0x38, 0xE7, 0x1C,
  0x0E, 0x39, 0xC7, 0x03, 0x8C, 0x73, 0x80, 0xE7, 0x1C, 0xE0, 0x39, 0x87,
  0x38, 0x0E, 0xE1, 0xDC, 0x03, 0xB8, 0x77, 0x00, 0xEC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80,
  0xE0, 0x78, 0x3C, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x1B, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE3, 0x80,
  0x3C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0x1E, 0x00, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C, 0x1C,
  0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x07, 0x38,
  0x0D, 0xC0, 0x37, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xE3, 0x8E,
  0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x77, 0x00, 0xCE,
  0x03, 0x8C, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0x63, 0x80, 0xEE,
  0x01, 0xFC, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x9C, 0xE3,
  0x1C, 0x03, 0xE6, 0x1F, 0xDC, 0x3D, 0xF8, 0xF0, 0xF3, 0xC1, 0xC7, 0x03,
  0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE,
  0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC3, 0xE3, 0xCD,
  0xC3, 0xFB, 0x03, 0xE6, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0xF8,
  0x3B, 0xF8, 0x7E, 0xF0, 0xF0, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C,
  0x0E, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07,
  0x3C, 0x0E, 0x70, 0x38, 0xF0, 0x71, 0xE1, 0xC7, 0xE7, 0x8E, 0xFE, 0x1C,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x83, 0xCC, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x60, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x01, 0xF7, 0x03, 0xFB,
  0x81, 0xEF, 0xC1, 0xE3, 0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x0E, 0x1E, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3,
  0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x7C, 0x1E, 0x6C,
  0x07, 0xF6, 0x01, 0xF3, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xCE, 0x38, 0x73,
  0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x0E, 0x70, 0xF7, 0xFF, 0x3F, 0xE1, 0xF0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x30,
  0xFF, 0x83, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x09, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF9, 0x81, 0xFD, 0xC0, 0xF7, 0xE0, 0xF0, 0xF0, 0xF0, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x0F, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70, 0x38, 0x38,
  0x3C, 0x1C, 0x3E, 0x0F, 0x37, 0x03, 0xFF, 0x01, 0xFB, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x20, 0x38, 0x1C, 0x7C,
  0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0xF8,
  0x3B, 0xF0, 0x7F, 0xF0, 0xF0, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C,
  0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x0E, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC1, 0xC3, 0x83, 0x8E, 0x07, 0x1C,
  0x0E, 0x00, 0x01, 0x01, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x00, 0x00,
  0x08, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x2F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x78, 0x1C, 0xF0,
  0x1C, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x3B, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3D, 0xC0, 0x39, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x00, 0x0E, 0x7C, 0x7C, 0x1F, 0xFB, 0xF8, 0x3F, 0xFF,
  0xF8, 0x78, 0xF8, 0x71, 0xE0, 0xE0, 0xE3, 0xC1, 0xC1, 0xC7, 0x07, 0x07,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x70, 0x38, 0x38, 0xE0, 0x70, 0x71,
  0xC1, 0xC1, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x07, 0x1C, 0x0E, 0x0E, 0x38,
  0x3C, 0x1C, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE3, 0xC1, 0xC1, 0xC7, 0x03,
  0x83, 0x8E, 0x0E, 0x0F, 0x00, 0x0E, 0x7C, 0x1D, 0xF8, 0x3F, 0xF8, 0x78,
  0x71, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x78, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x00, 0x03, 0xF0, 0x1F,
  0xE0, 0xF7, 0x87, 0x0F, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x07, 0x70,
  0x1D, 0xC0, 0x7F, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x38,
  0x1C, 0xE0, 0xF3, 0x83, 0x87, 0x3C, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0x9F,
  0x01, 0xDF, 0xC0, 0xF9, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1C,
  0x0E, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70,
  0xE0, 0x70, 0x70, 0x38, 0x78, 0x1C, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x0E,
  0x06, 0xCF, 0x07, 0x7F, 0x03, 0x9F, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xE6, 0x1F, 0xDC, 0x3D, 0xF8, 0xF1, 0xF3, 0xC1, 0xC7,
  0x03, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x73, 0xC0, 0xE7, 0x01,
  0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC3, 0xE3,
  0xCD, 0xC3, 0xFF, 0x07, 0xEE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E,
  0x78, 0x77, 0x83, 0x7C, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0xC7, 0x9C, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC4, 0x1E, 0x31, 0xE1, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0xFD, 0xFE, 0xFF, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE8,
  0xFC, 0x3E, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x83, 0xC7, 0x07, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xC3,
  0xC3, 0xCF, 0x87, 0xF7, 0x07, 0xCE, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1D,
  0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x38,
  0xE1, 0xCE, 0x0E, 0x70, 0x37, 0x01, 0xB8, 0x0D, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x3F, 0x07, 0x83, 0xF8,
  0x3C, 0x1D, 0xC1, 0xE0, 0xEE, 0x1F, 0x0E, 0x70, 0xD8, 0x73, 0x86, 0xC3,
  0x1C, 0x76, 0x38, 0xE3, 0x31, 0xC7, 0x39, 0x9C, 0x39, 0xCC, 0xE1, 0xCC,
  0x66, 0x0E, 0xE7, 0x70, 0x76, 0x3B, 0x83, 0xF1, 0xD8, 0x1F, 0x8F, 0xC0,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0x80, 0x71, 0xC0, 0x39,
  0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x1C, 0xE0,
  0x1C, 0x70, 0x1E, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x80, 0x03,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x6E, 0x00, 0x0D,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x2F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x1C,
  0x01, 0xF0, 0x0F, 0xC0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x0F, 0x80,
  0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x7C, 0x01, 0xE0, 0x1F, 0x80, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFE, 0x80, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 28, 9, 0, -28 },
  { 36, 11, 10, 13, 4, -28 },
  { 50, 17, 28, 17, 0, -28 },
  { 110, 16, 32, 15, 0, -30 },
  { 174, 20, 28, 24, 2, -28 },
  { 244, 16, 28, 17, 0, -28 },
  { 300, 5, 10, 7, 4, -28 },
  { 307, 12, 34, 10, 1, -28 },
  { 358, 12, 34, 10, -3, -28 },
  { 409, 12, 13, 14, 4, -30 },
  { 429, 14, 18, 17, 2, -23 },
  { 461, 7, 9, 8, -2, -4 },
  { 469, 8, 3, 10, 1, -12 },
  { 472, 5, 4, 8, 0, -4 },
  { 475, 18, 28, 13, -2, -28 },
  { 538, 14, 28, 15, 1, -28 },
  { 587, 10, 28, 15, 4, -28 },
  { 622, 16, 28, 15, -1, -28 },
  { 678, 16, 28, 15, -1, -28 },
  { 734, 17, 28, 15, -1, -28 },
  { 794, 16, 28, 15, 0, -28 },
  { 850, 15, 28, 15, 1, -28 },
  { 903, 16, 28, 15, 1, -28 },
  { 959, 16, 28, 15, 0, -28 },
  { 1015, 15, 28, 15, 0, -28 },
  { 1068, 8, 21, 8, 0, -21 },
  { 1089, 10, 26, 8, -2, -21 },
  { 1122, 14, 18, 17, 2, -23 },
  { 1154, 14, 11, 17, 2, -19 },
  { 1174, 14, 18, 17, 2, -23 },
  { 1206, 12, 28, 11, 1, -28 },
  { 1248, 21, 31, 23, 1, -28 },
  { 1330, 16, 28, 16, -3, -28 },
  { 1386, 17, 28, 17, 0, -28 },
  { 1446, 17, 28, 15, 1, -28 },
  { 1506, 18, 28, 18, 0, -28 },
  { 1569, 16, 28, 14, 0, -28 },
  { 1625, 16, 28, 13, 0, -28 },
  { 1681, 19, 28, 19, 1, -28 },
  { 1748, 20, 28, 19, 0, -28 },
  { 1818, 15, 28, 10, -2, -28 },
  { 1871, 15, 35, 8, -6, -28 },
  { 1937, 19, 28, 16, 0, -28 },
  { 2004, 11, 28, 13, 0, -28 },
  { 2043, 26, 28, 25, 0, -28 },
  { 2134, 21, 28, 20, 0, -28 },
  { 2208, 18, 28, 19, 1, -28 },
  { 2271, 16, 28, 16, 0, -28 },
  { 2327, 18, 35, 19, 1, -28 },
  { 2406, 17, 28, 16, 0, -28 },
  { 2466, 17, 28, 15, -1, -28 },
  { 2526, 13, 28, 13, 3, -28 },
  { 2572, 18, 28, 18, 1, -28 },
  { 2635, 16, 28, 16, 3, -28 },
  { 2691, 26, 28, 25, 3, -28 },
  { 2782, 19, 28, 14, -2, -28 },
  { 2849, 14, 28, 14, 3, -28 },
  { 2898, 17, 28, 13, -2, -28 },
  { 2958, 15, 34, 11, -1, -28 },
  { 3022, 6, 28, 13, 4, -28 },
  { 3043, 15, 34, 11, -3, -28 },
  { 3107, 15, 15, 16, 0, -28 },
  { 3136, 12, 3, 12, -3, 3 },
  { 3141, 5, 6, 10, 6, -30 },
  { 3145, 15, 21, 17, 1, -21 },
  { 3185, 15, 30, 16, 0, -30 },
  { 3242, 13, 21, 12, 1, -21 },
  { 3277, 17, 30, 16, 1, -30 },
  { 3341, 13, 21, 15, 1, -21 },
  { 3376, 19, 39, 9, -5, -30 },
  { 3469, 17, 30, 17, -1, -21 },
  { 3533, 15, 30, 16, 0, -30 },
  { 3590, 9, 29, 7, 0, -29 },
  { 3623, 14, 38, 8, -5, -29 },
  { 3690, 16, 30, 14, 0, -30 },
  { 3750, 9, 30, 7, 0, -30 },
  { 3784, 23, 21, 24, 0, -21 },
  { 3845, 15, 21, 16, 0, -21 },
  { 3885, 14, 21, 16, 1, -21 },
  { 3922, 17, 30, 16, -2, -21 },
  { 3986, 15, 30, 16, 1, -21 },
  { 4043, 13, 21, 11, 0, -21 },
  { 4078, 13, 21, 12, 0, -21 },
  { 4113, 9, 26, 9, 1, -26 },
  { 4143, 15, 21, 16, 1, -21 },
  { 4183, 13, 21, 13, 2, -21 },
  { 4218, 21, 21, 21, 2, -21 },
  { 4274, 17, 21, 13, -2, -21 },
  { 4319, 19, 30, 13, -4, -21 },
  { 4391, 13, 21, 11, -1, -21 },
  { 4426, 14, 34, 13, 1, -28 },
  { 4486, 2, 39, 14, 6, -30 },
  { 4496, 14, 34, 13, -2, -28 },
  { 4556, 14, 5, 17, 2, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Italic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC39PT7B_H_
