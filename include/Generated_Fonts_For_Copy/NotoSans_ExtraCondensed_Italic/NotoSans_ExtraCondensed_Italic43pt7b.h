#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x3C, 0x07, 0x81, 0xF0, 0x1C, 0x00, 0x3C, 0x73, 0x8F, 0x38,
  0xF7, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC6, 0x1C, 0xE1,
  0xC0, 0x00, 0x30, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x30, 0xE0, 0x0E,
  0x1C, 0x01, 0xC3, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x03, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC3,
  0x00, 0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x60,
  0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x1C, 0x00, 0xC3, 0x80,
  0x38, 0x60, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1C, 0xC4, 0x0E, 0x30, 0x03,
  0x88, 0x00, 0xE2, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x03, 0x98, 0x00, 0xF4,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xBC, 0x00, 0x67, 0x00, 0x19, 0xC0, 0x04, 0x70, 0x01, 0x1C, 0x00,
  0xC7, 0x08, 0x33, 0xC3, 0x8D, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x07, 0x80, 0x38, 0x1F, 0x80, 0xE0, 0x77, 0x01, 0xC0, 0xC7, 0x07, 0x03,
  0x8E, 0x0C, 0x06, 0x1C, 0x38, 0x1C, 0x38, 0x60, 0x38, 0x71, 0xC0, 0x70,
  0xC3, 0x00, 0xC3, 0x8E, 0x03, 0x87, 0x18, 0x07, 0x0E, 0x70, 0x0E, 0x18,
  0xC3, 0x9C, 0x73, 0x9F, 0xB8, 0xE6, 0x7F, 0x73, 0x9C, 0xE7, 0xFF, 0x73,
  0x8E, 0xFC, 0xE6, 0x1C, 0xF3, 0x9C, 0x38, 0x07, 0x38, 0x70, 0x1C, 0x70,
  0xC0, 0x38, 0xC3, 0x80, 0xE3, 0x87, 0x01, 0xC7, 0x0E, 0x07, 0x0E, 0x1C,
  0x0E, 0x1C, 0x70, 0x38, 0x38, 0xE0, 0x70, 0x71, 0x81, 0xC0, 0xE7, 0x03,
  0x80, 0xFC, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x01, 0xE7, 0x00, 0x79, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE1, 0xC7, 0x78, 0xF3, 0x8E,
  0x39, 0xE3, 0xCE, 0x70, 0xF7, 0x3C, 0x1D, 0xCE, 0x07, 0xF3, 0x81, 0xF8,
  0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x07, 0xC3, 0xC3, 0xF8, 0xFF, 0xFE, 0x1F,
  0xF7, 0x83, 0xF0, 0xF0, 0x3C, 0xF3, 0x8E, 0x39, 0xE7, 0x1C, 0x71, 0x8E,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x87, 0x06,
  0x30, 0x7D, 0x9D, 0xFF, 0xE1, 0xFF, 0x0F, 0x00, 0xEC, 0x0F, 0x70, 0xF3,
  0x83, 0x0E, 0x08, 0x60, 0x02, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x0E,
  0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x33, 0xDF, 0xF7, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x8E, 0x07, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0xF0,
  0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0,
  0x70, 0xE0, 0xF0, 0xE0, 0xE0, 0xF1, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x87, 0xF1, 0xFC, 0x7B, 0x9E, 0x77, 0x9E,
  0x23, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x0E, 0x1E, 0x03, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x0E, 0x1F, 0x02, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC2, 0x01, 0xE0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0xDE, 0x00, 0x77,
  0x00, 0x39, 0xC0, 0x0C, 0x70, 0x07, 0x3C, 0x01, 0x8E, 0x00, 0xE3, 0x80,
  0x70, 0xE0, 0x18, 0x38, 0x0E, 0x1E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0,
  0x70, 0x70, 0x3C, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x10, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x10,
  0x1E, 0x0F, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x9F, 0x03,
  0xDF, 0xC1, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x1C, 0x3C, 0x0E, 0x3C, 0x07,
  0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0xF1, 0xC0, 0x78, 0xE0,
  0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x1E, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xF0, 0xF0, 0x70, 0x38, 0x78,
  0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0xC3, 0xC3, 0xC0,
  0xE1, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0x3C, 0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0x80,
  0x79, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1E, 0x0F, 0x07,
  0xDF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0xF1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x38, 0x1E, 0x3C, 0x0F, 0x1C,
  0x07, 0x8E, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x78,
  0xF0, 0x7C, 0x38, 0x3E, 0x1F, 0x7F, 0x0F, 0xF7, 0x03, 0xF3, 0x80, 0xE1,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0x07, 0xC3, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x0F, 0x87,
  0x83, 0xC0, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0xFF, 0x87, 0xFE, 0x30, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x78, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00,
  0x07, 0x0E, 0x06, 0x07, 0x1C, 0x1F, 0xC7, 0x1C, 0x3F, 0xC7, 0x18, 0x71,
  0xC7, 0x38, 0x61, 0x87, 0x30, 0xE3, 0x86, 0x70, 0xC3, 0x86, 0x71, 0xC3,
  0x86, 0x61, 0xC3, 0x0E, 0x61, 0x87, 0x0E, 0x61, 0x87, 0x0C, 0xE3, 0x87,
  0x0C, 0xE3, 0x86, 0x1C, 0xE3, 0x8E, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x9F,
  0x70, 0xE1, 0xF3, 0xE0, 0xE1, 0xE3, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x04,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0xCE, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x07, 0x0F, 0x03, 0xC3,
  0xC0, 0xE0, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xC0, 0xF0,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xC3, 0xE0, 0x38, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x38, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81,
  0xC0, 0xE0, 0x78, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1E, 0x3E,
  0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xC0, 0x78,
  0x38, 0x3E, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0x04, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x40, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xCF, 0xE0, 0x38, 0x3E, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80,
  0x70, 0xE0, 0x0E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0x80, 0x38, 0x70, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x70, 0x0F,
  0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xC0, 0xF0,
  0x38, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3E, 0x0E, 0x07, 0x80, 0x20, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xFC, 0xF0, 0x3F,
  0x8E, 0x03, 0xF8, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0xF0,
  0x0E, 0x07, 0x80, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03,
  0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x70, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x0E,
  0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1C, 0x07,
  0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x38, 0x3C, 0x03,
  0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x38, 0xF0,
  0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x9C, 0x00,
  0x78, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x07,
  0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x78, 0x07,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xEE, 0x01, 0xFC,
  0x07, 0x70, 0x0E, 0xE0, 0x3B, 0x80, 0xFF, 0x03, 0xDC, 0x07, 0x78, 0x1C,
  0xE0, 0x3B, 0x80, 0xE7, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0xE0, 0x79, 0xC1,
  0xCF, 0x03, 0xCE, 0x0E, 0x78, 0x1C, 0x70, 0xE3, 0x80, 0xE3, 0x87, 0x1C,
  0x07, 0x1C, 0x79, 0xE0, 0x78, 0xE3, 0x8F, 0x03, 0xC7, 0x3C, 0x70, 0x1C,
  0x39, 0xC3, 0x80, 0xE1, 0xCE, 0x1C, 0x07, 0x0E, 0xE1, 0xE0, 0x78, 0x77,
  0x0F, 0x03, 0x83, 0xF0, 0x70, 0x1C, 0x1F, 0x83, 0x80, 0xE0, 0xF8, 0x1C,
  0x07, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x00,
  0x03, 0xE0, 0x0E, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0xE0,
  0x3E, 0x01, 0xC0, 0xFC, 0x03, 0x81, 0xDC, 0x0F, 0x03, 0xB8, 0x1E, 0x07,
  0x70, 0x38, 0x0E, 0xE0, 0x70, 0x3D, 0xC0, 0xE0, 0x73, 0x83, 0xC0, 0xE3,
  0x87, 0x01, 0xC7, 0x0E, 0x07, 0x8E, 0x1C, 0x0F, 0x1C, 0x78, 0x1C, 0x38,
  0xF0, 0x38, 0x71, 0xC0, 0x70, 0x73, 0x81, 0xE0, 0xE7, 0x03, 0xC1, 0xDE,
  0x07, 0x03, 0xBC, 0x0E, 0x07, 0x70, 0x1C, 0x0E, 0xE0, 0x78, 0x1F, 0xC0,
  0xE0, 0x1F, 0x81, 0xC0, 0x3E, 0x03, 0x80, 0x7C, 0x07, 0x00, 0xF8, 0x1E,
  0x01, 0xF0, 0x38, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3E, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xF0,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00,
  0x38, 0xF0, 0x07, 0x87, 0x00, 0x78, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0E, 0x7E, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0E, 0x03, 0x83, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0xFC,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x3C,
  0x70, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x87, 0x00, 0x78, 0x70, 0x0F,
  0x07, 0x00, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0E, 0x3E, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E,
  0x0E, 0x07, 0x83, 0x81, 0xE1, 0xE1, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFC, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0x70, 0x0E, 0x1E, 0x03, 0x87,
  0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1E, 0x0F, 0x07, 0x03, 0xC1, 0xC0, 0xF0,
  0x70, 0x3C, 0x3C, 0x07, 0x0F, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x0F, 0xFF, 0x01, 0xF0, 0xE0, 0x78, 0x04, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x82, 0x00, 0xF0, 0x70,
  0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFC, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x70, 0x78,
  0x07, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0, 0x1C, 0x1E, 0x01, 0xC1,
  0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x38,
  0x38, 0x07, 0x83, 0x80, 0x78, 0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07,
  0x07, 0x00, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0x70, 0x3C, 0x07, 0x83, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x01,
  0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x3C, 0x38,
  0x1E, 0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x03, 0x87, 0x81, 0xC3, 0x80,
  0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x78,
  0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x77,
  0x00, 0x70, 0x0F, 0x70, 0x0F, 0x00, 0xF7, 0x00, 0xF0, 0x0E, 0x70, 0x1F,
  0x01, 0xE7, 0x01, 0xF0, 0x1C, 0x70, 0x1F, 0x01, 0xC7, 0x03, 0xF0, 0x3C,
  0x70, 0x3F, 0x03, 0x87, 0x07, 0x70, 0x78, 0xF0, 0x77, 0x07, 0x0F, 0x07,
  0x70, 0x70, 0xF0, 0xE7, 0x0F, 0x0F, 0x0E, 0x70, 0xE0, 0xF1, 0xC7, 0x1E,
  0x0F, 0x1C, 0x71, 0xC0, 0xF1, 0xC7, 0x1C, 0x0F, 0x38, 0x73, 0xC0, 0xF3,
  0x87, 0x38, 0x0F, 0x38, 0x77, 0x80, 0xF7, 0x06, 0x70, 0x0E, 0x70, 0x67,
  0x00, 0xEE, 0x06, 0xF0, 0x0E, 0xE0, 0xEE, 0x00, 0xEE, 0x0E, 0xE0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x3C,
  0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x77, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xE0,
  0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x0F,
  0x03, 0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x70,
  0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x78,
  0x78, 0x78, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B,
  0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0x3C, 0x07, 0x8E, 0x03, 0x87,
  0x03, 0x83, 0x81, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0xF0,
  0x07, 0xF0, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0xF1, 0xE7, 0x8E, 0x38,
  0x70, 0xC0, 0x03, 0xF3, 0x83, 0xFD, 0xC3, 0xFF, 0xE3, 0xE1, 0xE1, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0E, 0x3C, 0x07, 0x1C,
  0x03, 0x8E, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x78,
  0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x07, 0xFB, 0x83, 0xF9,
  0xC0, 0xF8, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xCF, 0x81, 0xEF, 0xE0, 0xFE, 0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E,
  0x07, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0x79,
  0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xE1, 0xE3, 0xFB, 0xE1, 0xDF, 0xE0, 0xE7,
  0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x10, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xCE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x01, 0xC1, 0xE0, 0x38, 0x3C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x3C,
  0x07, 0x07, 0x80, 0xE0, 0xF0, 0x1C, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0x70,
  0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x1E, 0xEE, 0x03, 0xF9, 0x80, 0x3E,
  0x70, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3E, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7,
  0x83, 0xCE, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xE1, 0xF1, 0xFF, 0xC7, 0xFE,
  0x0F, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x87, 0xCE, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0xE0, 0x3F, 0xDC, 0x0F, 0xFF, 0x81, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x70, 0x1C, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x0E,
  0x0E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x0E, 0x0F, 0x01, 0xC1, 0xE0, 0x78,
  0x38, 0x0F, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x1F, 0x01, 0xFF, 0xE0,
  0x3F, 0xBC, 0x03, 0xE7, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x81, 0x01, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x7E, 0x07, 0xFF, 0x0E, 0xFF, 0x0F, 0x87, 0x0F, 0x07, 0x0F,
  0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C,
  0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x78, 0x00,
  0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0x80, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0xF0, 0x38, 0xF0, 0x1C,
  0x70, 0x0E, 0x78, 0x0F, 0x78, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFB, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x1C, 0x78, 0x1E, 0x3C,
  0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xE0, 0xF0, 0xE0,
  0x78, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x7E, 0x3F, 0x03,
  0x7F, 0xBF, 0xC3, 0xBF, 0xFF, 0xE1, 0xF0, 0xF8, 0x70, 0xF0, 0x78, 0x38,
  0x70, 0x38, 0x1C, 0x78, 0x1C, 0x0E, 0x3C, 0x1E, 0x0F, 0x1C, 0x0F, 0x07,
  0x0E, 0x07, 0x03, 0x87, 0x03, 0x81, 0xC7, 0x81, 0xC0, 0xE3, 0xC1, 0xE0,
  0xF1, 0xC0, 0xF0, 0x70, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1C, 0x78, 0x1C,
  0x1E, 0x38, 0x1E, 0x0F, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0x8F, 0x03,
  0x81, 0xC7, 0x83, 0xC1, 0xE3, 0x81, 0xE0, 0xF0, 0x07, 0x7E, 0x06, 0xFF,
  0x0E, 0xFF, 0x0F, 0x87, 0x0F, 0x07, 0x0F, 0x07, 0x1E, 0x07, 0x1E, 0x07,
  0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E,
  0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38,
  0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x78, 0x03, 0xF8, 0x0F, 0xF8, 0x3E, 0xF8,
  0x70, 0xF1, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x70, 0x1E,
  0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE7, 0x87, 0x87, 0xFE, 0x0F, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0xCF, 0x80, 0x33, 0xF8, 0x0E, 0xEF, 0x81, 0xF0, 0xF0,
  0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x07, 0x01, 0xE0,
  0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83,
  0x80, 0xF0, 0x70, 0x1C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0E, 0x7E, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0x83,
  0xFD, 0xC3, 0xFF, 0xE1, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0xCF, 0x01,
  0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x3C, 0x3C,
  0x1E, 0x1E, 0x1F, 0x0F, 0xFF, 0x83, 0xFB, 0xC0, 0xF9, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x06, 0x7C, 0x1B, 0xE0,
  0xEF, 0x83, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0xF8, 0x3F, 0xF1, 0xF3, 0x87, 0x02, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x20, 0x78,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x3F, 0xCF, 0xF3, 0xFE, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x0E, 0x07, 0x8F,
  0x03, 0x87, 0x81, 0xC3, 0x81, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0xF0, 0x38,
  0x78, 0x1C, 0x38, 0x1E, 0x1C, 0x0F, 0x0E, 0x07, 0x0F, 0x03, 0x87, 0x01,
  0xC3, 0x81, 0xE1, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x3E, 0x1E, 0x1E, 0x0F, 0xFF, 0x03, 0xFB, 0x81, 0xF9, 0xC0, 0xE0, 0x3F,
  0x80, 0xEE, 0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x70,
  0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0,
  0x3B, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x70, 0x3C, 0x0E, 0xE0, 0x78, 0x3D, 0xC1, 0xF0, 0x73,
  0x83, 0xE0, 0xE7, 0x0F, 0xC3, 0xCE, 0x1F, 0x87, 0x1C, 0x37, 0x0E, 0x38,
  0xEE, 0x38, 0x71, 0xDC, 0x70, 0xE7, 0x39, 0xE1, 0xCE, 0x73, 0x87, 0x98,
  0xE7, 0x0F, 0x71, 0xDC, 0x1E, 0xE3, 0x38, 0x3B, 0x86, 0xF0, 0x77, 0x0D,
  0xC0, 0xEE, 0x1B, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xF3, 0x80,
  0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0E, 0x70,
  0x07, 0x9E, 0x01, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x0F,
  0x03, 0xC0, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x81,
  0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x01,
  0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0,
  0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x3C, 0x01, 0xFF, 0x03, 0xFF, 0xEF, 0xC3, 0xFF, 0x80, 0xFE,
  0x80, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 31, 10, 0, -31 },
  { 44, 12, 11, 15, 4, -31 },
  { 61, 19, 31, 18, 0, -31 },
  { 135, 18, 36, 17, 0, -33 },
  { 216, 23, 31, 26, 2, -31 },
  { 306, 18, 31, 18, 0, -31 },
  { 376, 6, 11, 8, 4, -31 },
  { 385, 13, 38, 11, 1, -31 },
  { 447, 13, 38, 11, -3, -31 },
  { 509, 13, 15, 16, 4, -33 },
  { 534, 16, 20, 18, 2, -25 },
  { 574, 8, 11, 9, -2, -5 },
  { 585, 9, 3, 11, 1, -13 },
  { 589, 5, 5, 9, 0, -5 },
  { 593, 20, 31, 14, -2, -31 },
  { 671, 16, 31, 17, 1, -31 },
  { 733, 11, 31, 17, 4, -31 },
  { 776, 18, 31, 17, -1, -31 },
  { 846, 18, 31, 17, -1, -31 },
  { 916, 18, 31, 17, -1, -31 },
  { 986, 17, 31, 17, 0, -31 },
  { 1052, 17, 31, 17, 1, -31 },
  { 1118, 18, 31, 17, 1, -31 },
  { 1188, 17, 31, 17, 0, -31 },
  { 1254, 17, 31, 17, 0, -31 },
  { 1320, 9, 23, 9, 0, -23 },
  { 1346, 11, 29, 9, -2, -23 },
  { 1386, 16, 19, 18, 2, -25 },
  { 1424, 16, 12, 18, 2, -21 },
  { 1448, 16, 19, 18, 2, -25 },
  { 1486, 13, 31, 12, 1, -31 },
  { 1537, 24, 35, 25, 1, -31 },
  { 1642, 18, 31, 17, -3, -31 },
  { 1712, 19, 31, 18, 0, -31 },
  { 1786, 18, 31, 17, 2, -31 },
  { 1856, 19, 31, 20, 0, -31 },
  { 1930, 18, 31, 16, 0, -31 },
  { 2000, 18, 31, 15, 0, -31 },
  { 2070, 20, 31, 21, 2, -31 },
  { 2148, 22, 31, 21, 0, -31 },
  { 2234, 16, 31, 11, -2, -31 },
  { 2296, 16, 39, 9, -6, -31 },
  { 2374, 21, 31, 17, 0, -31 },
  { 2456, 12, 31, 14, 0, -31 },
  { 2503, 29, 31, 28, 0, -31 },
  { 2616, 23, 31, 22, 0, -31 },
  { 2706, 20, 31, 21, 1, -31 },
  { 2784, 18, 31, 17, 0, -31 },
  { 2854, 20, 38, 21, 1, -31 },
  { 2949, 18, 31, 18, 0, -31 },
  { 3019, 19, 31, 16, -1, -31 },
  { 3093, 15, 31, 15, 3, -31 },
  { 3152, 20, 31, 20, 1, -31 },
  { 3230, 17, 31, 17, 4, -31 },
  { 3296, 28, 31, 28, 3, -31 },
  { 3405, 22, 31, 16, -3, -31 },
  { 3491, 16, 31, 15, 3, -31 },
  { 3553, 19, 31, 14, -2, -31 },
  { 3627, 16, 38, 12, -1, -31 },
  { 3703, 7, 31, 15, 4, -31 },
  { 3731, 16, 38, 12, -3, -31 },
  { 3807, 17, 17, 17, 0, -31 },
  { 3844, 14, 2, 13, -4, 4 },
  { 3848, 6, 7, 11, 6, -33 },
  { 3854, 17, 23, 18, 1, -23 },
  { 3903, 17, 33, 18, 0, -33 },
  { 3974, 14, 23, 14, 1, -23 },
  { 4015, 19, 33, 18, 1, -33 },
  { 4094, 15, 23, 16, 1, -23 },
  { 4138, 20, 43, 10, -5, -33 },
  { 4246, 19, 33, 18, -1, -23 },
  { 4325, 16, 33, 18, 0, -33 },
  { 4391, 10, 32, 8, 0, -32 },
  { 4431, 16, 42, 8, -6, -32 },
  { 4515, 17, 33, 16, 0, -33 },
  { 4586, 10, 33, 8, 0, -33 },
  { 4628, 25, 23, 26, 0, -23 },
  { 4700, 16, 23, 18, 0, -23 },
  { 4746, 15, 23, 18, 1, -23 },
  { 4790, 19, 33, 18, -2, -23 },
  { 4869, 17, 33, 18, 1, -23 },
  { 4940, 14, 23, 12, 0, -23 },
  { 4981, 14, 23, 14, 0, -23 },
  { 5022, 11, 28, 10, 1, -28 },
  { 5061, 17, 23, 18, 1, -23 },
  { 5110, 14, 23, 14, 3, -23 },
  { 5151, 23, 23, 23, 2, -23 },
  { 5218, 18, 23, 15, -2, -23 },
  { 5270, 21, 33, 15, -4, -23 },
  { 5357, 15, 23, 12, -2, -23 },
  { 5401, 16, 38, 14, 1, -31 },
  { 5477, 3, 43, 16, 6, -33 },
  { 5494, 16, 38, 14, -3, -31 },
  { 5570, 16, 6, 18, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Italic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC43PT7B_H_
