#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x1E, 0x7C, 0x3C, 0xF8, 0xF9, 0xE1,
  0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xF0, 0xF1,
  0xE1, 0xE3, 0x83, 0x87, 0x07, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x70, 0x78, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xE0, 0xE0, 0x01, 0xE1, 0xE0, 0x01,
  0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0x80, 0x03,
  0x83, 0x80, 0x07, 0x87, 0x80, 0x07, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C,
  0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xF6, 0x78, 0x1F, 0x18, 0x40, 0x78, 0xE0, 0x01,
  0xE3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xE7,
  0x00, 0x07, 0x98, 0x00, 0x1F, 0x60, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0x9F, 0x00, 0x06, 0x3C, 0x00, 0x18, 0xF0, 0x00, 0x63,
  0xC0, 0x03, 0x8F, 0x00, 0x0C, 0x3C, 0x00, 0x30, 0xF0, 0x80, 0xC7, 0x83,
  0x03, 0x3E, 0x0F, 0xDF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x7F, 0x00,
  0x78, 0x0F, 0xF0, 0x07, 0x01, 0xE7, 0x80, 0xF0, 0x1C, 0x38, 0x0E, 0x03,
  0xC3, 0x81, 0xE0, 0x38, 0x38, 0x1C, 0x07, 0x83, 0x83, 0xC0, 0x70, 0x78,
  0x38, 0x07, 0x07, 0x87, 0x80, 0x70, 0x78, 0x70, 0x0F, 0x07, 0x0F, 0x00,
  0xF0, 0x70, 0xE0, 0x0E, 0x07, 0x1E, 0x00, 0xE0, 0xF1, 0xC0, 0x0E, 0x0E,
  0x3C, 0x30, 0xE0, 0xE3, 0x8F, 0xEE, 0x1E, 0x79, 0xFE, 0xE1, 0xC7, 0x1F,
  0xFE, 0x3C, 0xF3, 0xCF, 0xF7, 0x8E, 0x38, 0x7F, 0xF9, 0xE7, 0x07, 0x7F,
  0x1C, 0x70, 0x73, 0xC3, 0xCF, 0x07, 0x00, 0x38, 0xE0, 0xF0, 0x07, 0x0E,
  0x0F, 0x00, 0xF1, 0xE0, 0xF0, 0x0E, 0x1E, 0x0E, 0x01, 0xE1, 0xC0, 0xE0,
  0x1C, 0x1C, 0x1E, 0x03, 0xC1, 0xC1, 0xE0, 0x38, 0x1C, 0x1C, 0x07, 0x81,
  0xC1, 0xC0, 0x70, 0x1C, 0x3C, 0x0F, 0x01, 0xC3, 0x80, 0xE0, 0x1C, 0x78,
  0x1E, 0x01, 0xFF, 0x01, 0xC0, 0x1F, 0xE0, 0x3C, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3E,
  0x78, 0x00, 0xF1, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0xF1, 0xF3, 0xC3, 0xCF, 0x8F, 0x1F, 0x3C, 0x3E, 0x79, 0xE0,
  0xF9, 0xE7, 0x81, 0xEF, 0x3E, 0x07, 0xBC, 0xF0, 0x1F, 0xE3, 0xC0, 0x3F,
  0x8F, 0x00, 0xFC, 0x3C, 0x03, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x7F, 0x0F,
  0x83, 0xFC, 0x3F, 0x1F, 0xF8, 0x7F, 0xFB, 0xE1, 0xFF, 0xC7, 0x83, 0xFC,
  0x1F, 0x00, 0x80, 0x00, 0x3C, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0xF3, 0xCF,
  0x3C, 0xE3, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x06,
  0x1E, 0x03, 0xCE, 0x01, 0xFF, 0x1D, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xC1, 0xF8, 0x01, 0xFC, 0x01, 0xE7, 0x01, 0xF3, 0xC1, 0xF1, 0xE0, 0x70,
  0x78, 0x10, 0x38, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E,
  0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x01, 0xF1, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0xDF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0xF8, 0xFB, 0xCF, 0xBE, 0xF9, 0xE7, 0x8F, 0x18, 0x78,
  0x87, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x07,
  0xE0, 0x0C, 0x07, 0xC0, 0x10, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x01, 0xE0, 0x7C, 0x02, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x08, 0x01, 0xF0, 0x3C, 0x1F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xDE, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xE0, 0x01, 0xEF, 0x00,
  0x07, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x3C,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xE0, 0xF0,
  0x07, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x30, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0x00, 0x7E, 0x07, 0x83, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xCF, 0xE0, 0x3C, 0xFF, 0x81, 0xEF, 0xFC, 0x0F,
  0xF7, 0xF0, 0xFE, 0x0F, 0x87, 0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F,
  0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0,
  0x07, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0,
  0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xFC, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF9, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xE0, 0x7C, 0x07,
  0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1E, 0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x03,
  0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x1F,
  0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x0F, 0xE1, 0xF8,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xF7, 0x80, 0xFF, 0x3C, 0x01, 0xE3, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x01, 0x87, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x38, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xE0,
  0xF8, 0x40, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xE0, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x7F, 0x87, 0x0F, 0x03,
  0xFE, 0x1C, 0x38, 0x1F, 0xF8, 0x71, 0xE0, 0xE1, 0xC1, 0xC7, 0x07, 0x87,
  0x07, 0x1C, 0x1C, 0x1C, 0x1C, 0xF0, 0xF0, 0xF0, 0xF3, 0x83, 0x83, 0x83,
  0x8E, 0x1E, 0x0E, 0x0E, 0x38, 0x70, 0x38, 0x39, 0xE1, 0xC1, 0xE0, 0xE7,
  0x07, 0x07, 0x07, 0x9C, 0x3C, 0x1C, 0x1C, 0x70, 0xF0, 0xF0, 0x71, 0xC3,
  0x83, 0xC3, 0x87, 0x0E, 0x0F, 0x0E, 0x3C, 0x38, 0x78, 0x38, 0xF0, 0xE1,
  0xE1, 0xC3, 0xC3, 0xCD, 0xCE, 0x0E, 0x07, 0xF7, 0xF8, 0x38, 0x1F, 0x8F,
  0xC0, 0xF0, 0x3C, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x10, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3,
  0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80,
  0x0F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xF0,
  0xFE, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x3E, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x81,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3E, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x78, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0x80, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x08, 0x01,
  0xF8, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xF1, 0xFE, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3F, 0x01,
  0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x0F, 0x03,
  0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x3E,
  0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C,
  0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0x78, 0x3F, 0x80, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFC, 0x07, 0x00, 0x7C, 0x00, 0x40, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x1F, 0xF8, 0xF8, 0x07, 0xFC, 0x3E, 0x01, 0xFF, 0x0F, 0x80,
  0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3C,
  0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x07, 0xE0, 0x1E, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x07, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x07, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFE, 0x03, 0xDC,
  0x00, 0x3F, 0xC0, 0x3D, 0xE0, 0x03, 0xFC, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x3D, 0xE0, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xF7, 0xC0, 0x7D, 0xE0, 0x0F,
  0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x03, 0xCF, 0x80, 0x79, 0xE0, 0x3C, 0xF8, 0x0F, 0x1E, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x78, 0xF0, 0x0F, 0x1E, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0xF1,
  0xF0, 0x1F, 0x1E, 0x0F, 0x1E, 0x01, 0xE1, 0xE1, 0xE1, 0xE0, 0x1E, 0x1E,
  0x1E, 0x1E, 0x01, 0xE1, 0xE3, 0xC1, 0xE0, 0x1E, 0x1E, 0x3C, 0x3E, 0x03,
  0xE1, 0xE7, 0x83, 0xC0, 0x3C, 0x1E, 0x78, 0x3C, 0x03, 0xC1, 0xE7, 0x03,
  0xC0, 0x3C, 0x0E, 0xF0, 0x7C, 0x03, 0xC0, 0xEF, 0x07, 0xC0, 0x7C, 0x0F,
  0xE0, 0x78, 0x07, 0x80, 0xFE, 0x07, 0x80, 0x78, 0x0F, 0xC0, 0x78, 0x07,
  0x80, 0xFC, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0,
  0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xC0, 0x0F,
  0x00, 0xFE, 0x00, 0x78, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0x3C, 0x03,
  0xDE, 0x01, 0xE0, 0x1E, 0xF0, 0x0F, 0x00, 0xF7, 0x80, 0x78, 0x07, 0xBC,
  0x07, 0xC0, 0x3D, 0xE0, 0x3C, 0x03, 0xE7, 0x01, 0xE0, 0x1E, 0x3C, 0x0F,
  0x00, 0xF1, 0xE0, 0x78, 0x07, 0x8F, 0x07, 0xC0, 0x3C, 0x78, 0x3C, 0x03,
  0xC3, 0xC1, 0xE0, 0x1E, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0xF8, 0x07, 0x83,
  0xC7, 0x80, 0x7C, 0x1E, 0x3C, 0x03, 0xC0, 0xF1, 0xE0, 0x1E, 0x07, 0x8F,
  0x00, 0xF0, 0x1C, 0xF8, 0x07, 0x80, 0xF7, 0x80, 0x7C, 0x07, 0xBC, 0x03,
  0xC0, 0x3D, 0xE0, 0x1E, 0x01, 0xEF, 0x00, 0xF0, 0x0F, 0x78, 0x07, 0x80,
  0x3F, 0x80, 0x7C, 0x01, 0xFC, 0x03, 0xC0, 0x0F, 0xE0, 0x1E, 0x00, 0x7F,
  0x00, 0xF0, 0x03, 0xF0, 0x07, 0x80, 0x1F, 0x80, 0x78, 0x00, 0x7C, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x7F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0x3F, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF8,
  0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03,
  0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78,
  0x3F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0x1F, 0xC0,
  0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF8,
  0x07, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x03,
  0xF0, 0x3E, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3E, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F,
  0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x81, 0xC0, 0x7E, 0x00, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC1, 0x00, 0x1F, 0x03, 0x80, 0x7E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0xF8, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0xF8,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0,
  0x3C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3E,
  0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x1F,
  0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80,
  0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83,
  0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1F,
  0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0x00, 0x1E, 0x78, 0x01, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x00, 0x3C,
  0x78, 0x01, 0xF0, 0x07, 0xC7, 0x80, 0x3F, 0x00, 0x7C, 0x78, 0x03, 0xF0,
  0x07, 0x87, 0x80, 0x7F, 0x00, 0xF8, 0xF8, 0x07, 0xF0, 0x0F, 0x0F, 0x80,
  0x7F, 0x00, 0xF0, 0xF8, 0x0F, 0xF0, 0x1F, 0x0F, 0x80, 0xEF, 0x01, 0xE0,
  0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x81, 0xEF, 0x03, 0xC0, 0xF8, 0x1C, 0xF0,
  0x3C, 0x0F, 0x03, 0xCF, 0x07, 0xC0, 0xF0, 0x3C, 0xF0, 0x78, 0x0F, 0x07,
  0x8F, 0x0F, 0x80, 0xF0, 0x78, 0xE0, 0xF0, 0x0F, 0x07, 0x0E, 0x0F, 0x00,
  0xF0, 0xF0, 0xE1, 0xF0, 0x0F, 0x0F, 0x0E, 0x1E, 0x00, 0xF0, 0xE0, 0xE3,
  0xE0, 0x0F, 0x1E, 0x0E, 0x3C, 0x00, 0xF1, 0xC0, 0xE3, 0xC0, 0x0F, 0x3C,
  0x0E, 0x7C, 0x00, 0xF3, 0xC0, 0xE7, 0x80, 0x0F, 0x38, 0x0E, 0x78, 0x00,
  0xF7, 0x81, 0xEF, 0x00, 0x0F, 0x78, 0x1E, 0xF0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x00,
  0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x00, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C,
  0x78, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x1F,
  0x03, 0xC1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7,
  0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x10, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF0, 0x38, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0xF0, 0x00, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF9, 0xF1, 0xE3, 0xE3, 0xC3, 0x87, 0x87, 0x00, 0xFE, 0x3C, 0x07,
  0xFC, 0xE0, 0x3F, 0xF7, 0x81, 0xF8, 0xFE, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0xE0, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E,
  0x07, 0xE0, 0x78, 0x3F, 0x81, 0xF1, 0xFC, 0x07, 0xFE, 0xF0, 0x0F, 0xF3,
  0xC0, 0x1F, 0x8F, 0x00, 0x08, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x7E, 0x01, 0xEF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF7,
  0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00,
  0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F,
  0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x8F, 0x83, 0xDF,
  0xFC, 0x1E, 0x7F, 0xC0, 0xF1, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0x84, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x08, 0x1F, 0x8E, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x7C, 0x01, 0xFF, 0x78,
  0x03, 0xFF, 0x78, 0x07, 0xE3, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0,
  0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x78, 0x3F, 0x80, 0x7C, 0x7F, 0x00,
  0x7F, 0xEF, 0x00, 0x3F, 0xCF, 0x00, 0x1F, 0x8F, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF1, 0xE0, 0x78, 0x1E,
  0x1F, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC7, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03,
  0xFE, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x02, 0x0F,
  0xC1, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xE4, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0x00,
  0x7F, 0xCE, 0x00, 0xFF, 0xDE, 0x01, 0xF8, 0xFE, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0x7E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x1F,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x1E, 0x0F, 0xE0, 0x1F,
  0x1F, 0xC0, 0x1F, 0xFB, 0xC0, 0x0F, 0xFB, 0xC0, 0x07, 0xE3, 0xC0, 0x01,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x3E, 0x00, 0xC0,
  0x7E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xFE,
  0x01, 0xEF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0x3F, 0x07, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78,
  0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C,
  0x0F, 0x01, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x1F, 0x00, 0x78, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xEF,
  0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x80,
  0x3C, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xCF, 0xE1, 0xFC,
  0x03, 0x9F, 0xF3, 0xFE, 0x03, 0xBF, 0xF7, 0xFE, 0x07, 0xF9, 0xFF, 0x3E,
  0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E,
  0x0F, 0x01, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x3C,
  0x1E, 0x01, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x1E, 0x03, 0xE0, 0x3C,
  0x1E, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC0, 0x78,
  0x3C, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x80, 0xF0,
  0x7C, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x80, 0xF0,
  0x78, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xE0,
  0xF0, 0x1F, 0x01, 0xE0, 0x03, 0xCF, 0xE0, 0x1C, 0xFF, 0x80, 0xEF, 0xFC,
  0x0F, 0xF3, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF0,
  0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE1,
  0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03,
  0xE1, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x3E, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1E,
  0x0F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01,
  0xF3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x78, 0x1E, 0x07,
  0xC7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x10, 0x00,
  0x00, 0x78, 0xFC, 0x00, 0x73, 0xFE, 0x00, 0x77, 0xFE, 0x00, 0xF7, 0x1F,
  0x00, 0xFC, 0x0F, 0x00, 0xFC, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1E,
  0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0xC1, 0xF0, 0x0F, 0xE3, 0xE0, 0x0F, 0xFF, 0xE0, 0x1E, 0x7F, 0xC0,
  0x1E, 0x3F, 0x00, 0x1E, 0x08, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x3C, 0x07, 0xFC, 0xE0,
  0x3F, 0xF7, 0x81, 0xF8, 0xFE, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE0, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1E,
  0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE0,
  0x78, 0x3F, 0x81, 0xF1, 0xFC, 0x07, 0xFE, 0xF0, 0x0F, 0xF3, 0xC0, 0x1F,
  0x9F, 0x00, 0x10, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x8F, 0x81, 0xCF, 0xC0, 0xEF, 0xE0, 0xF7, 0xE0, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xE0, 0xE0, 0xF8, 0x08, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x80, 0x7C, 0x1E, 0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x01, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x87, 0xF8, 0x1F,
  0xC0, 0x7E, 0x00, 0x80, 0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0,
  0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC3,
  0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0xC3, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C,
  0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8,
  0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xE7,
  0xF8, 0x1F, 0xFB, 0x80, 0xFF, 0x9C, 0x03, 0xF8, 0xE0, 0x06, 0x00, 0x00,
  0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0x77, 0x80, 0x1D,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C,
  0x07, 0xBC, 0x07, 0xE0, 0x3D, 0xE0, 0x3F, 0x03, 0xEF, 0x01, 0xF8, 0x1E,
  0x78, 0x1F, 0xC0, 0xF3, 0xC0, 0xFE, 0x0F, 0x1E, 0x0F, 0xF0, 0x78, 0xF0,
  0x77, 0x87, 0xC7, 0x83, 0xBC, 0x3C, 0x3C, 0x3D, 0xE1, 0xE1, 0xE1, 0xCF,
  0x1E, 0x0F, 0x1E, 0x78, 0xF0, 0x78, 0xF3, 0xC7, 0x83, 0xC7, 0x1E, 0x78,
  0x1E, 0x78, 0xE3, 0xC0, 0xF3, 0x87, 0x3C, 0x07, 0xBC, 0x39, 0xE0, 0x3D,
  0xE1, 0xCF, 0x01, 0xEE, 0x0E, 0xF0, 0x0F, 0xF0, 0x77, 0x80, 0x7F, 0x03,
  0xB8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F,
  0x80, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x81,
  0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8,
  0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x13, 0xF8, 0x01, 0x7F, 0xE0, 0x3F, 0xFF,
  0xEF, 0xF3, 0xFF, 0xFC, 0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 39, 13, 1, -39 },
  { 65, 15, 14, 18, 5, -39 },
  { 92, 24, 39, 23, 0, -39 },
  { 209, 22, 44, 21, 0, -41 },
  { 330, 28, 40, 33, 3, -39 },
  { 470, 22, 40, 23, 0, -39 },
  { 580, 6, 14, 10, 6, -39 },
  { 591, 16, 48, 14, 1, -39 },
  { 687, 16, 48, 14, -4, -39 },
  { 783, 17, 18, 20, 5, -41 },
  { 822, 20, 26, 23, 2, -32 },
  { 887, 9, 13, 11, -2, -6 },
  { 902, 12, 4, 14, 1, -17 },
  { 908, 5, 6, 11, 1, -6 },
  { 912, 25, 39, 18, -3, -39 },
  { 1034, 20, 40, 21, 1, -39 },
  { 1134, 13, 39, 21, 6, -39 },
  { 1198, 23, 39, 21, -2, -39 },
  { 1311, 22, 40, 21, -1, -39 },
  { 1421, 22, 39, 21, -1, -39 },
  { 1529, 23, 40, 21, -1, -39 },
  { 1644, 21, 40, 21, 1, -39 },
  { 1749, 21, 39, 21, 2, -39 },
  { 1852, 22, 40, 21, 0, -39 },
  { 1962, 21, 40, 21, 0, -39 },
  { 2067, 11, 29, 11, 0, -29 },
  { 2107, 14, 36, 11, -3, -29 },
  { 2170, 20, 24, 23, 2, -31 },
  { 2230, 20, 16, 23, 2, -27 },
  { 2270, 20, 24, 23, 2, -31 },
  { 2330, 17, 39, 16, 1, -39 },
  { 2413, 30, 44, 32, 1, -39 },
  { 2578, 22, 39, 22, -4, -39 },
  { 2686, 24, 39, 23, 0, -39 },
  { 2803, 23, 40, 21, 2, -39 },
  { 2918, 24, 39, 25, 0, -39 },
  { 3035, 22, 39, 20, 0, -39 },
  { 3143, 22, 39, 19, 0, -39 },
  { 3251, 26, 40, 27, 2, -39 },
  { 3381, 27, 39, 26, 0, -39 },
  { 3513, 21, 39, 14, -3, -39 },
  { 3616, 21, 49, 11, -8, -39 },
  { 3745, 26, 39, 22, 0, -39 },
  { 3872, 15, 39, 18, 0, -39 },
  { 3946, 36, 39, 35, 0, -39 },
  { 4122, 29, 39, 28, 0, -39 },
  { 4264, 24, 40, 27, 2, -39 },
  { 4384, 23, 39, 22, 0, -39 },
  { 4497, 24, 48, 27, 2, -39 },
  { 4641, 23, 39, 23, 0, -39 },
  { 4754, 23, 40, 20, -1, -39 },
  { 4869, 19, 39, 19, 4, -39 },
  { 4962, 25, 40, 25, 2, -39 },
  { 5087, 21, 39, 22, 5, -39 },
  { 5190, 36, 39, 35, 4, -39 },
  { 5366, 27, 39, 20, -3, -39 },
  { 5498, 20, 39, 19, 4, -39 },
  { 5596, 23, 39, 18, -2, -39 },
  { 5709, 20, 48, 15, -1, -39 },
  { 5829, 9, 39, 18, 5, -39 },
  { 5873, 21, 48, 15, -4, -39 },
  { 5999, 20, 21, 21, 1, -39 },
  { 6052, 17, 4, 16, -5, 4 },
  { 6061, 7, 8, 13, 8, -41 },
  { 6068, 22, 30, 23, 1, -29 },
  { 6151, 21, 42, 23, 0, -41 },
  { 6262, 18, 30, 17, 1, -29 },
  { 6330, 24, 42, 23, 1, -41 },
  { 6456, 19, 30, 21, 1, -29 },
  { 6528, 26, 54, 12, -7, -41 },
  { 6704, 24, 42, 23, -1, -29 },
  { 6830, 21, 41, 22, 0, -41 },
  { 6938, 12, 40, 10, 0, -40 },
  { 6998, 19, 53, 10, -7, -40 },
  { 7124, 22, 41, 20, 0, -41 },
  { 7237, 13, 41, 10, 0, -41 },
  { 7304, 32, 29, 33, 0, -29 },
  { 7420, 21, 29, 22, 0, -29 },
  { 7497, 20, 30, 22, 1, -29 },
  { 7572, 24, 42, 23, -3, -29 },
  { 7698, 22, 42, 23, 1, -29 },
  { 7814, 17, 29, 15, 0, -29 },
  { 7876, 19, 30, 17, -1, -29 },
  { 7948, 13, 37, 13, 1, -36 },
  { 8009, 21, 30, 22, 1, -29 },
  { 8088, 18, 29, 18, 3, -29 },
  { 8154, 29, 29, 29, 3, -29 },
  { 8260, 23, 29, 19, -2, -29 },
  { 8344, 26, 42, 18, -5, -29 },
  { 8481, 19, 29, 15, -2, -29 },
  { 8550, 20, 48, 18, 1, -39 },
  { 8670, 4, 54, 20, 8, -41 },
  { 8697, 19, 48, 18, -3, -39 },
  { 8811, 20, 7, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Italic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC54PT7B_H_
