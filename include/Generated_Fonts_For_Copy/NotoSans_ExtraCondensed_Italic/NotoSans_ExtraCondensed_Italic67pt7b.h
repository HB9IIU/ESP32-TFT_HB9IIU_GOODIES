#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x20, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x03,
  0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x07,
  0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFB, 0x9F, 0x00, 0xFC, 0x60, 0xE0, 0x1F,
  0x0C, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x1F, 0x0E, 0x00,
  0x03, 0xC1, 0x80, 0x00, 0x78, 0x30, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF1,
  0xC0, 0x00, 0x3F, 0x38, 0x00, 0x07, 0xE6, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0x7E, 0x00, 0x00, 0x67, 0xE0, 0x00, 0x1C, 0x7C, 0x00, 0x03, 0x8F,
  0x80, 0x00, 0x71, 0xF0, 0x00, 0x0C, 0x1E, 0x00, 0x01, 0x83, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x1F, 0x00, 0x01, 0xC3, 0xE0, 0x80, 0x30, 0xFC,
  0x0C, 0x0E, 0x1F, 0x03, 0xE1, 0xCF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x78, 0x07, 0x80,
  0x1E, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0x3E, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xC0,
  0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x78, 0x00,
  0x78, 0x0F, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0xF0, 0x00, 0x78, 0x1E, 0x1E,
  0x00, 0x0F, 0x81, 0xE1, 0xE0, 0x00, 0xF0, 0x3E, 0x3C, 0x1F, 0x8F, 0x03,
  0xC7, 0xC3, 0xFC, 0xF0, 0x3C, 0x78, 0x7F, 0xEF, 0x07, 0xCF, 0x8F, 0xFE,
  0xF0, 0x78, 0xF1, 0xF1, 0xEF, 0x8F, 0x9F, 0x1E, 0x1E, 0x7F, 0xF1, 0xE3,
  0xC1, 0xF7, 0xFE, 0x3E, 0x3C, 0x1F, 0x3F, 0xC3, 0xC7, 0xC1, 0xF3, 0xF8,
  0x7C, 0x78, 0x1E, 0x04, 0x07, 0x87, 0x81, 0xE0, 0x00, 0xF8, 0xF8, 0x1E,
  0x00, 0x0F, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0xF0, 0x1E, 0x00, 0x1E, 0x0F,
  0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x1E, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x1E,
  0x0F, 0x00, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0xC0, 0x1E, 0x1E, 0x00, 0x78,
  0x01, 0xF7, 0xE0, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xF0, 0x7C, 0xF8, 0x3E, 0x0F,
  0x8F, 0x83, 0xE1, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0xC7, 0xC3, 0xE0, 0x7C,
  0x7C, 0x7E, 0x07, 0xC7, 0xC7, 0xC0, 0x7E, 0xF8, 0x7C, 0x03, 0xEF, 0x8F,
  0x80, 0x3F, 0xF0, 0xF8, 0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x01,
  0xFE, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0xC0,
  0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0xFE, 0x1F, 0xFE, 0x07, 0xFF,
  0xF3, 0xE0, 0x7F, 0xFE, 0x3F, 0x03, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x3F,
  0x80, 0x38, 0x00, 0x00, 0x1F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x04, 0x0F, 0x80, 0x70, 0xF0, 0x0F, 0xCF, 0x02, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xF3, 0xC0, 0x3F, 0x3E, 0x07, 0xE1, 0xE0, 0x7C, 0x1F, 0x03,
  0x81, 0xF8, 0x18, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xC0, 0x18, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0x7C, 0x20,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F,
  0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xBE, 0x3F, 0x9F, 0x3F, 0x9F,
  0x8F, 0x0F, 0x87, 0x07, 0xC1, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x3C, 0x07, 0xF0, 0x03, 0x80, 0x3F, 0x00,
  0x10, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x1C, 0x01, 0xF8, 0x03,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x02, 0x00, 0x0F, 0xE0,
  0x60, 0x03, 0xF8, 0x0F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x78,
  0xF8, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x1F, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x38, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x08,
  0x00, 0x3F, 0x80, 0xC0, 0x07, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x60,
  0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x3E, 0x3F, 0xE0,
  0x0F, 0xBF, 0xFC, 0x03, 0xEF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1,
  0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFE,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x7F,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xCF, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0xFE,
  0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x3F, 0xE0, 0xFF, 0x7F, 0xF0, 0x1F, 0xFF,
  0x7C, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0xCF, 0xC0, 0x1F, 0xC3, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x1F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE1, 0xFC, 0x1C, 0x07, 0xE0, 0x80, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x0F, 0xE0, 0x38, 0x1E, 0x01, 0xFF, 0xC1,
  0xE1, 0xF0, 0x1F, 0xFE, 0x0F, 0x0F, 0x01, 0xF9, 0xE0, 0x78, 0x78, 0x1F,
  0x0F, 0x03, 0x87, 0x80, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x07, 0xC1, 0xE3,
  0xC0, 0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F,
  0x03, 0xC7, 0x03, 0xC0, 0xF8, 0x1E, 0x78, 0x1E, 0x07, 0x80, 0xE3, 0xC1,
  0xF0, 0x3C, 0x0F, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0xF0, 0x78, 0x1F, 0x03,
  0xCF, 0x03, 0xC0, 0xF0, 0x1C, 0x78, 0x1E, 0x07, 0x81, 0xE3, 0xC1, 0xF0,
  0x7C, 0x0F, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0xF0, 0x78, 0x1F, 0x07, 0x87,
  0x83, 0xC1, 0xF0, 0x38, 0x3C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0xFE,
  0x3C, 0x0F, 0x03, 0xCE, 0xF3, 0xE0, 0x78, 0x1F, 0xF3, 0xFE, 0x03, 0xC0,
  0xFF, 0x1F, 0xE0, 0x1E, 0x03, 0xF0, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0C,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1E,
  0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x3E, 0x03, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0,
  0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0x3E, 0x07, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3E, 0x0F, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF1, 0xF0, 0x01,
  0xFE, 0x01, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x40, 0x03, 0xFC, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF0,
  0x3F, 0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0xFE, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0xFE,
  0x01, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0x80,
  0x1E, 0x00, 0x7F, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF8, 0x7E, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x7F, 0xF0, 0x7C, 0x00, 0x7F,
  0xF0, 0x7C, 0x00, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x07, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFC,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0x9F,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80,
  0x1F, 0x9E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xE0, 0x07,
  0xC7, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x3C, 0x00, 0xF9, 0xF8, 0x01, 0xF1,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x8F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x78,
  0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x78, 0x3F,
  0x00, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x3E, 0x0F, 0x80,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x1F, 0x07, 0xE0, 0x07,
  0xC0, 0xF9, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x03, 0xF0,
  0x3E, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x00, 0xF8, 0x0F,
  0xBC, 0x07, 0xE0, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xFE,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0x80,
  0x7C, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3E,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x3E,
  0x00, 0x7F, 0x80, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F,
  0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xBC, 0x00, 0xFC,
  0x01, 0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0x80, 0x1F, 0x3E, 0x01, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0x3F,
  0x1E, 0x01, 0xF0, 0x03, 0xE1, 0xE0, 0x1F, 0x00, 0x3E, 0x1F, 0x01, 0xF0,
  0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x3E, 0x1F, 0x03, 0xE0, 0x07, 0xE1, 0xF0,
  0x3E, 0x00, 0x7C, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x7C, 0x00, 0xF8, 0x0F, 0x87, 0xC0,
  0x0F, 0x80, 0xF8, 0x7C, 0x00, 0xF8, 0x07, 0x8F, 0xC0, 0x0F, 0x80, 0x78,
  0xF8, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF0,
  0x07, 0xCF, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x03, 0xDF, 0x00,
  0x3F, 0x00, 0x3D, 0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xE0,
  0x03, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xC1, 0xFE, 0x00,
  0x7C, 0x07, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7E,
  0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xC0, 0xFE, 0x00, 0x7C, 0x07, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F,
  0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0,
  0x07, 0x00, 0x3F, 0x80, 0x08, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x04, 0x00, 0x1F, 0xC0, 0x1C, 0x00, 0xFF, 0x00, 0x7F, 0x9F, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F,
  0x80, 0x07, 0xC7, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7F, 0x80, 0x1F,
  0x87, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFF, 0x80, 0x3F, 0x07,
  0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xFF, 0x00, 0x3E, 0x0F, 0xC0,
  0x1E, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xEF, 0x00, 0x7C, 0x0F, 0xC0, 0x3E,
  0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xCF, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0x8F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x8F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0xF0, 0x3F, 0x00,
  0xF8, 0x1F, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0xF0, 0x7E, 0x00, 0xF8,
  0x3E, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x00, 0xF8, 0x3C,
  0x0F, 0x0F, 0xC0, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F,
  0x1F, 0x80, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x1F, 0x1F,
  0x00, 0x0F, 0x8F, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0,
  0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF0, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xF0, 0xF0, 0x0F, 0xFE, 0x7C, 0x07, 0xFF, 0x9F, 0x01, 0xFF,
  0xF7, 0x80, 0xFE, 0x3F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0x7F, 0x03, 0xF0, 0x3F, 0xC0, 0xFE, 0x1D, 0xF0, 0x1F, 0xFF, 0x78, 0x07,
  0xFF, 0x9E, 0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xE3, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x04, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xF3, 0xFF, 0x00, 0x3E,
  0xFF, 0xF0, 0x07, 0xDF, 0xFF, 0x00, 0xFF, 0x8F, 0xE0, 0x3F, 0xC0, 0xFC,
  0x07, 0xF0, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0,
  0x1F, 0xE0, 0xFC, 0x03, 0xDF, 0xFF, 0x80, 0xF9, 0xFF, 0xE0, 0x1F, 0x3F,
  0xF8, 0x03, 0xC3, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFC,
  0x18, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x40, 0x7E, 0x0E, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x1F, 0x00, 0x07, 0xF8, 0xF8, 0x00,
  0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0x3E, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0,
  0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3F, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7C,
  0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x7E, 0x07, 0xF8, 0x03,
  0xF0, 0x77, 0x80, 0x0F, 0xFF, 0xBC, 0x00, 0x7F, 0xF9, 0xE0, 0x01, 0xFF,
  0x9F, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xC3, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x7E,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03,
  0xE7, 0xE0, 0x1F, 0x9F, 0x01, 0xFC, 0x7C, 0x3F, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x20, 0x7E, 0x03, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x03,
  0xFF, 0x3E, 0x00, 0x7F, 0xF9, 0xF0, 0x03, 0xFF, 0xEF, 0x00, 0x3F, 0x8F,
  0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01,
  0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC3, 0xBE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0x00, 0x0F, 0xFC,
  0xF8, 0x00, 0x3F, 0xC7, 0xC0, 0x00, 0x70, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x02, 0x00, 0x1F, 0x80, 0x18, 0x03, 0xF8, 0x00, 0xFE, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x81, 0x80, 0x03, 0xE7, 0xF8, 0x01, 0xF3, 0xFF, 0x00,
  0x7D, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0x03, 0xFC, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xE0,
  0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE7, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBE, 0x00, 0x0F,
  0xE7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC1, 0xF0,
  0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00,
  0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xE3, 0xFC, 0x0F, 0xF0, 0x07, 0xCF,
  0xFC, 0x3F, 0xF0, 0x0F, 0x3F, 0xFC, 0xFF, 0xF0, 0x1E, 0xFF, 0xFB, 0xFF,
  0xE0, 0x3F, 0xC3, 0xFF, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x1F, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x0F, 0xC1,
  0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x7C, 0x7F, 0x80, 0x1F, 0x3F, 0xF0, 0x07,
  0x9F, 0xFE, 0x01, 0xEF, 0xFF, 0x80, 0x7B, 0xC7, 0xF0, 0x3F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F,
  0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x78, 0x7F, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0x0F, 0xBF, 0xFC, 0x00,
  0x3C, 0xFF, 0xF8, 0x00, 0xF7, 0x87, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x1F,
  0xC0, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x01,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x7E, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFB, 0xFF, 0xC0, 0x07, 0xCF, 0xFE, 0x00, 0x1F,
  0x1F, 0xE0, 0x00, 0x7C, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF0, 0xF0, 0x07, 0xFE,
  0x7C, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0xF7, 0x80, 0xFE, 0x3F, 0xE0, 0x7E,
  0x07, 0xF8, 0x1F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0x3E, 0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x3F, 0xC0, 0xFE,
  0x1D, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xBE, 0x00, 0xFF, 0xCF, 0x80,
  0x1F, 0xC7, 0xE0, 0x01, 0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x34, 0x07,
  0xC7, 0xE0, 0x1E, 0x3F, 0x80, 0x79, 0xFE, 0x01, 0xEF, 0xF8, 0x07, 0xBF,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7E, 0x07, 0x81, 0xF8, 0x02, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x60, 0x0F, 0xE0, 0xF0, 0x3F,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x40,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x0C, 0x00, 0x07, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00,
  0xFE, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x7F, 0x81, 0xF8,
  0x7F, 0xC0, 0xFF, 0xFB, 0xE0, 0x7F, 0xF9, 0xE0, 0x1F, 0xF8, 0xF0, 0x07,
  0xF8, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0x80, 0x3E, 0xF8, 0x03, 0xF8, 0x07, 0xEF, 0x80,
  0x3F, 0x80, 0x7C, 0xF8, 0x07, 0xF8, 0x07, 0xCF, 0x80, 0x7F, 0x80, 0xF8,
  0xF8, 0x0F, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0x80, 0xF8, 0xF8, 0x0F, 0xF8,
  0x1F, 0x0F, 0x81, 0xFF, 0x01, 0xF0, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x83,
  0xEF, 0x03, 0xE0, 0xF8, 0x3C, 0xF0, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC0,
  0xF8, 0x7C, 0xF0, 0x7C, 0x0F, 0x87, 0x8F, 0x0F, 0x80, 0xF8, 0x78, 0xF0,
  0xF8, 0x0F, 0x8F, 0x8F, 0x0F, 0x80, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F, 0x9F,
  0x0F, 0x1F, 0x00, 0xF9, 0xE0, 0xF1, 0xE0, 0x0F, 0x9E, 0x0F, 0x3E, 0x00,
  0xFB, 0xE0, 0xF3, 0xE0, 0x0F, 0x3C, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0xF7,
  0xC0, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3F,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x9F, 0xF0, 0x00,
  0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFB, 0x00, 0x7F, 0xF9, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x60, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 49, 16, 1, -48 },
  { 99, 18, 17, 23, 7, -48 },
  { 138, 30, 48, 28, 0, -48 },
  { 318, 27, 55, 26, 0, -51 },
  { 504, 36, 50, 41, 3, -49 },
  { 729, 28, 50, 29, 0, -49 },
  { 904, 8, 17, 13, 7, -48 },
  { 921, 21, 59, 17, 1, -48 },
  { 1076, 20, 59, 17, -5, -48 },
  { 1224, 20, 22, 24, 7, -51 },
  { 1279, 24, 31, 29, 3, -39 },
  { 1372, 12, 17, 14, -3, -8 },
  { 1398, 15, 5, 17, 1, -21 },
  { 1408, 7, 9, 14, 1, -8 },
  { 1416, 30, 48, 22, -3, -48 },
  { 1596, 25, 50, 26, 1, -49 },
  { 1753, 17, 48, 26, 7, -48 },
  { 1855, 28, 49, 26, -2, -49 },
  { 2027, 27, 50, 26, -1, -49 },
  { 2196, 28, 48, 26, -1, -48 },
  { 2364, 28, 49, 26, -1, -48 },
  { 2536, 26, 50, 26, 2, -49 },
  { 2699, 27, 48, 26, 2, -48 },
  { 2861, 27, 50, 26, 0, -49 },
  { 3030, 26, 50, 26, 0, -49 },
  { 3193, 13, 37, 14, 0, -36 },
  { 3254, 17, 45, 14, -3, -36 },
  { 3350, 24, 30, 29, 3, -39 },
  { 3440, 24, 19, 29, 3, -33 },
  { 3497, 25, 30, 29, 3, -39 },
  { 3591, 21, 50, 19, 1, -49 },
  { 3723, 37, 54, 39, 2, -48 },
  { 3973, 27, 48, 27, -4, -48 },
  { 4135, 29, 48, 29, 0, -48 },
  { 4309, 29, 50, 26, 2, -49 },
  { 4491, 30, 48, 31, 0, -48 },
  { 4671, 27, 48, 25, 0, -48 },
  { 4833, 28, 48, 23, 0, -48 },
  { 5001, 32, 50, 33, 2, -49 },
  { 5201, 34, 48, 32, 0, -48 },
  { 5405, 25, 48, 17, -3, -48 },
  { 5555, 26, 61, 14, -10, -48 },
  { 5754, 33, 48, 27, 0, -48 },
  { 5952, 18, 48, 23, 0, -48 },
  { 6060, 45, 48, 43, 0, -48 },
  { 6330, 36, 48, 34, 0, -48 },
  { 6546, 30, 50, 33, 2, -49 },
  { 6734, 28, 48, 27, 0, -48 },
  { 6902, 30, 60, 33, 2, -49 },
  { 7127, 28, 48, 28, 0, -48 },
  { 7295, 30, 50, 25, -2, -49 },
  { 7483, 24, 48, 23, 4, -48 },
  { 7627, 31, 49, 32, 2, -48 },
  { 7817, 27, 48, 27, 6, -48 },
  { 7979, 44, 48, 44, 5, -48 },
  { 8243, 34, 48, 25, -4, -48 },
  { 8447, 25, 48, 24, 5, -48 },
  { 8597, 30, 48, 22, -3, -48 },
  { 8777, 25, 59, 19, -2, -48 },
  { 8962, 11, 48, 23, 7, -48 },
  { 9028, 25, 59, 19, -4, -48 },
  { 9213, 26, 26, 27, 1, -48 },
  { 9298, 21, 4, 20, -6, 6 },
  { 9309, 9, 10, 17, 10, -51 },
  { 9321, 26, 38, 28, 2, -37 },
  { 9445, 27, 52, 28, 0, -51 },
  { 9621, 21, 38, 21, 2, -37 },
  { 9721, 29, 52, 28, 2, -51 },
  { 9910, 22, 38, 26, 2, -37 },
  { 10015, 31, 67, 15, -8, -51 },
  { 10275, 29, 53, 28, -1, -37 },
  { 10468, 26, 51, 28, 0, -51 },
  { 10634, 15, 49, 13, 0, -49 },
  { 10726, 24, 65, 13, -9, -49 },
  { 10921, 27, 51, 24, 0, -51 },
  { 11094, 16, 51, 13, 0, -51 },
  { 11196, 39, 37, 41, 0, -37 },
  { 11377, 26, 37, 28, 0, -37 },
  { 11498, 24, 38, 27, 2, -37 },
  { 11612, 30, 53, 28, -3, -37 },
  { 11811, 26, 53, 28, 2, -37 },
  { 11984, 22, 37, 18, 0, -37 },
  { 12086, 23, 38, 21, -1, -37 },
  { 12196, 16, 45, 16, 2, -44 },
  { 12286, 25, 37, 28, 2, -36 },
  { 12402, 22, 36, 23, 4, -36 },
  { 12501, 36, 36, 36, 4, -36 },
  { 12663, 29, 36, 23, -3, -36 },
  { 12794, 32, 52, 23, -6, -36 },
  { 13002, 23, 36, 19, -2, -36 },
  { 13106, 24, 59, 22, 2, -48 },
  { 13283, 4, 67, 25, 10, -51 },
  { 13317, 24, 59, 22, -4, -48 },
  { 13494, 25, 9, 29, 3, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Italic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC67PT7B_H_
