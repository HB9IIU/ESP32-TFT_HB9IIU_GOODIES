#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1C, 0x07, 0x83, 0xC0,
  0x70, 0x00, 0x38, 0xEF, 0x1D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE3, 0x98, 0x77,
  0x0C, 0xE3, 0x9C, 0x73, 0x0C, 0x00, 0x00, 0x71, 0x80, 0x18, 0x60, 0x0E,
  0x38, 0x03, 0x8E, 0x00, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x0C, 0x30, 0x07, 0x1C, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x0C, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x18, 0x60, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0x62, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0x40, 0x1C, 0x40, 0x0E, 0xC0,
  0x0E, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0x38, 0x01, 0x38, 0x03, 0x18, 0x03, 0x18, 0x03, 0x38, 0x02, 0x38,
  0xC2, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x7C, 0x07, 0x07, 0x70, 0x70,
  0x73, 0x83, 0x83, 0x1C, 0x38, 0x38, 0xE1, 0x81, 0xC7, 0x1C, 0x0C, 0x38,
  0xC0, 0x61, 0x8E, 0x07, 0x0C, 0x60, 0x38, 0xE7, 0x01, 0x87, 0x30, 0x8C,
  0x33, 0x9F, 0x63, 0x99, 0xFF, 0x1D, 0xCC, 0xFD, 0xCC, 0xE7, 0x7C, 0xE6,
  0x3B, 0xC6, 0x71, 0xC0, 0x73, 0x0E, 0x03, 0x18, 0x70, 0x39, 0xC3, 0x01,
  0x8E, 0x18, 0x1C, 0x71, 0xC0, 0xC3, 0x8E, 0x0E, 0x18, 0x60, 0xE0, 0xE7,
  0x07, 0x07, 0x30, 0x70, 0x1F, 0x83, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x73, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x1C, 0x70,
  0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0xEE, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x87, 0x3D, 0xC7, 0x1C, 0xF3, 0x9C,
  0x39, 0xCE, 0x1D, 0xCE, 0x0E, 0xE7, 0x03, 0xE3, 0x81, 0xF1, 0xC0, 0xF0,
  0xE0, 0x78, 0x70, 0x7C, 0x3E, 0xFF, 0x0F, 0xF3, 0x83, 0xF1, 0xE0, 0x39,
  0xDE, 0xE7, 0x39, 0xCC, 0xE7, 0x38, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x70, 0x07, 0x08, 0x70, 0x67, 0x0F,
  0xE7, 0x7F, 0xF0, 0xFF, 0x1F, 0x03, 0xB0, 0x7B, 0x87, 0x1C, 0x21, 0xC0,
  0x10, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0E,
  0x3C, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0, 0x23,
  0xDF, 0xE7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x38, 0xE0, 0xE1, 0xC1, 0xC1, 0xC7, 0x03, 0x8E, 0x07,
  0x3C, 0x1E, 0x70, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C,
  0x07, 0x38, 0x1E, 0xF0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07,
  0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0xFE, 0x03,
  0xFC, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x1F, 0x8E, 0xEF,
  0x39, 0x9E, 0x47, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFF, 0xC0,
  0x71, 0xE0, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0x60, 0xF0, 0x20, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x40, 0x3C, 0x3C, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xB8, 0x01, 0xDC,
  0x00, 0xDC, 0x00, 0xEE, 0x00, 0x67, 0x00, 0x63, 0x80, 0x73, 0xC0, 0x31,
  0xC0, 0x38, 0xE0, 0x38, 0x70, 0x18, 0x38, 0x1C, 0x38, 0x0C, 0x1C, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1D, 0x80, 0x1F,
  0xE0, 0x1F, 0xF0, 0x18, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x80, 0xF0, 0xF7, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x39, 0xE0, 0x77, 0xF0, 0x7F,
  0xF8, 0x7C, 0x78, 0x78, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xF0,
  0xE0, 0x7B, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0x0E,
  0x0E, 0x0E, 0x1E, 0x07, 0x3C, 0x07, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1C, 0x70, 0x38, 0x78, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x38, 0xE0,
  0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xF0, 0x70, 0xF8, 0xF0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x38, 0xF0, 0xE0,
  0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x1C, 0xE0, 0x39,
  0xC0, 0x73, 0x81, 0xE7, 0x03, 0xCF, 0x0F, 0x8F, 0x7F, 0x1F, 0xFC, 0x1F,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x07, 0x83, 0x3E, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x02, 0x0F,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x0C,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x3C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF1,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0x8F, 0x00,
  0x70, 0x0E, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0xC3, 0x00,
  0x03, 0x1C, 0x1F, 0x0C, 0x60, 0xFE, 0x33, 0x87, 0x30, 0xCC, 0x38, 0xC3,
  0x30, 0xC7, 0x1D, 0xC7, 0x1C, 0x76, 0x18, 0x61, 0x98, 0xE1, 0x86, 0x63,
  0x8E, 0x1B, 0x8C, 0x38, 0xEE, 0x30, 0xC3, 0x30, 0xC7, 0x0C, 0xC3, 0x1C,
  0x63, 0x0C, 0xF3, 0x8C, 0x3F, 0xFC, 0x30, 0xF9, 0xE0, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x20, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0xE6,
  0x00, 0x73, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x0F, 0x1C, 0x07, 0x0F, 0x03, 0x87, 0x83, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xF0, 0xE0, 0x78, 0x70, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x07,
  0x9C, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0xF1, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x0E, 0x07, 0x0F, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC1, 0xE1, 0xE3,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0xF8, 0x1C, 0x1E, 0x1E, 0x07, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x38,
  0x70, 0x3C, 0x38, 0x3C, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x78, 0x20, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1E, 0x7E, 0x07, 0x07,
  0x81, 0xC0, 0xF0, 0x70, 0x3C, 0x1C, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x8F, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x38, 0x0F,
  0x0E, 0x03, 0x87, 0x81, 0xE1, 0xC0, 0xF0, 0x70, 0x7C, 0x1C, 0x3E, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E,
  0x0E, 0x07, 0x80, 0x40, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x3F, 0x87, 0x03, 0xF8, 0x70, 0x3F, 0x87, 0x00, 0x78,
  0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x3F, 0x7E, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70,
  0x78, 0x0F, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E,
  0x0F, 0x01, 0xE0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x1E, 0x03,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1C, 0x03, 0x83, 0xC0,
  0x78, 0x38, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x0F,
  0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x9E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0xC1, 0xC0, 0x70, 0x78, 0x0E, 0x1E,
  0x01, 0xC3, 0x80, 0x38, 0xF0, 0x0F, 0x3C, 0x01, 0xC7, 0x00, 0x39, 0xE0,
  0x07, 0x78, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1E, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x78, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x0E, 0xE0, 0x3B, 0x81, 0xDC, 0x07, 0x70, 0x3B, 0x81, 0xDE,
  0x07, 0x70, 0x3B, 0x81, 0xEE, 0x06, 0x70, 0x39, 0xC1, 0xCE, 0x07, 0x38,
  0x39, 0xC0, 0xE7, 0x0E, 0x78, 0x1C, 0xE1, 0xCE, 0x07, 0x1C, 0x71, 0xC0,
  0xE3, 0x8E, 0x38, 0x1C, 0x73, 0x87, 0x03, 0x8E, 0x71, 0xE0, 0x71, 0xDC,
  0x38, 0x1C, 0x1B, 0x87, 0x03, 0x83, 0x60, 0xE0, 0x70, 0x7C, 0x3C, 0x0E,
  0x0F, 0x87, 0x01, 0xC1, 0xE0, 0xE0, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0x03, 0xC0, 0x38, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x0F, 0x80, 0x70,
  0x7E, 0x07, 0x83, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x0E, 0xE0,
  0x70, 0x77, 0x07, 0x83, 0x98, 0x38, 0x1C, 0xE1, 0xC1, 0xE7, 0x0E, 0x0E,
  0x38, 0x70, 0x71, 0xC7, 0x03, 0x8E, 0x38, 0x1C, 0x31, 0xC1, 0xE1, 0xCE,
  0x0E, 0x0E, 0x70, 0x70, 0x77, 0x03, 0x83, 0xB8, 0x1C, 0x1D, 0xC1, 0xC0,
  0x6E, 0x0E, 0x03, 0xF0, 0x70, 0x1F, 0x03, 0x80, 0xF8, 0x1C, 0x07, 0xC1,
  0xC0, 0x3E, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x0F, 0x0F, 0x07, 0x03, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x78, 0x07,
  0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xDE,
  0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEF, 0x00,
  0x7B, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xE1, 0xC0, 0x78,
  0x70, 0x3C, 0x1E, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xF3, 0xE0, 0x70, 0x78, 0x38,
  0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xC1,
  0xC0, 0xE1, 0xE0, 0xF0, 0xE0, 0xF0, 0x70, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x0F, 0x07,
  0x03, 0xC3, 0xC0, 0x70, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x01, 0xCF, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x78, 0x01, 0xDE, 0x00, 0xF7, 0x00, 0x3D,
  0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1C, 0xF0,
  0x07, 0x3C, 0x03, 0xCF, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x3C, 0x1E, 0x1E,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xF3, 0xE0, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC0,
  0xE1, 0xE0, 0xF0, 0xE0, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1E,
  0x70, 0x0E, 0x38, 0x07, 0x1E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xE1, 0xC0,
  0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x1E, 0x07, 0x0E, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x60, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x60, 0x3C, 0x3F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x3C,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0xF0,
  0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0xC3, 0xC0,
  0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x01,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x07,
  0x07, 0x81, 0xE0, 0xF0, 0x38, 0x0E, 0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0,
  0x70, 0x70, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0x71, 0xC0, 0x73,
  0xC0, 0x73, 0x80, 0x73, 0x80, 0x77, 0x00, 0x77, 0x00, 0x7E, 0x00, 0x6E,
  0x00, 0x6E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x0E, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x3B, 0xC0,
  0x78, 0x0E, 0xE0, 0x3E, 0x07, 0xB8, 0x0F, 0x81, 0xCE, 0x03, 0xE0, 0x73,
  0x81, 0xF8, 0x38, 0xE0, 0x6E, 0x0E, 0x38, 0x3B, 0x87, 0x8E, 0x0E, 0xE1,
  0xC3, 0x83, 0x30, 0x70, 0xE1, 0xCC, 0x3C, 0x38, 0x73, 0x0E, 0x0E, 0x38,
  0xC7, 0x83, 0x8E, 0x31, 0xC0, 0xE3, 0x0C, 0x70, 0x39, 0xC3, 0x3C, 0x0E,
  0x70, 0xCE, 0x03, 0xB8, 0x73, 0x80, 0xEE, 0x1D, 0xC0, 0x3B, 0x07, 0x70,
  0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x73, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80,
  0x3C, 0x38, 0x03, 0x83, 0x80, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x3C,
  0x00, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x8E, 0x0E,
  0x1C, 0x3C, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x01, 0xDC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xE3, 0x8E, 0x38, 0x61,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0C, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xB8, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x0C, 0x1C, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE7, 0x9C, 0xE3, 0x9C, 0x60, 0x01, 0xC0, 0x07, 0xE7, 0x0F, 0xF6,
  0x1E, 0x3E, 0x1C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xF0, 0xF0, 0xF0, 0xF3, 0xF0, 0x7F, 0x70,
  0x3E, 0x60, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x38, 0x0E, 0xFE, 0x0E, 0xFE,
  0x0F, 0x8F, 0x0F, 0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F,
  0x1C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C,
  0x78, 0x1C, 0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0xEC, 0xF0, 0xEF, 0xE0,
  0xE7, 0xC0, 0x01, 0xF0, 0x3F, 0xC3, 0xFC, 0x3C, 0x21, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF3, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC7, 0x01, 0xF9,
  0xC0, 0xFF, 0xE0, 0x78, 0xF8, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xE1,
  0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0xE0, 0xE0,
  0x38, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0x70, 0x38, 0x3C,
  0x0E, 0x0F, 0x03, 0xCF, 0xC0, 0x7F, 0x70, 0x0F, 0x98, 0x00, 0x01, 0xE0,
  0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x1C, 0xE0, 0x73, 0x83, 0x9E, 0x0E,
  0x70, 0x79, 0xC7, 0xCF, 0xFE, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x30, 0x7F, 0xC0, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x20, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7E, 0x70, 0x3F, 0xD8, 0x1E, 0x3E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x38, 0x1C, 0x1C, 0x07, 0x07,
  0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x87, 0xC0, 0xF3, 0xF0,
  0x1F, 0xDC, 0x03, 0xEE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x02, 0x03, 0xC0, 0xC1, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x38, 0x1D, 0xFC, 0x3F, 0xF8,
  0x7C, 0x70, 0xF0, 0xE3, 0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE3, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x00,
  0x03, 0x81, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x02, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00,
  0xFC, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x78, 0x1C, 0xF0,
  0x1C, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3D, 0xC0,
  0x3D, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0xE0, 0x70, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x38, 0x1D,
  0xF9, 0xFC, 0x3F, 0xFF, 0xF8, 0x7C, 0x7C, 0x70, 0xF0, 0xF0, 0xE3, 0xC1,
  0xC1, 0xC7, 0x83, 0x83, 0x8E, 0x07, 0x07, 0x1C, 0x1C, 0x0E, 0x38, 0x38,
  0x3C, 0xF0, 0x70, 0x71, 0xC0, 0xE0, 0xE3, 0x81, 0xC1, 0xC7, 0x07, 0x03,
  0x8E, 0x0E, 0x0F, 0x38, 0x1C, 0x1C, 0x70, 0x38, 0x38, 0xE0, 0xF0, 0x71,
  0xC1, 0xC0, 0xE7, 0x83, 0x83, 0x8E, 0x07, 0x07, 0x1C, 0x0E, 0x0E, 0x00,
  0x00, 0x38, 0x1D, 0xFC, 0x3F, 0xF8, 0x7C, 0x70, 0xF0, 0xE3, 0xC1, 0xC7,
  0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE7,
  0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x87,
  0x8F, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x1D, 0xC0, 0x77,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73,
  0x83, 0xCF, 0x0E, 0x1E, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0xE7, 0xE0, 0x3B, 0xF8, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xE0, 0x70, 0x78,
  0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0x38, 0x0E,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x78, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xE1, 0xE0, 0x7C, 0xF0, 0x3B, 0xF8, 0x0E, 0x7C, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xE7, 0x0F,
  0xF6, 0x1E, 0x3E, 0x1C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xF0, 0xF1, 0xF0, 0xF3, 0xF0, 0x7F,
  0x70, 0x3E, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x00,
  0x38, 0x77, 0xC3, 0xFC, 0x1F, 0xA0, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x03,
  0xE0, 0x7F, 0xC7, 0xFE, 0x38, 0x23, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x20, 0xF1, 0xDF, 0x0F, 0xF8, 0x7F, 0x80, 0x07,
  0x01, 0x80, 0xE0, 0x38, 0x0E, 0x1F, 0xF7, 0xF8, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0xD0, 0xFC, 0x1F, 0x00, 0x1E, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38,
  0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x9E, 0x0E, 0x38, 0x1C,
  0x70, 0x78, 0xE0, 0xF1, 0xC3, 0xE3, 0xDD, 0x87, 0xFF, 0x07, 0xCE, 0x00,
  0xE0, 0x3F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0x1C,
  0x38, 0x61, 0xC3, 0x1C, 0x18, 0xE0, 0xCE, 0x06, 0x70, 0x37, 0x01, 0xB8,
  0x0D, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0,
  0x78, 0x3F, 0x81, 0xE0, 0xEE, 0x0F, 0x87, 0x38, 0x3E, 0x1C, 0xE1, 0xF8,
  0x73, 0x87, 0xE3, 0x8E, 0x1B, 0x8E, 0x38, 0xEE, 0x70, 0xE3, 0x39, 0xC3,
  0x9C, 0xC7, 0x0E, 0x73, 0x38, 0x39, 0x8C, 0xE0, 0xEE, 0x33, 0x03, 0xB8,
  0xDC, 0x0E, 0xC3, 0x70, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x07, 0x83,
  0xC3, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x1E, 0x38, 0x0E,
  0x1C, 0x0E, 0x0F, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x1C, 0x0E, 0x01,
  0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1D, 0xC0,
  0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x09, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00,
  0x07, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x00, 0x00,
  0x30, 0x07, 0xF8, 0x1F, 0xFC, 0xF1, 0xFF, 0x81, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 29, 9, 0, -29 },
  { 38, 11, 11, 14, 4, -29 },
  { 54, 18, 29, 17, 0, -29 },
  { 120, 16, 32, 16, 0, -30 },
  { 184, 21, 29, 24, 2, -29 },
  { 261, 17, 29, 17, 0, -29 },
  { 323, 5, 11, 7, 4, -29 },
  { 330, 12, 35, 10, 1, -29 },
  { 383, 12, 35, 10, -3, -29 },
  { 436, 12, 14, 14, 4, -31 },
  { 457, 14, 19, 17, 2, -24 },
  { 491, 7, 9, 8, -2, -4 },
  { 499, 9, 3, 10, 1, -12 },
  { 503, 5, 5, 8, 0, -5 },
  { 507, 18, 29, 13, -2, -29 },
  { 573, 15, 29, 16, 1, -29 },
  { 628, 10, 29, 16, 4, -29 },
  { 665, 17, 29, 16, -1, -29 },
  { 727, 17, 29, 16, -1, -29 },
  { 789, 17, 29, 16, -1, -29 },
  { 851, 16, 29, 16, 0, -29 },
  { 909, 16, 29, 16, 1, -29 },
  { 967, 16, 29, 16, 1, -29 },
  { 1025, 16, 29, 16, 0, -29 },
  { 1083, 15, 29, 16, 0, -29 },
  { 1138, 8, 22, 8, 0, -22 },
  { 1160, 10, 27, 8, -2, -22 },
  { 1194, 14, 18, 17, 2, -23 },
  { 1226, 14, 12, 17, 2, -20 },
  { 1247, 14, 18, 17, 2, -23 },
  { 1279, 12, 29, 12, 1, -29 },
  { 1323, 22, 32, 23, 1, -29 },
  { 1411, 17, 29, 16, -3, -29 },
  { 1473, 17, 29, 17, 0, -29 },
  { 1535, 17, 29, 15, 1, -29 },
  { 1597, 18, 29, 19, 0, -29 },
  { 1663, 16, 29, 15, 0, -29 },
  { 1721, 16, 29, 14, 0, -29 },
  { 1779, 20, 29, 20, 1, -29 },
  { 1852, 20, 29, 19, 0, -29 },
  { 1925, 15, 29, 10, -2, -29 },
  { 1980, 15, 37, 8, -6, -29 },
  { 2050, 19, 29, 16, 0, -29 },
  { 2119, 11, 29, 13, 0, -29 },
  { 2159, 27, 29, 26, 0, -29 },
  { 2257, 21, 29, 21, 0, -29 },
  { 2334, 18, 29, 20, 1, -29 },
  { 2400, 17, 29, 16, 0, -29 },
  { 2462, 18, 36, 20, 1, -29 },
  { 2543, 17, 29, 17, 0, -29 },
  { 2605, 17, 29, 15, -1, -29 },
  { 2667, 14, 29, 14, 3, -29 },
  { 2718, 19, 29, 19, 1, -29 },
  { 2787, 16, 29, 16, 3, -29 },
  { 2845, 26, 29, 26, 3, -29 },
  { 2940, 20, 29, 15, -2, -29 },
  { 3013, 15, 29, 14, 3, -29 },
  { 3068, 18, 29, 13, -2, -29 },
  { 3134, 15, 35, 11, -1, -29 },
  { 3200, 6, 29, 14, 4, -29 },
  { 3222, 15, 35, 11, -3, -29 },
  { 3288, 16, 16, 16, 0, -29 },
  { 3320, 12, 3, 12, -3, 3 },
  { 3325, 5, 7, 10, 6, -31 },
  { 3330, 16, 22, 17, 1, -22 },
  { 3374, 16, 30, 17, 0, -30 },
  { 3434, 13, 22, 13, 1, -22 },
  { 3470, 18, 30, 17, 1, -30 },
  { 3538, 14, 22, 15, 1, -22 },
  { 3577, 19, 41, 9, -5, -31 },
  { 3675, 18, 32, 17, -1, -22 },
  { 3747, 15, 30, 16, 0, -30 },
  { 3804, 9, 29, 8, 0, -29 },
  { 3837, 14, 39, 8, -5, -29 },
  { 3906, 16, 30, 14, 0, -30 },
  { 3966, 10, 30, 8, 0, -30 },
  { 4004, 23, 22, 25, 0, -22 },
  { 4068, 15, 22, 16, 0, -22 },
  { 4110, 14, 22, 16, 1, -22 },
  { 4149, 18, 31, 17, -2, -22 },
  { 4219, 16, 32, 17, 1, -22 },
  { 4283, 13, 22, 11, 0, -22 },
  { 4319, 13, 22, 13, 0, -22 },
  { 4355, 10, 26, 10, 1, -26 },
  { 4388, 15, 21, 17, 1, -21 },
  { 4428, 13, 21, 13, 2, -21 },
  { 4463, 22, 21, 22, 2, -21 },
  { 4521, 17, 21, 14, -2, -21 },
  { 4566, 20, 31, 14, -4, -21 },
  { 4644, 14, 21, 11, -1, -21 },
  { 4681, 15, 35, 13, 1, -29 },
  { 4747, 3, 40, 15, 6, -31 },
  { 4762, 14, 35, 13, -2, -29 },
  { 4824, 14, 5, 17, 2, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Italic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC40PT7B_H_
