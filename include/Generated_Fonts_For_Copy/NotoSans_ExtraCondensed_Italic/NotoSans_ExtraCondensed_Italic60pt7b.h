#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xE3, 0xC1, 0xF1, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0x70, 0x38,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x03, 0xC1, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFC, 0xE1, 0x80, 0x7C, 0x60, 0x00, 0x3C, 0x30, 0x00, 0x3E, 0x18,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x86, 0x00, 0x03, 0xE3,
  0x00, 0x01, 0xF3, 0x80, 0x00, 0x7D, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xBE, 0x00,
  0x01, 0xCF, 0x80, 0x00, 0xC7, 0xC0, 0x00, 0x61, 0xE0, 0x00, 0x30, 0xF0,
  0x00, 0x38, 0x78, 0x00, 0x18, 0x3C, 0x00, 0x0C, 0x3E, 0x08, 0x06, 0x1E,
  0x06, 0x07, 0x1F, 0x03, 0xE3, 0xBF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x78, 0x03, 0xFC, 0x00, 0xF0, 0x07,
  0xFC, 0x00, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x1E, 0x1E, 0x01, 0xC0, 0x1E,
  0x1E, 0x03, 0xC0, 0x3C, 0x1E, 0x03, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0x3C,
  0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x78, 0x1C, 0x1E, 0x00, 0x78,
  0x1C, 0x1E, 0x00, 0x70, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0xF0,
  0x3C, 0x78, 0x00, 0xF0, 0x38, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0,
  0x78, 0xF0, 0xF8, 0xF0, 0x71, 0xE1, 0xFC, 0xF0, 0xF1, 0xE3, 0xFE, 0xF0,
  0xF3, 0xC7, 0x9E, 0xF1, 0xE3, 0xCF, 0x0E, 0xF3, 0xE7, 0x8E, 0x0E, 0xFF,
  0xC7, 0x9E, 0x0F, 0x7F, 0x8F, 0x1E, 0x0E, 0x3F, 0x0F, 0x1C, 0x0E, 0x00,
  0x1E, 0x3C, 0x0E, 0x00, 0x1C, 0x3C, 0x1E, 0x00, 0x3C, 0x38, 0x1E, 0x00,
  0x38, 0x78, 0x1E, 0x00, 0x78, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1C, 0x00,
  0xF0, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x3C, 0x01, 0xE0, 0x70, 0x3C, 0x03,
  0xC0, 0x70, 0x78, 0x03, 0xC0, 0x70, 0x78, 0x07, 0x80, 0x70, 0x70, 0x07,
  0x80, 0x70, 0xF0, 0x0F, 0x00, 0x79, 0xE0, 0x0F, 0x00, 0x7F, 0xE0, 0x1E,
  0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x1F, 0x0F, 0x9E, 0x0F, 0x0F, 0x8F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7,
  0x81, 0xE3, 0xC7, 0xC0, 0xFB, 0xE3, 0xC0, 0x7D, 0xE3, 0xE0, 0x3F, 0xF1,
  0xF0, 0x0F, 0xF0, 0xF8, 0x07, 0xF8, 0x78, 0x03, 0xF8, 0x3C, 0x00, 0xFC,
  0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x7F, 0x07, 0xC0, 0x7F, 0x83, 0xF0, 0x7F,
  0xC1, 0xFF, 0xFD, 0xF0, 0x7F, 0xFC, 0xF8, 0x1F, 0xFC, 0x7C, 0x07, 0xF8,
  0x1F, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0xE8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x18, 0x38, 0x07, 0x8E, 0x03, 0xFB, 0x8F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xDC, 0x01, 0xF7,
  0x80, 0xF8, 0xF0, 0x7C, 0x3C, 0x0E, 0x0F, 0x81, 0x81, 0xE0, 0x00, 0x60,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFF, 0xFF,
  0xFF, 0xEF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xF8, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1F,
  0x00, 0xF0, 0x7C, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x1F,
  0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x01, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF,
  0x0F, 0xBE, 0x7E, 0x79, 0xF8, 0xF1, 0xE3, 0xE1, 0x87, 0xC2, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7C, 0x1F,
  0x80, 0x1C, 0x03, 0xE0, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0x03, 0xF0, 0x06, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x04,
  0x00, 0x3F, 0x03, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xE7, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1F,
  0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03,
  0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x10, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x3F, 0x03,
  0x80, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x1E, 0x7F,
  0xC0, 0x3E, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC3, 0xF0, 0x3F, 0x81,
  0xF0, 0x3F, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03,
  0xE0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x7E, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF1, 0xF8, 0x01, 0xF3, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xEF, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00,
  0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x07,
  0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78,
  0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8,
  0x07, 0xE1, 0xF0, 0x0F, 0xC1, 0xF0, 0x3F, 0x83, 0xF1, 0xFF, 0x07, 0xFF,
  0xBE, 0x07, 0xFF, 0x78, 0x07, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x70,
  0x7E, 0x08, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x20, 0x0E, 0x07,
  0x80, 0x7F, 0xC3, 0x81, 0xE0, 0x7F, 0xF0, 0xF0, 0xF0, 0x3F, 0xF8, 0x38,
  0x3C, 0x0F, 0x1E, 0x0E, 0x0E, 0x07, 0x87, 0x83, 0x87, 0x83, 0xC1, 0xE0,
  0xE1, 0xE0, 0xE0, 0x70, 0x38, 0x70, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F,
  0x07, 0x8F, 0x07, 0x03, 0xC1, 0xE3, 0x83, 0xC0, 0xE0, 0x70, 0xE0, 0xF0,
  0x78, 0x1C, 0x78, 0x38, 0x1E, 0x0F, 0x1E, 0x0E, 0x07, 0x83, 0xC7, 0x87,
  0x83, 0xC0, 0xE1, 0xC1, 0xE0, 0xF0, 0x78, 0x70, 0x78, 0x3C, 0x1C, 0x1C,
  0x1E, 0x1F, 0x07, 0x07, 0x07, 0x87, 0xC3, 0xC3, 0xC1, 0xE3, 0xF1, 0xE0,
  0xF0, 0x79, 0xDC, 0xF0, 0x3C, 0x0F, 0xF7, 0xFC, 0x0F, 0x03, 0xF8, 0xFE,
  0x03, 0xC0, 0x7C, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x40, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00,
  0x03, 0xCF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF, 0x00, 0x07, 0x8F, 0x00,
  0x0F, 0x8F, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x0F, 0x00,
  0x7C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x7F, 0x80, 0x3E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xC0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF0,
  0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xC1, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC1, 0xC0, 0x0F, 0xC0, 0x10,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xF0, 0x3F,
  0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x0F,
  0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x1E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x1F, 0xC0,
  0x1F, 0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0xF8, 0x03, 0xF0,
  0x01, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xC1, 0xF0, 0x07, 0xFE, 0x0F,
  0x80, 0x3F, 0xF0, 0x7C, 0x01, 0xFF, 0x87, 0xC0, 0x1F, 0xFC, 0x3E, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x07, 0xC0,
  0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x0F,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C,
  0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x87, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFD, 0xE0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x0F, 0xFC, 0x01, 0xEF, 0x00, 0x0F, 0x7C, 0x03,
  0xEF, 0x00, 0x1F, 0x7C, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x03, 0xEF, 0x00,
  0x3E, 0xF8, 0x03, 0xCF, 0x00, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x3C, 0xF8,
  0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x79, 0xF0, 0x07, 0xCF,
  0x00, 0xF9, 0xF0, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x07, 0x8F, 0x81, 0xF1,
  0xF0, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x0F,
  0x8F, 0x83, 0xC3, 0xE0, 0x0F, 0x0F, 0x83, 0xC3, 0xE0, 0x1F, 0x07, 0x87,
  0x83, 0xE0, 0x1F, 0x07, 0x87, 0x83, 0xC0, 0x1F, 0x07, 0x8F, 0x87, 0xC0,
  0x1E, 0x07, 0x8F, 0x07, 0xC0, 0x1E, 0x07, 0x9F, 0x07, 0xC0, 0x3E, 0x07,
  0x9E, 0x07, 0x80, 0x3E, 0x07, 0xBE, 0x0F, 0x80, 0x3E, 0x07, 0xBC, 0x0F,
  0x80, 0x3C, 0x07, 0xFC, 0x0F, 0x80, 0x3C, 0x07, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xF0,
  0x1F, 0x00, 0x78, 0x07, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0xFF,
  0x00, 0x3E, 0x01, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x3C, 0x01, 0xEF,
  0x00, 0x7C, 0x01, 0xEF, 0x00, 0x7C, 0x01, 0xEF, 0x80, 0x7C, 0x03, 0xEF,
  0x80, 0x7C, 0x03, 0xE7, 0x80, 0x78, 0x03, 0xE7, 0x80, 0xF8, 0x03, 0xC7,
  0x80, 0xF8, 0x03, 0xC7, 0x80, 0xF8, 0x07, 0xC7, 0xC0, 0xF0, 0x07, 0xC7,
  0xC0, 0xF0, 0x07, 0xC3, 0xC1, 0xF0, 0x07, 0x83, 0xC1, 0xF0, 0x07, 0x83,
  0xC1, 0xF0, 0x0F, 0x83, 0xC1, 0xE0, 0x0F, 0x83, 0xE1, 0xE0, 0x0F, 0x83,
  0xE3, 0xE0, 0x0F, 0x01, 0xE3, 0xE0, 0x1F, 0x01, 0xE3, 0xE0, 0x1F, 0x01,
  0xE3, 0xC0, 0x1F, 0x01, 0xE3, 0xC0, 0x1E, 0x01, 0xF7, 0xC0, 0x1E, 0x01,
  0xF7, 0xC0, 0x3E, 0x00, 0xF7, 0xC0, 0x3E, 0x00, 0xF7, 0x80, 0x3E, 0x00,
  0xF7, 0x80, 0x3C, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0xFF, 0x80, 0x7C, 0x00,
  0xFF, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x78, 0x00,
  0x7F, 0x00, 0x78, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0x9F, 0xF0, 0x07,
  0xC1, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F,
  0xC0, 0x3C, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x78, 0xF8,
  0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x5F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0x9F,
  0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x03,
  0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7C, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFE, 0x0F, 0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x30, 0x01, 0xF8, 0x0F, 0x01, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xFB,
  0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x7C, 0x00, 0xFE, 0x00, 0x78, 0x7C, 0x01,
  0xFE, 0x00, 0xF8, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xFC, 0x01,
  0xF0, 0x7C, 0x03, 0xDC, 0x01, 0xF0, 0x7C, 0x03, 0xDC, 0x01, 0xE0, 0x7C,
  0x03, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xBC, 0x03, 0xE0, 0x78, 0x07, 0xBC,
  0x07, 0xC0, 0x78, 0x0F, 0xBC, 0x07, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x3C, 0x0F, 0x80, 0x78, 0x1E,
  0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x3C, 0x3E, 0x00, 0x78,
  0x78, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x3C, 0xF8, 0x00,
  0x79, 0xE0, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x3D, 0xF0, 0x00, 0xFB, 0xC0,
  0x3D, 0xF0, 0x00, 0xFB, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x3B, 0xE0,
  0x00, 0xFF, 0x80, 0x3B, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8,
  0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7E,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x07,
  0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x08, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0xF9, 0xE0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0xF8,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x3E, 0x00,
  0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x07,
  0xBE, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0xF8, 0xFC, 0x7C, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0x8F, 0x00, 0xFF, 0xCF, 0x01, 0xFF, 0xDF,
  0x03, 0xF9, 0xFF, 0x07, 0xE0, 0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0,
  0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x78, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x7C, 0x0F, 0xE0,
  0x7C, 0x1F, 0xC0, 0x7F, 0xFB, 0xC0, 0x3F, 0xF3, 0xC0, 0x3F, 0xE3, 0xC0,
  0x1F, 0xC3, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0xE0,
  0x01, 0xE3, 0xF8, 0x03, 0xEF, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xDE, 0x7E,
  0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x7F, 0x07, 0xE0,
  0x7F, 0xDF, 0xC0, 0xFB, 0xFF, 0x80, 0xF3, 0xFF, 0x00, 0xF1, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFC, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x04, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x1C, 0x1E, 0x00, 0x1F, 0xE7, 0xC0, 0x07, 0xFE, 0xF8, 0x01, 0xFF,
  0xDF, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0x83,
  0xF8, 0x01, 0xFD, 0xEF, 0x00, 0x1F, 0xF9, 0xE0, 0x03, 0xFE, 0x3C, 0x00,
  0x3F, 0x87, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0x7C, 0x1F,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C,
  0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF0, 0x7F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x10, 0x1F,
  0xCF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xF8, 0xF0, 0x03, 0xFF, 0x3C, 0x01, 0xFF, 0xDF, 0x00, 0xFE, 0x7F, 0x80,
  0x3E, 0x0F, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0xF0,
  0x1E, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x0F, 0xE0, 0x1F, 0x07, 0xF0, 0x07, 0xFF, 0xBC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xF7, 0xC0, 0x07, 0xF1, 0xF0, 0x00, 0x30, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x07, 0xE0, 0x0C,
  0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x79, 0xFE, 0x01,
  0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xBF, 0xFC, 0x0F, 0xE0, 0xF8, 0x1F,
  0x81, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF8, 0x03,
  0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07,
  0x8F, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xDE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0xFF,
  0x07, 0xF0, 0x0F, 0x3F, 0xF3, 0xFF, 0x01, 0xEF, 0xFE, 0xFF, 0xF0, 0x3F,
  0xEF, 0xFE, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x01, 0xE0, 0xF8, 0x07,
  0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x1E, 0x01, 0xF0, 0x78,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x07, 0x83, 0xE0, 0x1F, 0x00, 0xF0,
  0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x0F,
  0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x03, 0xC1, 0xF0,
  0x0F, 0x80, 0x78, 0x3E, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0xF0, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x0F, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xCF, 0xF0,
  0x0F, 0x3F, 0xF0, 0x1E, 0xFF, 0xF0, 0x3D, 0xFF, 0xE0, 0x7F, 0x07, 0xC0,
  0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF9, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xDF, 0x00,
  0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x78, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8,
  0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x1F,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x8F, 0xE0, 0x01, 0xE3,
  0xFE, 0x00, 0x3C, 0xFF, 0xE0, 0x07, 0xBC, 0xFC, 0x00, 0xFE, 0x0F, 0x80,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xFE, 0x0F, 0xC0, 0x1E, 0xFF, 0xF0, 0x03, 0xDF, 0xFC, 0x00,
  0xF9, 0xFF, 0x00, 0x1F, 0x1F, 0xC0, 0x03, 0xE0, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x8F,
  0x00, 0xFF, 0xCF, 0x01, 0xFF, 0xDF, 0x03, 0xFB, 0xFE, 0x03, 0xE0, 0xFE,
  0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C, 0x1F, 0xC0, 0x7F, 0xFB, 0xC0,
  0x7F, 0xF7, 0xC0, 0x3F, 0xF7, 0xC0, 0x1F, 0xC7, 0xC0, 0x02, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x38, 0xFC, 0x0F, 0x3F, 0x81, 0xEF,
  0xF0, 0x3D, 0xFC, 0x07, 0xF8, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x03,
  0xE0, 0x10, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC1, 0x00, 0x3E, 0x0C,
  0x03, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xFF, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF0, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0x00, 0x03, 0xC0, 0x1E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF0,
  0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x07,
  0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3C, 0x03, 0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x1F, 0x83, 0xE0, 0x3F,
  0x03, 0xE1, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFE, 0xF0, 0x0F, 0xF9, 0xE0,
  0x0F, 0xE3, 0xC0, 0x06, 0x00, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0x78, 0x03, 0xEF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80,
  0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0x07,
  0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3E,
  0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x78, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07,
  0xE0, 0x3E, 0x78, 0x0F, 0xE0, 0x3E, 0x78, 0x0F, 0xE0, 0x3C, 0x78, 0x1F,
  0xE0, 0x7C, 0x78, 0x1F, 0xE0, 0x78, 0x78, 0x1D, 0xE0, 0xF8, 0x78, 0x3D,
  0xE0, 0xF8, 0x78, 0x3D, 0xE0, 0xF0, 0x78, 0x79, 0xE1, 0xF0, 0x78, 0x79,
  0xE1, 0xE0, 0x78, 0x79, 0xE1, 0xE0, 0x78, 0xF1, 0xE3, 0xE0, 0xF8, 0xF1,
  0xE3, 0xC0, 0xF9, 0xE1, 0xE7, 0xC0, 0xF9, 0xE1, 0xE7, 0x80, 0xF9, 0xE1,
  0xE7, 0x80, 0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xCF, 0x00, 0xFB, 0xC1,
  0xCF, 0x00, 0xFF, 0x81, 0xDE, 0x00, 0xF7, 0x83, 0xDE, 0x00, 0xF7, 0x03,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x80, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x02, 0x7F, 0xC0, 0x0D, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xA0, 0x03, 0xFE, 0x40, 0x00, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 43, 14, 1, -43 },
  { 77, 17, 16, 20, 6, -43 },
  { 111, 27, 43, 25, 0, -43 },
  { 257, 25, 49, 23, 0, -46 },
  { 411, 32, 44, 36, 3, -43 },
  { 587, 25, 44, 26, 0, -43 },
  { 725, 8, 16, 11, 6, -43 },
  { 741, 18, 52, 15, 1, -43 },
  { 858, 18, 52, 15, -4, -43 },
  { 975, 18, 20, 22, 6, -46 },
  { 1020, 22, 28, 26, 2, -35 },
  { 1097, 11, 15, 12, -3, -7 },
  { 1118, 13, 4, 16, 1, -18 },
  { 1125, 6, 7, 12, 1, -7 },
  { 1131, 28, 43, 20, -3, -43 },
  { 1282, 22, 44, 23, 1, -43 },
  { 1403, 15, 43, 23, 6, -43 },
  { 1484, 26, 43, 23, -2, -43 },
  { 1624, 25, 44, 23, -1, -43 },
  { 1762, 25, 43, 23, -1, -43 },
  { 1897, 25, 44, 23, -1, -43 },
  { 2035, 24, 44, 23, 1, -43 },
  { 2167, 24, 43, 23, 2, -43 },
  { 2296, 24, 44, 23, 0, -43 },
  { 2428, 23, 44, 23, 0, -43 },
  { 2555, 12, 32, 12, 0, -32 },
  { 2603, 15, 40, 12, -3, -32 },
  { 2678, 23, 27, 26, 2, -35 },
  { 2756, 22, 17, 26, 2, -30 },
  { 2803, 23, 27, 26, 2, -35 },
  { 2881, 19, 43, 17, 1, -43 },
  { 2984, 34, 48, 35, 1, -43 },
  { 3188, 24, 43, 24, -4, -43 },
  { 3317, 26, 43, 26, 0, -43 },
  { 3457, 26, 45, 23, 2, -44 },
  { 3604, 27, 43, 28, 0, -43 },
  { 3750, 25, 43, 22, 0, -43 },
  { 3885, 25, 43, 21, 0, -43 },
  { 4020, 29, 45, 30, 2, -44 },
  { 4184, 30, 43, 29, 0, -43 },
  { 4346, 23, 43, 16, -3, -43 },
  { 4470, 23, 55, 12, -9, -43 },
  { 4629, 29, 43, 24, 0, -43 },
  { 4785, 16, 43, 20, 0, -43 },
  { 4871, 40, 43, 39, 0, -43 },
  { 5086, 32, 43, 31, 0, -43 },
  { 5258, 27, 44, 30, 2, -43 },
  { 5407, 25, 43, 24, 0, -43 },
  { 5542, 27, 53, 30, 2, -43 },
  { 5721, 25, 43, 25, 0, -43 },
  { 5856, 26, 44, 23, -1, -43 },
  { 5999, 21, 43, 21, 4, -43 },
  { 6112, 28, 44, 28, 2, -43 },
  { 6266, 24, 43, 24, 5, -43 },
  { 6395, 40, 43, 39, 4, -43 },
  { 6610, 31, 43, 22, -4, -43 },
  { 6777, 23, 43, 21, 4, -43 },
  { 6901, 26, 43, 20, -2, -43 },
  { 7041, 23, 53, 17, -2, -43 },
  { 7194, 10, 43, 20, 6, -43 },
  { 7248, 23, 53, 17, -4, -43 },
  { 7401, 23, 23, 24, 1, -43 },
  { 7468, 19, 4, 18, -5, 5 },
  { 7478, 8, 10, 15, 9, -46 },
  { 7488, 24, 34, 25, 1, -33 },
  { 7590, 24, 47, 25, 0, -46 },
  { 7731, 20, 34, 19, 1, -33 },
  { 7816, 27, 47, 25, 1, -46 },
  { 7975, 21, 34, 23, 1, -33 },
  { 8065, 28, 60, 14, -7, -46 },
  { 8275, 26, 47, 25, -1, -33 },
  { 8428, 23, 46, 25, 0, -46 },
  { 8561, 14, 44, 12, 0, -44 },
  { 8638, 22, 58, 12, -8, -44 },
  { 8798, 24, 46, 22, 0, -46 },
  { 8936, 14, 46, 11, 0, -46 },
  { 9017, 35, 33, 37, 0, -33 },
  { 9162, 23, 33, 25, 0, -33 },
  { 9257, 22, 34, 24, 1, -33 },
  { 9351, 27, 47, 25, -3, -33 },
  { 9510, 24, 47, 25, 1, -33 },
  { 9651, 19, 33, 17, 0, -33 },
  { 9730, 21, 34, 19, -1, -33 },
  { 9820, 15, 40, 14, 1, -39 },
  { 9895, 23, 33, 25, 1, -32 },
  { 9990, 19, 32, 20, 4, -32 },
  { 10066, 32, 32, 33, 3, -32 },
  { 10194, 26, 32, 21, -3, -32 },
  { 10298, 30, 46, 20, -6, -32 },
  { 10471, 21, 32, 17, -2, -32 },
  { 10555, 22, 52, 20, 1, -43 },
  { 10698, 4, 60, 22, 9, -46 },
  { 10728, 22, 52, 20, -4, -43 },
  { 10871, 23, 8, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Italic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC60PT7B_H_
