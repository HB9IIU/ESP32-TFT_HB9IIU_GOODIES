#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x3E, 0x78, 0x7D, 0xF0, 0xFB,
  0xE1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xC7, 0x87, 0x8E, 0x0F, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0E, 0x01, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x01, 0xC1, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C,
  0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x83, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xCE, 0x38, 0x0F, 0x18, 0x20, 0x3C, 0x30,
  0x00, 0x78, 0x60, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xC6, 0x00,
  0x07, 0x8C, 0x00, 0x0F, 0x98, 0x00, 0x1F, 0x70, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xDF, 0x00, 0x03, 0x9E, 0x00, 0x07,
  0x3E, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0x78, 0x00, 0x30, 0xF0, 0x00, 0xE1,
  0xE0, 0x01, 0x87, 0x82, 0x03, 0x0F, 0x07, 0x06, 0x7C, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x01, 0xFE,
  0x00, 0xF0, 0x1F, 0xF0, 0x07, 0x01, 0xE3, 0x80, 0x78, 0x0E, 0x1E, 0x03,
  0x80, 0xF0, 0xF0, 0x3C, 0x07, 0x07, 0x81, 0xC0, 0x38, 0x3C, 0x1E, 0x03,
  0xC1, 0xC0, 0xE0, 0x1C, 0x0E, 0x0F, 0x00, 0xE0, 0x70, 0x70, 0x0F, 0x07,
  0x87, 0x80, 0x78, 0x3C, 0x78, 0x03, 0xC1, 0xE3, 0xC0, 0x1C, 0x0E, 0x3C,
  0x00, 0xE0, 0xF1, 0xE0, 0x87, 0x07, 0x9E, 0x1F, 0x38, 0x38, 0xE3, 0xFD,
  0xC3, 0xCF, 0x1F, 0xFE, 0x1C, 0x71, 0xE7, 0xF9, 0xE7, 0x9E, 0x1F, 0xFE,
  0x38, 0xE0, 0xEF, 0xE3, 0xC7, 0x07, 0x7E, 0x1C, 0x78, 0x38, 0x41, 0xE3,
  0x83, 0xC0, 0x0E, 0x1C, 0x1E, 0x00, 0xF1, 0xE0, 0xF0, 0x07, 0x0F, 0x07,
  0x80, 0x78, 0x70, 0x38, 0x03, 0x83, 0x81, 0xC0, 0x3C, 0x1C, 0x1E, 0x01,
  0xC1, 0xE0, 0xF0, 0x1E, 0x0F, 0x07, 0x00, 0xE0, 0x78, 0x78, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0x1E, 0x3C, 0x07, 0x80, 0xF1, 0xC0, 0x78, 0x03, 0xFE,
  0x03, 0xC0, 0x1F, 0xE0, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0x8F, 0x9E, 0x0F, 0x1E, 0x3E, 0x3E,
  0x7C, 0x7C, 0x79, 0xF0, 0x78, 0xF3, 0xC0, 0xFB, 0xC7, 0x81, 0xF7, 0x9F,
  0x01, 0xFE, 0x3C, 0x03, 0xFC, 0x78, 0x07, 0xF0, 0xF0, 0x07, 0xE1, 0xE0,
  0x0F, 0x83, 0xC0, 0x3F, 0x07, 0x80, 0xFF, 0x0F, 0x83, 0xFE, 0x1F, 0x8F,
  0xBC, 0x1F, 0xFE, 0x7C, 0x3F, 0xF8, 0xF8, 0x1F, 0xE1, 0xF8, 0x04, 0x00,
  0x00, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x04, 0x0E, 0x03, 0x87, 0x01, 0xF3, 0x82, 0xFF,
  0xDF, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0xFE, 0x00, 0xF7, 0x00,
  0xFB, 0xC0, 0xF9, 0xE0, 0xF8, 0x78, 0x18, 0x3E, 0x04, 0x0E, 0x00, 0x04,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC1,
  0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFE,
  0xFB, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xF8, 0x78, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x78,
  0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF1, 0xF0,
  0x07, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0,
  0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x07, 0x87,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF8,
  0x3F, 0xE3, 0xFF, 0x1F, 0xBC, 0xFC, 0xF3, 0xC7, 0xC6, 0x1F, 0x10, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x70, 0x3F, 0x00, 0x60, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x9F, 0xC0, 0x18, 0x0F, 0xC0, 0x20, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x0C,
  0x01, 0xF8, 0x1F, 0x1F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xEF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x39,
  0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xE1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xCC, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x38, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x82, 0x00, 0x3F, 0x06, 0x00, 0xFC, 0x0F, 0x8F, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0x98,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3F, 0x00, 0xFB, 0xFE, 0x03,
  0xDF, 0xFC, 0x0F, 0x7F, 0xF0, 0x3F, 0x87, 0xE1, 0xFC, 0x0F, 0x87, 0xE0,
  0x3E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x3E,
  0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03,
  0xC0, 0x7C, 0x1F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7C,
  0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0xF8, 0x0F,
  0x00, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x03, 0xEF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x0F, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFD, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x03, 0xF8, 0x3E, 0x1F, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xBC, 0x07, 0xFD, 0xF0, 0x0F, 0xC7, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0x8F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xBF, 0x83, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x38, 0x07, 0xF8, 0x70, 0x70, 0x3F, 0xF0, 0xE1, 0xC0, 0xFF,
  0xE1, 0xC3, 0x81, 0xC3, 0x83, 0x8F, 0x07, 0x07, 0x07, 0x1C, 0x1E, 0x1E,
  0x0E, 0x38, 0x38, 0x3C, 0x1C, 0xF0, 0xF0, 0x70, 0x79, 0xC1, 0xC0, 0xE0,
  0xE3, 0x83, 0x83, 0xC1, 0xCF, 0x0F, 0x07, 0x83, 0x9E, 0x1C, 0x0E, 0x07,
  0x38, 0x38, 0x1C, 0x1C, 0x70, 0x70, 0x78, 0x38, 0xE0, 0xE0, 0xF0, 0x71,
  0xC3, 0xC1, 0xC1, 0xC3, 0x87, 0x87, 0x83, 0x8F, 0x0F, 0x0F, 0x0E, 0x1E,
  0x1E, 0x36, 0x1C, 0x3C, 0x1E, 0xEE, 0xF0, 0x78, 0x3F, 0x9F, 0xC0, 0xF0,
  0x3E, 0x1F, 0x01, 0xE0, 0x10, 0x08, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0,
  0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F,
  0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0x03, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x78, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFC, 0x04, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x02, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x07, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC1,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF8,
  0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F,
  0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x3C, 0x03, 0xF0, 0x3E, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0x00, 0x7E, 0x00, 0x20, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0xF0, 0x07, 0xFC,
  0x3E, 0x00, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x07,
  0xE0, 0x0F, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x3E,
  0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0x80, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x01,
  0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0x80,
  0x0F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x01, 0x1F, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x01,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x3D, 0xE0,
  0x07, 0xBE, 0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x1F, 0x78, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3E, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x00, 0xF0,
  0xE0, 0x3C, 0x78, 0x07, 0x87, 0x83, 0xC7, 0xC0, 0x3C, 0x3C, 0x1E, 0x3E,
  0x03, 0xE1, 0xE1, 0xE1, 0xE0, 0x1F, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0x78,
  0xF0, 0x78, 0x07, 0x83, 0xC7, 0x87, 0xC0, 0x3C, 0x1E, 0x78, 0x3E, 0x03,
  0xE0, 0xF3, 0xC1, 0xE0, 0x1E, 0x07, 0xBE, 0x0F, 0x00, 0xF0, 0x3D, 0xE0,
  0x78, 0x07, 0x81, 0xEF, 0x07, 0xC0, 0x3C, 0x0F, 0xF0, 0x3E, 0x03, 0xE0,
  0x7F, 0x81, 0xE0, 0x1E, 0x03, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0xC0, 0xF8,
  0x07, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x07, 0xE0, 0x3C, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x3C, 0x03,
  0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x1E, 0x01, 0xFE,
  0x00, 0x78, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F, 0x80,
  0x3C, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xC0, 0x3C, 0xE0, 0x1F,
  0x00, 0xF3, 0xC0, 0x7C, 0x03, 0xCF, 0x01, 0xE0, 0x0F, 0x3C, 0x07, 0x80,
  0x7C, 0xF0, 0x1E, 0x01, 0xE3, 0xC0, 0xF8, 0x07, 0x8F, 0x03, 0xE0, 0x1E,
  0x1E, 0x0F, 0x00, 0x78, 0x78, 0x3C, 0x03, 0xE1, 0xE0, 0xF0, 0x0F, 0x07,
  0x87, 0xC0, 0x3C, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x78, 0x07, 0xC0, 0xF1,
  0xE0, 0x1F, 0x03, 0xCF, 0x80, 0x78, 0x0F, 0x3E, 0x01, 0xE0, 0x3C, 0xF0,
  0x07, 0x80, 0xF3, 0xC0, 0x3E, 0x03, 0xCF, 0x00, 0xF8, 0x07, 0xBC, 0x03,
  0xC0, 0x1F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x3C, 0x01, 0xFE, 0x01, 0xF0,
  0x07, 0xF8, 0x07, 0x80, 0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0x00, 0x78, 0x00,
  0xFC, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3C, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xF0, 0xFE, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xE0,
  0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3E, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x83,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0xFE, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0x80, 0xF8, 0x07,
  0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x0E, 0x03,
  0xF0, 0x04, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x80, 0x0F, 0xC0, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x05, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00,
  0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78,
  0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF0,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x3E, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1E,
  0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C,
  0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x3C, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00,
  0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF1,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0,
  0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFB,
  0xC0, 0x07, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0x00, 0x7C, 0xF0, 0x01, 0xF0,
  0x03, 0xE7, 0x80, 0x1F, 0x80, 0x1E, 0x3C, 0x00, 0xFC, 0x01, 0xF1, 0xE0,
  0x0F, 0xE0, 0x0F, 0x0F, 0x00, 0x7F, 0x00, 0xF8, 0x78, 0x03, 0xF8, 0x07,
  0xC3, 0xC0, 0x3F, 0xC0, 0x3C, 0x1E, 0x01, 0xFE, 0x03, 0xE0, 0xF0, 0x1E,
  0xF0, 0x1E, 0x07, 0x80, 0xF7, 0x80, 0xF0, 0x3C, 0x07, 0x3C, 0x0F, 0x81,
  0xE0, 0x79, 0xC0, 0x78, 0x1F, 0x03, 0xCE, 0x07, 0xC0, 0xF8, 0x3C, 0x70,
  0x3C, 0x07, 0xC1, 0xE3, 0x81, 0xE0, 0x3E, 0x0F, 0x1C, 0x1F, 0x01, 0xF0,
  0xF0, 0xE0, 0xF0, 0x0F, 0x87, 0x87, 0x0F, 0x80, 0x7C, 0x78, 0x38, 0x78,
  0x03, 0xE3, 0xC3, 0xC3, 0xC0, 0x1F, 0x1E, 0x1E, 0x3E, 0x00, 0xF9, 0xE0,
  0xF1, 0xE0, 0x07, 0xCF, 0x07, 0x9F, 0x00, 0x3C, 0x70, 0x3C, 0xF8, 0x01,
  0xE7, 0x81, 0xE7, 0x80, 0x0F, 0x3C, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x7B,
  0xC0, 0x03, 0xDE, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1E,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xFB, 0xE0,
  0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07,
  0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF0, 0x01,
  0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x78, 0x1E,
  0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0,
  0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3C, 0x1E, 0x1E,
  0x0E, 0x07, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x3C, 0x07, 0xFE, 0xF0, 0x1F,
  0xFD, 0xE0, 0x3F, 0x3B, 0xC0, 0xF8, 0x3F, 0x83, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07,
  0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1F, 0x07,
  0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xF3, 0xBC, 0x07, 0xFF,
  0x78, 0x07, 0xFC, 0xF0, 0x07, 0xF1, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x80, 0x0F, 0x9F,
  0xC0, 0x3C, 0xFF, 0x80, 0xF7, 0xFE, 0x03, 0xFC, 0xFC, 0x1F, 0xC1, 0xF0,
  0x7E, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00,
  0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0xC7, 0xE0,
  0xF7, 0xFF, 0x03, 0xCF, 0xF8, 0x0F, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xF1, 0x81, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x81,
  0xF8, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x83, 0xE0, 0x03, 0xF9, 0xE0, 0x07, 0xFE, 0xF0, 0x07, 0xFF,
  0x78, 0x03, 0xF3, 0xBC, 0x03, 0xE0, 0xFE, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x7C,
  0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xFC, 0x01, 0xE0, 0x7E,
  0x00, 0xF8, 0xEF, 0x00, 0x7F, 0xF7, 0x80, 0x1F, 0xF3, 0x80, 0x07, 0xF1,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x3E, 0x3E, 0x0F, 0x83, 0xC3, 0xE0, 0x78, 0x78, 0x0F,
  0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xC0, 0x7C,
  0xF8, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x08, 0x3F, 0x07, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xF8, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xDF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xE3, 0xC0, 0x1F, 0xFB, 0xC0, 0x1F, 0xFD, 0xE0,
  0x0F, 0xCE, 0xF0, 0x0F, 0x83, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x07, 0x83, 0xF8, 0x03,
  0xF3, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0x00, 0x1F, 0xCF, 0x00,
  0x02, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x02, 0x00, 0x7C,
  0x01, 0x80, 0x7C, 0x00, 0xF9, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x18, 0x01, 0xE3, 0xF8, 0x0F, 0x7F, 0xE0, 0x7F, 0xFF, 0x03,
  0xFD, 0xF8, 0x3F, 0x83, 0xC1, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0x7C, 0x07,
  0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00,
  0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x0F,
  0x00, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x03, 0xE0, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xC0,
  0x1F, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF7, 0x80, 0x07, 0xCF,
  0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x01,
  0x80, 0x10, 0x01, 0xE7, 0xF8, 0x7F, 0x00, 0xF7, 0xFC, 0x7F, 0xC0, 0x7F,
  0xFF, 0x7F, 0xE0, 0x3B, 0x9F, 0xF9, 0xF8, 0x3F, 0x87, 0xF0, 0x7C, 0x1F,
  0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x83,
  0xC0, 0x7C, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x78,
  0x3E, 0x03, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x1F,
  0x07, 0x80, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x03,
  0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x01, 0xF0, 0x78, 0x07, 0x80,
  0xF0, 0x7C, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x07, 0xC0, 0x7C,
  0x07, 0x83, 0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x1E, 0x3F, 0x80,
  0xF7, 0xFE, 0x07, 0xFF, 0xF0, 0x3B, 0xDF, 0x83, 0xF8, 0x3C, 0x1F, 0x81,
  0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F,
  0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x1E,
  0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0,
  0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3,
  0xE0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03,
  0xC3, 0xC0, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xE3, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x7C, 0x1F, 0x07,
  0xE7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x3C, 0x7F, 0x00, 0x1E, 0x7F, 0xC0, 0x0F, 0x7F,
  0xE0, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3E,
  0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x7E, 0x00, 0xF7, 0xFE, 0x00, 0xFB, 0xFE, 0x00, 0x78, 0xFE,
  0x00, 0x3C, 0x10, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x3C,
  0x07, 0xFE, 0xF0, 0x1F, 0xFD, 0xE0, 0x3F, 0x3B, 0xC0, 0xF8, 0x3F, 0x83,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78,
  0x03, 0xE1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x01, 0xE0, 0xFE, 0x03,
  0xF3, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFD, 0xF0, 0x07, 0xF3, 0xC0, 0x01,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0xF3, 0xF0, 0x3D, 0xFC, 0x0E, 0x7E, 0x03, 0xBF,
  0x81, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7E, 0x1C, 0x0F,
  0x00, 0x83, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC3, 0x00, 0xF8, 0x78, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x83, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF2, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x20, 0x00, 0x07, 0xC0,
  0x7C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x78,
  0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x7C,
  0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF8, 0x07,
  0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07,
  0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x07, 0xCF, 0xF0,
  0x1F, 0xFB, 0xC0, 0x7F, 0xCF, 0x00, 0xFE, 0x3C, 0x00, 0x40, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9,
  0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xCF, 0x80, 0x39, 0xE0, 0x07,
  0x3C, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x3F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xBE,
  0x07, 0xF0, 0x3E, 0xF8, 0x1F, 0xC0, 0xF3, 0xE0, 0x7F, 0x03, 0xCF, 0x83,
  0xFC, 0x1F, 0x3E, 0x0E, 0xE0, 0x78, 0xF0, 0x3B, 0x83, 0xE3, 0xC1, 0xEE,
  0x0F, 0x0F, 0x07, 0x38, 0x3C, 0x3C, 0x3C, 0xE1, 0xE0, 0xF0, 0xF3, 0x87,
  0x83, 0xC3, 0x8E, 0x1E, 0x0F, 0x1E, 0x38, 0xF0, 0x3C, 0x70, 0xE3, 0xC0,
  0xF3, 0xC3, 0x9E, 0x03, 0xCF, 0x1E, 0x78, 0x0F, 0x38, 0x79, 0xE0, 0x3D,
  0xE1, 0xEF, 0x00, 0xF7, 0x87, 0xBC, 0x03, 0xFC, 0x1E, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x80, 0x07,
  0x8F, 0x80, 0x0F, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1E,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x3E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x0F, 0xF2, 0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 40, 13, 1, -40 },
  { 66, 15, 14, 19, 6, -40 },
  { 93, 25, 40, 24, 0, -40 },
  { 218, 23, 46, 22, 0, -43 },
  { 351, 29, 42, 34, 3, -41 },
  { 504, 23, 42, 24, 0, -41 },
  { 625, 7, 14, 10, 6, -40 },
  { 638, 17, 49, 14, 1, -40 },
  { 743, 17, 49, 14, -4, -40 },
  { 848, 17, 19, 20, 5, -43 },
  { 889, 21, 26, 24, 2, -33 },
  { 958, 10, 13, 11, -3, -6 },
  { 975, 12, 4, 15, 1, -17 },
  { 981, 6, 6, 11, 1, -6 },
  { 986, 26, 40, 19, -3, -40 },
  { 1116, 21, 42, 22, 1, -41 },
  { 1227, 14, 40, 22, 6, -40 },
  { 1297, 24, 41, 22, -2, -41 },
  { 1420, 23, 42, 22, -1, -41 },
  { 1541, 23, 40, 22, -1, -40 },
  { 1656, 23, 41, 22, -1, -40 },
  { 1774, 22, 42, 22, 1, -41 },
  { 1890, 22, 40, 22, 2, -40 },
  { 2000, 23, 42, 22, 0, -41 },
  { 2121, 22, 42, 22, 0, -41 },
  { 2237, 11, 30, 11, 0, -30 },
  { 2279, 14, 37, 11, -3, -30 },
  { 2344, 21, 25, 24, 2, -32 },
  { 2410, 21, 16, 24, 2, -28 },
  { 2452, 21, 25, 24, 2, -32 },
  { 2518, 18, 41, 16, 1, -41 },
  { 2611, 31, 45, 33, 1, -40 },
  { 2786, 23, 40, 23, -4, -40 },
  { 2901, 24, 40, 24, 0, -40 },
  { 3021, 24, 42, 22, 2, -41 },
  { 3147, 25, 40, 26, 0, -40 },
  { 3272, 23, 40, 21, 0, -40 },
  { 3387, 23, 40, 19, 0, -40 },
  { 3502, 27, 42, 28, 2, -41 },
  { 3644, 28, 40, 27, 0, -40 },
  { 3784, 22, 40, 15, -3, -40 },
  { 3894, 21, 51, 11, -8, -40 },
  { 4028, 27, 40, 23, 0, -40 },
  { 4163, 15, 40, 19, 0, -40 },
  { 4238, 37, 40, 36, 0, -40 },
  { 4423, 30, 40, 29, 0, -40 },
  { 4573, 25, 42, 28, 2, -41 },
  { 4705, 24, 40, 23, 0, -40 },
  { 4825, 25, 51, 28, 2, -41 },
  { 4985, 24, 40, 23, 0, -40 },
  { 5105, 24, 42, 21, -1, -41 },
  { 5231, 20, 40, 19, 4, -40 },
  { 5331, 26, 41, 26, 2, -40 },
  { 5465, 22, 40, 23, 5, -40 },
  { 5575, 37, 40, 37, 4, -40 },
  { 5760, 28, 40, 21, -3, -40 },
  { 5900, 21, 40, 20, 4, -40 },
  { 6005, 24, 40, 19, -2, -40 },
  { 6125, 22, 49, 16, -2, -40 },
  { 6260, 9, 40, 19, 6, -40 },
  { 6305, 21, 49, 16, -4, -40 },
  { 6434, 21, 21, 22, 1, -40 },
  { 6490, 18, 3, 17, -5, 5 },
  { 6497, 8, 9, 14, 8, -43 },
  { 6506, 23, 32, 24, 1, -31 },
  { 6598, 22, 44, 23, 0, -43 },
  { 6719, 18, 32, 18, 1, -31 },
  { 6791, 25, 44, 24, 1, -43 },
  { 6929, 19, 32, 21, 1, -31 },
  { 7005, 26, 56, 13, -7, -43 },
  { 7187, 25, 44, 24, -1, -31 },
  { 7325, 21, 43, 23, 0, -43 },
  { 7438, 13, 41, 11, 0, -41 },
  { 7505, 20, 54, 11, -7, -41 },
  { 7640, 23, 43, 20, 0, -43 },
  { 7764, 13, 43, 11, 0, -43 },
  { 7834, 33, 31, 34, 0, -31 },
  { 7962, 21, 31, 23, 0, -31 },
  { 8044, 20, 32, 23, 1, -31 },
  { 8124, 25, 44, 23, -3, -31 },
  { 8262, 23, 44, 24, 1, -31 },
  { 8389, 18, 31, 15, 0, -31 },
  { 8459, 19, 32, 18, -1, -31 },
  { 8535, 14, 38, 13, 1, -37 },
  { 8602, 22, 31, 23, 1, -30 },
  { 8688, 19, 30, 19, 3, -30 },
  { 8760, 30, 30, 30, 3, -30 },
  { 8873, 24, 30, 19, -3, -30 },
  { 8963, 27, 44, 19, -5, -30 },
  { 9112, 20, 30, 16, -2, -30 },
  { 9187, 21, 49, 18, 1, -40 },
  { 9316, 4, 56, 21, 8, -43 },
  { 9344, 20, 49, 18, -3, -40 },
  { 9467, 21, 7, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Italic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC56PT7B_H_
