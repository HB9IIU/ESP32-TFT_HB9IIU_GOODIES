#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x82, 0x10, 0x01, 0x0E,
  0x30, 0x66, 0xD9, 0x32, 0x6C, 0x99, 0x00, 0x06, 0xC1, 0x20, 0xC8, 0x26,
  0x3F, 0xCF, 0xF1, 0x10, 0x4C, 0x32, 0x0C, 0x8F, 0xF9, 0x90, 0x64, 0x13,
  0x04, 0x83, 0x20, 0x02, 0x03, 0x07, 0xE6, 0x93, 0x41, 0xA0, 0xD0, 0x30,
  0x1C, 0x07, 0x02, 0xC1, 0x61, 0x34, 0x93, 0xF8, 0xF0, 0x10, 0x10, 0x00,
  0x18, 0x03, 0xC6, 0x6C, 0x44, 0xCC, 0x4C, 0x8C, 0xD8, 0xC9, 0x0C, 0xB7,
  0xDA, 0xDF, 0x49, 0x6D, 0x90, 0x91, 0x19, 0x31, 0x13, 0x31, 0x22, 0x16,
  0x61, 0xC0, 0x06, 0x03, 0xC1, 0x90, 0x64, 0x1B, 0x06, 0xC1, 0xE0, 0x70,
  0x18, 0x0F, 0x36, 0xDB, 0x16, 0xC7, 0x31, 0xCC, 0x73, 0x3C, 0x7B, 0x00,
  0x6D, 0xA5, 0x80, 0x02, 0x0C, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0xC1,
  0x82, 0x04, 0x18, 0x30, 0x60, 0x40, 0x81, 0x03, 0x02, 0x00, 0x04, 0x0C,
  0x18, 0x30, 0x60, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x0C,
  0x18, 0x60, 0xC3, 0x0C, 0x00, 0x10, 0x31, 0x67, 0xB1, 0xE5, 0x1B, 0x26,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x33,
  0x66, 0x4C, 0x7F, 0xE0, 0x5F, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x06, 0x07, 0x86, 0x63, 0x33, 0x19, 0x8C, 0x86, 0xC3, 0x61,
  0xB0, 0x98, 0xC8, 0x64, 0x26, 0x31, 0x18, 0xD8, 0x78, 0x00, 0x1C, 0xF6,
  0xF6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x03, 0x07,
  0xE0, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0xFC, 0xFF, 0x00, 0x06, 0x1F, 0x84, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x30,
  0x19, 0x38, 0xF8, 0x00, 0x01, 0x80, 0xC0, 0xE0, 0xF0, 0x50, 0x58, 0x6C,
  0x26, 0x32, 0x33, 0x11, 0x98, 0xCF, 0xF0, 0x20, 0x30, 0x18, 0x0C, 0x00,
  0x1F, 0x8C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xF8, 0xFC, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x32, 0x71, 0xF0, 0x03, 0x87, 0x86, 0x06, 0x02, 0x03,
  0x01, 0x01, 0xBC, 0xE6, 0x63, 0x31, 0x90, 0xC8, 0x64, 0x33, 0x31, 0xB8,
  0x78, 0x00, 0x7F, 0x80, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0x06, 0x0F, 0xC6, 0x66,
  0x33, 0x19, 0x8C, 0xCC, 0x3C, 0x1C, 0x1B, 0x19, 0x98, 0x6C, 0x36, 0x1B,
  0x09, 0xDC, 0x7C, 0x00, 0x06, 0x0F, 0x86, 0x66, 0x33, 0x1B, 0x0D, 0x86,
  0xC3, 0x63, 0x9E, 0x8E, 0xC0, 0x60, 0x20, 0x30, 0x31, 0x30, 0xF0, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x00, 0x02, 0x31, 0x80, 0x1C, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC3, 0x18, 0x61, 0x0C, 0x00, 0x01, 0x07, 0x1E, 0x78,
  0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x07, 0x1C, 0x70, 0xE0, 0x80, 0x0C, 0x3E,
  0x23, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x20, 0x40, 0x00,
  0x40, 0xE0, 0xC0, 0x01, 0x80, 0x7E, 0x18, 0x31, 0x01, 0x20, 0x16, 0x39,
  0x44, 0x94, 0x99, 0xC9, 0x99, 0x93, 0x91, 0x29, 0x32, 0x93, 0x69, 0xDC,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x20, 0x3C, 0x00, 0x01, 0xC0, 0x70, 0x3C,
  0x0B, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0x08, 0xC7, 0xF1, 0xFC, 0xC3, 0x30,
  0xCC, 0x36, 0x0F, 0x83, 0x1F, 0x86, 0x71, 0x8C, 0x43, 0x30, 0xCC, 0x63,
  0x38, 0xF8, 0x23, 0x18, 0x66, 0x19, 0x86, 0x63, 0x10, 0xCF, 0xE3, 0xF0,
  0x03, 0x03, 0xF1, 0x88, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x90, 0x7C, 0x00, 0x1F, 0x86,
  0x71, 0x8C, 0x43, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x20, 0xD8, 0x36, 0x19,
  0x86, 0x63, 0x11, 0xCF, 0xE3, 0xE0, 0x1F, 0x8C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x7E, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0xF1, 0xF8,
  0x1F, 0x8C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x7E, 0x3E, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x03, 0x81, 0xFC, 0x61, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC3, 0xD8, 0xF3, 0x06, 0x60, 0xCC, 0x19,
  0x82, 0x30, 0xC3, 0xB8, 0x3F, 0x00, 0x18, 0x31, 0x86, 0x18, 0x61, 0x06,
  0x30, 0x63, 0x04, 0x30, 0xC3, 0xFC, 0x20, 0xC6, 0x0C, 0x61, 0x86, 0x18,
  0x61, 0x84, 0x18, 0xC1, 0x0C, 0x30, 0x1F, 0x82, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC1, 0xF0,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0xB0, 0xE0, 0x18, 0x63, 0x18, 0x66,
  0x09, 0x83, 0x30, 0x6C, 0x0F, 0x01, 0xE0, 0x3C, 0x0C, 0xC1, 0x98, 0x33,
  0x06, 0x60, 0x8C, 0x30, 0xC6, 0x18, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C,
  0x21, 0x86, 0x18, 0x61, 0x0F, 0xFF, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x78,
  0xA0, 0xF3, 0x43, 0x46, 0x87, 0x8D, 0x0B, 0x1A, 0x36, 0x24, 0x48, 0xC9,
  0xB1, 0x92, 0x63, 0x2C, 0xC4, 0x71, 0x88, 0xE2, 0x31, 0xCC, 0x63, 0x18,
  0x1C, 0x31, 0xC3, 0x1C, 0x31, 0x42, 0x34, 0x63, 0x66, 0x36, 0x63, 0x66,
  0x26, 0x46, 0x2C, 0x62, 0xC6, 0x3C, 0x63, 0xC4, 0x38, 0xC3, 0x8C, 0x18,
  0x07, 0x03, 0xE1, 0x8C, 0xC3, 0x60, 0xD8, 0x36, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1B, 0x06, 0xC1, 0xB0, 0xCC, 0x73, 0xB8, 0x7C, 0x00, 0x1F, 0x86,
  0x61, 0x8C, 0x43, 0x30, 0xCC, 0x63, 0x18, 0xCC, 0x3F, 0x1E, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x07, 0x03, 0xE1, 0x8C, 0xC3, 0x60,
  0xD8, 0x36, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC1, 0xB0, 0xCC,
  0x73, 0xB8, 0x7C, 0x02, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0x1F, 0x86, 0x61,
  0x8C, 0x43, 0x30, 0xCC, 0x63, 0x18, 0xDC, 0x3E, 0x19, 0x06, 0x61, 0x98,
  0x66, 0x11, 0x8C, 0x33, 0x0C, 0x03, 0x83, 0xF1, 0xC4, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x31,
  0xF8, 0xFC, 0x00, 0xFF, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x30, 0xCC, 0x33, 0x0C, 0x83,
  0x60, 0x98, 0x66, 0x19, 0x86, 0xC1, 0xB0, 0xCC, 0x33, 0x0C, 0xC3, 0x31,
  0x8E, 0xE1, 0xF0, 0xC1, 0xE1, 0xB0, 0xD8, 0x6C, 0x66, 0x33, 0x31, 0x98,
  0xC8, 0x6C, 0x36, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0x80, 0xC3, 0x07, 0x86,
  0x1B, 0x1C, 0x36, 0x38, 0xCC, 0x51, 0x99, 0xA2, 0x32, 0xCC, 0x6D, 0x98,
  0xDB, 0x61, 0xA6, 0xC2, 0xCD, 0x85, 0x9E, 0x0A, 0x3C, 0x1C, 0x70, 0x30,
  0xE0, 0x61, 0xC0, 0x18, 0x61, 0x98, 0x33, 0x06, 0xC0, 0xD0, 0x1E, 0x03,
  0x80, 0x30, 0x0E, 0x03, 0xC0, 0x78, 0x1B, 0x03, 0x20, 0xC4, 0x10, 0xC6,
  0x18, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0x58, 0x58, 0x70, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0F, 0xE3,
  0xF8, 0x07, 0x87, 0xC3, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x0F, 0x0F,
  0x80, 0xC4, 0x44, 0x66, 0x66, 0x62, 0x22, 0x33, 0x33, 0x07, 0x87, 0xC0,
  0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x0F, 0x0F, 0x80, 0x06, 0x07, 0x02,
  0xC3, 0x61, 0x31, 0x89, 0x87, 0xC3, 0xFE, 0xCD, 0x90, 0x08, 0x1E, 0xDC,
  0xCC, 0x64, 0x36, 0x1B, 0x09, 0x8C, 0x86, 0x43, 0x23, 0x9B, 0x8F, 0x40,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x21, 0xBC, 0xE6, 0x63, 0x31, 0x90, 0xD8,
  0x6C, 0x36, 0x13, 0x19, 0x8D, 0xCC, 0xDC, 0x00, 0x0C, 0x7D, 0xC3, 0x0C,
  0x18, 0x30, 0x60, 0x81, 0x03, 0x06, 0x47, 0x80, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x09, 0x8F, 0x47, 0x31, 0x8C, 0xC3, 0x30, 0xCC, 0x23, 0x18, 0x86,
  0x21, 0x88, 0xE3, 0x70, 0xF4, 0x00, 0x0C, 0x7D, 0x8B, 0x1C, 0x79, 0xFF,
  0x40, 0x81, 0x02, 0x06, 0x27, 0xC0, 0x00, 0xC0, 0x3C, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x03, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x38, 0x02, 0x00, 0x02, 0x01, 0xEC, 0x73, 0x0C, 0x61, 0x0C, 0x61, 0x8C,
  0x21, 0x8C, 0x21, 0x84, 0x30, 0x8E, 0x1B, 0x83, 0xF0, 0x06, 0x00, 0xC0,
  0x10, 0x86, 0x1F, 0x80, 0x40, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x21,
  0xFC, 0xE6, 0x63, 0x31, 0x90, 0x98, 0xCC, 0x66, 0x33, 0x19, 0x09, 0x8C,
  0xC6, 0x00, 0x08, 0xC4, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x21, 0x18,
  0xC0, 0x01, 0x03, 0x01, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xE0, 0x40,
  0x0C, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x8C, 0xCC, 0x6C, 0x34, 0x16, 0x1F,
  0x0F, 0x86, 0xC2, 0x61, 0x11, 0x8C, 0xC6, 0x00, 0x0C, 0x61, 0x86, 0x10,
  0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC0, 0x02, 0x11, 0xFB,
  0xCE, 0x76, 0x63, 0x13, 0x11, 0x91, 0x8D, 0x8C, 0x6C, 0x63, 0x63, 0x13,
  0x11, 0x91, 0x8D, 0x8C, 0x6C, 0x63, 0x00, 0x02, 0x1F, 0xCE, 0x66, 0x33,
  0x19, 0x09, 0x8C, 0xC6, 0x63, 0x31, 0x90, 0x98, 0xCC, 0x60, 0x0C, 0x3E,
  0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC2, 0x86, 0x86, 0x8C, 0xDC, 0x78, 0x01,
  0x06, 0xF1, 0xCC, 0x63, 0x18, 0xC4, 0x33, 0x0C, 0xC3, 0x30, 0x8C, 0x63,
  0x19, 0xCC, 0x6E, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x1E,
  0xDC, 0xCC, 0x64, 0x36, 0x1B, 0x09, 0x8C, 0x86, 0x43, 0x23, 0x9B, 0x8F,
  0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x00, 0x02, 0x7C, 0xE1, 0x83,
  0x04, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x00, 0x0C, 0x3F, 0x22, 0x60,
  0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x0C, 0x98, 0xF8, 0x31, 0x89, 0xF6,
  0x31, 0x88, 0xC6, 0x31, 0x88, 0x73, 0x80, 0x63, 0x63, 0x63, 0x63, 0x42,
  0xC6, 0xC6, 0xC6, 0x86, 0x8C, 0xDC, 0xFC, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC,
  0xC8, 0xD8, 0xD0, 0xF0, 0x70, 0x60, 0x60, 0xC7, 0x3E, 0x31, 0xB3, 0x89,
  0x9C, 0xCC, 0xA6, 0x6D, 0x23, 0x4B, 0x1E, 0x50, 0xF3, 0x87, 0x1C, 0x38,
  0xC1, 0x86, 0x00, 0x19, 0xC6, 0x61, 0xB0, 0x68, 0x0E, 0x03, 0x01, 0xC0,
  0x50, 0x36, 0x19, 0x86, 0x63, 0x18, 0x18, 0x61, 0x18, 0x23, 0x04, 0x40,
  0x98, 0x12, 0x02, 0xC0, 0x58, 0x0A, 0x01, 0xC0, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x03, 0x06, 0x04, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0x7C, 0xFC, 0x07, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x70, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40,
  0x40, 0x70, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x16, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x03, 0x0E, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0xE0, 0x80, 0x21, 0xF9, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 10, 16, 10, 0, -16 },
  { 39, 9, 18, 9, 0, -17 },
  { 60, 12, 17, 14, 1, -17 },
  { 86, 10, 17, 10, 0, -17 },
  { 108, 3, 6, 4, 2, -16 },
  { 111, 7, 21, 6, 0, -17 },
  { 130, 7, 21, 6, -2, -17 },
  { 149, 7, 8, 8, 2, -18 },
  { 156, 8, 11, 10, 1, -14 },
  { 167, 4, 6, 5, -1, -3 },
  { 170, 6, 2, 6, 0, -7 },
  { 172, 3, 3, 5, 0, -3 },
  { 174, 10, 16, 8, -1, -16 },
  { 194, 9, 17, 9, 0, -17 },
  { 214, 6, 16, 9, 2, -16 },
  { 226, 10, 17, 9, -1, -17 },
  { 248, 9, 17, 9, 0, -17 },
  { 268, 9, 17, 9, 0, -17 },
  { 288, 9, 16, 9, 0, -16 },
  { 306, 9, 17, 9, 1, -17 },
  { 326, 9, 16, 9, 1, -16 },
  { 344, 9, 17, 9, 0, -17 },
  { 364, 9, 17, 9, 0, -17 },
  { 384, 5, 12, 5, 0, -12 },
  { 392, 6, 15, 5, -1, -12 },
  { 404, 8, 10, 10, 1, -13 },
  { 414, 8, 6, 10, 1, -11 },
  { 420, 8, 10, 10, 1, -13 },
  { 430, 8, 17, 7, 0, -17 },
  { 447, 12, 19, 13, 1, -17 },
  { 476, 10, 16, 9, -2, -16 },
  { 496, 10, 16, 10, 0, -16 },
  { 516, 10, 17, 9, 1, -17 },
  { 538, 10, 16, 11, 0, -16 },
  { 558, 9, 16, 8, 0, -16 },
  { 576, 9, 16, 8, 0, -16 },
  { 594, 11, 17, 11, 1, -17 },
  { 618, 12, 16, 11, 0, -16 },
  { 642, 9, 16, 6, -1, -16 },
  { 660, 8, 20, 5, -3, -16 },
  { 680, 11, 16, 9, 0, -16 },
  { 702, 6, 16, 8, 0, -16 },
  { 714, 15, 16, 15, 0, -16 },
  { 744, 12, 16, 12, 0, -16 },
  { 768, 10, 17, 11, 1, -17 },
  { 790, 10, 16, 9, 0, -16 },
  { 810, 10, 21, 11, 1, -17 },
  { 837, 10, 16, 10, 0, -16 },
  { 857, 10, 17, 9, -1, -17 },
  { 879, 8, 16, 8, 2, -16 },
  { 895, 10, 16, 11, 1, -16 },
  { 915, 9, 16, 9, 2, -16 },
  { 933, 15, 16, 15, 2, -16 },
  { 963, 11, 16, 9, -1, -16 },
  { 985, 8, 16, 8, 2, -16 },
  { 1001, 10, 16, 8, -1, -16 },
  { 1021, 9, 21, 6, -1, -17 },
  { 1045, 4, 16, 8, 2, -16 },
  { 1053, 9, 21, 6, -2, -17 },
  { 1077, 9, 8, 9, 0, -16 },
  { 1086, 7, 1, 7, -2, 2 },
  { 1087, 3, 4, 6, 3, -18 },
  { 1089, 9, 13, 10, 1, -13 },
  { 1104, 9, 17, 10, 0, -17 },
  { 1124, 7, 13, 7, 1, -13 },
  { 1136, 10, 17, 10, 1, -17 },
  { 1158, 7, 13, 9, 1, -13 },
  { 1170, 11, 24, 5, -3, -18 },
  { 1203, 11, 19, 10, -1, -13 },
  { 1230, 9, 17, 9, 0, -17 },
  { 1250, 5, 17, 4, 0, -17 },
  { 1261, 8, 23, 4, -3, -17 },
  { 1284, 9, 17, 8, 0, -17 },
  { 1304, 6, 17, 4, 0, -17 },
  { 1317, 13, 13, 14, 0, -13 },
  { 1339, 9, 13, 9, 0, -13 },
  { 1354, 8, 13, 9, 1, -13 },
  { 1367, 10, 18, 10, -1, -13 },
  { 1390, 9, 19, 10, 1, -13 },
  { 1412, 7, 13, 6, 0, -13 },
  { 1424, 8, 13, 7, 0, -13 },
  { 1437, 5, 15, 5, 1, -15 },
  { 1447, 8, 12, 10, 1, -12 },
  { 1459, 8, 12, 8, 1, -12 },
  { 1471, 13, 12, 12, 1, -12 },
  { 1491, 10, 12, 8, -1, -12 },
  { 1506, 11, 18, 8, -2, -12 },
  { 1531, 8, 12, 7, -1, -12 },
  { 1543, 8, 20, 8, 1, -16 },
  { 1563, 2, 23, 8, 3, -18 },
  { 1569, 8, 20, 8, -1, -16 },
  { 1589, 8, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Italic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC23PT7B_H_
