#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x63, 0x18, 0x84, 0x63, 0x00, 0x0C, 0x60, 0x4E, 0xF7,
  0x29, 0x00, 0x09, 0x04, 0x82, 0x43, 0x47, 0xF8, 0x90, 0xD0, 0x48, 0x24,
  0x7F, 0x12, 0x09, 0x05, 0x84, 0x80, 0x04, 0x1E, 0x3B, 0x28, 0x28, 0x28,
  0x38, 0x1C, 0x14, 0x14, 0x14, 0x9C, 0xF8, 0x20, 0x20, 0x30, 0x9E, 0x45,
  0x93, 0x68, 0x92, 0x25, 0x09, 0x5E, 0xA9, 0x4A, 0x44, 0x91, 0x6C, 0x92,
  0x24, 0x90, 0xC0, 0x0C, 0x1E, 0x12, 0x36, 0x34, 0x3C, 0x18, 0x38, 0x5B,
  0xCA, 0x8E, 0x8C, 0xCC, 0x76, 0x5F, 0x80, 0x04, 0x21, 0x84, 0x30, 0x86,
  0x10, 0x41, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x60, 0x10, 0x42, 0x10, 0x84,
  0x21, 0x08, 0xC6, 0x23, 0x11, 0x88, 0x80, 0x20, 0xCA, 0x1F, 0x73, 0x45,
  0x80, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x2D, 0x28, 0xFF,
  0x80, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x0C, 0x3C, 0xC9, 0x12, 0x2C, 0x50,
  0xA3, 0x46, 0x8B, 0x16, 0x65, 0x8E, 0x00, 0x19, 0x9D, 0xA3, 0x18, 0x84,
  0x23, 0x18, 0x84, 0x60, 0x06, 0x1F, 0x11, 0x01, 0x01, 0x03, 0x02, 0x06,
  0x0C, 0x18, 0x10, 0x20, 0x42, 0xFC, 0x1C, 0x3E, 0x03, 0x02, 0x02, 0x06,
  0x3C, 0x38, 0x0C, 0x04, 0x04, 0x0C, 0x98, 0xF0, 0x03, 0x06, 0x06, 0x0E,
  0x16, 0x14, 0x24, 0x64, 0x4C, 0x8C, 0xFE, 0x08, 0x18, 0x18, 0x1F, 0x1E,
  0x30, 0x20, 0x20, 0x20, 0x7C, 0x0C, 0x06, 0x04, 0x04, 0x0C, 0x98, 0xF0,
  0x07, 0x0F, 0x10, 0x30, 0x20, 0x68, 0x5C, 0x66, 0x46, 0x46, 0xC6, 0x44,
  0x4C, 0x78, 0x7E, 0xFC, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x00, 0x0C, 0x3E, 0x23, 0x23, 0x22, 0x36, 0x1C, 0x38, 0x6C,
  0xC4, 0x84, 0x84, 0xCC, 0x78, 0x0C, 0x7C, 0x8B, 0x16, 0x2C, 0x59, 0xB7,
  0x3E, 0x08, 0x30, 0x41, 0x9E, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x23, 0x11, 0x88, 0x00, 0x02, 0x1C, 0xE7, 0x0C,
  0x0E, 0x07, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0xC0, 0xC0, 0x60,
  0x63, 0x18, 0x60, 0x18, 0xF0, 0x41, 0x0C, 0x21, 0x0C, 0x21, 0x80, 0x00,
  0xC3, 0x00, 0x03, 0x81, 0x98, 0x61, 0x88, 0x12, 0x7A, 0x5A, 0x52, 0x4A,
  0x4B, 0x52, 0x4A, 0x4B, 0x5A, 0x64, 0xC4, 0x00, 0x80, 0x09, 0x80, 0xC0,
  0x06, 0x0C, 0x18, 0x70, 0xA3, 0x44, 0x99, 0x3E, 0x7D, 0x8A, 0x1C, 0x38,
  0x40, 0x1C, 0x1F, 0x31, 0x31, 0x31, 0x23, 0x3E, 0x7E, 0x66, 0x42, 0x42,
  0x46, 0xCC, 0xF8, 0x0E, 0x1F, 0x30, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xC8, 0x78, 0x1C, 0x0F, 0x8C, 0xC6, 0x23, 0x19, 0x0C,
  0x84, 0xC2, 0x63, 0x21, 0x90, 0x88, 0xCD, 0xC7, 0xC0, 0x1F, 0x1F, 0x30,
  0x30, 0x30, 0x20, 0x3C, 0x7C, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xF8, 0x1F,
  0x1F, 0x30, 0x30, 0x30, 0x20, 0x20, 0x7C, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0x0F, 0x0F, 0xCC, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x1E, 0x82, 0x41,
  0x21, 0x90, 0xCC, 0x43, 0xE0, 0x10, 0xC4, 0x23, 0x08, 0xC6, 0x31, 0x88,
  0x63, 0xF1, 0xFC, 0x63, 0x10, 0xC4, 0x21, 0x08, 0xC2, 0x31, 0x80, 0x1E,
  0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x1F, 0x00,
  0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83,
  0x04, 0x08, 0xF1, 0x80, 0x10, 0x88, 0xCC, 0xC6, 0xC3, 0x41, 0x60, 0xE0,
  0xF0, 0x68, 0x26, 0x13, 0x09, 0x8C, 0x46, 0x30, 0x10, 0x8C, 0x63, 0x10,
  0x8C, 0x62, 0x10, 0x8C, 0x7C, 0x18, 0x38, 0xC1, 0x8E, 0x0C, 0x70, 0xA2,
  0x87, 0x14, 0x78, 0xA2, 0x8D, 0x34, 0x69, 0x62, 0x5B, 0x12, 0x98, 0x9C,
  0x8C, 0xC4, 0x66, 0x60, 0x18, 0x46, 0x33, 0x8C, 0xE3, 0x28, 0x8A, 0x22,
  0xD9, 0xB6, 0x65, 0x11, 0x44, 0x51, 0x1C, 0xC7, 0x31, 0x80, 0x0E, 0x3F,
  0x23, 0x61, 0x41, 0xC1, 0xC3, 0xC3, 0x83, 0x82, 0x86, 0x84, 0xCC, 0x78,
  0x1C, 0x1E, 0x33, 0x33, 0x33, 0x23, 0x22, 0x7E, 0x78, 0x40, 0x40, 0x40,
  0xC0, 0xC0, 0x0E, 0x3F, 0x23, 0x61, 0x41, 0xC1, 0xC3, 0xC3, 0x83, 0x82,
  0x86, 0x84, 0xCC, 0x78, 0x10, 0x18, 0x18, 0x1C, 0x1E, 0x33, 0x33, 0x33,
  0x23, 0x26, 0x7C, 0x68, 0x4C, 0x4C, 0x4C, 0xC4, 0xC4, 0x0E, 0x3F, 0x20,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x98, 0xF8, 0x7F,
  0xFC, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x00,
  0x21, 0x21, 0x63, 0x63, 0x43, 0x42, 0x42, 0xC6, 0xC6, 0x86, 0x84, 0x8C,
  0xC8, 0xF8, 0x83, 0x0E, 0x14, 0x68, 0xD1, 0x26, 0x48, 0xB1, 0x43, 0x87,
  0x0C, 0x18, 0x00, 0x42, 0x1A, 0x10, 0x91, 0x84, 0x8C, 0x64, 0x62, 0x25,
  0x31, 0x29, 0x9B, 0x48, 0xD2, 0xC6, 0x94, 0x38, 0xE1, 0xC7, 0x0E, 0x30,
  0x61, 0x80, 0x18, 0x8C, 0xC6, 0x43, 0x60, 0xA0, 0x70, 0x30, 0x18, 0x1C,
  0x1A, 0x09, 0x0C, 0x84, 0x46, 0x30, 0x42, 0x8D, 0x12, 0x66, 0x8F, 0x1C,
  0x38, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x00, 0x1F, 0x8F, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x07, 0xE0, 0x0F,
  0x0E, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x40, 0x40, 0xF0, 0x93, 0x6C, 0x92, 0x49, 0xB6, 0x40, 0x1E, 0x3C,
  0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18,
  0xE0, 0x04, 0x0C, 0x1C, 0x14, 0x36, 0x22, 0x42, 0xC3, 0xFC, 0xB4, 0x1D,
  0x33, 0x62, 0x62, 0x42, 0x46, 0x46, 0xC4, 0x4C, 0x74, 0x18, 0x10, 0x30,
  0x30, 0x2E, 0x32, 0x23, 0x62, 0x62, 0x42, 0x46, 0x44, 0xCC, 0xB8, 0x1E,
  0x61, 0x83, 0x04, 0x08, 0x30, 0x60, 0x48, 0xF0, 0x01, 0x80, 0x80, 0x40,
  0x21, 0xF1, 0x99, 0x88, 0xC4, 0x42, 0x23, 0x31, 0x98, 0x84, 0xC3, 0xA0,
  0x1E, 0x65, 0x9B, 0x27, 0xC8, 0x30, 0x60, 0x44, 0xF0, 0x01, 0x83, 0x81,
  0x00, 0x80, 0xC0, 0xF0, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x38, 0x10, 0x00, 0x1D, 0x33, 0x62, 0x62,
  0x42, 0x46, 0xC6, 0xC4, 0x4C, 0x7C, 0x0C, 0x08, 0x18, 0xF0, 0x60, 0x18,
  0x20, 0xC1, 0x82, 0xE6, 0x48, 0xB1, 0x66, 0x8D, 0x12, 0x2C, 0xD9, 0x80,
  0x11, 0x00, 0x32, 0x26, 0x64, 0x44, 0xCC, 0x04, 0x10, 0x00, 0x0C, 0x20,
  0x86, 0x18, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x63, 0x08, 0x00, 0x18, 0x10,
  0x30, 0x31, 0x22, 0x24, 0x2C, 0x78, 0x78, 0x78, 0x48, 0x48, 0xC8, 0xCC,
  0x18, 0x8C, 0x62, 0x10, 0x8C, 0x62, 0x10, 0x8C, 0x60, 0x2E, 0xE6, 0x64,
  0x88, 0xB3, 0x36, 0x66, 0x88, 0x91, 0x12, 0x22, 0xCC, 0xD9, 0x98, 0x2E,
  0x64, 0x8B, 0x16, 0x68, 0xD1, 0x22, 0xCD, 0x98, 0x1E, 0x65, 0x8B, 0x14,
  0x28, 0xF1, 0xE2, 0x4C, 0xF0, 0x17, 0x0C, 0x84, 0x66, 0x23, 0x11, 0x08,
  0x8C, 0x44, 0x66, 0x3E, 0x10, 0x08, 0x0C, 0x06, 0x00, 0x1D, 0x33, 0x62,
  0x62, 0x42, 0x46, 0xC6, 0xC4, 0x4C, 0x7C, 0x0C, 0x0C, 0x08, 0x08, 0x18,
  0x2C, 0xC2, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x00, 0x3D, 0x86, 0x18, 0x30,
  0x61, 0x86, 0x9B, 0xC0, 0x10, 0x8C, 0xF2, 0x11, 0x8C, 0x42, 0x11, 0x86,
  0x00, 0x33, 0x22, 0x22, 0x62, 0x66, 0x46, 0x44, 0x4C, 0xCC, 0x7C, 0xC7,
  0x3C, 0xB6, 0xD3, 0xCE, 0x28, 0xE3, 0x00, 0xCC, 0xF3, 0x3D, 0xCB, 0x56,
  0x95, 0x29, 0x4A, 0x73, 0x98, 0xCE, 0x33, 0x00, 0x33, 0x12, 0x16, 0x1C,
  0x18, 0x18, 0x38, 0x2C, 0x6C, 0xC4, 0x18, 0x8C, 0xC6, 0x43, 0x61, 0xA0,
  0xD0, 0x78, 0x38, 0x1C, 0x0C, 0x06, 0x02, 0x03, 0x07, 0x01, 0x00, 0x3E,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x30, 0x41, 0xF0, 0x02, 0x1C, 0x20, 0x41,
  0x83, 0x04, 0x18, 0x61, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x30, 0xFF,
  0xFF, 0xF0, 0x10, 0x38, 0x30, 0x60, 0xC1, 0x02, 0x04, 0x06, 0x30, 0x40,
  0x83, 0x06, 0x08, 0x30, 0xC0, 0xE3, 0x7E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 4, 0, -14 },
  { 10, 5, 5, 6, 2, -14 },
  { 14, 9, 14, 8, 0, -14 },
  { 30, 8, 15, 7, 0, -14 },
  { 45, 10, 14, 12, 1, -14 },
  { 63, 8, 14, 8, 0, -14 },
  { 77, 2, 5, 4, 2, -14 },
  { 79, 6, 17, 5, 0, -14 },
  { 92, 5, 17, 5, -1, -14 },
  { 103, 6, 7, 7, 2, -15 },
  { 109, 7, 9, 8, 1, -11 },
  { 117, 3, 5, 4, -1, -2 },
  { 119, 5, 2, 5, 0, -6 },
  { 121, 2, 2, 4, 0, -2 },
  { 122, 9, 14, 6, -1, -14 },
  { 138, 7, 14, 7, 0, -14 },
  { 151, 5, 14, 7, 2, -14 },
  { 160, 8, 14, 7, -1, -14 },
  { 174, 8, 14, 7, 0, -14 },
  { 188, 8, 14, 7, 0, -14 },
  { 202, 8, 14, 7, 0, -14 },
  { 216, 8, 14, 7, 0, -14 },
  { 230, 7, 14, 7, 1, -14 },
  { 243, 8, 14, 7, 0, -14 },
  { 257, 7, 14, 7, 0, -14 },
  { 270, 4, 10, 4, 0, -10 },
  { 275, 5, 13, 4, -1, -10 },
  { 284, 7, 8, 8, 1, -11 },
  { 291, 7, 5, 8, 1, -9 },
  { 296, 7, 8, 8, 1, -11 },
  { 303, 6, 14, 5, 0, -14 },
  { 314, 11, 16, 11, 0, -14 },
  { 336, 7, 14, 8, -1, -14 },
  { 349, 8, 14, 8, 0, -14 },
  { 363, 8, 14, 7, 1, -14 },
  { 377, 9, 14, 9, 0, -14 },
  { 393, 8, 14, 7, 0, -14 },
  { 407, 8, 14, 7, 0, -14 },
  { 421, 9, 14, 9, 1, -14 },
  { 437, 10, 14, 9, 0, -14 },
  { 455, 7, 14, 5, -1, -14 },
  { 468, 7, 18, 4, -3, -14 },
  { 484, 9, 14, 8, 0, -14 },
  { 500, 5, 14, 6, 0, -14 },
  { 509, 13, 14, 12, 0, -14 },
  { 532, 10, 14, 10, 0, -14 },
  { 550, 8, 14, 9, 1, -14 },
  { 564, 8, 14, 8, 0, -14 },
  { 578, 8, 17, 9, 1, -14 },
  { 595, 8, 14, 8, 0, -14 },
  { 609, 8, 14, 7, 0, -14 },
  { 623, 7, 14, 7, 1, -14 },
  { 636, 8, 14, 9, 1, -14 },
  { 650, 7, 14, 8, 2, -14 },
  { 663, 13, 14, 12, 1, -14 },
  { 686, 9, 14, 7, -1, -14 },
  { 702, 7, 14, 7, 1, -14 },
  { 715, 9, 14, 6, -1, -14 },
  { 731, 8, 17, 5, -1, -14 },
  { 748, 3, 14, 6, 2, -14 },
  { 754, 7, 17, 5, -1, -14 },
  { 769, 8, 8, 8, 0, -14 },
  { 777, 6, 1, 6, -2, 2 },
  { 778, 2, 3, 5, 3, -15 },
  { 779, 8, 10, 8, 0, -10 },
  { 789, 8, 14, 8, 0, -14 },
  { 803, 7, 10, 6, 0, -10 },
  { 812, 9, 14, 8, 0, -14 },
  { 828, 7, 10, 7, 0, -10 },
  { 837, 9, 20, 4, -2, -15 },
  { 860, 8, 15, 8, 0, -10 },
  { 875, 7, 14, 8, 0, -14 },
  { 888, 4, 14, 4, 0, -14 },
  { 895, 6, 19, 4, -2, -14 },
  { 910, 8, 14, 7, 0, -14 },
  { 924, 5, 14, 4, 0, -14 },
  { 933, 11, 10, 12, 0, -10 },
  { 947, 7, 10, 8, 0, -10 },
  { 956, 7, 10, 8, 0, -10 },
  { 965, 9, 14, 8, -1, -10 },
  { 981, 8, 15, 8, 0, -10 },
  { 996, 6, 10, 5, 0, -10 },
  { 1004, 6, 10, 6, 0, -10 },
  { 1012, 5, 13, 5, 0, -13 },
  { 1021, 8, 10, 8, 0, -10 },
  { 1031, 6, 10, 6, 1, -10 },
  { 1039, 10, 10, 10, 1, -10 },
  { 1052, 8, 10, 7, -1, -10 },
  { 1062, 9, 15, 6, -2, -10 },
  { 1079, 7, 10, 5, -1, -10 },
  { 1088, 7, 17, 6, 0, -14 },
  { 1103, 1, 20, 7, 3, -15 },
  { 1106, 7, 17, 6, -1, -14 },
  { 1121, 7, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Italic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC19PT7B_H_
