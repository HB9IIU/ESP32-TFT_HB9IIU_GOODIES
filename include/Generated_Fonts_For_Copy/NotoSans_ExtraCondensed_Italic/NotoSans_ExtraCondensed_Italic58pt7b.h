#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x01,
  0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x0F, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xF3, 0x0C, 0x03, 0xC3, 0x04, 0x07, 0xC7, 0x00, 0x07, 0x86, 0x00,
  0x07, 0x86, 0x00, 0x07, 0x86, 0x00, 0x07, 0x8E, 0x00, 0x07, 0x8E, 0x00,
  0x07, 0xCC, 0x00, 0x03, 0xEC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x37, 0xE0, 0x00, 0x33, 0xE0, 0x00, 0x31, 0xE0,
  0x00, 0x71, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x61, 0xE0, 0x00, 0x61, 0xE0,
  0x00, 0x61, 0xE0, 0x00, 0xE1, 0xE0, 0xC0, 0xE3, 0xC0, 0xF0, 0xCF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x10, 0x0F, 0xE0,
  0x07, 0x80, 0x7F, 0x80, 0x1E, 0x03, 0xFF, 0x00, 0xF0, 0x1E, 0x3C, 0x03,
  0xC0, 0x78, 0x70, 0x1E, 0x03, 0xC1, 0xC0, 0x78, 0x0F, 0x07, 0x03, 0xC0,
  0x38, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xC0, 0x1C,
  0x0F, 0x0F, 0x00, 0x70, 0x3C, 0x38, 0x03, 0xC0, 0xE1, 0xE0, 0x0F, 0x07,
  0x87, 0x00, 0x3C, 0x1E, 0x3C, 0x00, 0xF0, 0x78, 0xE0, 0x03, 0x81, 0xC7,
  0x87, 0xCE, 0x0F, 0x1C, 0x7F, 0xB8, 0x38, 0xF1, 0xFF, 0xE1, 0xE3, 0x8F,
  0x3F, 0xC7, 0x9E, 0x78, 0x7F, 0xFC, 0xF1, 0xC1, 0xDF, 0xE3, 0xCF, 0x07,
  0x7F, 0x1E, 0x3C, 0x1C, 0xF8, 0x78, 0xE0, 0x70, 0x03, 0xC7, 0x83, 0xC0,
  0x0F, 0x1E, 0x0F, 0x00, 0x78, 0x70, 0x3C, 0x01, 0xE1, 0xC0, 0xF0, 0x0F,
  0x0F, 0x03, 0x80, 0x3C, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x78, 0x07, 0x83,
  0xC1, 0xE0, 0x3C, 0x0F, 0x07, 0x00, 0xE0, 0x38, 0x3C, 0x07, 0x80, 0xE0,
  0xE0, 0x1C, 0x03, 0xC7, 0x80, 0xF0, 0x0F, 0x3C, 0x03, 0x80, 0x3F, 0xF0,
  0x1E, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x78, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE1, 0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xC0,
  0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0x0F, 0xBE, 0x1F,
  0x1F, 0x3E, 0x1E, 0x3E, 0x1E, 0x1E, 0x3C, 0x1F, 0x3E, 0x7C, 0x1F, 0x3C,
  0x78, 0x0F, 0x3C, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF0, 0x07, 0xF0,
  0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xE0,
  0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xF0, 0xFE, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0,
  0x3F, 0xF0, 0xF8, 0x1F, 0xE0, 0xF8, 0x02, 0x00, 0x00, 0x3E, 0x7C, 0xF9,
  0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x04, 0x1E, 0x03, 0x8F, 0x03, 0xF7, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0x83, 0xFF, 0xC1, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF3,
  0x81, 0xF1, 0xE0, 0xF8, 0xF8, 0x38, 0x3C, 0x08, 0x1E, 0x00, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x11, 0xEF, 0xFF,
  0xFF, 0xEF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFC, 0xF8, 0x07, 0xC1, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00,
  0x7C, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0xF9, 0xF0,
  0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xDE, 0x3F, 0x7C, 0xFC, 0xF8, 0xF1, 0xE1, 0xC3, 0xC1, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0x80, 0xF8,
  0x00, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xF0, 0x7E, 0x00, 0xC0, 0x3F, 0x00,
  0x80, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xC0, 0xC0, 0x1F, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x3C, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x0F,
  0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x80, 0x07, 0xC0, 0xC0, 0x1F, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xF0, 0x40, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x1F, 0x00, 0x3C, 0xFF, 0x80, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFC, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80,
  0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xF8,
  0x0F, 0x83, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x87, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x07,
  0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x01,
  0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xE7,
  0xE0, 0x1F, 0x87, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x0F,
  0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF8,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F,
  0x80, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF8, 0xFC, 0x0F, 0xC1,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0,
  0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xF0,
  0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3F, 0x1F, 0x01, 0xF8, 0x3E, 0x0F, 0xE0, 0xFE, 0xF7, 0x83,
  0xFF, 0xFE, 0x07, 0xFE, 0xF8, 0x0F, 0xE3, 0xC0, 0x1E, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7E, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0F, 0x0F, 0xC1, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x07, 0x80, 0xFF, 0x87, 0x07, 0x01, 0xFF, 0x87, 0x0F, 0x03,
  0xFF, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x1E, 0x0F, 0x0F, 0x07, 0x1E, 0x0E,
  0x0F, 0x07, 0x1C, 0x1E, 0x0E, 0x07, 0x3C, 0x1C, 0x0E, 0x0F, 0x3C, 0x3C,
  0x1E, 0x0F, 0x38, 0x3C, 0x1E, 0x0E, 0x38, 0x38, 0x1E, 0x0E, 0x78, 0x38,
  0x1C, 0x0E, 0x78, 0x78, 0x3C, 0x1E, 0x70, 0x78, 0x3C, 0x1C, 0x70, 0x70,
  0x3C, 0x1C, 0x70, 0x70, 0x78, 0x3C, 0x70, 0x70, 0x78, 0x38, 0x70, 0x70,
  0x78, 0x78, 0xF0, 0x70, 0xF8, 0x70, 0xF0, 0x79, 0xF8, 0xF0, 0xF0, 0x7F,
  0xBF, 0xE0, 0xF0, 0x7F, 0x9F, 0xC0, 0xF0, 0x3E, 0x1F, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xDF, 0x00, 0x03, 0xDF, 0x00, 0x07, 0xDF, 0x00, 0x07, 0x9F, 0x00, 0x07,
  0x9F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0,
  0x1F, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x01, 0xF8, 0x07, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0xF8,
  0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7C, 0x3F,
  0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xF0, 0xE0, 0x07, 0xE0, 0x10, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x08, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x3F, 0x80, 0x3C, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1E,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F,
  0x80, 0x7C, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0x87, 0xE0, 0x0F, 0xC0, 0x0C, 0x01, 0xF8, 0x00,
  0x40, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0x78, 0x03, 0xFF, 0x0F, 0x80, 0x3F, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x78, 0x07, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x10, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3C, 0x7E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x0F, 0xBC, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x01, 0xF7,
  0x80, 0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0xF3,
  0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0xF9,
  0xE0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x07, 0xCF, 0x80, 0x3C,
  0x78, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x07, 0x87, 0x83, 0xC3, 0xE0, 0x1F,
  0x0F, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x3C,
  0x3E, 0x00, 0xF0, 0x78, 0xF8, 0x7C, 0x01, 0xE0, 0xF1, 0xE0, 0xF8, 0x07,
  0xC1, 0xE7, 0xC1, 0xE0, 0x0F, 0x83, 0xCF, 0x03, 0xC0, 0x1E, 0x07, 0xBE,
  0x0F, 0x80, 0x3C, 0x0F, 0x78, 0x1F, 0x00, 0x78, 0x1F, 0xF0, 0x3E, 0x01,
  0xF0, 0x3F, 0xC0, 0x78, 0x03, 0xE0, 0x7F, 0x80, 0xF0, 0x07, 0x80, 0x7E,
  0x03, 0xE0, 0x0F, 0x00, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0xF0, 0x07, 0xF0,
  0x01, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x7F, 0x80,
  0x1F, 0x00, 0xFF, 0x80, 0x3C, 0x01, 0xEF, 0x00, 0x78, 0x03, 0xDE, 0x01,
  0xF0, 0x0F, 0xBC, 0x03, 0xE0, 0x1F, 0x78, 0x07, 0xC0, 0x3C, 0xF0, 0x0F,
  0x00, 0x79, 0xF0, 0x1E, 0x00, 0xF1, 0xE0, 0x7C, 0x03, 0xE3, 0xC0, 0xF8,
  0x07, 0xC7, 0x81, 0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x1E, 0x1E, 0x07, 0x80,
  0x3C, 0x3E, 0x1F, 0x00, 0xF8, 0x3C, 0x3E, 0x01, 0xF0, 0x78, 0x78, 0x03,
  0xC0, 0xF0, 0xF0, 0x07, 0x81, 0xE1, 0xE0, 0x1F, 0x03, 0xC7, 0xC0, 0x3E,
  0x07, 0x8F, 0x80, 0x7C, 0x07, 0x9E, 0x00, 0xF0, 0x0F, 0x3C, 0x01, 0xE0,
  0x1E, 0x78, 0x07, 0xC0, 0x3D, 0xF0, 0x0F, 0x80, 0x7B, 0xE0, 0x1E, 0x00,
  0xF7, 0x80, 0x3C, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xFE, 0x01, 0xF0, 0x03,
  0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x0F, 0xE0, 0x0F, 0x00, 0x1F,
  0xC0, 0x1E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x7F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x01, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x07, 0x80, 0xFC, 0x07, 0x81, 0xF8, 0x0F, 0x8F, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x79, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x83, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0x03, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x7C,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x3F,
  0x00, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x1F, 0x01,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF3, 0xF0, 0x0F, 0xC0, 0x30, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x08, 0x00, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x00,
  0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B,
  0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF0,
  0x01, 0xF7, 0x80, 0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x3F, 0x00, 0x3E, 0x78,
  0x00, 0xFC, 0x00, 0xF9, 0xE0, 0x07, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0xC0,
  0x1F, 0x1E, 0x00, 0x7F, 0x00, 0x78, 0x78, 0x03, 0xFC, 0x03, 0xE1, 0xE0,
  0x0F, 0xF0, 0x0F, 0x87, 0x80, 0x7B, 0xC0, 0x7C, 0x1E, 0x01, 0xEE, 0x01,
  0xF0, 0x78, 0x07, 0xB8, 0x07, 0x81, 0xE0, 0x3C, 0xE0, 0x3E, 0x07, 0x80,
  0xF3, 0x80, 0xF8, 0x1E, 0x07, 0x9E, 0x07, 0xC0, 0x78, 0x1E, 0x78, 0x1F,
  0x01, 0xE0, 0x79, 0xE0, 0x78, 0x07, 0x83, 0xC7, 0x83, 0xE0, 0x1E, 0x0F,
  0x1E, 0x0F, 0x80, 0x78, 0x78, 0x78, 0x3C, 0x01, 0xE1, 0xE1, 0xE1, 0xF0,
  0x0F, 0x87, 0x87, 0x87, 0x80, 0x3E, 0x3C, 0x1E, 0x3E, 0x00, 0xF8, 0xF0,
  0x78, 0xF8, 0x03, 0xE3, 0xC1, 0xE3, 0xC0, 0x0F, 0x9E, 0x07, 0x9F, 0x00,
  0x3E, 0x78, 0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x7B, 0xE0, 0x03, 0xEF, 0x01,
  0xEF, 0x80, 0x0F, 0xBC, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xF7, 0x80, 0x7F, 0x80, 0x03, 0xDC, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x3C, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x1E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x80, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x80,
  0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x03, 0xC0, 0xF0,
  0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xC0, 0x07,
  0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x3C, 0x03, 0xFE, 0x78, 0x0F, 0xFE,
  0xF0, 0x3F, 0xBF, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C,
  0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0x81, 0xE0, 0x3F, 0x03, 0xE0, 0xFE, 0x07, 0xE7, 0xFC,
  0x0F, 0xFE, 0xF0, 0x0F, 0xF9, 0xE0, 0x0F, 0xE3, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x7C, 0xFE, 0x00, 0xFB, 0xFE, 0x01, 0xEF, 0xFE, 0x03, 0xFC,
  0xFC, 0x07, 0xF0, 0x7C, 0x1F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0,
  0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x83, 0xE0, 0x7F, 0x9F, 0x81, 0xE7, 0xFF,
  0x03, 0xCF, 0xFC, 0x07, 0x8F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x9C, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x02, 0x07, 0xF3, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x0C, 0x1E, 0x00,
  0x1F, 0xC7, 0x80, 0x0F, 0xF9, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFB, 0xFE,
  0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0,
  0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x1F, 0x01, 0xE0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x07, 0x80, 0xFC, 0x01,
  0xF0, 0x7F, 0x00, 0x7E, 0x7F, 0xC0, 0x1F, 0xFD, 0xE0, 0x03, 0xFE, 0x78,
  0x00, 0x7F, 0x1E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xF1, 0xF0, 0x7C, 0x0F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x01, 0xF3,
  0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0xFC, 0x7D, 0xFF, 0x87, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x10, 0x7F, 0x0F, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xE3, 0xC0, 0x0F, 0xF9, 0xE0, 0x0F, 0xFE, 0xF0,
  0x0F, 0xEF, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00,
  0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x07, 0x80, 0xFC, 0x03,
  0xE0, 0xFE, 0x01, 0xF9, 0xFF, 0x00, 0xFF, 0xEF, 0x00, 0x3F, 0xE7, 0x80,
  0x0F, 0xE7, 0xC0, 0x00, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x80, 0x1F, 0x00, 0x70, 0x3F, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x0F,
  0x9F, 0xC0, 0x3E, 0xFF, 0x80, 0xF7, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xC1,
  0xF0, 0x7E, 0x03, 0xC1, 0xF8, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x0F,
  0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3C, 0x1E, 0x00,
  0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xE0,
  0x00, 0x30, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x8F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0x83,
  0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x7C, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xEF, 0x80, 0x0F, 0x8F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0xF0,
  0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0xF1, 0xFC, 0x1F, 0xC0, 0x3C, 0xFF, 0x9F, 0xF8, 0x0F, 0x7F,
  0xF7, 0xFF, 0x03, 0xFD, 0xFF, 0xDF, 0xC0, 0xFC, 0x1F, 0xC1, 0xF0, 0x7E,
  0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0x1E,
  0x0F, 0x80, 0xF8, 0x07, 0x83, 0xC0, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x80,
  0xF8, 0x7C, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x0F, 0x07, 0xC0, 0x7C,
  0x07, 0xC1, 0xE0, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0x80, 0x7C, 0x3E, 0x01,
  0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x07, 0x83, 0xC0, 0x3E, 0x03, 0xE0, 0xF0,
  0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x0F, 0x07,
  0xC0, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0x7C,
  0x3E, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x07, 0x83, 0xE0, 0x3E, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x0F, 0x1F, 0xC0, 0x3C, 0xFF, 0x80, 0xF7, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xC1, 0xF0, 0x7E, 0x03, 0xC1, 0xF8, 0x0F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF0,
  0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x3F, 0x03, 0xE0, 0x7C, 0x1E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x1F,
  0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC3, 0xC0,
  0x3E, 0x1E, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1E, 0x3F, 0x80, 0x07, 0x9F, 0xF0, 0x01, 0xEF, 0xFE, 0x00, 0x7F, 0x8F,
  0x80, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x1E,
  0x03, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0,
  0x3F, 0x83, 0xE0, 0x0F, 0xF3, 0xF0, 0x03, 0xDF, 0xFC, 0x01, 0xF7, 0xFE,
  0x00, 0x7C, 0xFE, 0x00, 0x1E, 0x06, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x3C, 0x03, 0xFE, 0x78, 0x0F,
  0xFE, 0xF0, 0x3F, 0xBF, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xC0,
  0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xF0, 0x03,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78,
  0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8,
  0x07, 0xC1, 0xF0, 0x1F, 0x81, 0xE0, 0x3F, 0x03, 0xE0, 0xFE, 0x07, 0xE7,
  0xFC, 0x0F, 0xFE, 0xF0, 0x0F, 0xF9, 0xE0, 0x0F, 0xE7, 0xC0, 0x02, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x78, 0xF8, 0x0F, 0x3F, 0x01, 0xEF,
  0xE0, 0x3F, 0xFC, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xE1, 0xE0, 0x7C, 0x04, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x0C, 0x03, 0xE0, 0xFD, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF0, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF6, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0xC1, 0xF0,
  0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0xC0,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x1E,
  0x01, 0xF0, 0x3C, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xF0,
  0xFE, 0x03, 0xF7, 0xBC, 0x07, 0xFF, 0x78, 0x0F, 0xFC, 0xE0, 0x0F, 0xF1,
  0xC0, 0x03, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x7C,
  0x03, 0xEF, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78,
  0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF0,
  0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0xF0, 0x0F,
  0x80, 0x7D, 0xE0, 0x3F, 0x00, 0xF3, 0xC0, 0x7E, 0x03, 0xE7, 0x80, 0xFC,
  0x07, 0x8F, 0x03, 0xF8, 0x0F, 0x1E, 0x07, 0x70, 0x3E, 0x3C, 0x1E, 0xE0,
  0x78, 0xF8, 0x3F, 0xC1, 0xF1, 0xF0, 0x77, 0x83, 0xC3, 0xE1, 0xEF, 0x07,
  0x87, 0xC3, 0xDE, 0x1F, 0x0F, 0x8F, 0x3C, 0x3C, 0x1F, 0x1E, 0x78, 0x78,
  0x3E, 0x3C, 0xF1, 0xE0, 0x7C, 0xF1, 0xE3, 0xC0, 0xF9, 0xE3, 0xCF, 0x81,
  0xF3, 0x87, 0x9E, 0x03, 0xCF, 0x0F, 0x3C, 0x07, 0x9E, 0x1E, 0xF0, 0x0F,
  0x78, 0x3D, 0xE0, 0x1E, 0xF0, 0x7B, 0xC0, 0x3D, 0xC0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07,
  0xC3, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x79, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x87,
  0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x07, 0x80, 0xF0,
  0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x8F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x04, 0xFF, 0x80, 0x37, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xE8, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 41, 14, 1, -41 },
  { 73, 16, 15, 20, 6, -41 },
  { 103, 26, 41, 25, 0, -41 },
  { 237, 24, 47, 23, 0, -44 },
  { 378, 30, 43, 35, 3, -42 },
  { 540, 24, 43, 25, 0, -42 },
  { 669, 7, 15, 11, 6, -41 },
  { 683, 18, 51, 15, 1, -42 },
  { 798, 17, 51, 15, -4, -42 },
  { 907, 17, 19, 21, 6, -44 },
  { 948, 22, 27, 25, 2, -34 },
  { 1023, 11, 15, 12, -3, -7 },
  { 1044, 13, 5, 15, 1, -18 },
  { 1053, 6, 7, 12, 1, -7 },
  { 1059, 27, 42, 19, -3, -42 },
  { 1201, 22, 43, 23, 1, -42 },
  { 1320, 15, 41, 23, 6, -41 },
  { 1397, 25, 42, 23, -2, -42 },
  { 1529, 24, 43, 23, -1, -42 },
  { 1658, 24, 42, 23, -1, -42 },
  { 1784, 24, 42, 23, -1, -41 },
  { 1910, 23, 43, 23, 1, -42 },
  { 2034, 23, 41, 23, 2, -41 },
  { 2152, 23, 43, 23, 0, -42 },
  { 2276, 22, 43, 23, 0, -42 },
  { 2395, 11, 31, 12, 0, -31 },
  { 2438, 15, 39, 12, -3, -31 },
  { 2512, 22, 26, 25, 2, -34 },
  { 2584, 22, 17, 25, 2, -29 },
  { 2631, 22, 26, 25, 2, -34 },
  { 2703, 18, 42, 17, 1, -42 },
  { 2798, 32, 47, 34, 1, -42 },
  { 2986, 24, 42, 23, -4, -42 },
  { 3112, 25, 41, 25, 0, -41 },
  { 3241, 25, 43, 22, 2, -42 },
  { 3376, 26, 41, 27, 0, -41 },
  { 3510, 24, 41, 21, 0, -41 },
  { 3633, 24, 41, 20, 0, -41 },
  { 3756, 28, 43, 29, 2, -42 },
  { 3907, 29, 41, 28, 0, -41 },
  { 4056, 22, 41, 15, -3, -41 },
  { 4169, 22, 52, 12, -9, -41 },
  { 4312, 28, 41, 23, 0, -41 },
  { 4456, 16, 41, 20, 0, -41 },
  { 4538, 39, 41, 38, 0, -41 },
  { 4738, 31, 41, 30, 0, -41 },
  { 4897, 26, 43, 29, 2, -42 },
  { 5037, 24, 41, 23, 0, -41 },
  { 5160, 26, 52, 29, 2, -42 },
  { 5329, 25, 41, 24, 0, -41 },
  { 5458, 25, 43, 22, -1, -42 },
  { 5593, 20, 41, 20, 4, -41 },
  { 5696, 27, 42, 27, 2, -41 },
  { 5838, 23, 41, 23, 5, -41 },
  { 5956, 38, 41, 38, 4, -41 },
  { 6151, 29, 41, 22, -3, -41 },
  { 6300, 22, 41, 21, 4, -41 },
  { 6413, 25, 41, 19, -2, -41 },
  { 6542, 22, 51, 16, -2, -42 },
  { 6683, 9, 42, 20, 6, -42 },
  { 6731, 22, 51, 16, -4, -42 },
  { 6872, 22, 22, 23, 1, -41 },
  { 6933, 18, 3, 18, -5, 5 },
  { 6940, 8, 9, 14, 8, -44 },
  { 6949, 23, 33, 25, 1, -32 },
  { 7044, 23, 45, 24, 0, -44 },
  { 7174, 19, 33, 18, 1, -32 },
  { 7253, 26, 45, 24, 1, -44 },
  { 7400, 20, 33, 22, 1, -32 },
  { 7483, 27, 58, 13, -7, -44 },
  { 7679, 25, 46, 25, -1, -32 },
  { 7823, 22, 44, 24, 0, -44 },
  { 7944, 13, 43, 11, 0, -43 },
  { 8014, 20, 57, 11, -7, -43 },
  { 8157, 23, 44, 21, 0, -44 },
  { 8284, 14, 44, 11, 0, -44 },
  { 8361, 34, 32, 36, 0, -32 },
  { 8497, 22, 32, 24, 0, -32 },
  { 8585, 21, 33, 24, 1, -32 },
  { 8672, 26, 46, 24, -3, -32 },
  { 8822, 23, 46, 24, 1, -32 },
  { 8955, 19, 32, 16, 0, -32 },
  { 9031, 20, 33, 18, -1, -32 },
  { 9114, 15, 39, 14, 1, -38 },
  { 9188, 23, 32, 24, 1, -31 },
  { 9280, 19, 31, 19, 3, -31 },
  { 9354, 31, 31, 32, 3, -31 },
  { 9475, 25, 31, 20, -3, -31 },
  { 9572, 28, 45, 20, -5, -31 },
  { 9730, 20, 31, 16, -2, -31 },
  { 9808, 22, 50, 19, 1, -41 },
  { 9946, 5, 58, 21, 8, -44 },
  { 9983, 20, 50, 19, -3, -41 },
  { 10108, 22, 7, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Italic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC58PT7B_H_
