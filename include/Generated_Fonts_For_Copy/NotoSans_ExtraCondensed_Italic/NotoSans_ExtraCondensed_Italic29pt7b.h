#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x06, 0x0C, 0x00, 0x00, 0x01, 0x87, 0x0E, 0x00, 0x77, 0x67, 0x66, 0x66,
  0xC6, 0xC6, 0xCC, 0xCC, 0x03, 0x18, 0x18, 0x80, 0xCC, 0x04, 0x60, 0x62,
  0x03, 0x30, 0xFF, 0xE7, 0xFF, 0x0C, 0xC0, 0x46, 0x06, 0x20, 0x33, 0x01,
  0x98, 0x7F, 0xF3, 0xFF, 0x86, 0x60, 0x23, 0x03, 0x10, 0x19, 0x80, 0x8C,
  0x0C, 0xC0, 0x00, 0x00, 0x80, 0x08, 0x03, 0x80, 0xFF, 0x1D, 0x61, 0x90,
  0x1B, 0x03, 0xA0, 0x1A, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x58,
  0x05, 0xC0, 0x4C, 0x0C, 0xC8, 0x98, 0xEF, 0x8F, 0xF0, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x0E, 0x0C, 0x1E, 0x0C, 0x33, 0x18, 0x23, 0x18, 0x63,
  0x30, 0x62, 0x30, 0x66, 0x60, 0x46, 0x60, 0xC6, 0xCC, 0xC4, 0xDE, 0xCD,
  0xB3, 0x79, 0x33, 0x73, 0x63, 0x02, 0x63, 0x06, 0x66, 0x04, 0x66, 0x0C,
  0x46, 0x18, 0xC6, 0x18, 0xCC, 0x30, 0x7C, 0x30, 0x78, 0x03, 0x80, 0x7C,
  0x0C, 0xE0, 0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xD8, 0x0F, 0x00, 0xE0,
  0x1E, 0x03, 0xE3, 0x77, 0x76, 0x36, 0xE3, 0x6C, 0x3C, 0xC1, 0xCC, 0x38,
  0xC3, 0xCF, 0xEC, 0x7C, 0xE0, 0x76, 0x66, 0xEC, 0xCC, 0x03, 0x06, 0x0E,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0xE0, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x32, 0x1F, 0x67, 0xF9, 0xC1,
  0xF1, 0xCC, 0x46, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x3F, 0xFF, 0xFF, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x39, 0x9C, 0xC6, 0x63, 0x00, 0x7F, 0xFC, 0x7F, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x83, 0xF1,
  0xCC, 0x63, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x60, 0xF8, 0x3E, 0x1F, 0x07,
  0xC1, 0xB0, 0x6C, 0x3B, 0x0C, 0xC3, 0x31, 0xCC, 0xE3, 0xF0, 0x78, 0x00,
  0x06, 0x1C, 0x79, 0xFE, 0xD9, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x86,
  0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x00, 0x03, 0xE0, 0x7F, 0x0C, 0x70,
  0x83, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F,
  0xFC, 0xFF, 0x80, 0x03, 0xE0, 0xFF, 0x0C, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0xE0, 0x7C, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x83, 0x8F, 0xF8, 0x7E, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1F, 0x00, 0xB0, 0x0D, 0x80, 0xCC,
  0x06, 0x60, 0x67, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x10, 0xE1, 0xFF, 0x8F,
  0xFC, 0x81, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x0F, 0xF0,
  0xFE, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3E, 0x03,
  0xF8, 0x23, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x87, 0x0F, 0xF0, 0xFC, 0x00, 0x01, 0xE0, 0xFC, 0x38, 0x0E, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x6F, 0x0F, 0xF3, 0xC6, 0x70, 0xCE, 0x19,
  0x83, 0x30, 0x66, 0x0C, 0xC3, 0x98, 0x63, 0x1C, 0x7F, 0x07, 0xC0, 0x3F,
  0xF3, 0xFE, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x61,
  0x87, 0x18, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x1D, 0xC0, 0xF8, 0x0F, 0x03,
  0xB8, 0x71, 0x86, 0x1C, 0xE1, 0xCC, 0x0C, 0xC1, 0xCC, 0x18, 0xE3, 0x87,
  0xF0, 0x7E, 0x00, 0x07, 0x81, 0xF8, 0x73, 0x8C, 0x33, 0x86, 0x60, 0xCC,
  0x19, 0x83, 0x30, 0xE6, 0x1C, 0xC7, 0x9F, 0xE1, 0xEC, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x18, 0x7F, 0x0F, 0x80, 0x08, 0x71, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x38, 0x04, 0x1C, 0x38, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x38, 0x60, 0xC3,
  0x04, 0x00, 0x00, 0x20, 0x0C, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x08,
  0x00, 0x0F, 0x0F, 0xE1, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x07,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x06, 0x06, 0x0C, 0x06,
  0x18, 0x02, 0x10, 0x03, 0x31, 0xF3, 0x23, 0x33, 0x62, 0x23, 0x46, 0x62,
  0x44, 0x62, 0xCC, 0x66, 0xCC, 0x46, 0xCC, 0xC4, 0xCC, 0xCC, 0x8D, 0xC8,
  0x8F, 0x78, 0x86, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x80,
  0x3F, 0x80, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1B, 0x01, 0xB0, 0x1B, 0x03,
  0x30, 0x33, 0x07, 0x30, 0x63, 0x0E, 0x30, 0xC3, 0x0F, 0xF1, 0xFF, 0x18,
  0x73, 0x87, 0x30, 0x73, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x70, 0x0F, 0x80,
  0x7F, 0x83, 0x1C, 0x18, 0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xC3, 0x0E, 0x18,
  0x61, 0xFE, 0x0F, 0xE0, 0x63, 0x83, 0x0E, 0x18, 0x31, 0xC1, 0x8E, 0x1C,
  0x60, 0xE3, 0x06, 0x18, 0xF1, 0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7F,
  0x0E, 0x21, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x61, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0x3C, 0x18, 0x71,
  0xC3, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x60,
  0x63, 0x03, 0x18, 0x39, 0xC1, 0xCC, 0x0C, 0x60, 0xE3, 0x0E, 0x18, 0xE1,
  0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0xFC, 0x3F, 0x83, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x3F, 0xC3, 0xF8, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0xF0,
  0xF1, 0x87, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x1F, 0x38, 0x7C, 0xE0, 0x73, 0x01, 0xCC, 0x06, 0x30, 0x18,
  0xE0, 0x63, 0x83, 0x87, 0x0C, 0x1F, 0xF0, 0x3F, 0xC0, 0x0E, 0x0E, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x61, 0xC1, 0xC3, 0x83, 0x86, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x7F, 0xF0, 0xFF, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x0E, 0x1C,
  0x1C, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x83, 0x87, 0x07, 0x0C, 0x0C,
  0x00, 0x0F, 0xE1, 0xF8, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x3E, 0x0F, 0xC0, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0xF8, 0x1E, 0x01, 0x80, 0x00, 0x0E, 0x1C, 0x30, 0x60,
  0xC3, 0x83, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0x9C, 0x06, 0x60, 0x1B, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3B, 0x00, 0xCC, 0x07, 0x38, 0x18, 0xE0,
  0x61, 0x81, 0x86, 0x06, 0x18, 0x38, 0x70, 0xC1, 0xC0, 0x0E, 0x0C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0x60, 0xFF, 0xFF, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x36, 0x07, 0x86, 0xC1, 0xB0, 0xD8,
  0x36, 0x1B, 0x0D, 0xC7, 0x61, 0xB0, 0xCC, 0x66, 0x19, 0x8C, 0xC3, 0x33,
  0xB8, 0x66, 0x67, 0x1C, 0xCC, 0xC3, 0x1B, 0x18, 0x63, 0x63, 0x0C, 0x78,
  0xE1, 0x8F, 0x1C, 0x71, 0xC3, 0x0C, 0x38, 0x60, 0x0E, 0x07, 0x0E, 0x06,
  0x0F, 0x06, 0x0F, 0x06, 0x1F, 0x0E, 0x1B, 0x0C, 0x1B, 0x0C, 0x1B, 0x0C,
  0x1B, 0x0C, 0x39, 0x9C, 0x31, 0x98, 0x31, 0x98, 0x31, 0x98, 0x31, 0xB8,
  0x71, 0xB8, 0x60, 0xF0, 0x60, 0xF0, 0x60, 0xF0, 0x60, 0xF0, 0xE0, 0xE0,
  0xC0, 0xE0, 0x03, 0xE0, 0x3F, 0x83, 0x8C, 0x38, 0x73, 0x83, 0x98, 0x0C,
  0xC0, 0x6E, 0x07, 0x60, 0x3B, 0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x03, 0x70,
  0x3B, 0x01, 0x98, 0x0C, 0xC0, 0xE7, 0x0E, 0x38, 0x60, 0xFF, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0xFE, 0x0C, 0xF0, 0xC7, 0x1C, 0x31, 0xC3, 0x18, 0x31,
  0x87, 0x18, 0x73, 0x8E, 0x39, 0xE3, 0xFC, 0x3F, 0x03, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F,
  0x83, 0x8C, 0x38, 0x73, 0x83, 0x98, 0x0C, 0xC0, 0x6E, 0x07, 0x60, 0x3B,
  0x01, 0xF8, 0x0F, 0xC0, 0x6E, 0x03, 0x70, 0x3B, 0x01, 0x98, 0x0C, 0xC0,
  0xE7, 0x0E, 0x38, 0x60, 0xFF, 0x03, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0xFE, 0x0C, 0xF0, 0xC7, 0x1C, 0x31,
  0xC3, 0x18, 0x31, 0x87, 0x18, 0x73, 0x8E, 0x3F, 0xC3, 0xF8, 0x33, 0x03,
  0x30, 0x73, 0x86, 0x38, 0x61, 0x86, 0x18, 0x61, 0x8E, 0x1C, 0xC1, 0xC0,
  0x03, 0xF0, 0x3F, 0xC3, 0x84, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x10, 0xF1, 0xFF, 0x07, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x00, 0x1C, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x73, 0x83, 0x98, 0x18,
  0xC0, 0xC6, 0x06, 0x30, 0x73, 0x83, 0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x70,
  0x73, 0x83, 0x18, 0x18, 0xC1, 0xC6, 0x0C, 0x38, 0xE0, 0xFE, 0x07, 0xE0,
  0x00, 0xE0, 0x76, 0x07, 0x60, 0x66, 0x0E, 0x60, 0xC6, 0x1C, 0x61, 0x86,
  0x18, 0x63, 0x86, 0x30, 0x67, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x6C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x60, 0x7C,
  0x1C, 0x1F, 0x83, 0x83, 0x70, 0x70, 0x6E, 0x1E, 0x1D, 0xC3, 0xC3, 0x38,
  0xD8, 0xE7, 0x1B, 0x18, 0xE3, 0x63, 0x1C, 0xCC, 0xE3, 0x99, 0x98, 0x66,
  0x37, 0x0C, 0xC6, 0xC1, 0x98, 0x98, 0x36, 0x37, 0x06, 0xC6, 0xC0, 0xD8,
  0xD8, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x0E, 0x0E, 0x00, 0x07,
  0x0E, 0x0E, 0x18, 0x1C, 0x70, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x03, 0x86,
  0x0E, 0x0E, 0x00, 0xE0, 0xEC, 0x19, 0x87, 0x30, 0xC6, 0x38, 0xC6, 0x19,
  0xC3, 0x30, 0x6E, 0x0F, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xFC, 0x1F, 0x80, 0xC6, 0x31, 0x8E, 0x31, 0x8C,
  0x63, 0x18, 0xC7, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x80, 0x07, 0xE0, 0xFC,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0xFC, 0x1F, 0x80, 0x01, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0xEC, 0x19, 0x86, 0x30, 0xC6, 0x30, 0x6E, 0x0F, 0x81,
  0x80, 0x7F, 0xFF, 0xE0, 0xE6, 0x73, 0x0E, 0x63, 0xEC, 0xE7, 0x98, 0x77,
  0x0C, 0xC1, 0xB8, 0x37, 0x06, 0xC1, 0xD8, 0x33, 0x06, 0x61, 0xCC, 0x39,
  0x8E, 0x3F, 0xC3, 0xD8, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x70, 0xDF, 0x1E, 0x63, 0x8C, 0xE1, 0x9C, 0x33, 0x06, 0x60, 0xCC,
  0x1B, 0x87, 0x60, 0xEC, 0x19, 0x87, 0x78, 0xCD, 0xF9, 0xBE, 0x00, 0x07,
  0x0F, 0xCE, 0x26, 0x07, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x13, 0xF0, 0xF8, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x39, 0x83, 0xEC, 0x39, 0xE1, 0x87, 0x1C, 0x30, 0xC1,
  0x8E, 0x0C, 0x70, 0xE3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x1C, 0x30, 0xE1,
  0x8E, 0x0F, 0xF0, 0x3D, 0x80, 0x07, 0x07, 0xE3, 0x98, 0xC7, 0x61, 0x98,
  0x6E, 0x3B, 0xFC, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x4F, 0xE1,
  0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1F, 0x00, 0xFC, 0x05, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0x03, 0x98, 0x3E, 0xC3, 0x9E, 0x18, 0x71, 0xC3,
  0x0C, 0x18, 0x60, 0xC7, 0x0E, 0x30, 0x71, 0x83, 0x0C, 0x18, 0x61, 0xC3,
  0x0E, 0x18, 0xE0, 0xFF, 0x03, 0xD8, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x0C, 0x70, 0x7F, 0x81, 0xF0, 0x00, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x70, 0xDF, 0x1E, 0xE3, 0x0C, 0xE1, 0x9C, 0x33, 0x0E,
  0x61, 0x8C, 0x33, 0x86, 0x60, 0xCC, 0x39, 0x86, 0x30, 0xCE, 0x19, 0x87,
  0x00, 0x0E, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83,
  0x06, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x00, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x03, 0xE0, 0x78, 0x00, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x71, 0x86, 0x18,
  0xC1, 0x9C, 0x3B, 0x83, 0x30, 0x36, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0x67,
  0x06, 0x30, 0x63, 0x06, 0x30, 0xE3, 0x0C, 0x38, 0x06, 0x1C, 0x30, 0x60,
  0xC1, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x83, 0x0E, 0x18, 0x00, 0x19, 0xC7, 0x0D, 0xFF, 0xC7, 0xBC, 0xE3, 0x0C,
  0x33, 0x86, 0x19, 0xC7, 0x1C, 0xC3, 0x0C, 0x61, 0x86, 0x30, 0xC3, 0x38,
  0x61, 0x98, 0x71, 0xCC, 0x30, 0xC6, 0x18, 0x67, 0x0C, 0x33, 0x8E, 0x19,
  0x87, 0x1C, 0x19, 0xC3, 0x7C, 0x7B, 0x8C, 0x33, 0x86, 0x70, 0xCC, 0x39,
  0x86, 0x30, 0xCE, 0x19, 0x87, 0x30, 0xE6, 0x19, 0xC3, 0x38, 0x66, 0x1C,
  0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x60, 0xD8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0,
  0x6C, 0x1B, 0x0E, 0xC3, 0x31, 0xCF, 0xE1, 0xF0, 0x0C, 0xE0, 0xDF, 0x0F,
  0x30, 0xE3, 0x1C, 0x31, 0xC3, 0x18, 0x31, 0x83, 0x18, 0x33, 0x87, 0x30,
  0x73, 0x06, 0x30, 0xE3, 0x8C, 0x6F, 0xC6, 0xF8, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0E, 0x63, 0xEC, 0xE7, 0x98,
  0x77, 0x0C, 0xC1, 0xB8, 0x37, 0x0E, 0xC1, 0x98, 0x33, 0x06, 0x61, 0xCC,
  0x39, 0x8E, 0x3F, 0xC3, 0xD8, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x19, 0x8D, 0xC7, 0xE3, 0x83, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0x0F, 0x07, 0xF3,
  0x88, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x60, 0x1C,
  0x06, 0x21, 0x8F, 0xE3, 0xF0, 0x18, 0x30, 0x61, 0xF7, 0xE6, 0x0C, 0x38,
  0x70, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0xE3, 0xC0, 0x30, 0x66,
  0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0x73, 0x0C, 0x61, 0x9C, 0x33,
  0x0E, 0x61, 0xCC, 0x31, 0x8E, 0x3F, 0xC7, 0xD8, 0xC1, 0xE1, 0xF0, 0xD8,
  0x6C, 0x66, 0x33, 0x39, 0x98, 0xCC, 0x6C, 0x36, 0x1E, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xC3, 0x87, 0x87, 0x1F, 0x1E, 0x36, 0x3C, 0x6C, 0x59, 0xD9,
  0xB3, 0x33, 0x66, 0x6C, 0xD8, 0xD9, 0x31, 0xB2, 0xE3, 0xCD, 0x87, 0x9B,
  0x0E, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0x61, 0xC0, 0x1C, 0x31, 0xC6, 0x0C,
  0xE0, 0xCC, 0x0D, 0xC0, 0xD8, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x1B,
  0x03, 0xB0, 0x33, 0x07, 0x30, 0x63, 0x8C, 0x38, 0x06, 0x0C, 0x18, 0x30,
  0x61, 0x81, 0x86, 0x06, 0x38, 0x18, 0xC0, 0x67, 0x01, 0x98, 0x06, 0x60,
  0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0F, 0xE3, 0xF8, 0x00, 0x40, 0xF0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0xF0, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0xE0, 0x38, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x06, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x1E, 0x03, 0x81, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0xF0,
  0x10, 0x00, 0x78, 0x3F, 0xEE, 0x1F, 0xC0, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 21, 7, 0, -21 },
  { 20, 8, 8, 10, 3, -21 },
  { 28, 13, 21, 12, 0, -21 },
  { 63, 12, 24, 11, 0, -22 },
  { 99, 16, 21, 18, 1, -21 },
  { 141, 12, 21, 12, 0, -21 },
  { 173, 4, 8, 5, 3, -21 },
  { 177, 8, 26, 7, 1, -21 },
  { 203, 9, 26, 7, -2, -21 },
  { 233, 9, 10, 10, 3, -22 },
  { 245, 11, 14, 12, 1, -17 },
  { 265, 5, 7, 6, -1, -3 },
  { 270, 7, 2, 8, 0, -9 },
  { 272, 3, 3, 6, 0, -3 },
  { 274, 13, 21, 10, -1, -21 },
  { 309, 10, 21, 11, 1, -21 },
  { 336, 7, 21, 11, 3, -21 },
  { 355, 12, 21, 11, -1, -21 },
  { 387, 12, 21, 11, -1, -21 },
  { 419, 13, 21, 11, -1, -21 },
  { 454, 12, 21, 11, 0, -21 },
  { 486, 11, 21, 11, 1, -21 },
  { 515, 12, 21, 11, 1, -21 },
  { 547, 12, 21, 11, 0, -21 },
  { 579, 11, 21, 11, 0, -21 },
  { 608, 6, 16, 6, 0, -16 },
  { 620, 7, 20, 6, -1, -16 },
  { 638, 11, 13, 12, 1, -17 },
  { 656, 11, 8, 12, 1, -14 },
  { 667, 11, 13, 12, 1, -17 },
  { 685, 10, 21, 8, 0, -21 },
  { 712, 16, 23, 17, 1, -21 },
  { 758, 12, 21, 12, -2, -21 },
  { 790, 13, 21, 12, 0, -21 },
  { 825, 12, 21, 11, 1, -21 },
  { 857, 13, 21, 13, 0, -21 },
  { 892, 12, 21, 11, 0, -21 },
  { 924, 12, 21, 10, 0, -21 },
  { 956, 14, 21, 14, 1, -21 },
  { 993, 15, 21, 14, 0, -21 },
  { 1033, 11, 21, 8, -1, -21 },
  { 1062, 11, 27, 6, -4, -21 },
  { 1100, 14, 21, 12, 0, -21 },
  { 1137, 8, 21, 10, 0, -21 },
  { 1158, 19, 21, 19, 0, -21 },
  { 1208, 16, 21, 15, 0, -21 },
  { 1250, 13, 21, 14, 1, -21 },
  { 1285, 12, 21, 12, 0, -21 },
  { 1317, 13, 26, 14, 1, -21 },
  { 1360, 12, 21, 12, 0, -21 },
  { 1392, 13, 21, 11, -1, -21 },
  { 1427, 10, 21, 10, 2, -21 },
  { 1454, 13, 21, 14, 1, -21 },
  { 1489, 12, 21, 12, 2, -21 },
  { 1521, 19, 21, 19, 2, -21 },
  { 1571, 15, 21, 11, -2, -21 },
  { 1611, 11, 21, 10, 2, -21 },
  { 1640, 13, 21, 10, -1, -21 },
  { 1675, 11, 26, 8, -1, -21 },
  { 1711, 5, 21, 10, 3, -21 },
  { 1725, 11, 26, 8, -2, -21 },
  { 1761, 11, 11, 12, 0, -21 },
  { 1777, 10, 2, 9, -3, 2 },
  { 1780, 4, 4, 7, 4, -22 },
  { 1782, 11, 16, 12, 1, -16 },
  { 1804, 11, 22, 12, 0, -22 },
  { 1835, 9, 16, 9, 1, -16 },
  { 1853, 13, 22, 12, 1, -22 },
  { 1889, 10, 16, 11, 1, -16 },
  { 1909, 14, 29, 7, -4, -22 },
  { 1960, 13, 23, 12, -1, -16 },
  { 1998, 11, 22, 12, 0, -22 },
  { 2029, 7, 21, 6, 0, -21 },
  { 2048, 11, 28, 6, -4, -21 },
  { 2087, 12, 22, 10, 0, -22 },
  { 2120, 7, 22, 6, 0, -22 },
  { 2140, 17, 16, 18, 0, -16 },
  { 2174, 11, 16, 12, 0, -16 },
  { 2196, 10, 16, 12, 1, -16 },
  { 2216, 12, 23, 12, -1, -16 },
  { 2251, 11, 23, 12, 1, -16 },
  { 2283, 9, 16, 8, 0, -16 },
  { 2301, 10, 16, 9, 0, -16 },
  { 2321, 7, 19, 7, 1, -19 },
  { 2338, 11, 16, 12, 1, -16 },
  { 2360, 9, 16, 10, 2, -16 },
  { 2378, 15, 16, 16, 2, -16 },
  { 2408, 12, 16, 10, -1, -16 },
  { 2432, 14, 23, 10, -3, -16 },
  { 2473, 10, 16, 8, -1, -16 },
  { 2493, 10, 26, 10, 1, -21 },
  { 2526, 2, 29, 11, 4, -22 },
  { 2534, 11, 26, 9, -2, -21 },
  { 2570, 11, 4, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Italic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC29PT7B_H_
