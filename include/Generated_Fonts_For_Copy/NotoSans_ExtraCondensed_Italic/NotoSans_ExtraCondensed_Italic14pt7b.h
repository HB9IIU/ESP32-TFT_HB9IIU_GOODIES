#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x44, 0x40, 0x4C, 0x55, 0x5A, 0x14, 0x52, 0x9F, 0x29,
  0x4F, 0x94, 0x92, 0x80, 0x08, 0x43, 0xD4, 0x50, 0x81, 0x0A, 0x2B, 0xC4,
  0x10, 0x65, 0x4A, 0xA5, 0x4B, 0x7B, 0x4A, 0x95, 0x55, 0x18, 0x38, 0xA2,
  0x8C, 0x31, 0xD9, 0xA6, 0x9B, 0xA0, 0x56, 0x19, 0x08, 0x84, 0x22, 0x10,
  0x84, 0x20, 0x80, 0x11, 0x11, 0x11, 0x11, 0x22, 0x4C, 0x25, 0x1E, 0xC5,
  0x00, 0x21, 0x09, 0xF2, 0x10, 0x29, 0x40, 0xE0, 0x70, 0x06, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x10, 0x41, 0x80, 0x39, 0x52, 0x94, 0xA6, 0x32, 0x93,
  0x00, 0x37, 0xE2, 0x22, 0x64, 0x44, 0x3A, 0x42, 0x11, 0x88, 0x88, 0x87,
  0x80, 0x78, 0x30, 0x82, 0x30, 0x41, 0x86, 0x13, 0x80, 0x0C, 0x61, 0x8A,
  0x49, 0x49, 0x3E, 0x10, 0xC0, 0x3C, 0x84, 0x10, 0x70, 0x60, 0x86, 0x13,
  0x80, 0x1C, 0x86, 0x10, 0x79, 0x2C, 0xA2, 0xD1, 0xC0, 0x7C, 0x10, 0x82,
  0x10, 0x42, 0x08, 0x43, 0x00, 0x39, 0x94, 0xDA, 0x31, 0x48, 0xA2, 0x9B,
  0xC0, 0x3B, 0x52, 0x94, 0xBC, 0x22, 0x17, 0x00, 0x2C, 0x00, 0x26, 0x13,
  0x00, 0x00, 0x24, 0x48, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0x83,
  0x0C, 0x36, 0x40, 0x70, 0x44, 0x22, 0x21, 0x00, 0x46, 0x00, 0x1E, 0x21,
  0x21, 0x5D, 0x55, 0xA5, 0xAA, 0xAA, 0x94, 0x40, 0x78, 0x0C, 0x31, 0x45,
  0x24, 0x93, 0xD1, 0x47, 0x10, 0x3C, 0x92, 0x51, 0x79, 0x24, 0x92, 0x8B,
  0xC0, 0x1C, 0x86, 0x10, 0x41, 0x0C, 0x10, 0x41, 0xC0, 0x38, 0x92, 0x59,
  0x45, 0x14, 0x52, 0x9B, 0xC0, 0x3C, 0x82, 0x18, 0x79, 0x04, 0x10, 0x83,
  0xC0, 0x3C, 0x82, 0x18, 0x49, 0xC4, 0x10, 0x82, 0x00, 0x1E, 0x61, 0x82,
  0x04, 0x09, 0xB1, 0x22, 0x4C, 0xF0, 0x22, 0x44, 0x9B, 0x27, 0xC8, 0x91,
  0x24, 0x89, 0x10, 0x3C, 0x41, 0x04, 0x10, 0x82, 0x08, 0x23, 0xC0, 0x08,
  0x42, 0x31, 0x08, 0x42, 0x21, 0x08, 0xCC, 0x00, 0x26, 0x48, 0xA2, 0x87,
  0x0E, 0x14, 0x28, 0x91, 0x30, 0x22, 0x24, 0x44, 0x44, 0x8F, 0x31, 0x98,
  0xCC, 0x6A, 0x55, 0x32, 0xA9, 0x54, 0xB2, 0x9B, 0x49, 0x00, 0x33, 0x32,
  0x32, 0x52, 0x56, 0x54, 0x4C, 0x4C, 0x8C, 0x88, 0x1C, 0x4D, 0x8A, 0x14,
  0x68, 0x91, 0x62, 0x48, 0xE0, 0x38, 0x92, 0x51, 0x49, 0xC4, 0x10, 0x82,
  0x00, 0x1C, 0x4D, 0x8A, 0x14, 0x68, 0x91, 0x62, 0x48, 0xE0, 0x40, 0xC0,
  0x38, 0x92, 0x59, 0x49, 0xC5, 0x14, 0x92, 0x60, 0x3D, 0x84, 0x10, 0x20,
  0x41, 0x06, 0x93, 0xC0, 0xF9, 0x08, 0x84, 0x21, 0x18, 0x84, 0x00, 0x22,
  0x44, 0x92, 0x24, 0x48, 0x93, 0x64, 0xC8, 0xE0, 0x8E, 0x28, 0xA4, 0x92,
  0x8A, 0x28, 0xC3, 0x00, 0x88, 0xC4, 0x66, 0x53, 0x2A, 0xA5, 0x52, 0xA9,
  0x98, 0xCC, 0x44, 0x00, 0x32, 0x28, 0x50, 0xC1, 0x83, 0x0A, 0x14, 0x49,
  0x90, 0x8C, 0xB4, 0xC6, 0x21, 0x08, 0x84, 0x00, 0x3E, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x41, 0xF0, 0x39, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0x80, 0x89, 0x24, 0x92, 0x44, 0x38, 0x42, 0x11, 0x08, 0x42, 0x11, 0x09,
  0xC0, 0x10, 0xA2, 0x92, 0xCC, 0xF0, 0x94, 0x14, 0xB4, 0x92, 0xCA, 0x2D,
  0x9C, 0x20, 0x82, 0x0E, 0x69, 0x34, 0x92, 0x4B, 0x6F, 0x00, 0x11, 0x50,
  0x8C, 0x43, 0x0E, 0x06, 0x08, 0x10, 0xA2, 0xC9, 0x12, 0x64, 0x89, 0x31,
  0xC0, 0x11, 0x52, 0xBE, 0x43, 0x0E, 0x06, 0x10, 0x20, 0x61, 0x82, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x18, 0x00, 0x14, 0xB4, 0x92, 0xCA, 0x29,
  0x9C, 0x10, 0x4E, 0x00, 0x21, 0x08, 0x76, 0xA5, 0x29, 0x4C, 0xA4, 0x20,
  0xA4, 0x92, 0x90, 0x08, 0x02, 0x21, 0x08, 0x42, 0x21, 0x08, 0x4C, 0x00,
  0x20, 0x82, 0x0B, 0x49, 0x46, 0x1C, 0x52, 0x49, 0x00, 0x24, 0x94, 0x92,
  0x52, 0x00, 0x3B, 0x6D, 0x49, 0x49, 0x49, 0x4A, 0x92, 0x92, 0x3B, 0x52,
  0x94, 0xA6, 0x52, 0x11, 0x52, 0x9C, 0xC7, 0x4E, 0x1C, 0x68, 0x99, 0x22,
  0x44, 0x9B, 0x3C, 0x40, 0x83, 0x00, 0x14, 0xB4, 0x92, 0xCA, 0x29, 0x9C,
  0x10, 0x43, 0x00, 0x5B, 0x90, 0x84, 0x22, 0x10, 0x32, 0x50, 0x82, 0x18,
  0xDC, 0x23, 0x44, 0x44, 0x48, 0xC0, 0x25, 0x34, 0x92, 0x4B, 0x29, 0x1C,
  0x99, 0xBA, 0xAC, 0xC8, 0x93, 0x26, 0xD5, 0xAD, 0x5B, 0x36, 0x48, 0x24,
  0x93, 0x84, 0x10, 0xC5, 0xB2, 0x24, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x21,
  0x8C, 0x00, 0x38, 0x46, 0x22, 0x11, 0x1E, 0x18, 0x84, 0x42, 0x33, 0x0C,
  0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x30, 0xC4, 0x21, 0x08, 0x64, 0x21, 0x09,
  0x80, 0xCD, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 10, 3, 0, -10 },
  { 6, 4, 4, 5, 1, -10 },
  { 8, 6, 10, 6, 0, -10 },
  { 16, 6, 12, 5, 0, -11 },
  { 25, 7, 10, 9, 1, -10 },
  { 34, 6, 10, 6, 0, -10 },
  { 42, 2, 4, 3, 1, -10 },
  { 43, 5, 12, 4, 0, -10 },
  { 51, 4, 12, 4, -1, -10 },
  { 57, 5, 5, 5, 1, -11 },
  { 61, 5, 6, 6, 1, -8 },
  { 65, 3, 4, 3, -1, -2 },
  { 67, 3, 1, 4, 0, -4 },
  { 68, 2, 2, 3, 0, -2 },
  { 69, 7, 10, 5, -1, -10 },
  { 78, 5, 10, 5, 0, -10 },
  { 85, 4, 10, 5, 1, -10 },
  { 90, 5, 10, 5, 0, -10 },
  { 97, 6, 10, 5, 0, -10 },
  { 105, 6, 10, 5, 0, -10 },
  { 113, 6, 10, 5, 0, -10 },
  { 121, 6, 10, 5, 0, -10 },
  { 129, 6, 10, 5, 0, -10 },
  { 137, 6, 10, 5, 0, -10 },
  { 145, 5, 10, 5, 0, -10 },
  { 152, 3, 8, 3, 0, -8 },
  { 155, 4, 10, 3, -1, -8 },
  { 160, 5, 6, 6, 1, -8 },
  { 164, 5, 4, 6, 1, -7 },
  { 167, 5, 6, 6, 1, -8 },
  { 171, 5, 10, 4, 0, -10 },
  { 178, 8, 11, 8, 0, -10 },
  { 189, 6, 10, 6, -1, -10 },
  { 197, 6, 10, 6, 0, -10 },
  { 205, 6, 10, 5, 0, -10 },
  { 213, 6, 10, 7, 0, -10 },
  { 221, 6, 10, 5, 0, -10 },
  { 229, 6, 10, 5, 0, -10 },
  { 237, 7, 10, 7, 0, -10 },
  { 246, 7, 10, 7, 0, -10 },
  { 255, 6, 10, 4, -1, -10 },
  { 263, 5, 13, 3, -2, -10 },
  { 272, 7, 10, 6, 0, -10 },
  { 281, 4, 10, 5, 0, -10 },
  { 286, 9, 10, 9, 0, -10 },
  { 298, 8, 10, 7, 0, -10 },
  { 308, 7, 10, 7, 0, -10 },
  { 317, 6, 10, 6, 0, -10 },
  { 325, 7, 12, 7, 0, -10 },
  { 336, 6, 10, 6, 0, -10 },
  { 344, 6, 10, 5, 0, -10 },
  { 352, 5, 10, 5, 1, -10 },
  { 359, 7, 10, 7, 0, -10 },
  { 368, 6, 10, 6, 1, -10 },
  { 376, 9, 10, 9, 1, -10 },
  { 388, 7, 10, 5, -1, -10 },
  { 397, 5, 10, 5, 1, -10 },
  { 404, 7, 10, 5, -1, -10 },
  { 413, 5, 12, 4, 0, -10 },
  { 421, 3, 10, 5, 1, -10 },
  { 425, 5, 12, 4, -1, -10 },
  { 433, 6, 5, 6, 0, -10 },
  { 437, 4, 1, 4, -1, 1 },
  { 438, 2, 3, 3, 2, -11 },
  { 439, 6, 8, 6, 0, -8 },
  { 445, 6, 11, 6, 0, -11 },
  { 454, 5, 8, 4, 0, -8 },
  { 459, 7, 11, 6, 0, -11 },
  { 469, 5, 8, 5, 0, -8 },
  { 474, 7, 14, 3, -2, -11 },
  { 487, 6, 11, 6, 0, -8 },
  { 496, 5, 11, 6, 0, -11 },
  { 503, 3, 10, 3, 0, -10 },
  { 507, 5, 13, 3, -2, -10 },
  { 516, 6, 11, 5, 0, -11 },
  { 525, 3, 11, 3, 0, -11 },
  { 530, 8, 8, 9, 0, -8 },
  { 538, 5, 8, 6, 0, -8 },
  { 543, 5, 8, 6, 0, -8 },
  { 548, 7, 11, 6, -1, -8 },
  { 558, 6, 11, 6, 0, -8 },
  { 567, 5, 8, 4, 0, -8 },
  { 572, 5, 8, 4, 0, -8 },
  { 577, 4, 9, 3, 0, -9 },
  { 582, 6, 8, 6, 0, -8 },
  { 588, 4, 8, 5, 1, -8 },
  { 592, 7, 8, 8, 1, -8 },
  { 599, 6, 8, 5, -1, -8 },
  { 605, 6, 11, 5, -1, -8 },
  { 614, 5, 8, 4, -1, -8 },
  { 619, 5, 12, 5, 0, -10 },
  { 627, 1, 14, 5, 2, -11 },
  { 629, 5, 12, 5, -1, -10 },
  { 637, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Italic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC14PT7B_H_
