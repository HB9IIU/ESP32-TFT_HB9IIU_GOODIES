#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xF0, 0x37, 0x6E, 0xAC, 0x27, 0x44, 0x26, 0xC4, 0x4B,
  0xAD, 0xD7, 0xAD, 0x60, 0x26, 0x64, 0xBA, 0xE0, 0xC0, 0x6A, 0x49, 0x20,
  0x24, 0x92, 0xB0, 0x5F, 0x00, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x32, 0x44,
  0x88, 0x25, 0x59, 0xAA, 0xC0, 0xD6, 0xA0, 0x25, 0x12, 0x48, 0xE0, 0x25,
  0x16, 0x22, 0xC0, 0x32, 0x6A, 0xE4, 0x74, 0x62, 0x2C, 0x34, 0x4E, 0xAA,
  0xE0, 0x72, 0x24, 0x48, 0x25, 0x56, 0xAA, 0xE0, 0x2E, 0xD6, 0x70, 0x40,
  0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x44, 0xA4, 0x20, 0x7A,
  0xEF, 0xBB, 0x41, 0x80, 0x13, 0x37, 0x5D, 0x75, 0x69, 0xAE, 0x34, 0x48,
  0x88, 0x60, 0x75, 0x59, 0xAE, 0x74, 0x68, 0x8C, 0x74, 0x68, 0x88, 0x32,
  0x51, 0x0B, 0x49, 0x80, 0x5A, 0x9D, 0x29, 0x50, 0x69, 0x29, 0x80, 0x24,
  0xA4, 0x94, 0x56, 0x4A, 0xAA, 0x56, 0xB0, 0x45, 0x35, 0x6E, 0xAA, 0xA0,
  0x4B, 0x5D, 0x6B, 0x48, 0x25, 0x59, 0x99, 0x60, 0x75, 0x68, 0x88, 0x25,
  0x59, 0x99, 0x62, 0x20, 0x75, 0x6A, 0xAA, 0x34, 0x44, 0x22, 0xC0, 0xF2,
  0x49, 0x00, 0x55, 0x59, 0x9E, 0xB7, 0x69, 0x00, 0xAE, 0xAE, 0xAC, 0xB2,
  0x80, 0x29, 0x88, 0x45, 0x68, 0xBA, 0x49, 0x00, 0x72, 0x44, 0x8C, 0x69,
  0x49, 0x30, 0xFC, 0x31, 0x22, 0x22, 0xC0, 0x26, 0x90, 0xE0, 0x90, 0x75,
  0xAA, 0xE0, 0x44, 0x65, 0x9A, 0xE0, 0x72, 0x4C, 0x11, 0x75, 0xAA, 0xE0,
  0x77, 0x4E, 0x12, 0x62, 0x44, 0x44, 0x80, 0x75, 0xAA, 0xE2, 0xC0, 0x49,
  0xBB, 0x68, 0x45, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x44, 0x56, 0x4A, 0xA0,
  0x55, 0xA8, 0x6A, 0xEB, 0x5A, 0x80, 0x6E, 0xDA, 0x76, 0xDE, 0x65, 0x9A,
  0xE8, 0x80, 0x75, 0xAA, 0xE2, 0x20, 0x6A, 0x48, 0x71, 0x2C, 0x76, 0xB0,
  0x55, 0xAA, 0xE0, 0xFA, 0x80, 0xAD, 0x7A, 0xA9, 0x00, 0x6D, 0x2C, 0x4A,
  0x94, 0x42, 0x23, 0x00, 0x69, 0x4C, 0x34, 0x48, 0x44, 0xC0, 0xFF, 0x80,
  0x22, 0x21, 0x24, 0xC0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 5, 7, 5, 0, -7 },
  { 16, 4, 7, 4, 0, -7 },
  { 20, 1, 2, 2, 1, -6 },
  { 21, 3, 7, 2, 0, -6 },
  { 24, 3, 7, 2, -1, -6 },
  { 27, 3, 3, 3, 1, -7 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 2, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 4, 6, 3, 0, -6 },
  { 37, 4, 7, 4, 0, -7 },
  { 41, 2, 6, 4, 1, -6 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 3, 7, 4, 0, -7 },
  { 71, 2, 5, 2, 0, -5 },
  { 73, 2, 6, 2, 0, -5 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 4, 2, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 3, 7, 3, 0, -7 },
  { 83, 5, 7, 5, 0, -6 },
  { 88, 4, 6, 4, -1, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 7, 3, 0, -7 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 4, 6, 3, 0, -6 },
  { 104, 4, 6, 3, 0, -6 },
  { 107, 5, 7, 4, 0, -7 },
  { 112, 5, 6, 4, 0, -6 },
  { 116, 3, 6, 2, 0, -6 },
  { 119, 3, 8, 2, -1, -6 },
  { 122, 4, 6, 4, 0, -6 },
  { 125, 2, 6, 3, 0, -6 },
  { 127, 6, 6, 6, 0, -6 },
  { 132, 5, 6, 5, 0, -6 },
  { 136, 4, 7, 4, 0, -7 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 9, 4, 0, -7 },
  { 148, 4, 6, 4, 0, -6 },
  { 151, 4, 7, 3, 0, -7 },
  { 155, 3, 6, 3, 1, -6 },
  { 158, 4, 6, 4, 0, -6 },
  { 161, 3, 6, 4, 1, -6 },
  { 164, 6, 6, 6, 1, -6 },
  { 169, 5, 6, 3, -1, -6 },
  { 173, 3, 6, 3, 1, -6 },
  { 176, 4, 6, 3, 0, -6 },
  { 179, 3, 7, 3, 0, -6 },
  { 182, 1, 6, 3, 1, -6 },
  { 183, 4, 7, 3, -1, -6 },
  { 187, 4, 3, 4, 0, -6 },
  { 189, 3, 1, 3, -1, 1 },
  { 190, 2, 2, 2, 1, -7 },
  { 191, 4, 5, 4, 0, -5 },
  { 194, 4, 7, 4, 0, -7 },
  { 198, 3, 5, 3, 0, -5 },
  { 200, 4, 7, 4, 0, -7 },
  { 204, 3, 5, 3, 0, -5 },
  { 206, 4, 9, 2, -1, -7 },
  { 211, 4, 7, 4, 0, -5 },
  { 215, 3, 7, 4, 0, -7 },
  { 218, 2, 7, 2, 0, -7 },
  { 220, 3, 9, 2, -1, -7 },
  { 224, 4, 7, 3, 0, -7 },
  { 228, 2, 7, 2, 0, -7 },
  { 230, 5, 5, 6, 0, -5 },
  { 234, 3, 5, 4, 0, -5 },
  { 236, 3, 5, 4, 0, -5 },
  { 238, 4, 7, 4, 0, -5 },
  { 242, 4, 7, 4, 0, -5 },
  { 246, 3, 5, 2, 0, -5 },
  { 248, 3, 5, 3, 0, -5 },
  { 250, 2, 6, 2, 0, -6 },
  { 252, 4, 5, 4, 0, -5 },
  { 255, 2, 5, 3, 1, -5 },
  { 257, 5, 5, 5, 0, -5 },
  { 261, 3, 5, 3, 0, -5 },
  { 263, 5, 7, 3, -1, -5 },
  { 268, 3, 5, 3, 0, -5 },
  { 270, 4, 7, 3, 0, -6 },
  { 274, 1, 9, 3, 1, -7 },
  { 276, 4, 7, 3, -1, -6 },
  { 280, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Italic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC9PT7B_H_
