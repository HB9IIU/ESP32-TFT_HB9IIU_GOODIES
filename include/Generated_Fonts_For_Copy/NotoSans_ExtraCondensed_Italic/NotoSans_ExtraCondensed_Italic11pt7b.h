#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x84, 0xB6, 0x80, 0x29, 0x5E, 0xA5, 0x7A, 0x94, 0x13,
  0x58, 0xC2, 0x2A, 0x88, 0x40, 0xCE, 0xB5, 0xDB, 0xAD, 0xB2, 0x32, 0x94,
  0x46, 0xDA, 0x5E, 0xE8, 0x32, 0x44, 0x88, 0x88, 0x84, 0x22, 0x11, 0x22,
  0x22, 0x48, 0xCE, 0x80, 0x22, 0xF2, 0x20, 0x70, 0xE0, 0x80, 0x0C, 0x21,
  0x04, 0x20, 0x84, 0x30, 0x35, 0x55, 0x99, 0xAE, 0x3D, 0x24, 0x94, 0x71,
  0x11, 0x24, 0x8E, 0x71, 0x16, 0x21, 0x2E, 0x11, 0x35, 0x9F, 0x22, 0x34,
  0x46, 0x11, 0x1E, 0x3A, 0x10, 0xE9, 0x4A, 0x4C, 0x78, 0x84, 0x42, 0x21,
  0x18, 0x35, 0x56, 0x69, 0x9E, 0x35, 0x55, 0x71, 0x2C, 0x40, 0x20, 0x20,
  0x00, 0xB0, 0x1B, 0x30, 0x60, 0x80, 0xF0, 0xF0, 0xC1, 0x86, 0xC8, 0x00,
  0x61, 0x22, 0x44, 0x08, 0x1C, 0x95, 0xDB, 0xAE, 0xDA, 0xA0, 0x70, 0x18,
  0xCA, 0x52, 0xBD, 0x31, 0x32, 0x52, 0xE5, 0x4A, 0x5C, 0x39, 0x10, 0x88,
  0x42, 0x0C, 0x32, 0x52, 0x94, 0xCA, 0x5C, 0x3A, 0x10, 0xE4, 0x42, 0x1C,
  0x3A, 0x10, 0x87, 0x42, 0x10, 0x1C, 0x84, 0x10, 0x9A, 0x28, 0x9C, 0x25,
  0x24, 0x9E, 0x4A, 0x49, 0x24, 0x38, 0x88, 0x42, 0x10, 0x9C, 0x08, 0x84,
  0x21, 0x10, 0x84, 0x26, 0x00, 0x2A, 0x94, 0xC6, 0x52, 0x92, 0x29, 0x25,
  0x27, 0x22, 0xCD, 0x9B, 0x56, 0xD5, 0xAD, 0x5A, 0x25, 0x96, 0x9A, 0x5A,
  0x69, 0xA4, 0x3A, 0x52, 0x98, 0xC6, 0x4E, 0x32, 0x52, 0xA6, 0x42, 0x10,
  0x3A, 0x52, 0x98, 0xC6, 0x4E, 0x20, 0x80, 0x32, 0x52, 0xA6, 0x52, 0x92,
  0x3A, 0x10, 0x82, 0x08, 0x9C, 0xF4, 0x44, 0x88, 0x88, 0x6A, 0x52, 0x94,
  0xCA, 0x4C, 0x99, 0xAA, 0xAC, 0xC8, 0x93, 0x26, 0xD5, 0xAD, 0x9B, 0x26,
  0x48, 0x24, 0xA2, 0x84, 0x30, 0xC5, 0x34, 0x9A, 0xAC, 0xC8, 0x88, 0x71,
  0x22, 0x44, 0x8E, 0x34, 0x44, 0x48, 0x88, 0x8C, 0xAA, 0x55, 0x31, 0x11,
  0x12, 0x22, 0x2C, 0x23, 0x5D, 0xF0, 0x80, 0x3A, 0xA5, 0x29, 0x78, 0x64,
  0x75, 0x59, 0x9E, 0x34, 0x88, 0x86, 0x08, 0x4E, 0xA9, 0x4A, 0x5E, 0x35,
  0xBC, 0x86, 0x19, 0x0C, 0x42, 0x11, 0x08, 0x42, 0x20, 0x3A, 0xA5, 0x29,
  0x70, 0x94, 0xC0, 0x24, 0x75, 0x59, 0x9A, 0x61, 0x25, 0x24, 0x30, 0x22,
  0x24, 0x44, 0x44, 0x80, 0x24, 0x56, 0x66, 0xAA, 0x29, 0x25, 0x24, 0x7D,
  0x55, 0x65, 0x96, 0x90, 0x75, 0x59, 0x9A, 0x35, 0x99, 0x96, 0x39, 0x4A,
  0x94, 0xB9, 0x08, 0x80, 0x3A, 0xA5, 0x29, 0x70, 0x84, 0x20, 0x74, 0x48,
  0x88, 0x74, 0x42, 0x2C, 0x4D, 0x29, 0x30, 0x55, 0x59, 0x9E, 0xB7, 0x69,
  0x00, 0xAE, 0xAE, 0xBC, 0xB2, 0x80, 0x29, 0x8C, 0x45, 0x68, 0x29, 0x4C,
  0x62, 0x10, 0x88, 0x80, 0x65, 0x29, 0x80, 0x12, 0x22, 0xC4, 0x44, 0x44,
  0xFF, 0xE0, 0x31, 0x11, 0x12, 0x22, 0x4C, 0x4D, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 5, 8, 5, 0, -8 },
  { 11, 5, 9, 4, 0, -8 },
  { 17, 5, 8, 7, 1, -8 },
  { 22, 5, 8, 5, 0, -8 },
  { 27, 2, 3, 2, 1, -8 },
  { 28, 4, 10, 3, 0, -8 },
  { 33, 4, 10, 3, -1, -8 },
  { 38, 3, 3, 4, 1, -8 },
  { 40, 4, 5, 5, 0, -6 },
  { 43, 2, 2, 2, -1, -1 },
  { 44, 3, 1, 3, 0, -3 },
  { 45, 1, 1, 2, 0, -1 },
  { 46, 6, 8, 4, -1, -8 },
  { 52, 4, 8, 4, 0, -8 },
  { 56, 3, 8, 4, 1, -8 },
  { 59, 4, 8, 4, 0, -8 },
  { 63, 4, 8, 4, 0, -8 },
  { 67, 4, 8, 4, 0, -8 },
  { 71, 4, 8, 4, 0, -8 },
  { 75, 5, 8, 4, 0, -8 },
  { 80, 5, 8, 4, 0, -8 },
  { 85, 4, 8, 4, 0, -8 },
  { 89, 4, 8, 4, 0, -8 },
  { 93, 2, 6, 2, 0, -6 },
  { 95, 3, 7, 2, -1, -6 },
  { 98, 5, 5, 5, 0, -6 },
  { 102, 4, 3, 5, 0, -5 },
  { 104, 5, 5, 5, 0, -6 },
  { 108, 4, 8, 3, 0, -8 },
  { 112, 6, 9, 6, 0, -8 },
  { 119, 5, 8, 4, -1, -8 },
  { 124, 5, 8, 5, 0, -8 },
  { 129, 5, 8, 4, 0, -8 },
  { 134, 5, 8, 5, 0, -8 },
  { 139, 5, 8, 4, 0, -8 },
  { 144, 5, 8, 4, 0, -8 },
  { 149, 6, 8, 5, 0, -8 },
  { 155, 6, 8, 5, 0, -8 },
  { 161, 5, 8, 3, -1, -8 },
  { 166, 5, 10, 2, -2, -8 },
  { 173, 5, 8, 4, 0, -8 },
  { 178, 3, 8, 4, 0, -8 },
  { 181, 7, 8, 7, 0, -8 },
  { 188, 6, 8, 6, 0, -8 },
  { 194, 5, 8, 5, 0, -8 },
  { 199, 5, 8, 4, 0, -8 },
  { 204, 5, 10, 5, 0, -8 },
  { 211, 5, 8, 5, 0, -8 },
  { 216, 5, 8, 4, 0, -8 },
  { 221, 4, 8, 4, 1, -8 },
  { 225, 5, 8, 5, 0, -8 },
  { 230, 4, 8, 4, 1, -8 },
  { 234, 7, 8, 7, 1, -8 },
  { 241, 6, 8, 4, -1, -8 },
  { 247, 4, 8, 4, 1, -8 },
  { 251, 4, 8, 4, 0, -8 },
  { 255, 4, 10, 3, 0, -8 },
  { 260, 2, 8, 4, 1, -8 },
  { 262, 4, 10, 3, -1, -8 },
  { 267, 4, 4, 4, 0, -8 },
  { 269, 4, 1, 3, -1, 1 },
  { 270, 1, 1, 3, 2, -8 },
  { 271, 5, 6, 5, 0, -6 },
  { 275, 4, 8, 5, 0, -8 },
  { 279, 4, 6, 3, 0, -6 },
  { 282, 5, 8, 5, 0, -8 },
  { 287, 4, 6, 4, 0, -6 },
  { 290, 5, 11, 3, -1, -8 },
  { 297, 5, 9, 5, 0, -6 },
  { 303, 4, 8, 5, 0, -8 },
  { 307, 3, 8, 2, 0, -8 },
  { 310, 4, 11, 2, -1, -8 },
  { 316, 4, 8, 4, 0, -8 },
  { 320, 3, 8, 2, 0, -8 },
  { 323, 6, 6, 7, 0, -6 },
  { 328, 4, 6, 5, 0, -6 },
  { 331, 4, 6, 4, 0, -6 },
  { 334, 5, 9, 5, -1, -6 },
  { 340, 5, 9, 5, 0, -6 },
  { 346, 4, 6, 3, 0, -6 },
  { 349, 4, 6, 3, 0, -6 },
  { 352, 3, 7, 3, 0, -7 },
  { 355, 4, 6, 5, 0, -6 },
  { 358, 3, 6, 4, 1, -6 },
  { 361, 6, 6, 6, 1, -6 },
  { 366, 5, 6, 4, -1, -6 },
  { 370, 5, 9, 4, -1, -6 },
  { 376, 3, 6, 3, 0, -6 },
  { 379, 4, 10, 4, 0, -8 },
  { 384, 1, 11, 4, 1, -8 },
  { 386, 4, 10, 4, -1, -8 },
  { 391, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Italic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC11PT7B_H_
