#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x01, 0xE0, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xDD, 0xF8, 0x03, 0xF8, 0xC1, 0xC0, 0x1F, 0x8E, 0x02, 0x00, 0xF8,
  0x70, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xE1, 0xC0,
  0x00, 0x1F, 0x0E, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0x3F, 0x18, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x0E, 0x7E, 0x00, 0x00,
  0x73, 0xF0, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x38, 0x7C, 0x00, 0x01, 0xC3,
  0xE0, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x03, 0x07, 0xC0,
  0x00, 0x38, 0x3E, 0x00, 0x01, 0xC1, 0xF0, 0x10, 0x0E, 0x1F, 0x01, 0xE0,
  0x71, 0xF8, 0x0F, 0xE3, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00,
  0x7F, 0xC0, 0x01, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x3E, 0xF8, 0x00,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x3E, 0x03, 0xE0,
  0x07, 0x81, 0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0x78,
  0x1F, 0x00, 0x1E, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x0F, 0x80, 0x0F,
  0x80, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x87, 0xC0, 0x03, 0xC0, 0x7C, 0x3C,
  0x00, 0x1E, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x07, 0x81,
  0xF1, 0xF0, 0x18, 0x7C, 0x0F, 0x0F, 0x07, 0xF3, 0xE0, 0x78, 0xF8, 0x7F,
  0xDF, 0x07, 0xC7, 0x87, 0xFE, 0xF8, 0x3C, 0x7C, 0x7F, 0xFF, 0xC3, 0xE3,
  0xC7, 0xC7, 0xDE, 0x1E, 0x3E, 0x3C, 0x1E, 0xFB, 0xF1, 0xE3, 0xE0, 0xF7,
  0xFF, 0x1F, 0x1E, 0x07, 0x9F, 0xF0, 0xF0, 0xF0, 0x3C, 0x7F, 0x0F, 0x8F,
  0x01, 0xE0, 0xC0, 0x78, 0x78, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x78, 0x00,
  0x3C, 0x3E, 0x07, 0xC0, 0x03, 0xE1, 0xE0, 0x3E, 0x00, 0x1E, 0x0F, 0x01,
  0xE0, 0x01, 0xF0, 0x78, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x78, 0x00, 0xF0,
  0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x01, 0xE0,
  0x07, 0xC0, 0x78, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x1E,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0x83, 0xC0, 0x0F,
  0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0x07, 0xFE,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x01, 0xF0, 0x7E, 0xFC, 0x1F,
  0x87, 0xE7, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0x7E, 0x3F,
  0x07, 0xE3, 0xE1, 0xF0, 0x1F, 0x1F, 0x1F, 0x80, 0xFD, 0xF8, 0xF8, 0x07,
  0xEF, 0x8F, 0xC0, 0x1F, 0xFC, 0x7E, 0x00, 0xFF, 0xC3, 0xE0, 0x07, 0xFE,
  0x1F, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xF0, 0x3E,
  0x00, 0x3F, 0x81, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x7E, 0x03,
  0xFF, 0x83, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x1F,
  0x81, 0xFF, 0xF0, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x30, 0x3C, 0x01, 0xE1,
  0xE0, 0x0F, 0xCF, 0x01, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7,
  0xC0, 0x1F, 0x9E, 0x01, 0xF8, 0xF8, 0x1F, 0x83, 0xE0, 0x78, 0x1F, 0x01,
  0xC0, 0xFC, 0x04, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x20, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01,
  0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xDF, 0x0F, 0xEF, 0xC7, 0xF3, 0xF3, 0xF0, 0xF8,
  0x78, 0x3E, 0x0C, 0x1F, 0x82, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xC7, 0xFC,
  0x00, 0xF8, 0x0F, 0xE0, 0x03, 0x00, 0x3F, 0x00, 0x10, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xE0, 0x1F, 0xC0, 0x04, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x08, 0x00,
  0x1F, 0xC0, 0x60, 0x03, 0xFC, 0x03, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x87,
  0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x07,
  0xE0, 0x07, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0x81, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0x00, 0x03, 0xF8, 0x0C, 0x00, 0x7F,
  0x80, 0x7C, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC1, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x01, 0xF1, 0xFE, 0x00, 0x7E, 0x7F,
  0xF0, 0x0F, 0x9F, 0xFE, 0x01, 0xF7, 0xFF, 0xE0, 0x3F, 0xF3, 0xFC, 0x0F,
  0xF8, 0x1F, 0xC1, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3F,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xCF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x3F,
  0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0xC1, 0xF8, 0x07, 0xF8, 0x3F, 0x81, 0xFF, 0x03,
  0xFD, 0xFF, 0xC0, 0x7F, 0xFE, 0xF8, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0xE7,
  0xE0, 0x0F, 0xF0, 0xF8, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x30, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0x8F, 0xF0, 0x30, 0x0F, 0xC0, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xFF, 0x83, 0xC1, 0xE0, 0x1F, 0xFE,
  0x0F, 0x07, 0x80, 0xFF, 0xF8, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0xF0, 0xF0,
  0x1E, 0x0F, 0x03, 0xC7, 0x80, 0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0xC1, 0xF0,
  0x3C, 0x78, 0x1E, 0x07, 0xC0, 0xF3, 0xC0, 0xF8, 0x1E, 0x03, 0xCF, 0x03,
  0xC0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xE0, 0x79, 0xF0, 0x7C, 0x0F, 0x81,
  0xE7, 0x81, 0xE0, 0x3C, 0x07, 0x9E, 0x07, 0x80, 0xF0, 0x1E, 0x78, 0x1E,
  0x07, 0xC0, 0xF1, 0xE0, 0xF8, 0x1F, 0x03, 0xCF, 0x83, 0xC0, 0x78, 0x0F,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x81, 0xE3, 0xC0, 0xF0,
  0x3E, 0x07, 0x0F, 0x03, 0xC1, 0xF8, 0x3C, 0x3C, 0x0F, 0x07, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3F, 0x87, 0x83, 0xC0, 0xF8, 0xFE, 0x3C, 0x0F, 0x03, 0xFF,
  0x7F, 0xF0, 0x3C, 0x07, 0xF8, 0xFF, 0x80, 0xF0, 0x1F, 0xC3, 0xFC, 0x03,
  0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x60, 0x00, 0x07,
  0xF0, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x7C, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7F,
  0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7E,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0x83, 0xFE, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC,
  0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xF1,
  0xF0, 0x01, 0xFE, 0x01, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x30, 0x00, 0xFF, 0x9F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7E, 0x07, 0xF8,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7E, 0x0F, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x87,
  0xF8, 0x01, 0xFE, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x0C, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x3F,
  0x00, 0x1F, 0xFE, 0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0x07,
  0xE0, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC3,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xEF, 0x80, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xF3,
  0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x1E, 0x03,
  0xE1, 0xF8, 0x01, 0xF8, 0x3C, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x78, 0x1F,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0xF8,
  0x3F, 0x00, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC7, 0xC0,
  0xF8, 0x00, 0xF8, 0x0F, 0x9F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xFB, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7C,
  0x00, 0x7C, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x07,
  0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0x80, 0x1F, 0x9F, 0x00, 0x7C, 0x00, 0x7E, 0x7C, 0x01, 0xF0, 0x01, 0xF1,
  0xF0, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0xFC,
  0x00, 0xFC, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0xF8, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x3E, 0x00, 0x3E, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0x1F, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x3E, 0x00,
  0x3F, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x1F,
  0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x7E, 0x00, 0x7E, 0x00, 0xF9, 0xF0, 0x01,
  0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x3E,
  0xFC, 0x00, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x03,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFE, 0x00, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xF8, 0x3F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x00, 0xF8, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xE0, 0x1E, 0x00, 0x3F, 0x80, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x06, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xE1, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xFF,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7D, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xE7, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x9F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x80, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x1E, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x80, 0x1F, 0x03, 0xE1, 0xE0, 0x7E, 0x00,
  0x7C, 0x0F, 0x07, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x1E, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x78, 0x3F, 0x00, 0x3F, 0x0F, 0x81, 0xE0, 0xF8, 0x00, 0xFC,
  0x3E, 0x07, 0x87, 0xE0, 0x03, 0xF0, 0xF0, 0x1E, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xF8,
  0x0F, 0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0x80,
  0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x0F,
  0xBF, 0x00, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x00, 0x1F, 0xC1, 0xE0, 0x07, 0xFC, 0x7C,
  0x03, 0xFF, 0xCF, 0x80, 0xFF, 0xFD, 0xF0, 0x3F, 0xFF, 0xBE, 0x07, 0xF0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x7E,
  0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0xC1, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F, 0xF8, 0x1F, 0xC3, 0xFE, 0x01,
  0xFF, 0xF7, 0xC0, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0x1F, 0x00, 0x3F, 0xC3,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x87,
  0xF0, 0x00, 0xF8, 0xFF, 0x80, 0x1F, 0xBF, 0xFC, 0x01, 0xFB, 0xFF, 0xC0,
  0x1F, 0x7F, 0xFE, 0x01, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0x7E, 0x03, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x80,
  0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xC3, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xF9, 0xFF, 0xF0, 0x0F, 0x8F, 0xFC, 0x00, 0xF0, 0x7F, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x40, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0x01, 0xFC, 0x3C, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x7F, 0xE3, 0xE0, 0x01, 0xFF, 0xE7, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x80,
  0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7F, 0x00,
  0x3F, 0x01, 0xFE, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0xFB, 0xE0, 0x01, 0xFF, 0xE7, 0xC0, 0x01, 0xFF, 0x8F, 0x80, 0x01,
  0xFE, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0x7E, 0x1F, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x40, 0x7F,
  0x01, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x43, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x1E, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0xFF,
  0xFD, 0xF0, 0x01, 0xFF, 0xFB, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7C, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0xC3, 0xFE, 0x00, 0x1F, 0xFF,
  0x7C, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x3F, 0xC7,
  0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x40, 0x01, 0xFC, 0x00, 0xC0, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC3, 0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x1F, 0x7F, 0xF8, 0x07, 0xDF, 0xFF,
  0x00, 0xFB, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01,
  0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3F,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x04, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE3,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0xFC, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xC0,
  0x01, 0xFC, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x1F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0xF0, 0x7F, 0x01, 0xFC, 0x00, 0x78, 0xFF, 0xC3, 0xFF,
  0x00, 0x7C, 0xFF, 0xF3, 0xFF, 0xC0, 0x3E, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFD, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x1E, 0x3F, 0xF0,
  0x07, 0xCF, 0xFF, 0x00, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x00, 0x3C, 0x3F, 0xE0,
  0x00, 0x78, 0xFF, 0xE0, 0x01, 0xF3, 0xFF, 0xC0, 0x03, 0xEF, 0xBF, 0xC0,
  0x07, 0xFC, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0xC0, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80,
  0x1F, 0xF0, 0xFE, 0x00, 0x3E, 0xFF, 0xF8, 0x00, 0x7D, 0xFF, 0xF0, 0x01,
  0xF9, 0xFF, 0x80, 0x03, 0xF1, 0xFE, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC1, 0xE0, 0x07, 0xFC, 0x7C, 0x03, 0xFF, 0xCF, 0x80, 0xFF, 0xFD, 0xF0,
  0x1F, 0xFF, 0xBE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x0F,
  0xF8, 0x1F, 0xC3, 0xFE, 0x01, 0xFF, 0xF7, 0xC0, 0x3F, 0xFC, 0xF8, 0x03,
  0xFF, 0x3F, 0x00, 0x3F, 0xC7, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x7E, 0x01, 0xE3, 0xF8, 0x07, 0xCF,
  0xF0, 0x0F, 0xBF, 0xE0, 0x1F, 0x7F, 0x80, 0x3F, 0xFB, 0x00, 0x7B, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x7E, 0x03, 0xF0, 0x0C,
  0x07, 0xE0, 0x04, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x80, 0x0F, 0xE0, 0xC0, 0x0F, 0xC0, 0xF8, 0x3F, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x87, 0xFF,
  0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x20, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0,
  0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F,
  0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x07, 0xE0,
  0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0xC7,
  0xBE, 0x03, 0xFF, 0xF7, 0x80, 0x3F, 0xFC, 0xF0, 0x07, 0xFF, 0x3E, 0x00,
  0x7F, 0x87, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x00, 0x3F,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0,
  0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x01, 0xE7, 0xC0,
  0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8,
  0x03, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0xC0, 0x3F, 0x7E, 0x01, 0xFE, 0x01,
  0xF3, 0xE0, 0x1F, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0x80, 0xFC, 0xF8, 0x07,
  0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0xE0, 0x7E, 0x3E, 0x03, 0xDF, 0x03, 0xE1,
  0xF0, 0x3E, 0xF8, 0x1F, 0x0F, 0x81, 0xF7, 0xC1, 0xF8, 0x7C, 0x0F, 0x3C,
  0x0F, 0x83, 0xE0, 0xF9, 0xE0, 0x7C, 0x1F, 0x07, 0xCF, 0x07, 0xC0, 0xF8,
  0x3C, 0x78, 0x3E, 0x07, 0xC3, 0xE3, 0xC3, 0xF0, 0x3E, 0x1E, 0x1E, 0x1F,
  0x01, 0xF1, 0xF0, 0xF0, 0xF8, 0x0F, 0x8F, 0x87, 0x8F, 0x80, 0x7C, 0x78,
  0x3C, 0x7C, 0x03, 0xE7, 0xC1, 0xE7, 0xE0, 0x1F, 0x3C, 0x0F, 0x3E, 0x00,
  0xFB, 0xE0, 0x79, 0xF0, 0x07, 0xDF, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x3E,
  0xF8, 0x01, 0xFF, 0x81, 0xF7, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x10, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x4F, 0xFE, 0x00, 0x37, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFA, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x70, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 51, 16, 1, -50 },
  { 110, 19, 18, 24, 7, -50 },
  { 153, 31, 50, 30, 0, -50 },
  { 347, 29, 57, 27, 0, -53 },
  { 554, 37, 52, 43, 3, -51 },
  { 795, 29, 52, 30, 0, -51 },
  { 984, 9, 18, 13, 7, -50 },
  { 1005, 21, 61, 18, 1, -50 },
  { 1166, 21, 61, 18, -5, -50 },
  { 1327, 21, 23, 25, 7, -53 },
  { 1388, 26, 33, 30, 3, -41 },
  { 1496, 12, 17, 14, -3, -8 },
  { 1522, 16, 6, 18, 1, -22 },
  { 1534, 7, 9, 14, 1, -8 },
  { 1542, 32, 50, 23, -3, -50 },
  { 1742, 25, 52, 27, 2, -51 },
  { 1905, 18, 50, 27, 7, -50 },
  { 2018, 29, 51, 27, -2, -51 },
  { 2203, 29, 52, 27, -1, -51 },
  { 2392, 29, 50, 27, -1, -50 },
  { 2574, 29, 51, 27, -1, -50 },
  { 2759, 27, 52, 27, 2, -51 },
  { 2935, 28, 50, 27, 2, -50 },
  { 3110, 28, 52, 27, 0, -51 },
  { 3292, 27, 52, 27, 0, -51 },
  { 3468, 14, 39, 14, 0, -38 },
  { 3537, 18, 47, 14, -4, -38 },
  { 3643, 26, 31, 30, 3, -40 },
  { 3744, 26, 20, 30, 3, -35 },
  { 3809, 26, 31, 30, 3, -40 },
  { 3910, 22, 52, 20, 1, -51 },
  { 4053, 38, 56, 41, 2, -50 },
  { 4319, 29, 50, 28, -5, -50 },
  { 4501, 31, 50, 30, 0, -50 },
  { 4695, 29, 52, 27, 3, -51 },
  { 4884, 32, 50, 33, 0, -50 },
  { 5084, 29, 50, 26, 0, -50 },
  { 5266, 29, 50, 24, 0, -50 },
  { 5448, 33, 52, 34, 3, -51 },
  { 5663, 35, 50, 34, 0, -50 },
  { 5882, 27, 50, 18, -4, -50 },
  { 6051, 26, 63, 14, -10, -50 },
  { 6256, 34, 50, 28, 0, -50 },
  { 6469, 19, 50, 24, 0, -50 },
  { 6588, 47, 50, 45, 0, -50 },
  { 6882, 38, 50, 36, 0, -50 },
  { 7120, 32, 52, 35, 2, -51 },
  { 7328, 30, 50, 28, 0, -50 },
  { 7516, 32, 63, 35, 2, -51 },
  { 7768, 30, 50, 29, 0, -50 },
  { 7956, 31, 52, 26, -2, -51 },
  { 8158, 24, 50, 24, 5, -50 },
  { 8308, 33, 51, 33, 2, -50 },
  { 8519, 28, 50, 28, 6, -50 },
  { 8694, 46, 50, 46, 5, -50 },
  { 8982, 35, 50, 26, -4, -50 },
  { 9201, 26, 50, 25, 5, -50 },
  { 9364, 31, 50, 23, -3, -50 },
  { 9558, 27, 61, 20, -2, -50 },
  { 9764, 11, 50, 24, 7, -50 },
  { 9833, 27, 61, 20, -5, -50 },
  { 10039, 27, 27, 28, 1, -50 },
  { 10131, 22, 4, 21, -6, 6 },
  { 10142, 10, 12, 17, 10, -54 },
  { 10157, 27, 39, 30, 2, -38 },
  { 10289, 28, 54, 29, 0, -53 },
  { 10478, 22, 39, 22, 2, -38 },
  { 10586, 31, 54, 30, 2, -53 },
  { 10796, 24, 39, 27, 2, -38 },
  { 10913, 33, 71, 16, -9, -54 },
  { 11206, 31, 55, 30, -2, -38 },
  { 11420, 27, 53, 29, 0, -53 },
  { 11599, 16, 52, 13, 0, -52 },
  { 11703, 25, 69, 14, -9, -52 },
  { 11919, 28, 53, 25, 0, -53 },
  { 12105, 17, 53, 13, 0, -53 },
  { 12218, 41, 38, 43, 0, -38 },
  { 12413, 27, 38, 29, 0, -38 },
  { 12542, 25, 39, 28, 2, -38 },
  { 12664, 31, 54, 29, -3, -38 },
  { 12874, 27, 55, 30, 2, -38 },
  { 13060, 23, 38, 19, 0, -38 },
  { 13170, 24, 39, 22, -1, -38 },
  { 13287, 17, 47, 17, 2, -46 },
  { 13387, 27, 39, 29, 2, -38 },
  { 13519, 23, 38, 24, 4, -38 },
  { 13629, 37, 38, 38, 4, -38 },
  { 13805, 30, 38, 24, -3, -38 },
  { 13948, 34, 55, 24, -7, -38 },
  { 14182, 25, 38, 20, -3, -38 },
  { 14301, 25, 61, 23, 2, -50 },
  { 14492, 5, 70, 26, 10, -53 },
  { 14536, 25, 61, 23, -4, -50 },
  { 14727, 26, 9, 30, 3, -29 },
};

const GFXfont NotoSans_ExtraCondensed_Italic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC70PT7B_H_
