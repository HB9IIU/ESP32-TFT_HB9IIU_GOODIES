#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x00, 0x39, 0xCE, 0x73, 0x1D, 0xC6, 0x73,
  0x98, 0xE6, 0x39, 0x8C, 0xE3, 0x00, 0x00, 0xC6, 0x01, 0xC6, 0x01, 0x8E,
  0x01, 0x8C, 0x01, 0x8C, 0x03, 0x1C, 0x03, 0x18, 0x1F, 0xFF, 0x3F, 0xFE,
  0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60,
  0xFF, 0xF8, 0xFF, 0xF8, 0x38, 0xC0, 0x31, 0xC0, 0x31, 0x80, 0x31, 0x80,
  0x63, 0x80, 0x63, 0x00, 0x63, 0x00, 0xC7, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x07, 0xFC, 0x3F, 0xF0, 0xEC, 0x87, 0x20, 0x18, 0x80,
  0x62, 0x01, 0xD8, 0x07, 0x60, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x02, 0xE0, 0x09, 0xC0, 0x27, 0x01, 0x9C, 0x06, 0x72, 0x11, 0x8C, 0x5E,
  0x3F, 0xF0, 0x7F, 0x80, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x1E,
  0x03, 0x0F, 0xC1, 0xC3, 0x30, 0x61, 0x8C, 0x38, 0x63, 0x0C, 0x18, 0xC7,
  0x0E, 0x31, 0x83, 0x0C, 0xE0, 0xC7, 0x30, 0x31, 0x9C, 0x0C, 0x66, 0x7B,
  0x3B, 0xBF, 0xCC, 0xCC, 0xFF, 0x66, 0x37, 0x99, 0x8C, 0x0C, 0xE3, 0x03,
  0x30, 0xC1, 0x8C, 0x70, 0x63, 0x18, 0x30, 0xC6, 0x0C, 0x71, 0x86, 0x1C,
  0xC1, 0x87, 0x30, 0xC0, 0xF8, 0x70, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x1C, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x8C, 0x07, 0x38, 0x0E,
  0x60, 0x0D, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF1, 0xCE, 0xE7,
  0x38, 0xCE, 0x61, 0xD9, 0xC3, 0xF3, 0x83, 0xC7, 0x07, 0x8E, 0x0E, 0x1C,
  0x3E, 0x38, 0xFC, 0x7F, 0xB8, 0x7E, 0x38, 0x77, 0x6E, 0xEE, 0xCC, 0xC0,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60,
  0x18, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x06, 0x00,
  0xE0, 0x18, 0x23, 0x07, 0x67, 0xFF, 0xC3, 0xF8, 0xF0, 0x3B, 0x0E, 0x70,
  0xC6, 0x00, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x86,
  0x1C, 0x30, 0xE0, 0xFF, 0xFF, 0xF8, 0x77, 0xF6, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0x3F, 0x83, 0xDC, 0x18, 0x71, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x70,
  0x33, 0x81, 0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x70, 0x3B, 0x81, 0x9C, 0x1C,
  0xE0, 0xE7, 0x07, 0x30, 0x31, 0x83, 0x8C, 0x18, 0x71, 0xC3, 0x9C, 0x0F,
  0xE0, 0x7C, 0x00, 0x07, 0x0F, 0x1F, 0x3F, 0x76, 0xEE, 0xCE, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0x01, 0xF8, 0x0F, 0xF8, 0x1C, 0x70, 0x20, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x1C, 0x78, 0x20, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x3F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x30, 0x78, 0x7F, 0xE0,
  0x7F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0x60, 0x07, 0xC0,
  0x1B, 0x80, 0x37, 0x00, 0xCC, 0x03, 0xB8, 0x06, 0x70, 0x18, 0xE0, 0x31,
  0x80, 0xC3, 0x03, 0x8E, 0x06, 0x1C, 0x18, 0x38, 0x70, 0x60, 0xFF, 0xF9,
  0xFF, 0xE7, 0xFF, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xF8, 0x11, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x08, 0x3C, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F,
  0xE0, 0x78, 0x83, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xCE, 0x07, 0x7C, 0x1F, 0xF8, 0x78, 0xE3, 0xC1, 0x8E, 0x07, 0x38,
  0x18, 0xE0, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0F,
  0x38, 0x1F, 0xE0, 0x3E, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE1, 0xC3, 0x07, 0x1C, 0x1C, 0x70, 0x71,
  0xC1, 0xC7, 0x06, 0x1C, 0x38, 0x39, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0xC0,
  0x7F, 0x03, 0x8E, 0x1C, 0x38, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x30, 0x1C,
  0xE0, 0x73, 0x83, 0x8F, 0x1E, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xE0, 0xF3, 0x83, 0x8E, 0x1C, 0x18, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38,
  0x18, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x78, 0xFF, 0xE1, 0xFB, 0x03,
  0x9C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x08,
  0x78, 0x3F, 0xC0, 0xFC, 0x00, 0x0E, 0x1C, 0x78, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF1, 0xE3, 0x80, 0x03, 0x81,
  0xC1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x81,
  0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1C,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x00, 0xF8, 0x1F, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x03, 0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x18,
  0xE0, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x03, 0x80, 0x60, 0xE0, 0x06, 0x18, 0x00,
  0xC6, 0x00, 0x18, 0xC3, 0xF3, 0x30, 0xFC, 0x66, 0x31, 0x8D, 0x86, 0x31,
  0xB1, 0x8E, 0x36, 0x31, 0x86, 0xCE, 0x31, 0xB1, 0x86, 0x36, 0x31, 0xC6,
  0xC6, 0x31, 0x98, 0xC6, 0x33, 0x19, 0x4C, 0x63, 0xEF, 0x8C, 0x39, 0xC1,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x04, 0x00,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0x9C, 0x0E, 0x70, 0x39,
  0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x70,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x07, 0xE0,
  0x1C, 0x07, 0xF0, 0x0F, 0xF8, 0x1C, 0xF8, 0x30, 0x70, 0xE0, 0xE1, 0xC1,
  0xC3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x71, 0xE0, 0xFF, 0x81,
  0xFF, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x60, 0x71, 0xC0,
  0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x1E, 0x18, 0xF8, 0x7F, 0xE0, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xFC, 0x1E, 0x10, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x30, 0x1F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x0E,
  0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x18,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x30, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xE0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xE0, 0xFF, 0x83, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xC1,
  0xE0, 0x20, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x07, 0xE7, 0x03, 0xF3, 0x80,
  0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x07,
  0x03, 0x83, 0x81, 0xC1, 0xF0, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x07,
  0x01, 0xC1, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0E, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x60,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x30, 0x38,
  0x1C, 0x0C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x0E,
  0x06, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x30, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00, 0x07, 0x03, 0x83, 0x83,
  0x81, 0xC3, 0x80, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x38,
  0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0x83, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0D,
  0x83, 0xE0, 0x3F, 0x06, 0xC0, 0x6E, 0x1D, 0xC1, 0xDC, 0x3B, 0x83, 0xB0,
  0x77, 0x0E, 0xE0, 0xEE, 0x1D, 0xC1, 0x9C, 0x33, 0x87, 0x38, 0xE7, 0x0E,
  0x71, 0x8C, 0x1C, 0xE7, 0x38, 0x31, 0xCC, 0x70, 0x63, 0xB8, 0xE1, 0xC7,
  0x61, 0x83, 0x8F, 0xC7, 0x07, 0x0F, 0x8E, 0x0C, 0x1E, 0x1C, 0x18, 0x3C,
  0x38, 0x70, 0x70, 0x60, 0xE0, 0xE1, 0xC0, 0x07, 0x80, 0xE0, 0xF0, 0x18,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0xF8, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x60,
  0x6E, 0x1C, 0x1C, 0xC3, 0x83, 0x98, 0x70, 0x73, 0x0E, 0x0E, 0x61, 0x81,
  0x8E, 0x70, 0x71, 0xCE, 0x0E, 0x39, 0xC1, 0xC3, 0x30, 0x30, 0x66, 0x06,
  0x0D, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xC0, 0xC0, 0x78, 0x18,
  0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0x9E, 0x0E, 0x0E, 0x0E, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0x78, 0x70, 0x70, 0x79, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x30, 0xE0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07,
  0x1C, 0x0C, 0x38, 0x38, 0x70, 0x70, 0xE1, 0xC1, 0x8F, 0x87, 0xFE, 0x0F,
  0xF0, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0x9E, 0x0E, 0x0E, 0x0E, 0x07, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38,
  0xE0, 0x78, 0x70, 0x70, 0x79, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x30, 0xF0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87,
  0x07, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xF0, 0xE3, 0xC1, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x1C, 0xE0, 0x39, 0xC0, 0x61, 0x81, 0xC3, 0x83, 0x87, 0x07,
  0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x38, 0xE0, 0x70, 0x01, 0xFE, 0x07,
  0xFC, 0x1E, 0x38, 0x78, 0x10, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x10, 0x1E, 0x3C, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xFB, 0xFF, 0x9F,
  0xFC, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x00, 0x0E, 0x03, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x1C,
  0x0E, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0,
  0x38, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0x71, 0xE0, 0x7F,
  0xC0, 0x3F, 0x80, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x73,
  0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE0,
  0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x70,
  0x1C, 0x07, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x1C, 0x70,
  0x78, 0x1C, 0x70, 0x78, 0x18, 0x70, 0x78, 0x38, 0x70, 0xF8, 0x38, 0x70,
  0xD8, 0x70, 0x71, 0xD8, 0x70, 0x61, 0x98, 0x60, 0x61, 0x98, 0xE0, 0x63,
  0x98, 0xE0, 0x63, 0x19, 0xC0, 0x67, 0x19, 0xC0, 0x66, 0x19, 0xC0, 0x66,
  0x1B, 0x80, 0x6E, 0x1B, 0x80, 0x6C, 0x1B, 0x00, 0x7C, 0x1F, 0x00, 0x78,
  0x1F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0xE0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0x60, 0x07, 0x30, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0x87, 0x01, 0xC3,
  0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x00, 0xE0, 0x7E, 0x07, 0xE0,
  0xEE, 0x0E, 0xE1, 0xC6, 0x1C, 0x63, 0x86, 0x38, 0x77, 0x07, 0x60, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x00,
  0xC6, 0x31, 0x8E, 0x73, 0x9C, 0x63, 0x18, 0xC7, 0x39, 0xCE, 0x31, 0x8C,
  0x63, 0x9C, 0xE7, 0x18, 0x03, 0xF8, 0x1F, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0x60, 0x1D, 0xC0, 0x67, 0x03, 0x8C, 0x1C, 0x38, 0x60,
  0xE3, 0x81, 0x8C, 0x06, 0xF0, 0x1C, 0xFF, 0xFF, 0xFC, 0xE3, 0x9C, 0x63,
  0x8C, 0x07, 0x9C, 0x3F, 0x61, 0xE7, 0x8F, 0x1E, 0x38, 0x39, 0xC0, 0xE7,
  0x03, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3,
  0x83, 0x8E, 0x1E, 0x38, 0x78, 0xE3, 0xC1, 0xFB, 0x07, 0xCC, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0xF0, 0x37, 0xE1, 0xF3, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x71,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x03, 0x8C, 0x0E, 0x70, 0x39,
  0xC1, 0xC7, 0x07, 0x1C, 0x38, 0xF9, 0xE3, 0xFF, 0x0C, 0xF8, 0x00, 0x07,
  0xE1, 0xFC, 0x79, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF1, 0x0F, 0xE0,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x07, 0x9C, 0x1F, 0xB0, 0x79, 0xE1, 0xE3,
  0xC3, 0x83, 0x8E, 0x07, 0x1C, 0x0C, 0x38, 0x38, 0x60, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE3,
  0xC1, 0xFD, 0x81, 0xF3, 0x00, 0x03, 0xC0, 0xFE, 0x1E, 0xF3, 0x87, 0x38,
  0x77, 0x07, 0x70, 0xE6, 0x1E, 0xFF, 0xCF, 0xF0, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x87, 0xF8, 0x3F, 0x80, 0x00, 0x0E,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE7, 0x03, 0xF6,
  0x07, 0x9E, 0x0F, 0x1E, 0x0E, 0x0E, 0x0C, 0x0E, 0x1C, 0x0C, 0x1C, 0x1C,
  0x18, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x78, 0x38, 0x70, 0x38, 0xF0, 0x3F, 0xF0, 0x1F, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0xC3, 0xC0, 0xFF, 0x80,
  0x7F, 0x00, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0xF0, 0x6F, 0xC7, 0xDE, 0x3C, 0x31, 0xC1, 0x8E,
  0x1C, 0x60, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x1C, 0x60, 0xE7, 0x07,
  0x38, 0x39, 0xC1, 0x8C, 0x1C, 0x60, 0xE7, 0x07, 0x38, 0x30, 0x03, 0x07,
  0x07, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18,
  0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x1C,
  0x30, 0xE0, 0xC3, 0x87, 0x1C, 0x1C, 0xE0, 0x77, 0x01, 0x9C, 0x0E, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0E, 0xE0, 0x71, 0x81, 0xC7, 0x07, 0x1C,
  0x18, 0x70, 0x61, 0xC3, 0x87, 0x0E, 0x0E, 0x00, 0x03, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x0C,
  0xF1, 0xE0, 0x6F, 0xDF, 0x87, 0xDF, 0xDC, 0x3C, 0x78, 0x71, 0xC3, 0xC3,
  0x0E, 0x1C, 0x18, 0x60, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x30, 0x71, 0xC3,
  0x83, 0x0E, 0x1C, 0x18, 0x60, 0xE1, 0xC7, 0x07, 0x0E, 0x38, 0x30, 0x71,
  0xC3, 0x83, 0x0C, 0x1C, 0x38, 0xE0, 0xE1, 0xC7, 0x06, 0x0E, 0x38, 0x70,
  0x70, 0x0C, 0xF0, 0x6F, 0xC7, 0xDE, 0x3C, 0x31, 0xC1, 0x8E, 0x1C, 0x60,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x1C, 0x60, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x30, 0x07, 0xC0, 0xFE, 0x1E,
  0xF3, 0x87, 0x38, 0x37, 0x03, 0x70, 0x37, 0x07, 0x60, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE3, 0x87, 0xF0, 0x3E,
  0x00, 0x03, 0x3C, 0x03, 0x7E, 0x07, 0xCF, 0x07, 0x87, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x06, 0x0C, 0x0E, 0x0C,
  0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x1E, 0x78, 0x3F,
  0xF0, 0x3B, 0xE0, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0x9C, 0x3F, 0x61, 0xE7,
  0x8F, 0x1E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x1C, 0x1C, 0x60, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x70, 0xE3,
  0xC3, 0xFF, 0x07, 0xDC, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x0C, 0xE1, 0xBC, 0x7F, 0x8F,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x00, 0x07, 0xC1,
  0xFF, 0x1C, 0x63, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x87, 0x0F,
  0xF0, 0xFE, 0x00, 0x0E, 0x0C, 0x0C, 0x1C, 0x1F, 0x7F, 0x7F, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF8, 0xF8, 0x1C, 0x18, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x1C, 0x38,
  0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0x63, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0xFE, 0x1F, 0x60, 0xE0, 0x7E, 0x0E,
  0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E, 0x30, 0xE7, 0x0E, 0x70,
  0xEE, 0x0E, 0xE0, 0xEC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0xE0, 0xE0, 0xFC, 0x3C, 0x3B, 0x87, 0x87, 0x70, 0xF0, 0xCE,
  0x36, 0x39, 0xC6, 0xC7, 0x39, 0xF8, 0xC7, 0x37, 0x38, 0xE6, 0xE6, 0x1D,
  0xDD, 0xC3, 0xB3, 0xB8, 0x6E, 0x76, 0x0D, 0x8F, 0xC1, 0xB1, 0xB0, 0x3E,
  0x36, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xC0, 0x73, 0x80, 0x6E, 0x00,
  0xD8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xEC,
  0x01, 0xD8, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0xE1, 0xC3, 0xC1, 0xC0,
  0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x38,
  0x60, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00,
  0x6E, 0x00, 0x36, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x03, 0xE0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0xE0, 0x0E, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x0F, 0x80, 0x78, 0x02, 0x00, 0x00, 0x10,
  0x0B, 0xF0, 0x7F, 0xFF, 0x87, 0xF8, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 25, 8, 0, -25 },
  { 30, 10, 9, 12, 3, -25 },
  { 42, 16, 25, 15, 0, -25 },
  { 92, 14, 29, 14, 0, -27 },
  { 143, 18, 25, 21, 2, -25 },
  { 200, 15, 25, 15, 0, -25 },
  { 247, 4, 9, 7, 4, -25 },
  { 252, 10, 31, 9, 1, -25 },
  { 291, 11, 31, 9, -3, -25 },
  { 334, 11, 12, 13, 3, -27 },
  { 351, 13, 17, 15, 1, -21 },
  { 379, 7, 9, 7, -2, -4 },
  { 387, 7, 3, 9, 1, -11 },
  { 390, 4, 4, 7, 0, -4 },
  { 392, 16, 25, 12, -2, -25 },
  { 442, 13, 25, 14, 1, -25 },
  { 483, 8, 25, 14, 4, -25 },
  { 508, 15, 25, 14, -1, -25 },
  { 555, 15, 25, 14, -1, -25 },
  { 602, 15, 25, 14, -1, -25 },
  { 649, 14, 25, 14, 0, -25 },
  { 693, 14, 25, 14, 1, -25 },
  { 737, 14, 25, 14, 1, -25 },
  { 781, 14, 25, 14, 0, -25 },
  { 825, 14, 25, 14, 0, -25 },
  { 869, 7, 19, 7, 0, -19 },
  { 886, 9, 24, 7, -2, -19 },
  { 913, 13, 15, 15, 1, -20 },
  { 938, 13, 10, 15, 1, -17 },
  { 955, 13, 15, 15, 1, -20 },
  { 980, 12, 25, 10, 0, -25 },
  { 1018, 19, 28, 21, 1, -25 },
  { 1085, 14, 25, 14, -2, -25 },
  { 1129, 15, 25, 15, 0, -25 },
  { 1176, 15, 25, 14, 1, -25 },
  { 1223, 16, 25, 16, 0, -25 },
  { 1273, 14, 25, 13, 0, -25 },
  { 1317, 14, 25, 12, 0, -25 },
  { 1361, 17, 25, 17, 1, -25 },
  { 1415, 18, 25, 17, 0, -25 },
  { 1472, 14, 25, 9, -2, -25 },
  { 1516, 13, 32, 7, -5, -25 },
  { 1568, 17, 25, 14, 0, -25 },
  { 1622, 9, 25, 12, 0, -25 },
  { 1651, 23, 25, 23, 0, -25 },
  { 1723, 19, 25, 18, 0, -25 },
  { 1783, 16, 25, 17, 1, -25 },
  { 1833, 15, 25, 14, 0, -25 },
  { 1880, 16, 31, 17, 1, -25 },
  { 1942, 15, 25, 15, 0, -25 },
  { 1989, 15, 25, 13, -1, -25 },
  { 2036, 13, 25, 12, 2, -25 },
  { 2077, 16, 25, 17, 1, -25 },
  { 2127, 14, 25, 14, 3, -25 },
  { 2171, 24, 25, 23, 2, -25 },
  { 2246, 17, 25, 13, -2, -25 },
  { 2300, 12, 25, 12, 3, -25 },
  { 2338, 15, 25, 12, -1, -25 },
  { 2385, 13, 31, 10, -1, -25 },
  { 2436, 5, 25, 12, 4, -25 },
  { 2452, 13, 31, 10, -2, -25 },
  { 2503, 14, 13, 14, 0, -25 },
  { 2526, 11, 2, 11, -3, 3 },
  { 2529, 5, 6, 9, 5, -27 },
  { 2533, 14, 19, 15, 1, -19 },
  { 2567, 14, 27, 15, 0, -27 },
  { 2615, 11, 19, 11, 1, -19 },
  { 2642, 15, 27, 15, 1, -27 },
  { 2693, 12, 19, 13, 1, -19 },
  { 2722, 16, 35, 8, -4, -27 },
  { 2792, 16, 27, 15, -1, -19 },
  { 2846, 13, 27, 14, 0, -27 },
  { 2890, 8, 26, 7, 0, -26 },
  { 2916, 13, 34, 7, -5, -26 },
  { 2972, 14, 27, 13, 0, -27 },
  { 3020, 8, 27, 7, 0, -27 },
  { 3047, 21, 19, 21, 0, -19 },
  { 3097, 13, 19, 14, 0, -19 },
  { 3128, 12, 19, 14, 1, -19 },
  { 3157, 16, 27, 15, -2, -19 },
  { 3211, 14, 27, 15, 1, -19 },
  { 3259, 11, 19, 10, 0, -19 },
  { 3286, 12, 19, 11, 0, -19 },
  { 3315, 8, 23, 8, 1, -23 },
  { 3338, 13, 19, 14, 1, -19 },
  { 3369, 12, 19, 12, 2, -19 },
  { 3398, 19, 19, 19, 2, -19 },
  { 3444, 15, 19, 12, -2, -19 },
  { 3480, 17, 27, 12, -3, -19 },
  { 3538, 12, 19, 10, -1, -19 },
  { 3567, 13, 31, 11, 1, -25 },
  { 3618, 3, 35, 13, 5, -27 },
  { 3632, 13, 31, 11, -2, -25 },
  { 3683, 13, 5, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Italic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC35PT7B_H_
