#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0x70, 0x00, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x70, 0xE7, 0x0E,
  0xF1, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x38, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x60, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x1C,
  0x38, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0xCE, 0x07, 0x18, 0x41, 0xE2, 0x00,
  0x38, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1E, 0x60, 0x03, 0xD8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xBC, 0x00, 0x33, 0x80, 0x04, 0x70, 0x01, 0x8E, 0x00,
  0x31, 0xC0, 0x06, 0x38, 0x00, 0xCF, 0x0C, 0x31, 0xE1, 0xF7, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x1C, 0x0F, 0xE0,
  0x1C, 0x0E, 0xE0, 0x38, 0x1C, 0x70, 0x38, 0x38, 0x70, 0x70, 0x38, 0x70,
  0x60, 0x38, 0x70, 0xE0, 0x70, 0x60, 0xC0, 0x70, 0xE1, 0xC0, 0x70, 0xE3,
  0x80, 0x70, 0xE3, 0x80, 0xE0, 0xE7, 0x00, 0xE0, 0xC7, 0x00, 0xE1, 0xCE,
  0x3E, 0xE1, 0xCE, 0x7F, 0xE3, 0x9C, 0xFF, 0xE3, 0x9C, 0xE7, 0xF7, 0x39,
  0xC7, 0x7F, 0x39, 0xC3, 0x3C, 0x71, 0x87, 0x00, 0x73, 0x87, 0x00, 0xE3,
  0x87, 0x00, 0xE3, 0x87, 0x01, 0xC7, 0x07, 0x01, 0xC7, 0x07, 0x03, 0x87,
  0x0E, 0x03, 0x87, 0x0E, 0x07, 0x07, 0x0E, 0x07, 0x07, 0x1C, 0x0E, 0x07,
  0x1C, 0x0E, 0x07, 0x38, 0x1C, 0x03, 0xF0, 0x38, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0F,
  0x00, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38,
  0x01, 0xCF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x1C, 0x7B, 0xC7, 0x9E, 0x78, 0xE3, 0x87, 0x1C,
  0xF0, 0xF7, 0x9C, 0x1E, 0xE7, 0x81, 0xFC, 0xF0, 0x3F, 0x1C, 0x07, 0xE3,
  0x80, 0x78, 0x70, 0x1F, 0x0F, 0x07, 0xE1, 0xE1, 0xFE, 0x3F, 0xFB, 0xC3,
  0xFE, 0x78, 0x3F, 0x87, 0x80, 0x3D, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xE3,
  0x8E, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0xE1, 0x06, 0x0E, 0x30, 0x7F, 0x8F, 0xFF, 0xE3, 0xFF, 0x0F,
  0x00, 0xFC, 0x0F, 0x60, 0xF3, 0x8F, 0x1E, 0x10, 0x70, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x0F,
  0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3B, 0xDF, 0xF7, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x78, 0xE0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1C,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x03,
  0xCE, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x38, 0xF0,
  0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x8F, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x1F, 0x87,
  0xF1, 0xFC, 0x7B, 0x9E, 0xF7, 0x9E, 0x63, 0xC8, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1E, 0x1F, 0x00, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x10, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x01,
  0xC1, 0xF0, 0x10, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x08, 0x03,
  0xE1, 0x80, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1B, 0x80, 0x07, 0xF0, 0x00, 0xDE, 0x00, 0x3B, 0xC0, 0x0E, 0x70, 0x01,
  0x8E, 0x00, 0x73, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x38,
  0x78, 0x07, 0x0F, 0x01, 0xC1, 0xE0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x81,
  0xE0, 0x70, 0x3C, 0x1C, 0x07, 0x93, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x04, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x08, 0x03, 0xE1, 0x80, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x70, 0x0E, 0x7F, 0x03, 0xBF, 0xC1, 0xFF,
  0xF8, 0x7E, 0x1E, 0x1F, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x38, 0xF0, 0x0E,
  0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x3E, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0x78, 0x1C, 0x0E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x3C,
  0x0E, 0x03, 0x83, 0xC0, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7C, 0xF0, 0x1E, 0x1F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x3C, 0x03, 0x87, 0x80, 0x78, 0xE0, 0x0F, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x0F, 0x0F, 0x01, 0xE1, 0xF0, 0x78, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1F, 0x1E, 0x07, 0x83, 0x83, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC7,
  0x01, 0xE1, 0xC0, 0x78, 0x70, 0x3E, 0x1E, 0x1F, 0x87, 0xDF, 0xE1, 0xFF,
  0x70, 0x3F, 0x9C, 0x07, 0x8F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x03, 0xC3,
  0xE1, 0xF0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0x0F, 0x10, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xCF, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x01, 0x87, 0x03, 0xF8,
  0xC7, 0x07, 0xF8, 0x63, 0x83, 0x9C, 0x31, 0x83, 0x8E, 0x19, 0xC3, 0x87,
  0x0C, 0xE1, 0xC3, 0x0E, 0x61, 0xC3, 0x87, 0x70, 0xE1, 0xC3, 0xB8, 0x60,
  0xE1, 0xDC, 0x70, 0xE0, 0xCC, 0x38, 0x70, 0xE6, 0x1C, 0x38, 0x77, 0x0E,
  0x1C, 0x33, 0x87, 0x1C, 0x39, 0xC3, 0x8E, 0x18, 0xE1, 0xCF, 0x9C, 0x70,
  0xFD, 0xFC, 0x38, 0x7E, 0x7C, 0x1C, 0x0C, 0x1C, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x01, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x07,
  0x38, 0x01, 0xE7, 0x00, 0x38, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x38,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x0F, 0x0F, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3C, 0x7E, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xE0,
  0x70, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xE3, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x03,
  0x83, 0xC0, 0x38, 0x3C, 0x03, 0x83, 0xC0, 0x38, 0x3C, 0x07, 0x83, 0x80,
  0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x07, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xF8, 0x60, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x20, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x07, 0xC1, 0xC0, 0x3C, 0x1E, 0x03,
  0xC0, 0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x38, 0xFE, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x10, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x1E, 0x07, 0xC0, 0x10, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x1F, 0xE3, 0xC0, 0x7F, 0x8F, 0x01, 0xFC, 0x3C,
  0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF8, 0x07, 0x01, 0xF0, 0x3C, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x01, 0xE0, 0x1E, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x78, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x38, 0x03,
  0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x0F, 0x01,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x38,
  0x03, 0xC0, 0x70, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1C, 0x07, 0x80,
  0x78, 0x0E, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3D,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x1C, 0x78, 0x00, 0xF0, 0xE0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xC0, 0x78, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x7E,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xDC, 0x07, 0xF0, 0x07, 0xF8, 0x0E, 0xE0, 0x0E, 0xF0, 0x1D,
  0xC0, 0x1D, 0xE0, 0x3B, 0xC0, 0x7B, 0x80, 0xF7, 0x80, 0xE7, 0x01, 0xEF,
  0x03, 0xDE, 0x03, 0x9E, 0x07, 0x3C, 0x07, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x38, 0xE0, 0x3C, 0xF0, 0xF3, 0xC0, 0x78, 0xE1, 0xC7, 0x80, 0xE1, 0xC3,
  0x8F, 0x01, 0xC3, 0x8E, 0x1C, 0x07, 0x87, 0x1C, 0x38, 0x0F, 0x0E, 0x78,
  0xF0, 0x1E, 0x1C, 0xE1, 0xE0, 0x38, 0x3B, 0xC3, 0xC0, 0x70, 0x77, 0x07,
  0x01, 0xE0, 0xFE, 0x0E, 0x03, 0xC1, 0xF8, 0x3C, 0x07, 0x03, 0xF0, 0x78,
  0x0E, 0x07, 0xC0, 0xF0, 0x1C, 0x0F, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x03, 0x80, 0xFC,
  0x01, 0xC0, 0x7E, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x78, 0x0F,
  0xC0, 0x38, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0x9C, 0x0F, 0x01,
  0xCE, 0x07, 0x00, 0xE7, 0x03, 0x80, 0xF3, 0x83, 0xC0, 0x79, 0xE1, 0xE0,
  0x38, 0xF0, 0xF0, 0x1C, 0x38, 0x70, 0x1E, 0x1C, 0x38, 0x0F, 0x0E, 0x3C,
  0x07, 0x87, 0x1E, 0x03, 0x83, 0x8F, 0x01, 0xC1, 0xE7, 0x01, 0xE0, 0x73,
  0x80, 0xF0, 0x3B, 0xC0, 0x78, 0x1D, 0xE0, 0x38, 0x0E, 0xE0, 0x1C, 0x07,
  0x70, 0x1E, 0x03, 0xF8, 0x0F, 0x00, 0xFC, 0x07, 0x00, 0x7E, 0x03, 0x80,
  0x3E, 0x01, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x07, 0x81,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38,
  0xE0, 0x07, 0x8E, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E,
  0x0F, 0x87, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xE7, 0xF0, 0x3C, 0x3E, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x07, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x1C,
  0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x70,
  0x3C, 0x1E, 0x1F, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3E, 0x3E, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00,
  0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0xF0,
  0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x87, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xE7, 0xF0, 0x3C,
  0x3E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x07, 0x07, 0x80, 0xE0, 0xF0,
  0x3C, 0x1C, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC1,
  0xF0, 0x70, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0x3C,
  0x01, 0xC7, 0x80, 0x78, 0x70, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x3C,
  0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C,
  0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x0E, 0x07, 0xC0, 0x20, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x80, 0x3E, 0x0E, 0x07, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x1E, 0x01,
  0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1E,
  0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0,
  0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07, 0x81,
  0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xDC, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF0,
  0x07, 0x00, 0x79, 0xE0, 0x1E, 0x00, 0xF3, 0xC0, 0x3C, 0x01, 0xC7, 0x00,
  0xF8, 0x07, 0x8E, 0x01, 0xF0, 0x0F, 0x1C, 0x03, 0xE0, 0x3C, 0x38, 0x0F,
  0xC0, 0x78, 0x70, 0x1F, 0x80, 0xE0, 0xE0, 0x7F, 0x03, 0xC1, 0xC0, 0xEE,
  0x07, 0x83, 0x81, 0xDC, 0x1E, 0x07, 0x07, 0xB8, 0x3C, 0x0E, 0x0E, 0x70,
  0x70, 0x1C, 0x1C, 0xE1, 0xE0, 0x38, 0x71, 0xC3, 0xC0, 0x70, 0xE3, 0x8F,
  0x00, 0xE3, 0xC7, 0x1E, 0x01, 0xC7, 0x0E, 0x38, 0x03, 0x8E, 0x1C, 0xF0,
  0x07, 0x38, 0x39, 0xE0, 0x1E, 0x70, 0x73, 0x80, 0x3D, 0xE0, 0xEF, 0x00,
  0x7B, 0x81, 0xDC, 0x00, 0xF7, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x0D, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0,
  0x07, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEF, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81,
  0xE3, 0xC0, 0xF0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x78, 0x1C, 0x38, 0x0F,
  0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x01, 0xEE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07,
  0x38, 0x03, 0x8F, 0x01, 0xE1, 0xC0, 0x70, 0x70, 0x3C, 0x1E, 0x0E, 0x07,
  0x87, 0x80, 0xE3, 0xC0, 0x38, 0xE0, 0x0F, 0x78, 0x01, 0xFC, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xF3, 0xC7, 0x9E, 0x38, 0x71, 0xC0,
  0x01, 0xF1, 0xC0, 0xFE, 0x70, 0x7F, 0xDC, 0x3E, 0x3F, 0x0F, 0x07, 0x87,
  0x81, 0xE1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8E, 0x01, 0xC7, 0x80,
  0x71, 0xE0, 0x1C, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x38,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E,
  0x3F, 0x07, 0xFF, 0xC1, 0xFE, 0xE0, 0x3F, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x79, 0xF0, 0x1C, 0xFE,
  0x07, 0x7F, 0x83, 0xF8, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x01, 0xC3,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0,
  0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0x87, 0xC1, 0xE1, 0xF0, 0xF0, 0xFF, 0xFC, 0x39,
  0xFE, 0x0E, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7C, 0x20,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x04, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x01, 0xF1, 0xC0, 0x3F, 0x9C, 0x07, 0xFF, 0xC0,
  0xF8, 0xFC, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0, 0x78,
  0x3C, 0x07, 0x87, 0x80, 0x70, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x70, 0x0F,
  0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x0F, 0xC0, 0x7F,
  0xFC, 0x07, 0xFB, 0x80, 0x3F, 0x38, 0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0x8F, 0x0F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x10, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x70, 0x0F, 0xE7, 0x01, 0xFF, 0x70,
  0x3E, 0x3F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0xE0, 0x1C, 0x1E, 0x01, 0xC1, 0xE0, 0x3C, 0x1C, 0x03,
  0xC1, 0xC0, 0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC3, 0xF0, 0x1F,
  0xFF, 0x01, 0xFE, 0xE0, 0x0F, 0xCE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x08, 0x07, 0x80,
  0xE0, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x79, 0xF0, 0x1D,
  0xFE, 0x07, 0x7F, 0x81, 0xF1, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0x83, 0x80, 0xE1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x01, 0xC1,
  0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xE0, 0xE0,
  0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x70, 0x70, 0x1C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x4F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x78, 0x0E,
  0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0E, 0x3C, 0x01, 0xCF, 0x00, 0x39,
  0xE0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3E, 0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x38, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x1F, 0x0F, 0x80, 0xEF, 0xF3, 0xF8,
  0x1F, 0xFE, 0xFF, 0x83, 0xE3, 0xF9, 0xF0, 0xF8, 0x3E, 0x1E, 0x1E, 0x07,
  0x83, 0xC3, 0xC0, 0xF0, 0x78, 0x70, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xC3,
  0xC0, 0xF0, 0x38, 0x78, 0x1C, 0x0F, 0x0E, 0x03, 0x81, 0xE1, 0xC0, 0xF0,
  0x3C, 0x78, 0x1E, 0x07, 0x0F, 0x03, 0xC0, 0xE1, 0xE0, 0x70, 0x3C, 0x38,
  0x0E, 0x07, 0x87, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1C, 0x3C, 0x0F, 0x03,
  0x87, 0x81, 0xC0, 0xF0, 0xE0, 0x38, 0x1E, 0x3C, 0x0F, 0x03, 0x87, 0x81,
  0xE0, 0x70, 0xF0, 0x38, 0x1E, 0x00, 0x07, 0x1F, 0x01, 0xDF, 0xE0, 0x7F,
  0xF8, 0x1F, 0x1F, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x38, 0x3C, 0x0E,
  0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1C, 0x1C, 0x07, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xF1, 0xE0,
  0xE0, 0xF0, 0xF0, 0x38, 0x70, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0xBC, 0x03,
  0x9E, 0x01, 0xCF, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x07, 0x83,
  0xC7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xC7, 0xC0,
  0x1C, 0xFE, 0x01, 0xDF, 0xE0, 0x1F, 0x8F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F,
  0x03, 0xC0, 0x70, 0x3C, 0x07, 0x03, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0,
  0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x38, 0x1F,
  0x07, 0x81, 0xF0, 0xF0, 0x1F, 0xFF, 0x03, 0xDF, 0xE0, 0x3C, 0xF8, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xF1, 0xC0, 0xFE, 0x70, 0x7F, 0xDC, 0x3E, 0x3F,
  0x0F, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8E,
  0x01, 0xC7, 0x80, 0x71, 0xE0, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xCF, 0x00,
  0xE3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0,
  0xF0, 0x7C, 0x3C, 0x3F, 0x07, 0xFF, 0xC1, 0xFE, 0xE0, 0x3F, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x07, 0x1E, 0x0E, 0xF8, 0x1D, 0xF0, 0x3F, 0xE0, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x86, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0xC0, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0xCF, 0xF9, 0xFF,
  0x4E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7F, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x03, 0xC3, 0x80, 0xF0,
  0xE0, 0x38, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x70, 0x70,
  0x1C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x38, 0x38, 0x0E,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1C, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x3E, 0x0F, 0xFB, 0x81, 0xFE,
  0xE0, 0x3E, 0x38, 0x00, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE,
  0x07, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xC3, 0xC3, 0x87,
  0x07, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xEF, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x70, 0x1E, 0x03, 0xB8, 0x0F, 0x03, 0xDC, 0x0F, 0x81,
  0xCE, 0x07, 0xC1, 0xE7, 0x07, 0xE0, 0xF3, 0x83, 0xF0, 0x71, 0xC1, 0xF8,
  0x78, 0xE1, 0xDC, 0x38, 0x70, 0xEE, 0x3C, 0x38, 0xE7, 0x1E, 0x1C, 0x73,
  0x8E, 0x0E, 0x39, 0xCF, 0x07, 0x38, 0xE7, 0x03, 0x9C, 0x73, 0x81, 0xDE,
  0x3B, 0xC0, 0xEE, 0x1D, 0xC0, 0x77, 0x1D, 0xE0, 0x3F, 0x0E, 0xE0, 0x1F,
  0x87, 0x70, 0x0F, 0xC3, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x38, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C,
  0x70, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x01, 0xE3, 0x80,
  0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xC0, 0xF0, 0x1E,
  0x00, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0x70, 0x1E,
  0x01, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE7,
  0x80, 0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x9F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x04, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xF8,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x0F,
  0xF4, 0x00, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 33, 11, 0, -33 },
  { 51, 12, 12, 16, 5, -33 },
  { 69, 21, 33, 19, 0, -33 },
  { 156, 19, 38, 18, 0, -35 },
  { 247, 24, 33, 28, 2, -33 },
  { 346, 19, 33, 20, 0, -33 },
  { 425, 6, 12, 9, 5, -33 },
  { 434, 14, 40, 12, 1, -33 },
  { 504, 14, 40, 12, -3, -33 },
  { 574, 13, 15, 17, 5, -35 },
  { 599, 17, 22, 20, 2, -27 },
  { 646, 8, 11, 9, -2, -5 },
  { 657, 10, 3, 12, 1, -14 },
  { 661, 5, 5, 9, 0, -5 },
  { 665, 21, 33, 15, -2, -33 },
  { 752, 17, 33, 18, 1, -33 },
  { 823, 11, 33, 18, 5, -33 },
  { 869, 20, 33, 18, -2, -33 },
  { 952, 19, 33, 18, -1, -33 },
  { 1031, 19, 33, 18, -1, -33 },
  { 1110, 19, 33, 18, -1, -33 },
  { 1189, 18, 33, 18, 1, -33 },
  { 1264, 19, 33, 18, 1, -33 },
  { 1343, 19, 33, 18, 0, -33 },
  { 1422, 18, 33, 18, 0, -33 },
  { 1497, 9, 25, 9, 0, -25 },
  { 1526, 11, 31, 9, -2, -25 },
  { 1569, 17, 21, 20, 2, -27 },
  { 1614, 17, 13, 20, 2, -23 },
  { 1642, 17, 21, 20, 2, -27 },
  { 1687, 14, 33, 13, 1, -33 },
  { 1745, 25, 37, 27, 1, -33 },
  { 1861, 19, 33, 19, -3, -33 },
  { 1940, 20, 33, 20, 0, -33 },
  { 2023, 19, 33, 18, 2, -33 },
  { 2102, 21, 33, 21, 0, -33 },
  { 2189, 19, 33, 17, 0, -33 },
  { 2268, 19, 33, 16, 0, -33 },
  { 2347, 22, 33, 23, 2, -33 },
  { 2438, 23, 33, 22, 0, -33 },
  { 2533, 17, 33, 12, -2, -33 },
  { 2604, 18, 42, 9, -7, -33 },
  { 2699, 22, 33, 19, 0, -33 },
  { 2790, 12, 33, 16, 0, -33 },
  { 2840, 31, 33, 30, 0, -33 },
  { 2968, 25, 33, 24, 0, -33 },
  { 3072, 20, 33, 23, 2, -33 },
  { 3155, 19, 33, 19, 0, -33 },
  { 3234, 20, 41, 23, 2, -33 },
  { 3337, 19, 33, 19, 0, -33 },
  { 3416, 20, 33, 17, -1, -33 },
  { 3499, 16, 33, 16, 3, -33 },
  { 3565, 21, 33, 22, 2, -33 },
  { 3652, 18, 33, 19, 4, -33 },
  { 3727, 31, 33, 30, 3, -33 },
  { 3855, 23, 33, 17, -3, -33 },
  { 3950, 17, 33, 16, 3, -33 },
  { 4021, 20, 33, 15, -2, -33 },
  { 4104, 17, 40, 13, -1, -33 },
  { 4189, 7, 33, 16, 5, -33 },
  { 4218, 17, 40, 13, -3, -33 },
  { 4303, 18, 18, 18, 0, -33 },
  { 4344, 15, 3, 14, -4, 4 },
  { 4350, 6, 7, 11, 7, -35 },
  { 4356, 18, 25, 19, 1, -25 },
  { 4413, 18, 35, 19, 0, -35 },
  { 4492, 15, 25, 15, 1, -25 },
  { 4539, 20, 35, 19, 1, -35 },
  { 4627, 16, 25, 18, 1, -25 },
  { 4677, 22, 46, 11, -6, -35 },
  { 4804, 20, 36, 19, -1, -25 },
  { 4894, 18, 35, 19, 0, -35 },
  { 4973, 11, 34, 9, 0, -34 },
  { 5020, 17, 45, 9, -6, -34 },
  { 5116, 19, 35, 17, 0, -35 },
  { 5200, 11, 35, 9, 0, -35 },
  { 5249, 27, 25, 28, 0, -25 },
  { 5334, 18, 25, 19, 0, -25 },
  { 5391, 17, 25, 19, 1, -25 },
  { 5445, 20, 36, 19, -2, -25 },
  { 5535, 18, 36, 19, 1, -25 },
  { 5616, 15, 25, 13, 0, -25 },
  { 5663, 16, 25, 15, -1, -25 },
  { 5713, 11, 30, 11, 1, -30 },
  { 5755, 18, 25, 19, 1, -25 },
  { 5812, 15, 25, 15, 3, -25 },
  { 5859, 25, 25, 25, 2, -25 },
  { 5938, 20, 25, 16, -2, -25 },
  { 6001, 22, 36, 16, -4, -25 },
  { 6100, 16, 25, 13, -2, -25 },
  { 6150, 17, 40, 15, 1, -33 },
  { 6235, 3, 46, 17, 7, -35 },
  { 6253, 17, 40, 15, -3, -33 },
  { 6338, 17, 6, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Italic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC46PT7B_H_
