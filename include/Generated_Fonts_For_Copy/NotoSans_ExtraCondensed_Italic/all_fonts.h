#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_Italic
// Headers: 67

#include "NotoSans_ExtraCondensed_Italic6pt7b.h"
#include "NotoSans_ExtraCondensed_Italic7pt7b.h"
#include "NotoSans_ExtraCondensed_Italic8pt7b.h"
#include "NotoSans_ExtraCondensed_Italic9pt7b.h"
#include "NotoSans_ExtraCondensed_Italic10pt7b.h"
#include "NotoSans_ExtraCondensed_Italic11pt7b.h"
#include "NotoSans_ExtraCondensed_Italic12pt7b.h"
#include "NotoSans_ExtraCondensed_Italic13pt7b.h"
#include "NotoSans_ExtraCondensed_Italic14pt7b.h"
#include "NotoSans_ExtraCondensed_Italic15pt7b.h"
#include "NotoSans_ExtraCondensed_Italic16pt7b.h"
#include "NotoSans_ExtraCondensed_Italic17pt7b.h"
#include "NotoSans_ExtraCondensed_Italic18pt7b.h"
#include "NotoSans_ExtraCondensed_Italic19pt7b.h"
#include "NotoSans_ExtraCondensed_Italic20pt7b.h"
#include "NotoSans_ExtraCondensed_Italic21pt7b.h"
#include "NotoSans_ExtraCondensed_Italic22pt7b.h"
#include "NotoSans_ExtraCondensed_Italic23pt7b.h"
#include "NotoSans_ExtraCondensed_Italic24pt7b.h"
#include "NotoSans_ExtraCondensed_Italic25pt7b.h"
#include "NotoSans_ExtraCondensed_Italic26pt7b.h"
#include "NotoSans_ExtraCondensed_Italic27pt7b.h"
#include "NotoSans_ExtraCondensed_Italic28pt7b.h"
#include "NotoSans_ExtraCondensed_Italic29pt7b.h"
#include "NotoSans_ExtraCondensed_Italic30pt7b.h"
#include "NotoSans_ExtraCondensed_Italic31pt7b.h"
#include "NotoSans_ExtraCondensed_Italic32pt7b.h"
#include "NotoSans_ExtraCondensed_Italic33pt7b.h"
#include "NotoSans_ExtraCondensed_Italic34pt7b.h"
#include "NotoSans_ExtraCondensed_Italic35pt7b.h"
#include "NotoSans_ExtraCondensed_Italic36pt7b.h"
#include "NotoSans_ExtraCondensed_Italic37pt7b.h"
#include "NotoSans_ExtraCondensed_Italic38pt7b.h"
#include "NotoSans_ExtraCondensed_Italic39pt7b.h"
#include "NotoSans_ExtraCondensed_Italic40pt7b.h"
#include "NotoSans_ExtraCondensed_Italic41pt7b.h"
#include "NotoSans_ExtraCondensed_Italic42pt7b.h"
#include "NotoSans_ExtraCondensed_Italic43pt7b.h"
#include "NotoSans_ExtraCondensed_Italic44pt7b.h"
#include "NotoSans_ExtraCondensed_Italic45pt7b.h"
#include "NotoSans_ExtraCondensed_Italic46pt7b.h"
#include "NotoSans_ExtraCondensed_Italic47pt7b.h"
#include "NotoSans_ExtraCondensed_Italic48pt7b.h"
#include "NotoSans_ExtraCondensed_Italic49pt7b.h"
#include "NotoSans_ExtraCondensed_Italic50pt7b.h"
#include "NotoSans_ExtraCondensed_Italic51pt7b.h"
#include "NotoSans_ExtraCondensed_Italic52pt7b.h"
#include "NotoSans_ExtraCondensed_Italic53pt7b.h"
#include "NotoSans_ExtraCondensed_Italic54pt7b.h"
#include "NotoSans_ExtraCondensed_Italic55pt7b.h"
#include "NotoSans_ExtraCondensed_Italic56pt7b.h"
#include "NotoSans_ExtraCondensed_Italic57pt7b.h"
#include "NotoSans_ExtraCondensed_Italic58pt7b.h"
#include "NotoSans_ExtraCondensed_Italic59pt7b.h"
#include "NotoSans_ExtraCondensed_Italic60pt7b.h"
#include "NotoSans_ExtraCondensed_Italic61pt7b.h"
#include "NotoSans_ExtraCondensed_Italic62pt7b.h"
#include "NotoSans_ExtraCondensed_Italic63pt7b.h"
#include "NotoSans_ExtraCondensed_Italic64pt7b.h"
#include "NotoSans_ExtraCondensed_Italic65pt7b.h"
#include "NotoSans_ExtraCondensed_Italic66pt7b.h"
#include "NotoSans_ExtraCondensed_Italic67pt7b.h"
#include "NotoSans_ExtraCondensed_Italic68pt7b.h"
#include "NotoSans_ExtraCondensed_Italic69pt7b.h"
#include "NotoSans_ExtraCondensed_Italic70pt7b.h"
#include "NotoSans_ExtraCondensed_Italic71pt7b.h"
#include "NotoSans_ExtraCondensed_Italic72pt7b.h"
