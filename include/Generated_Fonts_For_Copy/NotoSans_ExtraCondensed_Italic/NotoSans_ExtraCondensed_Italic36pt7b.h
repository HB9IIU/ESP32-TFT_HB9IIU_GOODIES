#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0xF0, 0x30, 0x00, 0x73, 0xDC, 0xE7, 0x39, 0x8E,
  0xE3, 0xB8, 0xCE, 0x73, 0x1C, 0xC6, 0x31, 0x80, 0x00, 0xC3, 0x00, 0xC6,
  0x01, 0xC6, 0x01, 0x86, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x1C,
  0x1F, 0xFF, 0x3F, 0xFF, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x70,
  0x0C, 0x60, 0x1C, 0x60, 0xFF, 0xFC, 0xFF, 0xF8, 0x38, 0xC0, 0x30, 0xC0,
  0x31, 0x80, 0x31, 0x80, 0x61, 0x80, 0x63, 0x00, 0x63, 0x00, 0xE3, 0x00,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xC9, 0x87,
  0x30, 0x0E, 0x60, 0x1C, 0x80, 0x39, 0x00, 0x76, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0x70, 0x04, 0xE0, 0x09, 0xC0,
  0x13, 0x80, 0x67, 0x10, 0xCE, 0x39, 0x78, 0x7F, 0xE0, 0x7F, 0x80, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x00, 0x0E, 0x01, 0x83, 0xE0, 0x60,
  0xEE, 0x0C, 0x19, 0xC3, 0x06, 0x38, 0x60, 0xC7, 0x18, 0x38, 0xC7, 0x07,
  0x18, 0xC0, 0xC3, 0x38, 0x18, 0x66, 0x03, 0x1D, 0xCE, 0x63, 0x33, 0xEC,
  0xEE, 0xED, 0x99, 0x99, 0xFF, 0x77, 0x3B, 0x8C, 0xC7, 0x03, 0x98, 0xE0,
  0x67, 0x18, 0x1C, 0xC3, 0x03, 0x18, 0x60, 0xE3, 0x1C, 0x18, 0x63, 0x06,
  0x0C, 0x60, 0xC1, 0x98, 0x30, 0x3F, 0x0E, 0x03, 0xC0, 0x01, 0xF0, 0x07,
  0xF0, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8E, 0x07, 0x18,
  0x0E, 0x70, 0x0D, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xF0, 0x0E,
  0xE3, 0x9C, 0xC6, 0x71, 0xDC, 0xC3, 0xBB, 0x87, 0xE7, 0x07, 0xCE, 0x0F,
  0x1C, 0x1E, 0x38, 0x7C, 0x79, 0xF8, 0x7F, 0x38, 0xFC, 0x70, 0x77, 0x76,
  0x6E, 0xEC, 0xCC, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x08, 0x03, 0x80, 0xE2, 0x38,
  0xEC, 0x7F, 0xF3, 0xFC, 0x70, 0x3E, 0x1D, 0xCE, 0x31, 0x0E, 0x02, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x86, 0x1C,
  0x30, 0xE0, 0xFF, 0xFE, 0xFE, 0x77, 0xF6, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x81, 0xFE, 0x1C, 0x71, 0xC3, 0x8E,
  0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC1, 0xCE,
  0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0x83,
  0xC3, 0xC7, 0xE7, 0xF7, 0xBB, 0x98, 0x9C, 0x0E, 0x07, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x70, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x30, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x3F,
  0xF8, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x30,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x20, 0x3C,
  0x61, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x06, 0xC0, 0x0F, 0x80, 0x37, 0x00, 0x6E, 0x01, 0x9C, 0x07,
  0x30, 0x0C, 0xE0, 0x31, 0xC0, 0xE3, 0x81, 0x86, 0x06, 0x0C, 0x1C, 0x38,
  0x30, 0x70, 0xE0, 0xE1, 0xFF, 0xF3, 0xFF, 0xE8, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x88, 0x1E, 0x30,
  0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3E, 0x81, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x3C,
  0x1F, 0xF8, 0x7C, 0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x3C, 0xF0, 0x7F,
  0x80, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0x70, 0xE0,
  0xC0, 0xE3, 0x81, 0x87, 0x03, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x70, 0x39,
  0xC0, 0x3F, 0x00, 0x78, 0x01, 0xF8, 0x07, 0x38, 0x1C, 0x70, 0x70, 0x71,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x78,
  0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0x87,
  0x1C, 0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x0F, 0x38, 0x78, 0xF3, 0xE1, 0xFF, 0x87, 0xEE, 0x04, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x21, 0xE0, 0xFF,
  0x03, 0xF0, 0x00, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xE3, 0x80, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0x00,
  0x04, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0x30,
  0x00, 0x07, 0xC1, 0xFE, 0x1F, 0xF1, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xC1, 0xC0,
  0x38, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x71, 0x83, 0xC3,
  0x38, 0x7E, 0x33, 0x0C, 0xE3, 0x31, 0x8C, 0x76, 0x18, 0xC6, 0x63, 0x0C,
  0x66, 0x31, 0xC6, 0xE3, 0x18, 0x6C, 0x71, 0x8E, 0xC6, 0x18, 0xCC, 0x63,
  0x8C, 0xC6, 0x39, 0x8C, 0x77, 0x98, 0xC7, 0xDF, 0x0C, 0x38, 0xE0, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x30, 0x03,
  0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1B,
  0x00, 0x6C, 0x03, 0xF0, 0x0D, 0xC0, 0x77, 0x01, 0xDC, 0x06, 0x70, 0x39,
  0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF1, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xE0,
  0x1F, 0x80, 0x70, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x0E, 0x06,
  0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C,
  0x1C, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x1C, 0x38, 0x1C, 0x30, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70,
  0x70, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x07, 0x82, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x7C, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x1E, 0x06, 0x0F, 0x0E, 0x07, 0x0E,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x30,
  0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x70, 0x70, 0xF0, 0x7F, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1E, 0x04, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x7E, 0x1C, 0x1F,
  0x8F, 0x07, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0xF0, 0x1C, 0x1C, 0x07, 0x07, 0x03, 0x81, 0xF0, 0xE0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C,
  0x07, 0x06, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03,
  0x07, 0x01, 0xC1, 0xC0, 0x70, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x83,
  0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x01, 0xC1, 0xC0,
  0x70, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0x81, 0x80, 0xE0, 0xE0, 0x38,
  0x38, 0x0E, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x03, 0xF0, 0x1F, 0x80, 0xF0, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0xE0,
  0x70, 0x70, 0x1C, 0x38, 0x06, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x39,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x03,
  0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x07, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0xEE, 0x0D, 0xC0, 0xFC, 0x1D, 0xC0, 0xDC, 0x1D, 0xC1, 0xDC,
  0x1D, 0xC1, 0x9C, 0x1D, 0xC3, 0x98, 0x19, 0xC3, 0x38, 0x39, 0xC7, 0x38,
  0x39, 0xC7, 0x38, 0x38, 0xCE, 0x38, 0x38, 0xCE, 0x30, 0x30, 0xCC, 0x70,
  0x70, 0xDC, 0x70, 0x70, 0xD8, 0x70, 0x70, 0xF8, 0x70, 0x60, 0xF0, 0xE0,
  0x60, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0x80, 0xE0,
  0xF0, 0x1C, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x7C, 0x0C, 0x1F, 0x83, 0x83,
  0xF0, 0x70, 0x7E, 0x0E, 0x0C, 0xC1, 0xC3, 0x98, 0x30, 0x73, 0x8E, 0x0E,
  0x71, 0xC1, 0xCE, 0x38, 0x31, 0xC6, 0x0E, 0x19, 0xC1, 0xC3, 0x38, 0x38,
  0x77, 0x07, 0x0E, 0xE0, 0xC1, 0xD8, 0x38, 0x3B, 0x07, 0x03, 0xE0, 0xE0,
  0x7C, 0x1C, 0x0F, 0x83, 0x01, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x80, 0x00,
  0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0x38, 0x70, 0x70, 0x79, 0xE0, 0x3F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x38, 0xF0, 0x60,
  0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x70,
  0xE0, 0xE1, 0xC3, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0x07,
  0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0x38,
  0x70, 0x70, 0x79, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x38, 0xF0, 0x60, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E,
  0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE1, 0xE1, 0xC7, 0x83, 0xFE, 0x0F, 0xF0,
  0x1C, 0xE0, 0x39, 0xC0, 0x71, 0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E,
  0x1C, 0x1C, 0x3C, 0x30, 0x38, 0xE0, 0x71, 0xC0, 0xE0, 0x00, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0x02, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x80, 0xF0, 0xF3, 0xE0, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38,
  0x1C, 0x18, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC3,
  0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x18, 0x38, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x83, 0xC0, 0xF3, 0xC0, 0x7F,
  0xC0, 0x1F, 0xC0, 0x00, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE,
  0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x87,
  0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x73, 0x80, 0xE7, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x60, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80,
  0xE0, 0x3F, 0x03, 0xC0, 0xEE, 0x07, 0x81, 0xDC, 0x1F, 0x07, 0x38, 0x36,
  0x0E, 0x70, 0x7C, 0x1C, 0xE1, 0xF8, 0x71, 0xC3, 0x70, 0xE3, 0x8E, 0xE3,
  0x87, 0x1D, 0xC7, 0x0E, 0x33, 0x8E, 0x1C, 0xE7, 0x38, 0x39, 0x8E, 0x70,
  0x77, 0x1D, 0xC0, 0xCE, 0x33, 0x81, 0x98, 0x67, 0x03, 0x70, 0xDC, 0x06,
  0xC1, 0xB8, 0x0D, 0x83, 0x60, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x78,
  0x1E, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x63, 0x80, 0x1C, 0xC0,
  0x07, 0x70, 0x01, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0xDC,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x38, 0x0E, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1D,
  0xC1, 0xC6, 0x0E, 0x30, 0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x1D,
  0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xC6,
  0x31, 0xCE, 0x73, 0x8C, 0x63, 0x18, 0xE7, 0x39, 0xC6, 0x31, 0x8C, 0x73,
  0x9C, 0xE3, 0x18, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x60, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0D, 0xC0, 0x73, 0x03, 0x8E, 0x0C, 0x38,
  0x70, 0xE1, 0x81, 0x8E, 0x07, 0x70, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0xFC,
  0xF3, 0x9C, 0x63, 0x8C, 0x01, 0x00, 0x1F, 0x30, 0xFF, 0xC7, 0x1F, 0x38,
  0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0xCF, 0x87,
  0xEC, 0x1F, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x9C, 0x0E, 0xF8, 0x37, 0xF1, 0xF1, 0xC7, 0x87,
  0x1C, 0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x01,
  0x8C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x1C, 0x3C, 0xF8, 0xE3, 0xFF,
  0x0C, 0xF8, 0x00, 0x01, 0xC0, 0xFC, 0x3F, 0x8E, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1E, 0x21, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x01, 0x1C, 0x07,
  0xDC, 0x0F, 0xFC, 0x1C, 0x7C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x30, 0x60, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xE0, 0xE3, 0xE0, 0x7E, 0xC0, 0x7C,
  0xC0, 0x01, 0xC0, 0x7E, 0x0F, 0xF1, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x77,
  0x0E, 0x61, 0xEF, 0xFC, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x08, 0x7F, 0x83, 0xF8, 0x00, 0x04, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01,
  0xF7, 0x03, 0xFF, 0x07, 0x1F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0C, 0x18, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x38, 0xF8, 0x1F, 0xB0, 0x1F,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x81,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x88, 0x0F, 0xF8, 0x37,
  0xF1, 0xF1, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x61, 0x81, 0x8E, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x0C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x18, 0x60, 0xE3, 0x83, 0x8E, 0x0E, 0x00, 0x02, 0x07, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x00, 0x10,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x07, 0xE0, 0x3E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x01,
  0x0E, 0x1C, 0x1C, 0x70, 0x31, 0xE0, 0xE3, 0x81, 0xCE, 0x03, 0xB8, 0x06,
  0x70, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xCC, 0x07, 0x1C,
  0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x61, 0xC1, 0xC1, 0xC3, 0x83, 0x80,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x00, 0x00, 0x30, 0x60, 0x6F, 0xCF,
  0x83, 0x7E, 0xFE, 0x3E, 0x7C, 0x71, 0xE1, 0xC3, 0x8E, 0x0E, 0x1C, 0x70,
  0x60, 0xE3, 0x07, 0x07, 0x38, 0x38, 0x31, 0xC1, 0xC3, 0x8E, 0x0C, 0x1C,
  0x70, 0xE0, 0xE3, 0x07, 0x07, 0x38, 0x38, 0x31, 0xC1, 0xC3, 0x8E, 0x0C,
  0x1C, 0x70, 0xE0, 0xE7, 0x07, 0x06, 0x38, 0x38, 0x71, 0xC1, 0xC3, 0x80,
  0x00, 0x30, 0x37, 0xE0, 0xDF, 0xC7, 0xC7, 0x1E, 0x1C, 0x70, 0x71, 0xC1,
  0x87, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0C, 0x30, 0x71, 0xC1,
  0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0x01,
  0xC0, 0x3F, 0x03, 0xFC, 0x38, 0xE3, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x3F, 0x01, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C,
  0x1C, 0xE1, 0xC7, 0x9E, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x1C, 0x03, 0x3E,
  0x03, 0x7F, 0x03, 0xC7, 0x07, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x0E, 0x1C, 0x0E,
  0x1C, 0x0E, 0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x78, 0x3B, 0xF0, 0x3B, 0xE0,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1F, 0x70, 0xFF, 0xC7, 0x1F, 0x38,
  0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0x80, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0x8F, 0x87,
  0xEC, 0x1F, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x70, 0xDE, 0x0D, 0xE1,
  0xF2, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xC2, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x88, 0x78, 0xFF, 0x0F, 0xE0, 0x06, 0x07, 0x03, 0x01, 0x81,
  0xC3, 0xFD, 0xFC, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xE0, 0xF0, 0x1C, 0x1C,
  0x60, 0x63, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xC3, 0x07, 0x1C, 0x1C,
  0x70, 0x71, 0xC1, 0xC7, 0x06, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1E,
  0x38, 0x70, 0xE3, 0xC3, 0xFB, 0x07, 0xDC, 0x00, 0xE0, 0x7E, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xEE,
  0x0E, 0xE0, 0xEC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x00, 0xE0, 0xE0, 0xFC, 0x3C, 0x1F, 0x87, 0x87, 0x70, 0xF0, 0xEE, 0x3E,
  0x19, 0xC6, 0xC7, 0x38, 0xD8, 0xE7, 0x3B, 0x38, 0xE6, 0x67, 0x1D, 0xCC,
  0xC3, 0xB1, 0xB8, 0x76, 0x37, 0x0F, 0xC6, 0xC1, 0xB1, 0xF8, 0x36, 0x3E,
  0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0x00, 0x07,
  0x0F, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x38, 0x03, 0x38, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0x60, 0x70, 0x70, 0xF0,
  0x70, 0x07, 0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC,
  0x00, 0x6E, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x7E,
  0x03, 0xE0, 0x10, 0x00, 0x3C, 0x05, 0xFC, 0x3F, 0xFF, 0xF0, 0x7E, 0x80,
  0x20,
};

const GFXglyph NotoSans_ExtraCondensed_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 26, 8, 0, -26 },
  { 31, 10, 10, 12, 4, -26 },
  { 44, 16, 26, 15, 0, -26 },
  { 96, 15, 29, 14, 0, -27 },
  { 151, 19, 26, 22, 2, -26 },
  { 213, 15, 26, 15, 0, -26 },
  { 262, 4, 10, 7, 4, -26 },
  { 267, 11, 32, 9, 1, -26 },
  { 311, 11, 32, 9, -3, -26 },
  { 355, 10, 13, 13, 4, -28 },
  { 372, 14, 17, 15, 1, -21 },
  { 402, 7, 9, 7, -2, -4 },
  { 410, 8, 3, 9, 1, -11 },
  { 413, 4, 4, 7, 0, -4 },
  { 415, 17, 26, 12, -2, -26 },
  { 471, 13, 26, 14, 1, -26 },
  { 514, 9, 26, 14, 4, -26 },
  { 544, 15, 26, 14, -1, -26 },
  { 593, 15, 26, 14, -1, -26 },
  { 642, 15, 26, 14, -1, -26 },
  { 691, 14, 26, 14, 0, -26 },
  { 737, 14, 26, 14, 1, -26 },
  { 783, 15, 26, 14, 1, -26 },
  { 832, 15, 26, 14, 0, -26 },
  { 881, 14, 26, 14, 0, -26 },
  { 927, 7, 19, 7, 0, -19 },
  { 944, 9, 24, 7, -2, -19 },
  { 971, 14, 16, 15, 1, -21 },
  { 999, 14, 10, 15, 1, -18 },
  { 1017, 14, 16, 15, 1, -21 },
  { 1045, 12, 26, 10, 0, -26 },
  { 1084, 20, 29, 21, 1, -26 },
  { 1157, 14, 26, 15, -2, -26 },
  { 1203, 16, 26, 15, 0, -26 },
  { 1255, 16, 26, 14, 1, -26 },
  { 1307, 16, 26, 17, 0, -26 },
  { 1359, 15, 26, 13, 0, -26 },
  { 1408, 15, 26, 12, 0, -26 },
  { 1457, 18, 26, 18, 1, -26 },
  { 1516, 18, 26, 17, 0, -26 },
  { 1575, 14, 26, 9, -2, -26 },
  { 1621, 13, 33, 7, -5, -26 },
  { 1675, 18, 26, 15, 0, -26 },
  { 1734, 10, 26, 12, 0, -26 },
  { 1767, 24, 26, 23, 0, -26 },
  { 1845, 19, 26, 18, 0, -26 },
  { 1907, 16, 26, 18, 1, -26 },
  { 1959, 15, 26, 15, 0, -26 },
  { 2008, 16, 32, 18, 1, -26 },
  { 2072, 15, 26, 15, 0, -26 },
  { 2121, 16, 26, 14, -1, -26 },
  { 2173, 13, 26, 12, 2, -26 },
  { 2216, 17, 26, 17, 1, -26 },
  { 2272, 15, 26, 15, 3, -26 },
  { 2321, 23, 26, 24, 3, -26 },
  { 2396, 18, 26, 13, -2, -26 },
  { 2455, 13, 26, 13, 3, -26 },
  { 2498, 15, 26, 12, -1, -26 },
  { 2547, 14, 32, 10, -1, -26 },
  { 2603, 5, 26, 12, 4, -26 },
  { 2620, 13, 32, 10, -2, -26 },
  { 2672, 14, 14, 14, 0, -26 },
  { 2697, 11, 2, 11, -3, 3 },
  { 2700, 5, 6, 9, 5, -28 },
  { 2704, 14, 20, 15, 1, -20 },
  { 2739, 14, 27, 15, 0, -27 },
  { 2787, 11, 20, 11, 1, -20 },
  { 2815, 16, 27, 15, 1, -27 },
  { 2869, 12, 20, 14, 1, -20 },
  { 2899, 16, 37, 8, -4, -28 },
  { 2973, 16, 29, 15, -1, -20 },
  { 3031, 14, 27, 15, 0, -27 },
  { 3079, 8, 27, 7, 0, -27 },
  { 3106, 13, 36, 7, -5, -27 },
  { 3165, 15, 27, 13, 0, -27 },
  { 3216, 9, 27, 7, 0, -27 },
  { 3247, 21, 20, 22, 0, -20 },
  { 3300, 14, 20, 15, 0, -20 },
  { 3335, 13, 20, 15, 1, -20 },
  { 3368, 16, 28, 15, -2, -20 },
  { 3424, 14, 29, 15, 1, -20 },
  { 3475, 12, 20, 10, 0, -20 },
  { 3505, 12, 20, 11, 0, -20 },
  { 3535, 9, 24, 9, 1, -24 },
  { 3562, 14, 19, 15, 1, -19 },
  { 3596, 12, 19, 12, 2, -19 },
  { 3625, 19, 19, 20, 2, -19 },
  { 3671, 16, 19, 12, -2, -19 },
  { 3709, 17, 28, 12, -3, -19 },
  { 3769, 12, 19, 10, -1, -19 },
  { 3798, 13, 32, 12, 1, -26 },
  { 3850, 3, 37, 13, 5, -28 },
  { 3864, 13, 32, 12, -2, -26 },
  { 3916, 14, 5, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Italic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC36PT7B_H_
