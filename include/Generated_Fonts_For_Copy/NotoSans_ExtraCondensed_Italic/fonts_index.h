#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_ExtraCondensed_Italic6pt7b, 6, "NotoSans_ExtraCondensed_Italic6pt7b" },
  { &NotoSans_ExtraCondensed_Italic7pt7b, 7, "NotoSans_ExtraCondensed_Italic7pt7b" },
  { &NotoSans_ExtraCondensed_Italic8pt7b, 8, "NotoSans_ExtraCondensed_Italic8pt7b" },
  { &NotoSans_ExtraCondensed_Italic9pt7b, 9, "NotoSans_ExtraCondensed_Italic9pt7b" },
  { &NotoSans_ExtraCondensed_Italic10pt7b, 10, "NotoSans_ExtraCondensed_Italic10pt7b" },
  { &NotoSans_ExtraCondensed_Italic11pt7b, 11, "NotoSans_ExtraCondensed_Italic11pt7b" },
  { &NotoSans_ExtraCondensed_Italic12pt7b, 12, "NotoSans_ExtraCondensed_Italic12pt7b" },
  { &NotoSans_ExtraCondensed_Italic13pt7b, 13, "NotoSans_ExtraCondensed_Italic13pt7b" },
  { &NotoSans_ExtraCondensed_Italic14pt7b, 14, "NotoSans_ExtraCondensed_Italic14pt7b" },
  { &NotoSans_ExtraCondensed_Italic15pt7b, 15, "NotoSans_ExtraCondensed_Italic15pt7b" },
  { &NotoSans_ExtraCondensed_Italic16pt7b, 16, "NotoSans_ExtraCondensed_Italic16pt7b" },
  { &NotoSans_ExtraCondensed_Italic17pt7b, 17, "NotoSans_ExtraCondensed_Italic17pt7b" },
  { &NotoSans_ExtraCondensed_Italic18pt7b, 18, "NotoSans_ExtraCondensed_Italic18pt7b" },
  { &NotoSans_ExtraCondensed_Italic19pt7b, 19, "NotoSans_ExtraCondensed_Italic19pt7b" },
  { &NotoSans_ExtraCondensed_Italic20pt7b, 20, "NotoSans_ExtraCondensed_Italic20pt7b" },
  { &NotoSans_ExtraCondensed_Italic21pt7b, 21, "NotoSans_ExtraCondensed_Italic21pt7b" },
  { &NotoSans_ExtraCondensed_Italic22pt7b, 22, "NotoSans_ExtraCondensed_Italic22pt7b" },
  { &NotoSans_ExtraCondensed_Italic23pt7b, 23, "NotoSans_ExtraCondensed_Italic23pt7b" },
  { &NotoSans_ExtraCondensed_Italic24pt7b, 24, "NotoSans_ExtraCondensed_Italic24pt7b" },
  { &NotoSans_ExtraCondensed_Italic25pt7b, 25, "NotoSans_ExtraCondensed_Italic25pt7b" },
  { &NotoSans_ExtraCondensed_Italic26pt7b, 26, "NotoSans_ExtraCondensed_Italic26pt7b" },
  { &NotoSans_ExtraCondensed_Italic27pt7b, 27, "NotoSans_ExtraCondensed_Italic27pt7b" },
  { &NotoSans_ExtraCondensed_Italic28pt7b, 28, "NotoSans_ExtraCondensed_Italic28pt7b" },
  { &NotoSans_ExtraCondensed_Italic29pt7b, 29, "NotoSans_ExtraCondensed_Italic29pt7b" },
  { &NotoSans_ExtraCondensed_Italic30pt7b, 30, "NotoSans_ExtraCondensed_Italic30pt7b" },
  { &NotoSans_ExtraCondensed_Italic31pt7b, 31, "NotoSans_ExtraCondensed_Italic31pt7b" },
  { &NotoSans_ExtraCondensed_Italic32pt7b, 32, "NotoSans_ExtraCondensed_Italic32pt7b" },
  { &NotoSans_ExtraCondensed_Italic33pt7b, 33, "NotoSans_ExtraCondensed_Italic33pt7b" },
  { &NotoSans_ExtraCondensed_Italic34pt7b, 34, "NotoSans_ExtraCondensed_Italic34pt7b" },
  { &NotoSans_ExtraCondensed_Italic35pt7b, 35, "NotoSans_ExtraCondensed_Italic35pt7b" },
  { &NotoSans_ExtraCondensed_Italic36pt7b, 36, "NotoSans_ExtraCondensed_Italic36pt7b" },
  { &NotoSans_ExtraCondensed_Italic37pt7b, 37, "NotoSans_ExtraCondensed_Italic37pt7b" },
  { &NotoSans_ExtraCondensed_Italic38pt7b, 38, "NotoSans_ExtraCondensed_Italic38pt7b" },
  { &NotoSans_ExtraCondensed_Italic39pt7b, 39, "NotoSans_ExtraCondensed_Italic39pt7b" },
  { &NotoSans_ExtraCondensed_Italic40pt7b, 40, "NotoSans_ExtraCondensed_Italic40pt7b" },
  { &NotoSans_ExtraCondensed_Italic41pt7b, 41, "NotoSans_ExtraCondensed_Italic41pt7b" },
  { &NotoSans_ExtraCondensed_Italic42pt7b, 42, "NotoSans_ExtraCondensed_Italic42pt7b" },
  { &NotoSans_ExtraCondensed_Italic43pt7b, 43, "NotoSans_ExtraCondensed_Italic43pt7b" },
  { &NotoSans_ExtraCondensed_Italic44pt7b, 44, "NotoSans_ExtraCondensed_Italic44pt7b" },
  { &NotoSans_ExtraCondensed_Italic45pt7b, 45, "NotoSans_ExtraCondensed_Italic45pt7b" },
  { &NotoSans_ExtraCondensed_Italic46pt7b, 46, "NotoSans_ExtraCondensed_Italic46pt7b" },
  { &NotoSans_ExtraCondensed_Italic47pt7b, 47, "NotoSans_ExtraCondensed_Italic47pt7b" },
  { &NotoSans_ExtraCondensed_Italic48pt7b, 48, "NotoSans_ExtraCondensed_Italic48pt7b" },
  { &NotoSans_ExtraCondensed_Italic49pt7b, 49, "NotoSans_ExtraCondensed_Italic49pt7b" },
  { &NotoSans_ExtraCondensed_Italic50pt7b, 50, "NotoSans_ExtraCondensed_Italic50pt7b" },
  { &NotoSans_ExtraCondensed_Italic51pt7b, 51, "NotoSans_ExtraCondensed_Italic51pt7b" },
  { &NotoSans_ExtraCondensed_Italic52pt7b, 52, "NotoSans_ExtraCondensed_Italic52pt7b" },
  { &NotoSans_ExtraCondensed_Italic53pt7b, 53, "NotoSans_ExtraCondensed_Italic53pt7b" },
  { &NotoSans_ExtraCondensed_Italic54pt7b, 54, "NotoSans_ExtraCondensed_Italic54pt7b" },
  { &NotoSans_ExtraCondensed_Italic55pt7b, 55, "NotoSans_ExtraCondensed_Italic55pt7b" },
  { &NotoSans_ExtraCondensed_Italic56pt7b, 56, "NotoSans_ExtraCondensed_Italic56pt7b" },
  { &NotoSans_ExtraCondensed_Italic57pt7b, 57, "NotoSans_ExtraCondensed_Italic57pt7b" },
  { &NotoSans_ExtraCondensed_Italic58pt7b, 58, "NotoSans_ExtraCondensed_Italic58pt7b" },
  { &NotoSans_ExtraCondensed_Italic59pt7b, 59, "NotoSans_ExtraCondensed_Italic59pt7b" },
  { &NotoSans_ExtraCondensed_Italic60pt7b, 60, "NotoSans_ExtraCondensed_Italic60pt7b" },
  { &NotoSans_ExtraCondensed_Italic61pt7b, 61, "NotoSans_ExtraCondensed_Italic61pt7b" },
  { &NotoSans_ExtraCondensed_Italic62pt7b, 62, "NotoSans_ExtraCondensed_Italic62pt7b" },
  { &NotoSans_ExtraCondensed_Italic63pt7b, 63, "NotoSans_ExtraCondensed_Italic63pt7b" },
  { &NotoSans_ExtraCondensed_Italic64pt7b, 64, "NotoSans_ExtraCondensed_Italic64pt7b" },
  { &NotoSans_ExtraCondensed_Italic65pt7b, 65, "NotoSans_ExtraCondensed_Italic65pt7b" },
  { &NotoSans_ExtraCondensed_Italic66pt7b, 66, "NotoSans_ExtraCondensed_Italic66pt7b" },
  { &NotoSans_ExtraCondensed_Italic67pt7b, 67, "NotoSans_ExtraCondensed_Italic67pt7b" },
  { &NotoSans_ExtraCondensed_Italic68pt7b, 68, "NotoSans_ExtraCondensed_Italic68pt7b" },
  { &NotoSans_ExtraCondensed_Italic69pt7b, 69, "NotoSans_ExtraCondensed_Italic69pt7b" },
  { &NotoSans_ExtraCondensed_Italic70pt7b, 70, "NotoSans_ExtraCondensed_Italic70pt7b" },
  { &NotoSans_ExtraCondensed_Italic71pt7b, 71, "NotoSans_ExtraCondensed_Italic71pt7b" },
  { &NotoSans_ExtraCondensed_Italic72pt7b, 72, "NotoSans_ExtraCondensed_Italic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
