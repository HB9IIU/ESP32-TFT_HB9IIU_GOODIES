#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x32, 0x22, 0x64, 0x40, 0xCC, 0xD9, 0x9A, 0x0A, 0x12, 0x12,
  0x7F, 0x24, 0x24, 0x28, 0xFC, 0x48, 0x50, 0x50, 0x90, 0x08, 0x10, 0xF9,
  0x46, 0x86, 0x0C, 0x0C, 0x1C, 0x5A, 0xA7, 0xC2, 0x04, 0x00, 0x71, 0x29,
  0x24, 0x92, 0x89, 0xC5, 0x5F, 0xF2, 0x29, 0x25, 0x92, 0x91, 0x48, 0xC0,
  0x1C, 0x68, 0x91, 0x63, 0x86, 0x1C, 0xAF, 0x8D, 0x1A, 0x77, 0xA0, 0xEA,
  0x08, 0x8C, 0x46, 0x21, 0x08, 0xC6, 0x31, 0x84, 0x21, 0x00, 0x10, 0xC2,
  0x10, 0x84, 0x63, 0x10, 0x8C, 0x46, 0x22, 0x00, 0x25, 0x3E, 0xCF, 0x08,
  0x20, 0x82, 0x3F, 0xFC, 0x82, 0x08, 0x2D, 0x60, 0xF0, 0xF0, 0x03, 0x02,
  0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x1C, 0x6C,
  0x9B, 0x34, 0x48, 0x91, 0x62, 0xCD, 0x93, 0x63, 0x80, 0x37, 0xA2, 0x26,
  0x64, 0x44, 0xCC, 0x1E, 0x13, 0x03, 0x02, 0x02, 0x04, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0xFC, 0x3C, 0x4C, 0x18, 0x20, 0xC7, 0x06, 0x06, 0x0C, 0x12,
  0x67, 0x80, 0x06, 0x18, 0x30, 0xA2, 0xC5, 0x92, 0x64, 0xFC, 0x30, 0x40,
  0x80, 0x3E, 0x40, 0x81, 0x06, 0x0F, 0x03, 0x06, 0x0C, 0x12, 0x67, 0x80,
  0x0E, 0x20, 0x81, 0x05, 0x8F, 0x91, 0x22, 0xC5, 0x99, 0x23, 0x80, 0x7C,
  0x10, 0x82, 0x10, 0x43, 0x08, 0x61, 0x0C, 0x20, 0x3C, 0x4C, 0x89, 0x32,
  0xC3, 0x1E, 0x66, 0x8D, 0x1B, 0x23, 0xC0, 0x3C, 0x49, 0x9A, 0x34, 0x48,
  0x9F, 0x12, 0x08, 0x10, 0x47, 0x00, 0x24, 0x00, 0x06, 0xC0, 0x11, 0x00,
  0x00, 0x02, 0x64, 0xC0, 0x04, 0x73, 0x30, 0xC0, 0xC0, 0xC1, 0xFC, 0x00,
  0x3F, 0x83, 0x03, 0x03, 0x1D, 0xCC, 0x20, 0x79, 0x30, 0xC2, 0x18, 0xC2,
  0x10, 0x40, 0x0C, 0x30, 0x0F, 0x84, 0x22, 0x04, 0x9D, 0x4A, 0x54, 0x95,
  0x29, 0x5A, 0x94, 0xA6, 0xCC, 0x01, 0x00, 0x7C, 0x00, 0x06, 0x14, 0x38,
  0xF1, 0x62, 0xCD, 0x9F, 0x66, 0x8D, 0x1E, 0x30, 0x3E, 0x64, 0x89, 0x12,
  0x6F, 0x9B, 0x22, 0x44, 0x8B, 0x37, 0xC0, 0x1E, 0x41, 0x82, 0x0C, 0x10,
  0x20, 0x40, 0x81, 0x03, 0x03, 0x80, 0x3E, 0x32, 0x23, 0x23, 0x23, 0x62,
  0x62, 0x42, 0x46, 0x44, 0xD8, 0xF0, 0x3E, 0x60, 0x81, 0x02, 0x0F, 0x98,
  0x20, 0x40, 0x83, 0x07, 0xC0, 0x3E, 0x60, 0x81, 0x02, 0x0C, 0x9E, 0x20,
  0x40, 0x83, 0x04, 0x00, 0x1F, 0x21, 0x60, 0x40, 0xC0, 0x80, 0x8E, 0x84,
  0x84, 0x84, 0xCC, 0x7C, 0x31, 0x98, 0x88, 0x44, 0x62, 0x33, 0xF1, 0x88,
  0x84, 0x46, 0x23, 0x31, 0x10, 0x80, 0x1E, 0x10, 0x60, 0xC1, 0x02, 0x04,
  0x18, 0x30, 0x40, 0x87, 0x80, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04,
  0x08, 0x10, 0x60, 0x81, 0x02, 0x38, 0x00, 0x33, 0x32, 0x24, 0x2C, 0x28,
  0x70, 0x78, 0x58, 0x48, 0x48, 0xCC, 0x8C, 0x31, 0x88, 0x42, 0x31, 0x88,
  0x42, 0x31, 0xF0, 0x30, 0x67, 0x0C, 0xE2, 0x9C, 0x73, 0x94, 0xF2, 0x92,
  0xD2, 0x56, 0x4E, 0xC9, 0x93, 0x32, 0x44, 0xC0, 0x30, 0x98, 0xCE, 0x65,
  0x22, 0x93, 0x49, 0x2C, 0x94, 0x4E, 0x23, 0x31, 0x90, 0xC0, 0x3E, 0x4D,
  0x0A, 0x1C, 0x30, 0x61, 0xC3, 0x85, 0x1A, 0x67, 0x80, 0x3C, 0x6C, 0x89,
  0x12, 0x6C, 0x9F, 0x20, 0x40, 0x83, 0x04, 0x00, 0x3E, 0x4D, 0x0A, 0x1C,
  0x30, 0x61, 0xC3, 0x85, 0x1A, 0x67, 0x83, 0x02, 0x06, 0x00, 0x3C, 0x6C,
  0x89, 0x12, 0x6D, 0x9E, 0x2C, 0x48, 0x93, 0x24, 0x60, 0x3E, 0x45, 0x83,
  0x02, 0x06, 0x06, 0x04, 0x08, 0x12, 0x67, 0x80, 0xFC, 0xC3, 0x08, 0x20,
  0x86, 0x10, 0x41, 0x0C, 0x30, 0x62, 0xC5, 0x0A, 0x34, 0x58, 0xA1, 0x46,
  0x8D, 0x12, 0x67, 0x80, 0xC3, 0x8F, 0x16, 0x6C, 0x9B, 0x14, 0x28, 0x70,
  0xC1, 0x82, 0x00, 0xC6, 0x38, 0xCF, 0x31, 0x66, 0x2C, 0xCD, 0xA9, 0x35,
  0x67, 0xA8, 0xE5, 0x14, 0xE3, 0x18, 0x63, 0x00, 0x11, 0x89, 0x86, 0x83,
  0x81, 0xC0, 0x40, 0x60, 0x30, 0x2C, 0x36, 0x13, 0x18, 0x80, 0xC6, 0x99,
  0x22, 0xC5, 0x0E, 0x18, 0x30, 0x40, 0x81, 0x06, 0x00, 0x1F, 0x02, 0x06,
  0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0x44, 0xF8, 0x1C, 0xC2, 0x08,
  0x20, 0x86, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x0E, 0x00, 0xAA, 0xF5, 0x55,
  0x1C, 0x10, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x8E, 0x00,
  0x08, 0x30, 0x71, 0x26, 0x58, 0xC0, 0xF8, 0xC8, 0x80, 0x3A, 0x4D, 0x9A,
  0x24, 0x58, 0xB3, 0x66, 0x78, 0x10, 0x60, 0xC1, 0x03, 0xC4, 0xD9, 0xA3,
  0x44, 0x89, 0x36, 0x4B, 0x80, 0x3C, 0x86, 0x10, 0x43, 0x0C, 0x10, 0x70,
  0x01, 0x03, 0x02, 0x02, 0x3A, 0x26, 0x66, 0x44, 0x44, 0xC4, 0xCC, 0xCC,
  0x78, 0x3C, 0x96, 0x53, 0x73, 0x0C, 0x10, 0x78, 0x07, 0x04, 0x0C, 0x08,
  0x1E, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60,
  0xC0, 0x3A, 0x4D, 0x9A, 0x24, 0x58, 0xB3, 0x66, 0x78, 0x10, 0x64, 0x8F,
  0x00, 0x10, 0x60, 0xC1, 0x03, 0xC4, 0xD9, 0x22, 0x44, 0x99, 0x36, 0x48,
  0x80, 0x13, 0x00, 0x22, 0x64, 0x44, 0x4C, 0x80, 0x04, 0x30, 0x00, 0x08,
  0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x18, 0xC0, 0x10, 0x60, 0xC1,
  0x02, 0x65, 0x9A, 0x28, 0x70, 0xA1, 0x66, 0xC8, 0x80, 0x13, 0x32, 0x22,
  0x64, 0x44, 0x4C, 0x80, 0x3D, 0xC9, 0x96, 0x45, 0x13, 0x44, 0x93, 0x24,
  0x8B, 0x26, 0x89, 0x80, 0x3C, 0x4D, 0x92, 0x24, 0x49, 0x93, 0x64, 0x88,
  0x3C, 0x49, 0x9A, 0x24, 0x58, 0xB3, 0x24, 0x70, 0x1E, 0x13, 0x33, 0x23,
  0x22, 0x22, 0x22, 0x64, 0x5C, 0x40, 0x40, 0xC0, 0xC0, 0x3A, 0x4D, 0x9A,
  0x24, 0x58, 0xB3, 0x66, 0x78, 0x10, 0x20, 0xC1, 0x00, 0x39, 0x98, 0xC4,
  0x21, 0x18, 0x80, 0x3D, 0x04, 0x18, 0x30, 0x41, 0x24, 0xF0, 0x11, 0x1E,
  0x46, 0x31, 0x08, 0x46, 0x18, 0x26, 0x4D, 0x92, 0x24, 0x49, 0x93, 0x64,
  0x78, 0x8E, 0x29, 0x24, 0xB2, 0x8E, 0x30, 0xC0, 0x89, 0xCC, 0xA6, 0x57,
  0x6A, 0xA5, 0x53, 0x31, 0x98, 0xCC, 0x00, 0x33, 0x14, 0x14, 0x18, 0x18,
  0x38, 0x28, 0x68, 0xCC, 0x11, 0x88, 0x84, 0xC2, 0x41, 0x60, 0xA0, 0x50,
  0x30, 0x18, 0x08, 0x04, 0x06, 0x0E, 0x00, 0x3C, 0x30, 0x86, 0x10, 0x86,
  0x10, 0xF8, 0x0E, 0x30, 0x60, 0x81, 0x02, 0x08, 0x60, 0x20, 0x40, 0x83,
  0x04, 0x0C, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x20, 0x82,
  0x08, 0x60, 0x83, 0x10, 0x43, 0x08, 0x21, 0x8C, 0x00, 0xE6, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 4, 4, 6, 2, -12 },
  { 9, 8, 12, 7, 0, -12 },
  { 21, 7, 14, 7, 0, -13 },
  { 34, 9, 12, 10, 1, -12 },
  { 48, 7, 12, 7, 0, -12 },
  { 59, 2, 4, 3, 2, -12 },
  { 60, 5, 15, 4, 0, -12 },
  { 70, 5, 15, 4, -1, -12 },
  { 80, 5, 6, 6, 2, -13 },
  { 84, 6, 8, 7, 1, -10 },
  { 90, 3, 4, 3, -1, -2 },
  { 92, 4, 1, 4, 0, -5 },
  { 93, 2, 2, 3, 0, -2 },
  { 94, 8, 12, 6, -1, -12 },
  { 106, 7, 12, 7, 0, -12 },
  { 117, 4, 12, 7, 2, -12 },
  { 123, 8, 12, 7, -1, -12 },
  { 135, 7, 12, 7, 0, -12 },
  { 146, 7, 12, 7, 0, -12 },
  { 157, 7, 12, 7, 0, -12 },
  { 168, 7, 12, 7, 0, -12 },
  { 179, 6, 12, 7, 1, -12 },
  { 188, 7, 12, 7, 0, -12 },
  { 199, 7, 12, 7, 0, -12 },
  { 210, 3, 9, 3, 0, -9 },
  { 214, 4, 11, 3, -1, -9 },
  { 220, 6, 8, 7, 1, -10 },
  { 226, 6, 4, 7, 1, -8 },
  { 229, 6, 8, 7, 1, -10 },
  { 235, 6, 12, 5, 0, -12 },
  { 244, 10, 13, 10, 0, -12 },
  { 261, 7, 12, 7, -1, -12 },
  { 272, 7, 12, 7, 0, -12 },
  { 283, 7, 12, 7, 1, -12 },
  { 294, 8, 12, 8, 0, -12 },
  { 306, 7, 12, 6, 0, -12 },
  { 317, 7, 12, 6, 0, -12 },
  { 328, 8, 12, 8, 1, -12 },
  { 340, 9, 12, 8, 0, -12 },
  { 354, 7, 12, 4, -1, -12 },
  { 365, 7, 15, 3, -3, -12 },
  { 379, 8, 12, 7, 0, -12 },
  { 391, 5, 12, 6, 0, -12 },
  { 399, 11, 12, 11, 0, -12 },
  { 416, 9, 12, 9, 0, -12 },
  { 430, 7, 12, 8, 1, -12 },
  { 441, 7, 12, 7, 0, -12 },
  { 452, 7, 15, 8, 1, -12 },
  { 466, 7, 12, 7, 0, -12 },
  { 477, 7, 12, 6, 0, -12 },
  { 488, 6, 12, 6, 1, -12 },
  { 497, 7, 12, 8, 1, -12 },
  { 508, 7, 12, 7, 1, -12 },
  { 519, 11, 12, 11, 1, -12 },
  { 536, 9, 12, 6, -1, -12 },
  { 550, 7, 12, 6, 1, -12 },
  { 561, 8, 12, 6, -1, -12 },
  { 573, 6, 15, 5, 0, -12 },
  { 585, 2, 12, 6, 2, -12 },
  { 588, 6, 15, 5, -1, -12 },
  { 600, 7, 6, 7, 0, -12 },
  { 606, 5, 1, 5, -1, 1 },
  { 607, 3, 3, 4, 2, -13 },
  { 609, 7, 9, 7, 0, -9 },
  { 617, 7, 13, 7, 0, -13 },
  { 629, 6, 9, 5, 0, -9 },
  { 636, 8, 13, 7, 0, -13 },
  { 649, 6, 9, 7, 0, -9 },
  { 656, 8, 17, 4, -2, -13 },
  { 673, 7, 13, 7, 0, -9 },
  { 685, 7, 13, 7, 0, -13 },
  { 697, 4, 13, 3, 0, -13 },
  { 704, 6, 17, 3, -2, -13 },
  { 717, 7, 13, 6, 0, -13 },
  { 729, 4, 13, 3, 0, -13 },
  { 736, 10, 9, 10, 0, -9 },
  { 748, 7, 9, 7, 0, -9 },
  { 756, 7, 9, 7, 0, -9 },
  { 764, 8, 13, 7, -1, -9 },
  { 777, 7, 13, 7, 0, -9 },
  { 789, 5, 9, 5, 0, -9 },
  { 795, 6, 9, 5, 0, -9 },
  { 802, 5, 11, 4, 0, -11 },
  { 809, 7, 9, 7, 0, -9 },
  { 817, 6, 9, 6, 1, -9 },
  { 824, 9, 9, 9, 1, -9 },
  { 835, 8, 9, 6, -1, -9 },
  { 844, 9, 13, 6, -2, -9 },
  { 859, 6, 9, 5, -1, -9 },
  { 866, 7, 15, 6, 0, -12 },
  { 880, 2, 17, 6, 2, -13 },
  { 885, 6, 15, 6, -1, -12 },
  { 897, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Italic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC17PT7B_H_
