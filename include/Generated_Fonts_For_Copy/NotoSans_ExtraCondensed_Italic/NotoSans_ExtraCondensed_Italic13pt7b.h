#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x84, 0xC0, 0x5A, 0xA0, 0x14, 0xA7, 0xCA, 0x53, 0xE5,
  0x28, 0xA0, 0x11, 0xD6, 0xA6, 0x18, 0xC6, 0xF2, 0x10, 0xE6, 0xAB, 0x2D,
  0xEC, 0xD5, 0x55, 0x98, 0x39, 0x4C, 0x66, 0x56, 0x72, 0xF8, 0x58, 0x12,
  0x44, 0x48, 0x88, 0x88, 0x40, 0x31, 0x11, 0x11, 0x22, 0x24, 0x80, 0x2E,
  0x3F, 0x44, 0x4F, 0x44, 0x6A, 0x00, 0xE0, 0xB0, 0x04, 0x20, 0x84, 0x10,
  0x82, 0x10, 0xC0, 0x3A, 0x52, 0x94, 0xC6, 0x52, 0x60, 0x3E, 0x22, 0x24,
  0x44, 0x40, 0x78, 0x42, 0x31, 0x11, 0x10, 0xF0, 0x78, 0x42, 0x27, 0x08,
  0x42, 0xE0, 0x08, 0xCA, 0x65, 0x4B, 0xE4, 0x20, 0x3A, 0x10, 0xE1, 0x08,
  0x42, 0xE0, 0x39, 0x10, 0xE5, 0xC6, 0x52, 0x60, 0x7C, 0x20, 0x84, 0x10,
  0x82, 0x10, 0xC0, 0x3A, 0x52, 0x67, 0x4A, 0x52, 0xF0, 0x3A, 0x52, 0x95,
  0x98, 0x46, 0xE0, 0x68, 0x01, 0x20, 0x32, 0x00, 0x02, 0x44, 0x80, 0x08,
  0xC9, 0x83, 0x04, 0xF0, 0xF0, 0x88, 0x61, 0x68, 0x71, 0x12, 0x44, 0x04,
  0x80, 0x1E, 0x45, 0x3A, 0xBA, 0xB5, 0x6A, 0xCA, 0x80, 0xF0, 0x08, 0xC6,
  0x52, 0x9D, 0x29, 0x88, 0x38, 0x94, 0xD2, 0x71, 0x24, 0xA6, 0xF0, 0x3C,
  0x84, 0x10, 0x43, 0x0C, 0x10, 0x70, 0x38, 0x94, 0x51, 0x45, 0x24, 0xA4,
  0xE0, 0x39, 0x10, 0x87, 0x21, 0x10, 0xF0, 0x39, 0x10, 0x87, 0x21, 0x10,
  0x80, 0x3E, 0x41, 0x02, 0x04, 0xD8, 0xB2, 0x24, 0x78, 0x26, 0x49, 0x12,
  0x27, 0xC9, 0x12, 0x44, 0x88, 0x38, 0x84, 0x62, 0x10, 0x84, 0xE0, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x39, 0x00, 0x24, 0xA5, 0x14, 0x71, 0x45,
  0x24, 0x90, 0x22, 0x44, 0x44, 0x48, 0xF0, 0x21, 0x91, 0x94, 0xCA, 0xA5,
  0x52, 0xB1, 0x69, 0x34, 0x92, 0x00, 0x22, 0x45, 0x52, 0xA5, 0x4A, 0x95,
  0x44, 0x88, 0x3C, 0x94, 0x51, 0x47, 0x1C, 0x92, 0x70, 0x39, 0x52, 0x97,
  0xA1, 0x10, 0x80, 0x3C, 0x94, 0x51, 0x47, 0x1C, 0x92, 0x70, 0x41, 0x00,
  0x38, 0xB4, 0x92, 0x71, 0x45, 0x24, 0x90, 0x3A, 0x10, 0xC3, 0x08, 0x42,
  0xE0, 0xF4, 0x44, 0x44, 0x88, 0x80, 0x24, 0x94, 0x51, 0x49, 0x2C, 0xB2,
  0x70, 0x8C, 0xE5, 0x2A, 0x53, 0x18, 0xC0, 0x89, 0xCC, 0xA6, 0x95, 0x4A,
  0xA5, 0x63, 0x31, 0x90, 0x88, 0x00, 0x36, 0x28, 0x60, 0xC1, 0x06, 0x0A,
  0x24, 0xC8, 0x9C, 0xA9, 0x44, 0x23, 0x10, 0x80, 0x3C, 0x20, 0x84, 0x10,
  0x82, 0x10, 0xF0, 0x39, 0x10, 0x84, 0x21, 0x10, 0x84, 0x30, 0xA5, 0x55,
  0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x11, 0x92, 0x98, 0x80,
  0xF0, 0x90, 0x3A, 0x53, 0x99, 0xC9, 0xC0, 0x21, 0x08, 0xB6, 0xA5, 0x29,
  0xD7, 0x80, 0x3A, 0x11, 0x08, 0x41, 0x80, 0x04, 0x10, 0x4E, 0x49, 0x2C,
  0xA2, 0x91, 0xC0, 0x3A, 0x55, 0xC8, 0x41, 0xC0, 0x0E, 0x10, 0x20, 0xE1,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x0C, 0x00, 0x3A, 0x53, 0x99, 0xC9,
  0xC2, 0x37, 0x00, 0x21, 0x08, 0xF4, 0xA5, 0x2A, 0x94, 0x80, 0x24, 0x24,
  0x92, 0x90, 0x08, 0x40, 0x21, 0x08, 0x42, 0x21, 0x08, 0x4C, 0x00, 0x21,
  0x08, 0x95, 0x31, 0x8C, 0x94, 0x80, 0x24, 0xA4, 0x92, 0x90, 0x7E, 0x49,
  0x4A, 0x4A, 0x52, 0x92, 0x96, 0x7A, 0x52, 0x95, 0x4A, 0x40, 0x3A, 0x53,
  0x98, 0xC9, 0x80, 0x2C, 0xD2, 0x49, 0x25, 0xA7, 0x90, 0x42, 0x00, 0x3A,
  0x53, 0x99, 0xC9, 0xC2, 0x11, 0x00, 0x56, 0x44, 0x48, 0x80, 0x74, 0x46,
  0x22, 0xE0, 0x25, 0xA4, 0x94, 0xC0, 0x4A, 0x52, 0x9D, 0x4B, 0xC0, 0x9A,
  0xAA, 0xCC, 0x80, 0xB7, 0x6A, 0xD6, 0xCD, 0x92, 0x24, 0x00, 0x24, 0xA3,
  0x04, 0x31, 0x4D, 0x80, 0x24, 0xA2, 0x8A, 0x30, 0xC2, 0x08, 0x43, 0x00,
  0x72, 0x24, 0x48, 0xE0, 0x18, 0x88, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF,
  0xF8, 0x30, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 11, 5, 0, -10 },
  { 21, 6, 9, 8, 1, -9 },
  { 28, 5, 9, 6, 0, -9 },
  { 34, 2, 3, 2, 1, -9 },
  { 35, 4, 11, 3, 0, -9 },
  { 41, 4, 11, 3, -1, -9 },
  { 47, 4, 4, 5, 1, -10 },
  { 49, 4, 6, 6, 1, -8 },
  { 52, 3, 3, 3, -1, -1 },
  { 54, 3, 1, 3, 0, -4 },
  { 55, 2, 2, 3, 0, -2 },
  { 56, 6, 9, 4, -1, -9 },
  { 63, 5, 9, 5, 0, -9 },
  { 69, 4, 9, 5, 1, -9 },
  { 74, 5, 9, 5, 0, -9 },
  { 80, 5, 9, 5, 0, -9 },
  { 86, 5, 9, 5, 0, -9 },
  { 92, 5, 9, 5, 0, -9 },
  { 98, 5, 9, 5, 0, -9 },
  { 104, 6, 9, 5, 0, -9 },
  { 111, 5, 9, 5, 0, -9 },
  { 117, 5, 9, 5, 0, -9 },
  { 123, 3, 7, 3, 0, -7 },
  { 126, 4, 9, 3, -1, -7 },
  { 131, 5, 6, 6, 0, -8 },
  { 135, 4, 3, 6, 1, -6 },
  { 137, 4, 6, 6, 1, -8 },
  { 140, 4, 9, 4, 0, -9 },
  { 145, 7, 10, 8, 0, -9 },
  { 154, 5, 9, 5, -1, -9 },
  { 160, 6, 9, 6, 0, -9 },
  { 167, 6, 9, 5, 0, -9 },
  { 174, 6, 9, 6, 0, -9 },
  { 181, 5, 9, 5, 0, -9 },
  { 187, 5, 9, 4, 0, -9 },
  { 193, 7, 9, 6, 0, -9 },
  { 201, 7, 9, 6, 0, -9 },
  { 209, 5, 9, 3, -1, -9 },
  { 215, 5, 12, 3, -2, -9 },
  { 223, 6, 9, 5, 0, -9 },
  { 230, 4, 9, 4, 0, -9 },
  { 235, 9, 9, 8, 0, -9 },
  { 246, 7, 9, 7, 0, -9 },
  { 254, 6, 9, 6, 0, -9 },
  { 261, 5, 9, 5, 0, -9 },
  { 267, 6, 11, 6, 0, -9 },
  { 276, 6, 9, 5, 0, -9 },
  { 283, 5, 9, 5, 0, -9 },
  { 289, 4, 9, 4, 1, -9 },
  { 294, 6, 9, 6, 0, -9 },
  { 301, 5, 9, 5, 1, -9 },
  { 307, 9, 9, 8, 1, -9 },
  { 318, 7, 9, 5, -1, -9 },
  { 326, 5, 9, 5, 1, -9 },
  { 332, 6, 9, 4, -1, -9 },
  { 339, 5, 11, 4, 0, -9 },
  { 346, 2, 9, 4, 1, -9 },
  { 349, 5, 11, 4, -1, -9 },
  { 356, 5, 5, 5, 0, -9 },
  { 360, 4, 1, 4, -1, 1 },
  { 361, 2, 2, 3, 2, -10 },
  { 362, 5, 7, 6, 0, -7 },
  { 367, 5, 10, 5, 0, -10 },
  { 374, 5, 7, 4, 0, -7 },
  { 379, 6, 10, 5, 0, -10 },
  { 387, 5, 7, 5, 0, -7 },
  { 392, 7, 13, 3, -2, -10 },
  { 404, 5, 10, 6, 0, -7 },
  { 411, 5, 10, 5, 0, -10 },
  { 418, 3, 10, 3, 0, -10 },
  { 422, 5, 13, 3, -2, -10 },
  { 431, 5, 10, 5, 0, -10 },
  { 438, 3, 10, 2, 0, -10 },
  { 442, 8, 7, 8, 0, -7 },
  { 449, 5, 7, 5, 0, -7 },
  { 454, 5, 7, 5, 0, -7 },
  { 459, 6, 10, 5, -1, -7 },
  { 467, 5, 10, 5, 0, -7 },
  { 474, 4, 7, 4, 0, -7 },
  { 478, 4, 7, 4, 0, -7 },
  { 482, 3, 9, 3, 0, -9 },
  { 486, 5, 7, 5, 0, -7 },
  { 491, 4, 7, 4, 1, -7 },
  { 495, 7, 7, 7, 1, -7 },
  { 502, 6, 7, 4, -1, -7 },
  { 508, 6, 10, 4, -1, -7 },
  { 516, 4, 7, 4, 0, -7 },
  { 520, 5, 11, 4, 0, -9 },
  { 527, 1, 13, 5, 2, -10 },
  { 529, 5, 11, 4, -1, -9 },
  { 536, 5, 1, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Italic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC13PT7B_H_
