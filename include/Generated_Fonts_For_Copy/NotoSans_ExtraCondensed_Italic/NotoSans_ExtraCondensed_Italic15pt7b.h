#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x44, 0x04, 0xC0, 0x5A, 0x95, 0xA0, 0x12, 0x28,
  0x53, 0xF2, 0x85, 0x12, 0x7E, 0x51, 0x22, 0x80, 0x08, 0xF7, 0x14, 0x70,
  0xC1, 0x8A, 0x2B, 0xC2, 0x10, 0x62, 0x64, 0xA4, 0xA8, 0xAA, 0xB5, 0xD9,
  0x29, 0x2A, 0x4A, 0xCC, 0x18, 0xA2, 0x8A, 0x30, 0xC5, 0x65, 0x9A, 0x6E,
  0xC0, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x18, 0x84, 0x21, 0x84, 0x00, 0x11,
  0x11, 0x11, 0x11, 0x12, 0x24, 0xC0, 0x37, 0xC8, 0xA1, 0x00, 0x21, 0x09,
  0xF2, 0x10, 0x80, 0x2D, 0x60, 0xFE, 0x70, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x83, 0x00, 0x18, 0x92, 0x51, 0x45, 0x34, 0xB2, 0x8B,
  0x47, 0x00, 0x2E, 0xB4, 0x92, 0xD2, 0x00, 0x1C, 0x2C, 0x08, 0x30, 0x41,
  0x82, 0x08, 0x20, 0x83, 0xE0, 0x38, 0xB0, 0x41, 0x08, 0xC1, 0x82, 0x08,
  0x4F, 0x00, 0x0C, 0x31, 0x86, 0x29, 0x25, 0xA4, 0xF8, 0x43, 0x00, 0x3C,
  0x82, 0x18, 0x71, 0x60, 0x82, 0x08, 0x6F, 0x00, 0x0C, 0x42, 0x10, 0x59,
  0xA4, 0xB2, 0xCB, 0x67, 0x00, 0x3E, 0x88, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x20, 0x83, 0x00, 0x18, 0x96, 0x59, 0x28, 0xC5, 0xA2, 0x8A, 0x2F, 0x00,
  0x18, 0xB4, 0x51, 0x4D, 0x37, 0x82, 0x18, 0x4E, 0x00, 0x2C, 0x00, 0x26,
  0x13, 0x00, 0x00, 0x24, 0x48, 0x08, 0xD9, 0x0E, 0x18, 0x20, 0xF8, 0x01,
  0xF0, 0x86, 0x0C, 0x33, 0x62, 0x00, 0x32, 0x42, 0x31, 0x11, 0x08, 0x02,
  0x30, 0x0E, 0x08, 0x88, 0x25, 0xD5, 0x4A, 0xA9, 0x55, 0x4A, 0x9E, 0x40,
  0x10, 0x0F, 0x00, 0x0C, 0x30, 0xC5, 0x14, 0xD3, 0xDF, 0x45, 0x1C, 0x40,
  0x38, 0x48, 0x99, 0x26, 0xCF, 0x13, 0x26, 0x4D, 0x93, 0xC0, 0x1C, 0x94,
  0x30, 0x82, 0x08, 0x20, 0x82, 0x0F, 0x00, 0x38, 0x48, 0x99, 0x36, 0x68,
  0xD1, 0x22, 0x4D, 0xB3, 0xC0, 0x3C, 0x82, 0x08, 0x61, 0xE4, 0x10, 0x43,
  0x0F, 0x00, 0x3C, 0x82, 0x08, 0x61, 0xE4, 0x10, 0x43, 0x08, 0x00, 0x1E,
  0x49, 0x06, 0x08, 0x13, 0xA3, 0x44, 0x89, 0x13, 0xE0, 0x23, 0x22, 0x22,
  0x22, 0x66, 0x7C, 0x44, 0x44, 0x44, 0xCC, 0x88, 0x3C, 0x61, 0x04, 0x10,
  0x43, 0x08, 0x20, 0x8F, 0x00, 0x08, 0x42, 0x11, 0x88, 0x42, 0x11, 0x88,
  0x46, 0x60, 0x22, 0x48, 0xB1, 0x47, 0x0E, 0x14, 0x28, 0x59, 0x92, 0x20,
  0x22, 0x22, 0x64, 0x44, 0x4C, 0xF0, 0x30, 0xCC, 0x33, 0x1C, 0xC6, 0x72,
  0x94, 0xA5, 0x69, 0x54, 0x55, 0x26, 0x49, 0x90, 0x31, 0x31, 0x33, 0x32,
  0x72, 0x5A, 0x4A, 0x4E, 0x4C, 0x8C, 0x8C, 0x19, 0x94, 0x71, 0x86, 0x18,
  0x62, 0x8A, 0x6F, 0x00, 0x38, 0xB2, 0x49, 0x65, 0x27, 0x10, 0x43, 0x08,
  0x00, 0x19, 0x94, 0x71, 0x86, 0x18, 0x63, 0x8A, 0x6F, 0x08, 0x30, 0x40,
  0x38, 0xB2, 0x49, 0x65, 0xE7, 0x14, 0x5B, 0x28, 0x80, 0x1C, 0x94, 0x10,
  0x60, 0xC1, 0x82, 0x0A, 0x6F, 0x00, 0xF9, 0x08, 0x46, 0x21, 0x08, 0x46,
  0x20, 0x22, 0x44, 0x89, 0x16, 0x68, 0x91, 0x22, 0xCC, 0x91, 0xE0, 0xC7,
  0x18, 0xA2, 0x9A, 0x4B, 0x28, 0xA3, 0x0C, 0x00, 0x84, 0x63, 0x38, 0xCA,
  0x52, 0x95, 0x25, 0x4A, 0xB2, 0xA8, 0xCA, 0x33, 0x0C, 0xC0, 0x13, 0x12,
  0x14, 0x14, 0x18, 0x18, 0x18, 0x28, 0x28, 0x48, 0xC8, 0xCF, 0x25, 0x14,
  0x61, 0x84, 0x10, 0x43, 0x08, 0x00, 0x1E, 0x4C, 0x10, 0x60, 0x82, 0x04,
  0x10, 0x60, 0x83, 0xE0, 0x39, 0x08, 0x42, 0x21, 0x08, 0x46, 0x21, 0x0E,
  0x00, 0xAA, 0xAA, 0x54, 0x1C, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x42,
  0x08, 0xE0, 0x10, 0x62, 0x8A, 0x4F, 0x10, 0xF0, 0xD0, 0x3D, 0x94, 0x53,
  0xCB, 0x2D, 0x9A, 0x30, 0x82, 0x0F, 0x65, 0x14, 0x53, 0x4B, 0x2B, 0x00,
  0x3B, 0x10, 0x8C, 0x63, 0x0E, 0x02, 0x0C, 0x11, 0xE6, 0x48, 0x93, 0x64,
  0xC9, 0xB1, 0xA0, 0x3B, 0x52, 0xFC, 0x63, 0x0E, 0x0E, 0x10, 0x20, 0xE1,
  0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x1C, 0x30, 0x00, 0x3D, 0x94,
  0x53, 0xCB, 0x2D, 0x9A, 0x18, 0x4B, 0x10, 0x30, 0x82, 0x0F, 0x65, 0x34,
  0x92, 0x4A, 0x29, 0x80, 0x24, 0x16, 0x92, 0x52, 0x00, 0x08, 0x40, 0x11,
  0x88, 0x42, 0x11, 0x08, 0x42, 0x62, 0x00, 0x30, 0x82, 0x0B, 0x69, 0x47,
  0x14, 0x52, 0x49, 0x80, 0x32, 0x22, 0x64, 0x44, 0x48, 0x80, 0x3F, 0xB6,
  0x53, 0x69, 0x24, 0x92, 0x4A, 0x25, 0x26, 0x3D, 0x94, 0xD2, 0x49, 0x28,
  0xA6, 0x39, 0xB4, 0x53, 0xCB, 0x2D, 0x9C, 0x1E, 0x64, 0x89, 0x12, 0x64,
  0x99, 0x2C, 0x40, 0x83, 0x04, 0x00, 0x3D, 0x94, 0x53, 0xCB, 0x2D, 0x9A,
  0x10, 0x41, 0x04, 0x3B, 0x10, 0x84, 0x22, 0x10, 0x7A, 0x10, 0xC3, 0x08,
  0x5C, 0x22, 0x76, 0x44, 0x44, 0xCE, 0x25, 0x94, 0xD2, 0x49, 0x2D, 0x9E,
  0x9C, 0xA5, 0x4A, 0x63, 0x18, 0x9B, 0x92, 0xB2, 0xB4, 0xD4, 0xD4, 0xD8,
  0x98, 0x26, 0x68, 0x60, 0xC3, 0x07, 0x12, 0x64, 0x26, 0x48, 0x91, 0x42,
  0x86, 0x0C, 0x18, 0x20, 0xC3, 0x04, 0x00, 0x3C, 0x21, 0x84, 0x20, 0x84,
  0x3C, 0x0C, 0x61, 0x04, 0x30, 0x8E, 0x18, 0x21, 0x84, 0x10, 0x60, 0xFF,
  0xFE, 0x10, 0x60, 0x86, 0x10, 0x40, 0xC4, 0x30, 0x82, 0x08, 0xC0, 0xEC,
  0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 5, 1, -11 },
  { 10, 7, 11, 6, 0, -11 },
  { 20, 6, 12, 6, 0, -11 },
  { 29, 8, 11, 9, 1, -11 },
  { 40, 6, 11, 6, 0, -11 },
  { 49, 1, 4, 3, 2, -11 },
  { 50, 5, 13, 4, 0, -11 },
  { 59, 4, 13, 4, -1, -11 },
  { 66, 5, 5, 5, 1, -11 },
  { 70, 5, 7, 6, 1, -9 },
  { 75, 3, 4, 3, -1, -2 },
  { 77, 4, 2, 4, 0, -5 },
  { 78, 2, 2, 3, 0, -2 },
  { 79, 7, 11, 5, -1, -11 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 3, 11, 6, 2, -11 },
  { 103, 7, 11, 6, -1, -11 },
  { 113, 6, 11, 6, 0, -11 },
  { 122, 6, 11, 6, 0, -11 },
  { 131, 6, 11, 6, 0, -11 },
  { 140, 6, 11, 6, 0, -11 },
  { 149, 7, 11, 6, 0, -11 },
  { 159, 6, 11, 6, 0, -11 },
  { 168, 6, 11, 6, 0, -11 },
  { 177, 3, 8, 3, 0, -8 },
  { 180, 4, 10, 3, -1, -8 },
  { 185, 5, 7, 6, 1, -9 },
  { 190, 5, 4, 6, 1, -7 },
  { 193, 5, 7, 6, 1, -9 },
  { 198, 5, 11, 4, 0, -11 },
  { 205, 9, 12, 9, 0, -11 },
  { 219, 6, 11, 6, -1, -11 },
  { 228, 7, 11, 6, 0, -11 },
  { 238, 6, 11, 6, 1, -11 },
  { 247, 7, 11, 7, 0, -11 },
  { 257, 6, 11, 5, 0, -11 },
  { 266, 6, 11, 5, 0, -11 },
  { 275, 7, 11, 7, 1, -11 },
  { 285, 8, 11, 7, 0, -11 },
  { 296, 6, 11, 4, -1, -11 },
  { 305, 5, 14, 3, -2, -11 },
  { 314, 7, 11, 6, 0, -11 },
  { 324, 4, 11, 5, 0, -11 },
  { 330, 10, 11, 10, 0, -11 },
  { 344, 8, 11, 8, 0, -11 },
  { 355, 6, 11, 7, 1, -11 },
  { 364, 6, 11, 6, 0, -11 },
  { 373, 6, 14, 7, 1, -11 },
  { 384, 6, 11, 6, 0, -11 },
  { 393, 6, 11, 6, 0, -11 },
  { 402, 5, 11, 5, 1, -11 },
  { 409, 7, 11, 7, 0, -11 },
  { 419, 6, 11, 6, 1, -11 },
  { 428, 10, 11, 10, 1, -11 },
  { 442, 8, 11, 6, -1, -11 },
  { 453, 6, 11, 5, 1, -11 },
  { 462, 7, 11, 5, -1, -11 },
  { 472, 5, 13, 4, 0, -11 },
  { 481, 2, 11, 5, 2, -11 },
  { 484, 6, 13, 4, -1, -11 },
  { 494, 6, 6, 6, 0, -11 },
  { 499, 4, 1, 5, -1, 1 },
  { 500, 2, 2, 4, 2, -11 },
  { 501, 6, 8, 6, 0, -8 },
  { 507, 6, 11, 6, 0, -11 },
  { 516, 5, 8, 5, 0, -8 },
  { 521, 7, 11, 6, 0, -11 },
  { 531, 5, 8, 6, 0, -8 },
  { 536, 7, 15, 3, -2, -11 },
  { 550, 6, 12, 6, 0, -8 },
  { 559, 6, 11, 6, 0, -11 },
  { 568, 3, 11, 3, 0, -11 },
  { 573, 5, 15, 3, -2, -11 },
  { 583, 6, 11, 5, 0, -11 },
  { 592, 4, 11, 3, 0, -11 },
  { 598, 9, 8, 9, 0, -8 },
  { 607, 6, 8, 6, 0, -8 },
  { 613, 6, 8, 6, 0, -8 },
  { 619, 7, 12, 6, -1, -8 },
  { 630, 6, 12, 6, 0, -8 },
  { 639, 5, 8, 4, 0, -8 },
  { 644, 5, 8, 5, 0, -8 },
  { 649, 4, 10, 4, 0, -10 },
  { 654, 6, 8, 6, 0, -8 },
  { 660, 5, 8, 5, 1, -8 },
  { 665, 8, 8, 8, 1, -8 },
  { 673, 7, 8, 5, -1, -8 },
  { 680, 7, 12, 5, -1, -8 },
  { 691, 6, 8, 4, -1, -8 },
  { 697, 6, 13, 5, 0, -11 },
  { 707, 1, 15, 5, 2, -11 },
  { 709, 6, 13, 5, -1, -11 },
  { 719, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Italic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC15PT7B_H_
