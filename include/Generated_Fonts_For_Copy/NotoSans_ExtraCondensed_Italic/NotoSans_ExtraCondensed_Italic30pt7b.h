#ifndef _NOTOSANS_EXTRACONDENSED_ITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_ITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x73, 0x67,
  0x67, 0x66, 0xC6, 0xC6, 0xCC, 0x01, 0x98, 0x18, 0xC0, 0xCC, 0x04, 0x60,
  0x63, 0x03, 0x30, 0xFF, 0xE1, 0x8C, 0x0C, 0x40, 0x66, 0x06, 0x30, 0x31,
  0x01, 0x98, 0x7F, 0xF0, 0xC4, 0x06, 0x60, 0x23, 0x03, 0x18, 0x19, 0x80,
  0x8C, 0x0C, 0x60, 0x00, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x0F, 0xF1,
  0xD1, 0x19, 0x01, 0x90, 0x1B, 0x01, 0xA0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x05, 0xC0, 0x4C, 0x04, 0xC0, 0xCC, 0x89, 0xCF, 0xF8, 0xFF, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x00, 0x0C, 0x02, 0x1E, 0x0C, 0x33, 0x0C,
  0x33, 0x18, 0x63, 0x18, 0x63, 0x30, 0x63, 0x30, 0x66, 0x60, 0x46, 0x60,
  0xC6, 0xCE, 0xC4, 0xDF, 0x4D, 0x93, 0x79, 0xB3, 0x33, 0x33, 0x03, 0x63,
  0x06, 0x63, 0x06, 0x63, 0x0C, 0x66, 0x0C, 0x66, 0x18, 0x66, 0x10, 0x6C,
  0x30, 0x78, 0x01, 0x80, 0x7C, 0x06, 0xE0, 0xC6, 0x0C, 0x60, 0xCE, 0x0C,
  0xC0, 0xCC, 0x0D, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3F, 0x37, 0x33, 0x63,
  0x7E, 0x3E, 0xC3, 0xEC, 0x1C, 0xC1, 0xCE, 0x3C, 0xFE, 0xC7, 0xCE, 0x76,
  0x66, 0x6C, 0xC0, 0x01, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x00, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x23, 0x1D, 0x9F, 0xF8, 0xFC,
  0xF0, 0xEC, 0xE6, 0x23, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x3F, 0xFF, 0xFF, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x39, 0x9C, 0xC6, 0x63, 0x00, 0x7F, 0xFC, 0x7F, 0x80, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x01,
  0xF8, 0x3F, 0x0C, 0x73, 0x8E, 0x61, 0xCC, 0x3B, 0x87, 0x60, 0xCC, 0x1B,
  0x83, 0x70, 0x6C, 0x1D, 0x83, 0xB0, 0x66, 0x0C, 0xC3, 0x98, 0x63, 0x1C,
  0x63, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x1E, 0x3E, 0x7E, 0xEE, 0x4C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x01, 0xC0, 0x3F, 0x83, 0xDC, 0x08, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFC,
  0x7F, 0xE0, 0x01, 0xC0, 0x3F, 0x83, 0xDC, 0x08, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x1F, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x71, 0x07, 0x8F, 0xF8,
  0x3F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0B, 0x00, 0xD8,
  0x0D, 0xC0, 0x6C, 0x06, 0x60, 0x33, 0x03, 0x38, 0x31, 0xC1, 0x8C, 0x18,
  0x61, 0x83, 0x0F, 0xFE, 0x7F, 0xF4, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0F, 0xF0, 0xFF, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x83, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0xE0,
  0x7C, 0x3C, 0x86, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x62, 0x0D, 0xF1,
  0xFE, 0x78, 0xEE, 0x1D, 0xC3, 0xB0, 0x76, 0x0C, 0xC1, 0x98, 0x33, 0x0E,
  0x73, 0x8F, 0xE0, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x7E, 0x0E, 0x71, 0xC3, 0x18, 0x31, 0x83, 0x18, 0x71,
  0x86, 0x1C, 0xE0, 0xDC, 0x0F, 0x01, 0xF0, 0x3B, 0x87, 0x1C, 0x61, 0xCE,
  0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0xCE, 0x18, 0x7F, 0x83, 0xE0, 0x03, 0x80,
  0x7E, 0x0E, 0xE1, 0xC6, 0x18, 0x73, 0x87, 0x30, 0x73, 0x07, 0x30, 0x63,
  0x06, 0x30, 0xE3, 0x9E, 0x3F, 0xE1, 0xEC, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0xFE, 0x0F, 0x80, 0x1C, 0x71, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x38, 0x07, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x38, 0x30,
  0x30, 0x60, 0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xE1, 0xF0, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x38, 0x1F, 0x0F, 0x87, 0xC1,
  0xE0, 0x70, 0x08, 0x00, 0x07, 0x07, 0xE1, 0xBC, 0x07, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x01, 0xFC,
  0x07, 0x0E, 0x0E, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x30, 0xE3, 0x31, 0xF3,
  0x63, 0x33, 0x62, 0x33, 0x66, 0x33, 0xC6, 0x63, 0xCC, 0x63, 0xCC, 0x66,
  0xCC, 0xE6, 0xCC, 0xC4, 0xCD, 0xCC, 0x8F, 0x78, 0xC6, 0x20, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0xC0, 0x3F, 0xC0, 0x04, 0x00, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xB0, 0x1B, 0x03, 0xB0, 0x33, 0x03, 0x30,
  0x73, 0x06, 0x30, 0xE3, 0x0C, 0x30, 0xFF, 0x1F, 0xF1, 0x83, 0x38, 0x33,
  0x83, 0x70, 0x37, 0x03, 0x60, 0x3E, 0x03, 0x0F, 0xF0, 0x7F, 0xC3, 0x0E,
  0x18, 0x31, 0xC1, 0x8E, 0x1C, 0x60, 0xE3, 0x0E, 0x18, 0xE1, 0xFE, 0x0F,
  0xF0, 0x61, 0xC3, 0x06, 0x18, 0x31, 0xC1, 0x8E, 0x0C, 0x60, 0xE3, 0x07,
  0x18, 0x71, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0xC3, 0xEC, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE1, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0xC3, 0x83,
  0x06, 0x1C, 0x18, 0x70, 0x71, 0x81, 0x86, 0x06, 0x18, 0x18, 0xE0, 0x63,
  0x83, 0x8C, 0x0E, 0x30, 0x38, 0xC0, 0xC7, 0x07, 0x1C, 0x18, 0x60, 0xE1,
  0x87, 0x06, 0x38, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0xFC, 0x3F, 0xC3,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3F, 0xC3, 0xF8, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x0F, 0xF0, 0x7B, 0xC3, 0x81, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x7E, 0xE1, 0xF3, 0x80, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x63, 0x81, 0x8E, 0x06, 0x1C, 0x38, 0x7F, 0xE0,
  0x7F, 0x00, 0x0E, 0x06, 0x1C, 0x1C, 0x30, 0x38, 0x60, 0x61, 0xC0, 0xC3,
  0x83, 0x87, 0x07, 0x0C, 0x0C, 0x18, 0x18, 0x7F, 0xF0, 0xFF, 0xE1, 0x81,
  0xC3, 0x03, 0x06, 0x06, 0x1C, 0x0C, 0x38, 0x38, 0x60, 0x70, 0xC0, 0xC1,
  0x81, 0x87, 0x07, 0x0E, 0x0E, 0x00, 0x07, 0xF0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x07, 0xE0,
  0xFF, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0xB8,
  0x1F, 0x03, 0x80, 0x00, 0x0E, 0x1E, 0x1C, 0x30, 0x30, 0xE0, 0x63, 0x81,
  0xC6, 0x03, 0x9C, 0x06, 0x70, 0x0D, 0xC0, 0x1B, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xD8, 0x03, 0xB0, 0x06, 0x70, 0x1C, 0xE0, 0x38, 0xC0, 0x61, 0x80,
  0xC3, 0x81, 0x87, 0x07, 0x0E, 0x0E, 0x0C, 0x00, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x1F, 0x03, 0x61, 0xF0, 0x3E, 0x1B, 0x07, 0xE1, 0xB0,
  0x6C, 0x1B, 0x0E, 0xC3, 0xB0, 0xCC, 0x3B, 0x0D, 0xC3, 0x31, 0x9C, 0x33,
  0x19, 0x83, 0x33, 0x18, 0x73, 0x31, 0x86, 0x36, 0x38, 0x63, 0x63, 0x06,
  0x3E, 0x30, 0x63, 0xC3, 0x0E, 0x1C, 0x70, 0xC1, 0x87, 0x00, 0x0F, 0x03,
  0x0F, 0x07, 0x0F, 0x06, 0x0F, 0x06, 0x1F, 0x06, 0x1F, 0x0E, 0x1B, 0x8E,
  0x19, 0x8C, 0x19, 0x8C, 0x39, 0x8C, 0x39, 0x9C, 0x31, 0x9C, 0x31, 0x98,
  0x30, 0xD8, 0x70, 0xD8, 0x60, 0xF8, 0x60, 0xF0, 0x60, 0xF0, 0x60, 0xF0,
  0xE0, 0x70, 0xC0, 0x70, 0x01, 0xC0, 0x3F, 0x83, 0xDE, 0x38, 0x71, 0x81,
  0x9C, 0x0C, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0x67, 0x07, 0x38, 0x30, 0xC3,
  0x87, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x83, 0x1C, 0x18, 0x71, 0xC3,
  0x8E, 0x1C, 0x60, 0xC3, 0x06, 0x18, 0x71, 0xC7, 0x0F, 0xF8, 0x7F, 0x03,
  0xE0, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xDE, 0x38, 0x71, 0x81, 0x9C,
  0x0C, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0x67, 0x07, 0x38, 0x30, 0xC3, 0x87,
  0xF8, 0x1F, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x0F,
  0xE0, 0x7F, 0x83, 0x0C, 0x18, 0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xC3, 0x06,
  0x18, 0x71, 0xC7, 0x0F, 0xF0, 0x7E, 0x03, 0x30, 0x19, 0xC1, 0xCE, 0x0E,
  0x30, 0x61, 0x83, 0x0C, 0x18, 0x71, 0xC3, 0x8E, 0x1C, 0x00, 0x00, 0xE0,
  0x3F, 0xC3, 0xFE, 0x1C, 0x11, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x87, 0x8F, 0xF8, 0x3F, 0x80, 0x7F, 0xFF,
  0xF8, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0C, 0x00, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0x86, 0x06, 0x38, 0x38,
  0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x30, 0x31, 0xC1, 0xC6, 0x07, 0x18, 0x18,
  0x60, 0x63, 0x81, 0x8E, 0x0E, 0x38, 0x30, 0xC0, 0xC3, 0x87, 0x0E, 0x38,
  0x1F, 0xE0, 0x3E, 0x00, 0xC0, 0x7C, 0x0E, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C,
  0x18, 0xC3, 0x8C, 0x30, 0xC7, 0x0C, 0x60, 0xCE, 0x0C, 0xE0, 0xCC, 0x0D,
  0xC0, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00,
  0x60, 0x60, 0x76, 0x0E, 0x06, 0x60, 0xE0, 0xE6, 0x0E, 0x0C, 0xE1, 0xE0,
  0xCE, 0x1E, 0x1C, 0xE3, 0xE1, 0x8E, 0x36, 0x38, 0xE3, 0x63, 0x0E, 0x66,
  0x30, 0xE6, 0x67, 0x0E, 0x66, 0x60, 0xEC, 0x6E, 0x0E, 0xC6, 0xC0, 0xF8,
  0x6C, 0x0D, 0x87, 0xC0, 0xD8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F,
  0x07, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x0E, 0x0E, 0x18, 0x0C, 0x70, 0x18,
  0xC0, 0x33, 0x80, 0x66, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0x30, 0x0E, 0x60, 0x18,
  0xC0, 0x71, 0x80, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x00, 0x60, 0xEC, 0x19,
  0x87, 0x30, 0xC6, 0x38, 0xC6, 0x1D, 0xC3, 0xB0, 0x7E, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x03, 0xF0, 0x3E, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0F, 0xC0, 0xFC, 0x00, 0xC6, 0x31, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xE3, 0x18, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x03, 0xE0, 0xFC, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0x80,
  0x38, 0x07, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xE3, 0x86, 0x30, 0x67,
  0x06, 0xE0, 0x30, 0x7F, 0xFF, 0xF0, 0xE6, 0x73, 0x10, 0x0F, 0x71, 0xFE,
  0x38, 0xE3, 0x0E, 0x70, 0xE6, 0x0C, 0xE0, 0xCE, 0x0C, 0xC0, 0xCC, 0x1C,
  0xC1, 0x8C, 0x18, 0xC3, 0x8C, 0x78, 0xFF, 0x87, 0xB0, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xFE, 0x1B, 0xE1, 0xC7,
  0x1C, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x73, 0x06, 0x70, 0x67, 0x0E,
  0x60, 0xC6, 0x1C, 0xF1, 0x8D, 0xF8, 0xDF, 0x00, 0x0F, 0x8F, 0xCE, 0x0E,
  0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x13,
  0xF8, 0xF8, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC1, 0xEC, 0x1F, 0xE1, 0xC7, 0x0C, 0x38, 0xE1, 0xC6, 0x0C, 0x70,
  0x63, 0x83, 0x18, 0x18, 0xC1, 0xC6, 0x0C, 0x30, 0x61, 0x87, 0x0C, 0x78,
  0x7F, 0xC1, 0xEC, 0x00, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x61, 0xD8, 0x6E,
  0x7B, 0xFC, 0xF8, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x4F, 0xF1, 0xF8,
  0x00, 0x3C, 0x01, 0xF0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xFC, 0x07, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xDC, 0x1F, 0xE0, 0xE3, 0x83, 0x0E,
  0x1C, 0x38, 0x60, 0xC3, 0x83, 0x0E, 0x0C, 0x30, 0x70, 0xC1, 0xC3, 0x06,
  0x0C, 0x38, 0x30, 0xE0, 0xC7, 0x83, 0xFE, 0x07, 0xB0, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x83, 0x83, 0xFC, 0x07, 0xE0, 0x00, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xFF, 0x1F, 0xE3, 0x8C,
  0x61, 0x9C, 0x33, 0x86, 0x60, 0xCC, 0x39, 0x86, 0x70, 0xCE, 0x19, 0x83,
  0x30, 0xE6, 0x19, 0xC3, 0x30, 0x60, 0x06, 0x1C, 0x38, 0x00, 0x00, 0x07,
  0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x87, 0x0E,
  0x18, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x7C, 0x0F, 0x00, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC7, 0x18, 0xE1, 0x8C, 0x19, 0xC3, 0xB8,
  0x3F, 0x03, 0x60, 0x3F, 0x03, 0xF0, 0x73, 0x06, 0x30, 0x63, 0x06, 0x30,
  0x63, 0x8E, 0x38, 0xC3, 0x80, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0E,
  0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C,
  0x30, 0x00, 0x1B, 0xEF, 0x87, 0xFF, 0xE1, 0xC7, 0x1C, 0x61, 0xC7, 0x38,
  0x61, 0x8E, 0x18, 0x63, 0x0E, 0x18, 0xC3, 0x8E, 0x30, 0xC3, 0x9C, 0x30,
  0xC6, 0x0C, 0x31, 0x87, 0x0C, 0x61, 0x87, 0x38, 0x61, 0x8E, 0x18, 0x63,
  0x0E, 0x18, 0x1B, 0xE3, 0xFC, 0x71, 0x8C, 0x33, 0x86, 0x70, 0xCC, 0x19,
  0x87, 0x30, 0xCE, 0x19, 0x83, 0x30, 0x66, 0x1D, 0xC3, 0x38, 0x66, 0x0C,
  0x0F, 0x87, 0xF3, 0x8C, 0xC3, 0x60, 0xD8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x7C, 0x1B, 0x06, 0xC3, 0xB1, 0xCF, 0xE1, 0xF0, 0x0C, 0xF0, 0x6F, 0x83,
  0x8E, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xE3, 0x07, 0x18, 0x31, 0xC1,
  0x8E, 0x1C, 0x60, 0xC3, 0x8E, 0x1C, 0x61, 0xFF, 0x0D, 0xF0, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0F, 0x71,
  0xFE, 0x38, 0xE3, 0x0E, 0x70, 0xE6, 0x0C, 0xE0, 0xCE, 0x0C, 0xC0, 0xCC,
  0x1C, 0xC1, 0x8C, 0x18, 0xC3, 0x8C, 0x78, 0xFF, 0x87, 0xB0, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x1B, 0xC6, 0xE1,
  0xE0, 0x70, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0x1F, 0xCF, 0xE3, 0x08, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x21, 0x8F, 0xE3,
  0xF0, 0x0C, 0x30, 0x60, 0xC7, 0xEF, 0xCC, 0x18, 0x70, 0xE1, 0x83, 0x06,
  0x1C, 0x38, 0x60, 0xC1, 0x83, 0xC7, 0x80, 0x38, 0x66, 0x0C, 0xC3, 0x98,
  0x67, 0x0C, 0xE1, 0x98, 0x33, 0x0E, 0x61, 0x9C, 0x33, 0x06, 0x61, 0xCC,
  0x39, 0x8E, 0x3F, 0xC7, 0xD8, 0xC1, 0xF0, 0x6C, 0x33, 0x0C, 0xC7, 0x31,
  0x8C, 0xE3, 0x30, 0xCC, 0x36, 0x0D, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xC3, 0x87, 0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8C, 0xC7, 0x8C, 0xCD,
  0x9C, 0xCD, 0x98, 0xC9, 0xB8, 0xD9, 0xB0, 0xD9, 0xB0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0xC1, 0x80, 0x1C, 0x30, 0xC6,
  0x0C, 0xE0, 0xCC, 0x0D, 0xC0, 0xF8, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x1B, 0x03, 0xB0, 0x33, 0x07, 0x38, 0x61, 0x8C, 0x18, 0x06, 0x0E, 0x0C,
  0x18, 0x18, 0x70, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x30,
  0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x1C, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0F, 0xF3,
  0xF8, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x0E, 0x01, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x07, 0xC1, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x01, 0xC0, 0xF8, 0x18, 0x00, 0x00, 0x2F, 0x87,
  0xFF, 0xC1, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 8, 7, 10, 3, -21 },
  { 29, 13, 21, 13, 0, -21 },
  { 64, 12, 25, 12, 0, -23 },
  { 102, 16, 22, 18, 1, -22 },
  { 146, 12, 22, 13, 0, -22 },
  { 179, 4, 7, 6, 3, -21 },
  { 183, 9, 27, 8, 1, -22 },
  { 214, 9, 27, 8, -2, -22 },
  { 245, 9, 10, 11, 3, -23 },
  { 257, 11, 14, 13, 1, -18 },
  { 277, 5, 7, 6, -1, -3 },
  { 282, 7, 2, 8, 0, -9 },
  { 284, 3, 3, 6, 0, -3 },
  { 286, 13, 22, 10, -1, -22 },
  { 322, 11, 22, 12, 1, -22 },
  { 353, 8, 21, 12, 3, -21 },
  { 374, 13, 22, 12, -1, -22 },
  { 410, 13, 22, 12, -1, -22 },
  { 446, 13, 22, 12, -1, -22 },
  { 482, 12, 21, 12, 0, -21 },
  { 514, 11, 22, 12, 1, -22 },
  { 545, 12, 21, 12, 1, -21 },
  { 577, 12, 22, 12, 0, -22 },
  { 610, 12, 22, 12, 0, -22 },
  { 643, 6, 16, 6, 0, -16 },
  { 655, 8, 20, 6, -2, -16 },
  { 675, 11, 13, 13, 1, -17 },
  { 693, 11, 9, 13, 1, -15 },
  { 706, 11, 13, 13, 1, -17 },
  { 724, 10, 22, 9, 0, -22 },
  { 752, 16, 25, 18, 1, -22 },
  { 802, 12, 22, 12, -2, -22 },
  { 835, 13, 21, 13, 0, -21 },
  { 870, 13, 22, 12, 1, -22 },
  { 906, 14, 21, 14, 0, -21 },
  { 943, 12, 21, 11, 0, -21 },
  { 975, 12, 21, 10, 0, -21 },
  { 1007, 14, 22, 15, 1, -22 },
  { 1046, 15, 21, 14, 0, -21 },
  { 1086, 12, 21, 8, -2, -21 },
  { 1118, 11, 27, 6, -4, -21 },
  { 1156, 15, 21, 12, 0, -21 },
  { 1196, 8, 21, 10, 0, -21 },
  { 1217, 20, 21, 19, 0, -21 },
  { 1270, 16, 21, 15, 0, -21 },
  { 1312, 13, 22, 15, 1, -22 },
  { 1348, 13, 21, 12, 0, -21 },
  { 1383, 13, 27, 15, 1, -22 },
  { 1427, 13, 21, 13, 0, -21 },
  { 1462, 13, 22, 11, -1, -22 },
  { 1498, 11, 21, 10, 2, -21 },
  { 1527, 14, 21, 14, 1, -21 },
  { 1564, 12, 21, 12, 3, -21 },
  { 1596, 20, 21, 20, 2, -21 },
  { 1649, 15, 21, 11, -2, -21 },
  { 1689, 11, 21, 11, 2, -21 },
  { 1718, 13, 21, 10, -1, -21 },
  { 1753, 12, 27, 8, -1, -22 },
  { 1794, 5, 22, 10, 3, -22 },
  { 1808, 11, 27, 8, -2, -22 },
  { 1846, 12, 11, 12, 0, -21 },
  { 1863, 10, 2, 9, -3, 2 },
  { 1866, 4, 5, 7, 4, -23 },
  { 1869, 12, 16, 13, 1, -16 },
  { 1893, 12, 23, 13, 0, -23 },
  { 1928, 9, 16, 10, 1, -16 },
  { 1946, 13, 23, 13, 1, -23 },
  { 1984, 10, 16, 11, 1, -16 },
  { 2004, 14, 30, 7, -4, -23 },
  { 2057, 14, 23, 13, -1, -16 },
  { 2098, 11, 23, 12, 0, -23 },
  { 2130, 7, 22, 6, 0, -22 },
  { 2150, 11, 29, 6, -4, -22 },
  { 2190, 12, 23, 11, 0, -23 },
  { 2225, 7, 23, 6, 0, -23 },
  { 2246, 18, 16, 18, 0, -16 },
  { 2282, 11, 16, 12, 0, -16 },
  { 2304, 10, 16, 12, 1, -16 },
  { 2324, 13, 23, 13, -1, -16 },
  { 2362, 12, 23, 13, 1, -16 },
  { 2397, 10, 16, 8, 0, -16 },
  { 2417, 10, 16, 9, 0, -16 },
  { 2437, 7, 20, 7, 1, -20 },
  { 2455, 11, 16, 12, 1, -16 },
  { 2477, 10, 16, 10, 2, -16 },
  { 2497, 16, 16, 16, 2, -16 },
  { 2529, 12, 16, 10, -1, -16 },
  { 2553, 15, 23, 10, -3, -16 },
  { 2597, 10, 16, 8, -1, -16 },
  { 2617, 11, 26, 10, 1, -21 },
  { 2653, 2, 30, 11, 4, -23 },
  { 2661, 11, 26, 10, -2, -21 },
  { 2697, 11, 4, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Italic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Italic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Italic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_ITALIC30PT7B_H_
