#ifndef _NOTOSANS_BOLD7PT7B_H_
#define _NOTOSANS_BOLD7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xC0, 0xB4, 0x5F, 0x6F, 0x60, 0x7C, 0x65, 0xE0, 0xCA, 0xCD,
  0xCB, 0x6C, 0x63, 0x9B, 0x77, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x70, 0x4F,
  0x60, 0x4F, 0x40, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x69, 0x99, 0x60, 0x7C,
  0x92, 0xE1, 0x24, 0xF0, 0xE1, 0x61, 0xE0, 0x26, 0x6F, 0x20, 0x68, 0xE1,
  0xE0, 0x68, 0xF9, 0x60, 0xF2, 0x26, 0x40, 0x69, 0x69, 0xE0, 0x69, 0xF1,
  0x60, 0xC3, 0xC3, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xC0, 0xE5, 0x04,
  0x39, 0xFA, 0xEF, 0x40, 0xE0, 0x22, 0x94, 0xE8, 0x80, 0xF7, 0xDE, 0x74,
  0x84, 0x70, 0xEB, 0x9B, 0xE0, 0xF3, 0x4E, 0xF3, 0x48, 0x7A, 0x36, 0xB7,
  0x80, 0x99, 0xF9, 0x90, 0xE9, 0x2E, 0x24, 0x93, 0xC0, 0xBC, 0xCA, 0xB0,
  0x92, 0x4E, 0x9E, 0xF7, 0xDA, 0x80, 0x9D, 0xDB, 0xB0, 0x72, 0x72, 0x97,
  0x00, 0xF7, 0xC8, 0x72, 0x72, 0x97, 0x0C, 0xEA, 0xEA, 0xB0, 0x78, 0x61,
  0xE0, 0xF6, 0x66, 0x60, 0x99, 0x99, 0xE0, 0x9A, 0x94, 0xC2, 0x00, 0x93,
  0x69, 0xB3, 0x66, 0xC0, 0xDB, 0x88, 0xAD, 0x80, 0x97, 0x62, 0x20, 0xF2,
  0x64, 0xF0, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x46, 0x90, 0xE0, 0xC0,
  0x63, 0xDF, 0x9E, 0xDE, 0x72, 0x30, 0x17, 0x99, 0x70, 0x69, 0xE7, 0x7D,
  0x24, 0x79, 0x97, 0x16, 0x9E, 0xDA, 0xD5, 0x40, 0xD5, 0x78, 0x97, 0x6A,
  0xF8, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0x69, 0x97, 0xF6, 0xF9, 0x00, 0x79,
  0x97, 0x11, 0xEA, 0x78, 0xF0, 0x5D, 0x26, 0xDD, 0xD7, 0x96, 0x66, 0xB6,
  0xD7, 0x92, 0x96, 0x6D, 0x96, 0x66, 0x4C, 0xE5, 0x70, 0x57, 0x50, 0xFE,
  0xC9, 0x35, 0x80, 0xF0,
};

const GFXglyph NotoSans_Bold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 5, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 1, 2, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 2, 6, 2, 0, -5 },
  { 23, 4, 3, 4, 0, -5 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 2, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -2 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 2, 5, 2, 0, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 3, 5, 3, 0, -5 },
  { 72, 6, 6, 6, 0, -5 },
  { 77, 5, 5, 5, 0, -5 },
  { 81, 3, 5, 5, 1, -5 },
  { 83, 4, 5, 5, 0, -5 },
  { 86, 4, 5, 5, 1, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 5, 5, 5, 0, -5 },
  { 97, 4, 5, 5, 1, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 3, 6, 2, -1, -5 },
  { 105, 4, 5, 5, 1, -5 },
  { 108, 3, 5, 4, 1, -5 },
  { 110, 5, 5, 7, 1, -5 },
  { 114, 4, 5, 6, 1, -5 },
  { 117, 5, 5, 6, 0, -5 },
  { 121, 3, 5, 4, 1, -5 },
  { 123, 5, 6, 6, 0, -5 },
  { 127, 4, 5, 5, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 5, 1, -5 },
  { 139, 5, 5, 5, 0, -5 },
  { 143, 7, 5, 7, 0, -5 },
  { 148, 5, 5, 5, 0, -5 },
  { 152, 4, 5, 4, 0, -5 },
  { 155, 4, 5, 4, 0, -5 },
  { 158, 2, 6, 2, 0, -5 },
  { 160, 3, 5, 3, 0, -5 },
  { 162, 2, 6, 2, 0, -5 },
  { 164, 4, 3, 4, 0, -5 },
  { 166, 3, 1, 3, 0, 0 },
  { 167, 2, 1, 3, 0, -5 },
  { 168, 4, 4, 4, 0, -4 },
  { 170, 3, 5, 4, 1, -5 },
  { 172, 3, 4, 4, 0, -4 },
  { 174, 4, 5, 4, 0, -5 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 3, 5, 3, 0, -5 },
  { 181, 4, 6, 4, 0, -4 },
  { 184, 3, 5, 5, 1, -5 },
  { 186, 2, 5, 2, 0, -5 },
  { 188, 2, 7, 2, 0, -5 },
  { 190, 3, 5, 4, 1, -5 },
  { 192, 1, 5, 2, 1, -5 },
  { 193, 5, 4, 7, 1, -4 },
  { 196, 3, 4, 5, 1, -4 },
  { 198, 4, 4, 4, 0, -4 },
  { 200, 3, 6, 4, 1, -4 },
  { 203, 4, 6, 4, 0, -4 },
  { 206, 2, 4, 3, 1, -4 },
  { 207, 3, 4, 4, 0, -4 },
  { 209, 3, 5, 3, 0, -5 },
  { 211, 4, 4, 5, 0, -4 },
  { 213, 4, 4, 4, 0, -4 },
  { 215, 6, 4, 6, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 3, 4, 3, 0, -4 },
  { 225, 2, 6, 3, 0, -5 },
  { 227, 1, 7, 4, 1, -5 },
  { 228, 3, 6, 3, 0, -5 },
  { 231, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Bold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold7pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_BOLD7PT7B_H_
