#ifndef _NOTOSANS_BOLD29PT7B_H_
#define _NOTOSANS_BOLD29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x07,
  0xBF, 0xFF, 0x00, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F,
  0x87, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E,
  0x01, 0xC7, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0xFE, 0x0F, 0xFF, 0x7F, 0xFD, 0xFF, 0xEF, 0xB0, 0xBE, 0xC0,
  0xFB, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x37,
  0xC0, 0xCF, 0xC3, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x1F, 0xC0, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x3E, 0x00, 0xF0, 0x7F, 0x01, 0xE0, 0x7F, 0x81,
  0xC0, 0xF3, 0x83, 0xC0, 0xE3, 0xC3, 0x80, 0xE3, 0xC7, 0x80, 0xE3, 0xC7,
  0x00, 0xE3, 0xCF, 0x00, 0xE3, 0xDE, 0x30, 0xF3, 0x9C, 0xFE, 0x7F, 0xBD,
  0xFE, 0x7F, 0x39, 0xCF, 0x1E, 0x79, 0xC7, 0x00, 0x73, 0xC7, 0x00, 0xF3,
  0xC7, 0x00, 0xE3, 0xC7, 0x01, 0xE1, 0xC7, 0x03, 0xC1, 0xCF, 0x03, 0x81,
  0xFF, 0x07, 0x80, 0xFE, 0x07, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7D, 0xF8, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1,
  0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x7C,
  0xFF, 0xC3, 0xC7, 0xDF, 0x3E, 0x7C, 0x7D, 0xF3, 0xE1, 0xFF, 0x1F, 0x07,
  0xF0, 0xF8, 0x1F, 0x83, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xEE, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x70, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0xF0, 0x70, 0x78,
  0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x70, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0xE7, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xDE, 0x1F, 0x3C, 0x18, 0xE0, 0x21, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x7D, 0xE7, 0x9C, 0xF3, 0xCE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7,
  0xFF, 0xE0, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC7, 0x87, 0xCF, 0x07, 0xBE, 0x0F, 0x7C,
  0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xDF, 0x07,
  0xBE, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xF9, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xFE, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0xFF, 0x7F, 0xFE, 0xFF, 0x3D, 0x8F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF,
  0xE7, 0x07, 0xC4, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x20, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x03,
  0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C, 0x1C, 0x7C, 0x3C, 0x7C, 0x78, 0x7C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x8C,
  0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0xC7, 0xFF,
  0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC3, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF7, 0xF1, 0xEF, 0xF3,
  0xFF, 0xF7, 0xE3, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x78,
  0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x1F, 0x3E, 0x3C, 0x3F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x87,
  0xCF, 0x9F, 0x0F, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3D, 0xF0, 0xF9, 0xFF,
  0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0xE3, 0xFF,
  0xCF, 0x87, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xF0, 0xFF,
  0xFF, 0xF3, 0xFF, 0xE3, 0xFB, 0xC1, 0xE7, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x07, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0xF7, 0xBF, 0xE6,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F, 0xFE, 0x79, 0xF7, 0xDE, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x05, 0xE7, 0x9E, 0x73, 0xCF, 0x38, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x70, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xE1, 0xFE,
  0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x1F, 0xC3, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF6, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1E, 0x00, 0x3C, 0x3C, 0x0C,
  0x1E, 0x38, 0x7F, 0xCE, 0x78, 0xFF, 0xCE, 0x71, 0xE3, 0xCF, 0x73, 0xC3,
  0xC7, 0xF3, 0xC3, 0x87, 0xF3, 0x83, 0x87, 0xF3, 0x83, 0x8E, 0xF3, 0x83,
  0x8E, 0xF3, 0xC7, 0xCE, 0x71, 0xFF, 0xFC, 0x70, 0xFC, 0xF8, 0x78, 0x38,
  0x70, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x20, 0x1F, 0xC7, 0xE0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7D, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0,
  0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3C, 0x03, 0xC7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0xFF, 0xC0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x3E, 0xF8, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E,
  0x04, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x02, 0x7F, 0x9E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0x3E, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x3F, 0x3F,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x01, 0xFC,
  0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x23, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x7C, 0x0F, 0xBF, 0xC7,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xE0, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3F, 0xFE, 0xFF, 0x7F, 0x3F, 0x00, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3,
  0xE0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xB8, 0x0F, 0xFE, 0xF0, 0x3B, 0xFB,
  0xC1, 0xEF, 0xE7, 0x07, 0xBF, 0x9C, 0x1C, 0xFF, 0x78, 0xF3, 0xFD, 0xE3,
  0xCF, 0xF3, 0x8E, 0x3F, 0xCF, 0x78, 0xFF, 0x3D, 0xE3, 0xFC, 0x77, 0x0F,
  0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0F, 0xF0,
  0xF8, 0x3C, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFE, 0xF8, 0x3F, 0x9E, 0x0F, 0xE7, 0xC3, 0xF8, 0xF0,
  0xFE, 0x3E, 0x3F, 0xC7, 0xCF, 0xF1, 0xF3, 0xFC, 0x3E, 0xFF, 0x07, 0xBF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7,
  0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0xF7, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFB, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFD, 0xF8, 0x0F, 0xBE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x07,
  0xCF, 0xF7, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0x83, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x7E, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xC7, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F,
  0x3E, 0x07, 0x9F, 0x03, 0xEF, 0x80, 0xF8, 0x0F, 0xE0, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFE, 0x78, 0x11, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0,
  0x7F, 0xE3, 0xEF, 0xFF, 0xBF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x7C, 0x0F,
  0xBF, 0xBF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0xF8, 0x03, 0xFF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x03, 0xE1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0x7C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0x80, 0xF0, 0x1F, 0x78, 0x1F, 0x81, 0xF7, 0x81, 0xF8,
  0x1E, 0x78, 0x1F, 0x81, 0xE7, 0xC1, 0xF8, 0x3E, 0x3C, 0x3F, 0xC3, 0xC3,
  0xC3, 0xFC, 0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x1E, 0x79,
  0xE7, 0x81, 0xE7, 0x9E, 0x78, 0x1E, 0x70, 0xE7, 0x81, 0xE7, 0x0E, 0x78,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0xFC, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x1E, 0x0F, 0x07, 0xC1, 0xF1,
  0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xEF,
  0x80, 0x78, 0xF8, 0x1F, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x3E, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xF8, 0xF0, 0x3C,
  0x3E, 0x1F, 0x07, 0x87, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFC, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC,
  0x07, 0x38, 0x1E, 0x78, 0x38, 0x70, 0x70, 0xF1, 0xC0, 0xE3, 0x81, 0xEF,
  0x01, 0xDC, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x1E, 0x0F, 0x0F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xC6, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x7F, 0xCF,
  0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xF7,
  0xFD, 0xCF, 0xE7, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0xFC, 0x7B, 0xFC, 0xFF, 0xFD, 0xFD, 0xFB, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF1, 0xF7, 0xFF, 0xEF, 0x7F, 0x9E, 0x7E, 0x00, 0x07, 0xF0, 0xFF,
  0xCF, 0xFE, 0xFC, 0xE7, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xE3, 0x9F, 0xFC, 0x7F, 0xE1, 0xFE, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xE7,
  0x9F, 0xEF, 0x3F, 0xFE, 0xFD, 0xFD, 0xF0, 0xFB, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x1E, 0xF8, 0x7D, 0xF9, 0xF9, 0xFF,
  0xF3, 0xFD, 0xE3, 0xF1, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1,
  0xE7, 0x81, 0xEF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x0F,
  0xF1, 0xFE, 0x3F, 0xE3, 0xE2, 0x3C, 0x03, 0xC0, 0x7F, 0xCF, 0xFC, 0xFF,
  0xC3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0F, 0x9E, 0x7F, 0xBC,
  0xFF, 0xFB, 0xF3, 0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0xC3, 0xE7, 0xFF, 0xCF, 0xF7,
  0x8F, 0xCF, 0x00, 0x1E, 0x00, 0x3D, 0x00, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0xFC, 0x7B, 0xFC, 0xFF, 0xFD, 0xFC, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x77, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x7F, 0xBF, 0xDF, 0xCF, 0xC0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8,
  0x3C, 0xF8, 0x78, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xF7, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xF0, 0xFC, 0xF7, 0xF9,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF3, 0xF1, 0xEF, 0xFB, 0xFF,
  0xF7, 0xF3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x1E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xF3, 0xF1, 0xEF,
  0xF3, 0xFF, 0xF7, 0xF7, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7, 0xDF, 0xFF, 0xBD,
  0xFE, 0x79, 0xF8, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xF3,
  0xF7, 0xC3, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC0, 0xF7, 0xC7, 0xE7, 0xFF, 0xCF, 0xF7, 0x8F, 0xCF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0xF1, 0xFE, 0xFB, 0xFF, 0x7F, 0xEF, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x1F,
  0xE7, 0xFF, 0x7F, 0xFF, 0x86, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x1C,
  0x03, 0x80, 0xF0, 0x3F, 0xEF, 0xFD, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF1, 0x3F, 0xE3, 0xFC,
  0x3F, 0x80, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xF7, 0x9F, 0xCF, 0xF8, 0x0F, 0xFC, 0x07,
  0x9E, 0x07, 0xCF, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C,
  0x78, 0x1E, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xBC, 0x1F, 0x07,
  0x9E, 0x1F, 0x83, 0xCF, 0x0F, 0xE3, 0xE3, 0xC7, 0x71, 0xE1, 0xE3, 0xB8,
  0xF0, 0xF3, 0xDC, 0x78, 0x79, 0xCF, 0x78, 0x1E, 0xE3, 0xBC, 0x0F, 0x71,
  0xDE, 0x07, 0xB8, 0xEF, 0x01, 0xF8, 0x77, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x3E, 0x0F,
  0x8F, 0x8F, 0x83, 0xCF, 0x81, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x83, 0xE3, 0xC1,
  0xF1, 0xF1, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E, 0x07,
  0xCF, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x78, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC1, 0xF0, 0xFC, 0x3F,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF3, 0xF8, 0xFC, 0x3F,
  0x0F, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFC,
  0x3F, 0x07, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x3E, 0x0F, 0xC3, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x7F, 0x07, 0xC3,
  0xF1, 0xFC, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x0F, 0xC3,
  0xF0, 0xF8, 0x20, 0x00, 0x18, 0x05, 0xFC, 0x1F, 0xFF, 0xFB, 0xFF, 0x81,
  0xF8,
};

const GFXglyph NotoSans_Bold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 21, 8, 2, -21 },
  { 15, 10, 8, 14, 2, -21 },
  { 25, 17, 21, 19, 1, -21 },
  { 70, 14, 24, 17, 1, -22 },
  { 112, 24, 21, 26, 1, -21 },
  { 175, 21, 21, 22, 1, -21 },
  { 231, 4, 8, 8, 2, -21 },
  { 235, 8, 26, 10, 1, -21 },
  { 261, 8, 26, 10, 1, -21 },
  { 287, 14, 14, 16, 1, -22 },
  { 312, 14, 14, 17, 1, -17 },
  { 337, 6, 7, 8, 1, -3 },
  { 343, 7, 4, 9, 1, -10 },
  { 347, 5, 4, 8, 2, -4 },
  { 350, 12, 21, 12, 0, -21 },
  { 382, 15, 21, 17, 1, -21 },
  { 422, 10, 21, 17, 2, -21 },
  { 449, 15, 21, 17, 1, -21 },
  { 489, 14, 21, 17, 1, -21 },
  { 526, 16, 21, 17, 0, -21 },
  { 568, 14, 21, 17, 1, -21 },
  { 605, 15, 21, 17, 1, -21 },
  { 645, 15, 21, 17, 1, -21 },
  { 685, 15, 21, 17, 1, -21 },
  { 725, 15, 21, 17, 1, -21 },
  { 765, 5, 16, 8, 2, -16 },
  { 775, 6, 20, 8, 1, -16 },
  { 790, 14, 15, 17, 1, -18 },
  { 817, 14, 9, 17, 1, -15 },
  { 833, 14, 15, 17, 1, -18 },
  { 860, 13, 21, 14, 0, -21 },
  { 895, 24, 23, 26, 1, -21 },
  { 964, 20, 21, 20, 0, -21 },
  { 1017, 16, 21, 19, 2, -21 },
  { 1059, 16, 21, 19, 2, -21 },
  { 1101, 18, 21, 21, 2, -21 },
  { 1149, 12, 21, 16, 3, -21 },
  { 1181, 11, 21, 16, 3, -21 },
  { 1210, 17, 21, 21, 2, -21 },
  { 1255, 17, 21, 22, 3, -21 },
  { 1300, 9, 21, 11, 1, -21 },
  { 1324, 9, 27, 10, -2, -21 },
  { 1355, 16, 21, 19, 3, -21 },
  { 1397, 13, 21, 16, 2, -21 },
  { 1432, 22, 21, 27, 3, -21 },
  { 1490, 18, 21, 24, 3, -21 },
  { 1538, 19, 21, 23, 2, -21 },
  { 1588, 15, 21, 18, 2, -21 },
  { 1628, 19, 26, 23, 2, -21 },
  { 1690, 17, 21, 19, 2, -21 },
  { 1735, 14, 21, 16, 1, -21 },
  { 1772, 15, 21, 17, 1, -21 },
  { 1812, 17, 21, 22, 2, -21 },
  { 1857, 19, 21, 19, 0, -21 },
  { 1907, 28, 21, 28, 0, -21 },
  { 1981, 19, 21, 19, 0, -21 },
  { 2031, 18, 21, 18, 0, -21 },
  { 2079, 15, 21, 17, 1, -21 },
  { 2119, 7, 26, 10, 2, -21 },
  { 2142, 12, 21, 12, 0, -21 },
  { 2174, 7, 26, 10, 1, -21 },
  { 2197, 15, 14, 17, 1, -21 },
  { 2224, 12, 2, 12, 0, 3 },
  { 2227, 8, 4, 11, 1, -22 },
  { 2231, 14, 16, 17, 1, -16 },
  { 2259, 15, 22, 18, 2, -22 },
  { 2301, 13, 16, 15, 1, -16 },
  { 2327, 15, 22, 18, 1, -22 },
  { 2369, 15, 16, 17, 1, -16 },
  { 2399, 12, 22, 11, 1, -22 },
  { 2432, 15, 23, 18, 1, -16 },
  { 2476, 15, 22, 19, 2, -22 },
  { 2518, 5, 22, 9, 2, -22 },
  { 2532, 9, 29, 9, -2, -22 },
  { 2565, 16, 22, 18, 2, -22 },
  { 2609, 5, 22, 9, 2, -22 },
  { 2623, 24, 16, 28, 2, -16 },
  { 2671, 15, 16, 19, 2, -16 },
  { 2701, 16, 16, 18, 1, -16 },
  { 2733, 15, 23, 18, 2, -16 },
  { 2777, 15, 23, 18, 1, -16 },
  { 2821, 11, 16, 13, 2, -16 },
  { 2843, 12, 16, 15, 1, -16 },
  { 2867, 11, 19, 13, 1, -19 },
  { 2894, 15, 16, 19, 2, -16 },
  { 2924, 17, 16, 17, 0, -16 },
  { 2958, 25, 16, 25, 0, -16 },
  { 3008, 17, 16, 17, 0, -16 },
  { 3042, 17, 23, 17, 0, -16 },
  { 3091, 12, 16, 14, 1, -16 },
  { 3115, 10, 26, 11, 0, -21 },
  { 3148, 4, 29, 16, 6, -22 },
  { 3163, 10, 26, 11, 1, -21 },
  { 3196, 14, 5, 17, 1, -13 },
};

const GFXfont NotoSans_Bold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold29pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_BOLD29PT7B_H_
