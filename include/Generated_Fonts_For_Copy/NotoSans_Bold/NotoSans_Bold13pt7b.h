#ifndef _NOTOSANS_BOLD13PT7B_H_
#define _NOTOSANS_BOLD13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDD, 0x90, 0x12, 0x16, 0x7F, 0x7F, 0x34, 0xFF,
  0x2C, 0x2C, 0x68, 0x21, 0xFF, 0xA8, 0xE1, 0xE3, 0xEB, 0xF8, 0x82, 0x00,
  0x71, 0x9B, 0x23, 0x6C, 0x6D, 0x67, 0x7E, 0x1A, 0x42, 0x48, 0xCD, 0x30,
  0xE0, 0x78, 0x66, 0x32, 0x0F, 0x0F, 0x36, 0xDB, 0x39, 0xFC, 0x7B, 0x80,
  0xF8, 0x7B, 0x49, 0x24, 0xD9, 0x80, 0xE6, 0x23, 0x33, 0x33, 0x26, 0xC0,
  0x10, 0x21, 0xFD, 0xC2, 0x8D, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00,
  0x6D, 0x60, 0xF0, 0xF0, 0x18, 0xC4, 0x63, 0x31, 0x88, 0xC0, 0x7C, 0xDD,
  0x9E, 0x3C, 0x68, 0xD9, 0xB6, 0x3C, 0x37, 0xF3, 0x33, 0x33, 0x30, 0xFC,
  0xCC, 0x18, 0x60, 0xC3, 0x0C, 0x3F, 0x7E, 0xFC, 0x9C, 0x19, 0xE3, 0xC0,
  0xC1, 0xE7, 0xFC, 0x0C, 0x38, 0xF1, 0x66, 0xD9, 0xBF, 0x86, 0x0C, 0xFB,
  0x0C, 0x3E, 0xFC, 0x30, 0xFE, 0xF8, 0x3C, 0xC1, 0x82, 0xEF, 0xF8, 0xD9,
  0xB7, 0x3C, 0xFE, 0x0C, 0x30, 0x61, 0x83, 0x06, 0x18, 0x70, 0x7C, 0xCD,
  0x9B, 0xE3, 0xCC, 0xF1, 0xB3, 0x7C, 0x7C, 0xDF, 0x1E, 0x37, 0xE6, 0xC1,
  0xAE, 0x78, 0xF0, 0x3C, 0x6C, 0x00, 0xDA, 0xC0, 0x04, 0x76, 0x30, 0x70,
  0x70, 0x40, 0xFF, 0xF0, 0x3F, 0x83, 0x83, 0x83, 0x7B, 0x08, 0x00, 0xFA,
  0x30, 0xC6, 0x30, 0x80, 0x0C, 0x30, 0x3F, 0x18, 0x6D, 0xEE, 0x49, 0xB2,
  0x6C, 0x9B, 0xFB, 0x24, 0x61, 0x0F, 0xC0, 0x1C, 0x0A, 0x0D, 0x86, 0xC3,
  0x63, 0xF9, 0xFC, 0xC6, 0xC1, 0x80, 0xFD, 0x9F, 0x1F, 0xEF, 0xD8, 0xF1,
  0xFF, 0xFC, 0x7F, 0xCB, 0x06, 0x0C, 0x18, 0x30, 0x3F, 0x3E, 0xFC, 0xCE,
  0xC7, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0xF8, 0xFF, 0x0C, 0x3E, 0xFB, 0x0C,
  0x3F, 0xFC, 0xFE, 0x31, 0x8F, 0xE3, 0x18, 0xC0, 0x7E, 0xC7, 0x06, 0x0C,
  0xF8, 0xF1, 0xBF, 0x3E, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xF9, 0x8C, 0x63, 0x18, 0xCE, 0xF8, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xFE, 0xC7, 0xCC, 0xD8, 0xF8, 0xF8, 0xD8, 0xCC, 0xCE, 0xC7, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xE1, 0xF8, 0x7F, 0x3F, 0xCF, 0xD2, 0xF6,
  0xBD, 0xEF, 0x33, 0xCC, 0xC0, 0xE1, 0xF1, 0xF1, 0xD9, 0xD9, 0xCD, 0xCF,
  0xC7, 0xC3, 0x7E, 0x73, 0xB0, 0xD8, 0x7C, 0x3E, 0x1B, 0x0C, 0xFE, 0x3E,
  0x00, 0xFD, 0x9B, 0x1E, 0x6F, 0xDF, 0x30, 0x60, 0xC0, 0x7E, 0x73, 0xB0,
  0xD8, 0x7C, 0x3E, 0x1B, 0x0C, 0xFE, 0x3E, 0x03, 0x01, 0xE0, 0xFC, 0xCC,
  0xC6, 0xCC, 0xFC, 0xD8, 0xCC, 0xCE, 0xC7, 0xFF, 0x2C, 0x38, 0x78, 0x60,
  0xFE, 0xF8, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x7C, 0xC3, 0x63, 0x63, 0x66, 0x26,
  0x34, 0x3C, 0x1C, 0x18, 0xC6, 0x3E, 0x39, 0x99, 0xCC, 0xDA, 0x66, 0xD2,
  0x34, 0xF0, 0xA7, 0x87, 0x1C, 0x38, 0xC0, 0xE3, 0x3B, 0x0D, 0x83, 0x81,
  0xC1, 0xE0, 0xD8, 0xCE, 0xE3, 0x80, 0xE3, 0x66, 0x76, 0x3C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0xFE, 0x0C, 0x30, 0xC1, 0x86, 0x18, 0x7F, 0xFE, 0xFB,
  0x6D, 0xB6, 0xDB, 0x80, 0xC3, 0x18, 0xC3, 0x18, 0x43, 0x18, 0xE4, 0x92,
  0x49, 0x27, 0x80, 0x10, 0x70, 0xA3, 0x24, 0x78, 0x40, 0xF8, 0xCC, 0xF9,
  0x30, 0xFF, 0xCF, 0x7F, 0xC0, 0xC1, 0x83, 0x07, 0xEE, 0xD8, 0xF1, 0xE7,
  0xED, 0xF8, 0x7E, 0x71, 0x8C, 0x75, 0xE0, 0x0C, 0x30, 0xDF, 0xCF, 0x3C,
  0xF3, 0xFD, 0xD0, 0x7B, 0x3C, 0xFF, 0xC3, 0x97, 0xC0, 0x3D, 0xE6, 0x3E,
  0x61, 0x86, 0x18, 0x61, 0x80, 0x7F, 0x3C, 0xF3, 0xCF, 0x37, 0xC3, 0xDF,
  0xE0, 0xC1, 0x83, 0x07, 0xEE, 0xD8, 0xF1, 0xE3, 0xC7, 0x8C, 0xF3, 0xFF,
  0xF0, 0x33, 0x03, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x7D,
  0x9F, 0x3C, 0x6C, 0xCD, 0x9C, 0xFF, 0xFF, 0xF0, 0xFF, 0xDD, 0xDF, 0x31,
  0xE6, 0x3C, 0xC7, 0x98, 0xF3, 0x18, 0xFD, 0xDB, 0x1E, 0x3C, 0x78, 0xF1,
  0x80, 0x79, 0x9B, 0x36, 0x7C, 0xD9, 0x9E, 0x00, 0xFD, 0xDB, 0x1E, 0x3C,
  0xFD, 0xBF, 0x60, 0xC1, 0x80, 0x7F, 0x3C, 0xF3, 0xCF, 0x37, 0xC3, 0x0C,
  0x30, 0xFF, 0xB1, 0x8C, 0x63, 0x00, 0xFC, 0x78, 0xE1, 0xCF, 0xC0, 0x21,
  0x3E, 0xC6, 0x31, 0x8F, 0x38, 0xC7, 0x1C, 0x71, 0xCF, 0xB7, 0x40, 0xC6,
  0xCD, 0x93, 0x63, 0xC7, 0x06, 0x00, 0xCE, 0x69, 0xCD, 0xAB, 0x35, 0xE7,
  0xBC, 0x73, 0x0C, 0x60, 0xE6, 0xD8, 0xF1, 0xC3, 0xCD, 0xB9, 0x80, 0xC6,
  0xCD, 0x93, 0x63, 0xC7, 0x06, 0x0C, 0xB1, 0xC0, 0x7C, 0x31, 0x8C, 0x61,
  0xFF, 0xC0, 0x39, 0x8C, 0x66, 0x60, 0x86, 0x31, 0x8E, 0xFF, 0xF8, 0xCC,
  0x44, 0x63, 0x64, 0x4C, 0xC0, 0xC7, 0xF8, 0x00,
};

const GFXglyph NotoSans_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 4, 3, 6, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 11, 9, 12, 0, -9 },
  { 37, 9, 9, 10, 1, -9 },
  { 48, 2, 3, 3, 1, -9 },
  { 49, 3, 11, 4, 1, -9 },
  { 54, 4, 11, 4, 0, -9 },
  { 60, 7, 6, 7, 0, -10 },
  { 66, 6, 7, 7, 1, -8 },
  { 72, 3, 4, 4, 0, -2 },
  { 74, 4, 1, 4, 0, -4 },
  { 75, 2, 2, 4, 1, -2 },
  { 76, 5, 9, 5, 0, -9 },
  { 82, 7, 9, 7, 0, -9 },
  { 90, 4, 9, 7, 1, -9 },
  { 95, 7, 9, 7, 0, -9 },
  { 103, 7, 9, 7, 0, -9 },
  { 111, 7, 9, 7, 0, -9 },
  { 119, 6, 9, 7, 1, -9 },
  { 126, 7, 9, 7, 0, -9 },
  { 134, 7, 9, 7, 0, -9 },
  { 142, 7, 9, 7, 0, -9 },
  { 150, 7, 9, 7, 0, -9 },
  { 158, 2, 7, 4, 1, -7 },
  { 160, 3, 9, 4, 0, -7 },
  { 164, 6, 7, 7, 1, -8 },
  { 170, 6, 4, 7, 1, -7 },
  { 173, 6, 7, 7, 1, -8 },
  { 179, 6, 9, 6, 0, -9 },
  { 186, 10, 10, 12, 1, -9 },
  { 199, 9, 9, 9, 0, -9 },
  { 210, 7, 9, 9, 1, -9 },
  { 218, 7, 9, 8, 1, -9 },
  { 226, 8, 9, 10, 1, -9 },
  { 235, 6, 9, 7, 1, -9 },
  { 242, 5, 9, 7, 1, -9 },
  { 248, 7, 9, 9, 1, -9 },
  { 256, 8, 9, 10, 1, -9 },
  { 265, 5, 9, 5, 0, -9 },
  { 271, 4, 12, 4, -1, -9 },
  { 277, 8, 9, 9, 1, -9 },
  { 286, 6, 9, 7, 1, -9 },
  { 293, 10, 9, 12, 1, -9 },
  { 305, 8, 9, 11, 1, -9 },
  { 314, 9, 9, 10, 1, -9 },
  { 325, 7, 9, 8, 1, -9 },
  { 333, 9, 11, 10, 1, -9 },
  { 346, 8, 9, 9, 1, -9 },
  { 355, 6, 9, 7, 1, -9 },
  { 362, 7, 9, 8, 0, -9 },
  { 370, 8, 9, 10, 1, -9 },
  { 379, 8, 9, 8, 0, -9 },
  { 388, 13, 9, 13, 0, -9 },
  { 403, 9, 9, 9, 0, -9 },
  { 414, 8, 9, 8, 0, -9 },
  { 423, 7, 9, 8, 0, -9 },
  { 431, 3, 11, 4, 1, -9 },
  { 436, 5, 9, 5, 0, -9 },
  { 442, 3, 11, 4, 0, -9 },
  { 447, 7, 6, 7, 0, -9 },
  { 453, 5, 1, 5, 0, 1 },
  { 454, 3, 2, 5, 1, -10 },
  { 455, 6, 7, 8, 1, -7 },
  { 461, 7, 10, 8, 1, -10 },
  { 470, 5, 7, 7, 1, -7 },
  { 475, 6, 10, 8, 1, -10 },
  { 483, 6, 7, 8, 1, -7 },
  { 489, 6, 10, 5, 0, -10 },
  { 497, 6, 10, 8, 1, -7 },
  { 505, 7, 10, 8, 1, -10 },
  { 514, 2, 10, 4, 1, -10 },
  { 517, 4, 13, 4, -1, -10 },
  { 524, 7, 10, 8, 1, -10 },
  { 533, 2, 10, 4, 1, -10 },
  { 536, 11, 7, 13, 1, -7 },
  { 546, 7, 7, 8, 1, -7 },
  { 553, 7, 7, 8, 1, -7 },
  { 560, 7, 10, 8, 1, -7 },
  { 569, 6, 10, 8, 1, -7 },
  { 577, 5, 7, 6, 1, -7 },
  { 582, 5, 7, 7, 1, -7 },
  { 587, 5, 9, 6, 0, -9 },
  { 593, 6, 7, 8, 1, -7 },
  { 599, 7, 7, 7, 0, -7 },
  { 606, 11, 7, 11, 0, -7 },
  { 616, 7, 7, 8, 0, -7 },
  { 623, 7, 10, 7, 0, -7 },
  { 632, 6, 7, 6, 0, -7 },
  { 638, 5, 11, 5, 0, -9 },
  { 645, 1, 13, 7, 3, -10 },
  { 647, 4, 11, 5, 1, -9 },
  { 653, 6, 3, 7, 1, -6 },
};

const GFXfont NotoSans_Bold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold13pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_BOLD13PT7B_H_
