#ifndef _NOTOSANS_BOLD8PT7B_H_
#define _NOTOSANS_BOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xEC, 0x31, 0xBE, 0xAF, 0xB0, 0x2F, 0xE3, 0xB6, 0x45,
  0x52, 0xD2, 0xD2, 0xA4, 0xC0, 0x71, 0x47, 0x1B, 0xD9, 0xF0, 0xD0, 0x5A,
  0x94, 0x95, 0x5C, 0x2F, 0x67, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25, 0x25,
  0x00, 0x6D, 0xD9, 0xD7, 0x3C, 0x92, 0x40, 0x6D, 0x12, 0x4F, 0x69, 0x37,
  0x1F, 0x33, 0x59, 0xF1, 0x74, 0x69, 0x1F, 0x34, 0xBD, 0xD7, 0xF1, 0x32,
  0x24, 0x6D, 0x77, 0x97, 0x6D, 0x97, 0x16, 0xC3, 0xC1, 0x80, 0x16, 0xC3,
  0xFF, 0x86, 0x3C, 0xEB, 0x24, 0x04, 0x38, 0x8A, 0xED, 0x5B, 0xC8, 0x0E,
  0x00, 0x30, 0xC5, 0x16, 0x7A, 0x30, 0xEB, 0xBF, 0x9E, 0x3A, 0x71, 0x84,
  0x3C, 0xEB, 0x99, 0x9E, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x51,
  0xB4, 0xBC, 0x99, 0x9F, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x5E, 0x9A,
  0xEE, 0xA9, 0x92, 0x49, 0xC0, 0x8F, 0x3D, 0x75, 0xB6, 0x90, 0x8E, 0x7B,
  0x5B, 0xCC, 0x39, 0x3C, 0x71, 0x4D, 0xE0, 0xEB, 0xBE, 0x88, 0x39, 0x3C,
  0x71, 0x4D, 0xE0, 0xC0, 0xEB, 0xBE, 0xA9, 0x7D, 0x43, 0x1F, 0xF2, 0x22,
  0x22, 0x99, 0x99, 0x9F, 0x8E, 0x54, 0xA7, 0x10, 0x93, 0x9A, 0x5A, 0x6A,
  0x6A, 0x64, 0xCA, 0x8C, 0x65, 0x64, 0x8A, 0x94, 0x42, 0x10, 0xF1, 0x26,
  0x4F, 0xFE, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x26, 0x59, 0xE0, 0xE0, 0x77,
  0xD7, 0x88, 0xEB, 0xBE, 0x7C, 0xC7, 0x11, 0x7D, 0xD7, 0x7F, 0xC7, 0x6B,
  0xA4, 0x80, 0x7D, 0xD7, 0x17, 0x88, 0xFB, 0xBB, 0xBC, 0x45, 0x56, 0x89,
  0xAC, 0xAB, 0xFC, 0xFE, 0xDB, 0x6D, 0xFB, 0xBB, 0x76, 0xF6, 0xE0, 0xEB,
  0xBE, 0x88, 0x7D, 0xD7, 0x11, 0xEA, 0xF6, 0x3E, 0x5D, 0x26, 0xBB, 0xBD,
  0xDA, 0x98, 0xC0, 0x96, 0xD9, 0xB3, 0x60, 0xDB, 0x1D, 0xB0, 0xDA, 0x98,
  0x42, 0x60, 0xF2, 0x4F, 0x29, 0x64, 0x98, 0xFF, 0xC9, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 5, 0, -6 },
  { 11, 7, 6, 7, 0, -6 },
  { 17, 6, 6, 6, 0, -6 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 2, 7, 3, 0, -6 },
  { 25, 2, 7, 3, 0, -6 },
  { 27, 4, 4, 4, 0, -6 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 2, 2, 2, 0, -1 },
  { 32, 2, 1, 3, 0, -3 },
  { 33, 2, 1, 2, 0, -1 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 3, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 5, 2, 0, -4 },
  { 70, 4, 4, 5, 0, -5 },
  { 72, 4, 2, 5, 0, -4 },
  { 73, 4, 4, 5, 0, -5 },
  { 75, 4, 6, 4, 0, -6 },
  { 78, 7, 7, 7, 0, -6 },
  { 85, 6, 6, 6, 0, -6 },
  { 90, 4, 6, 5, 1, -6 },
  { 93, 5, 6, 5, 0, -6 },
  { 97, 4, 6, 6, 1, -6 },
  { 100, 3, 6, 4, 1, -6 },
  { 103, 3, 6, 4, 1, -6 },
  { 106, 5, 6, 6, 0, -6 },
  { 110, 4, 6, 6, 1, -6 },
  { 113, 3, 6, 3, 0, -6 },
  { 116, 3, 8, 3, -1, -6 },
  { 119, 4, 6, 5, 1, -6 },
  { 122, 3, 6, 4, 1, -6 },
  { 125, 6, 6, 8, 1, -6 },
  { 130, 5, 6, 7, 1, -6 },
  { 134, 6, 6, 6, 0, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 6, 7, 6, 0, -6 },
  { 148, 4, 6, 5, 1, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 4, 6, 5, 0, -6 },
  { 157, 4, 6, 6, 1, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 8, 6, 8, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 5, 6, 5, 0, -6 },
  { 178, 4, 6, 5, 0, -6 },
  { 181, 1, 7, 3, 1, -6 },
  { 182, 3, 6, 3, 0, -6 },
  { 185, 2, 7, 3, 0, -6 },
  { 187, 4, 4, 5, 0, -6 },
  { 189, 3, 1, 3, 0, 0 },
  { 190, 3, 1, 3, 0, -6 },
  { 191, 4, 4, 5, 0, -4 },
  { 193, 4, 6, 5, 1, -6 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 4, 6, 5, 0, -6 },
  { 201, 4, 4, 5, 0, -4 },
  { 203, 3, 6, 3, 0, -6 },
  { 206, 4, 6, 5, 0, -4 },
  { 209, 4, 6, 5, 1, -6 },
  { 212, 1, 6, 2, 1, -6 },
  { 213, 2, 8, 2, 0, -6 },
  { 215, 4, 6, 5, 1, -6 },
  { 218, 1, 6, 2, 1, -6 },
  { 219, 6, 4, 8, 1, -4 },
  { 222, 4, 4, 5, 1, -4 },
  { 224, 5, 4, 5, 0, -4 },
  { 227, 4, 6, 5, 1, -4 },
  { 230, 4, 6, 5, 0, -4 },
  { 233, 2, 4, 4, 1, -4 },
  { 234, 4, 4, 4, 0, -4 },
  { 236, 3, 5, 3, 0, -5 },
  { 238, 4, 4, 5, 1, -4 },
  { 240, 5, 4, 5, 0, -4 },
  { 243, 7, 4, 7, 0, -4 },
  { 247, 5, 4, 5, 0, -4 },
  { 250, 5, 6, 5, 0, -4 },
  { 254, 4, 4, 4, 0, -4 },
  { 256, 3, 7, 3, 0, -6 },
  { 259, 1, 8, 4, 2, -6 },
  { 260, 3, 7, 3, 0, -6 },
  { 263, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_Bold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold8pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_BOLD8PT7B_H_
