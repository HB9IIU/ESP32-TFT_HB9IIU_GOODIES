#ifndef _NOTOSANS_BOLD31PT7B_H_
#define _NOTOSANS_BOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xC0, 0x03,
  0xBF, 0xFF, 0xFC, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x77, 0x8E, 0x03, 0xC7, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x07,
  0x8E, 0x01, 0xE3, 0x87, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xC7,
  0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x0E, 0x38, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x1C, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C,
  0x70, 0x0F, 0x3C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0xF9, 0x84, 0xF9, 0x80, 0xFD, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0x9E, 0x81, 0x9F, 0xE1, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x0F, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F, 0x00, 0x78, 0x1F,
  0xE0, 0x3C, 0x07, 0xFC, 0x0E, 0x03, 0xCF, 0x07, 0x80, 0xF1, 0xC1, 0xC0,
  0x3C, 0x70, 0xF0, 0x0F, 0x1C, 0x38, 0x03, 0xC7, 0x1E, 0x00, 0xF1, 0xCF,
  0x08, 0x3C, 0xF3, 0xDF, 0xC7, 0xFD, 0xE7, 0xF9, 0xFE, 0x73, 0xDE, 0x3F,
  0x3C, 0xE3, 0xC0, 0x0E, 0x38, 0xF0, 0x07, 0x9E, 0x3C, 0x01, 0xC7, 0x8F,
  0x00, 0xF0, 0xE3, 0xC0, 0x78, 0x38, 0xF0, 0x1E, 0x0F, 0x3C, 0x0F, 0x03,
  0xFE, 0x03, 0x80, 0x7F, 0x81, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8,
  0x03, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x0F, 0x8F, 0xF8, 0x3E, 0x7F, 0xF0, 0xF9, 0xF3, 0xE7, 0xCF, 0x87,
  0xFF, 0x3E, 0x0F, 0xF8, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x87, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3C, 0x3C,
  0x3E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x08, 0x38, 0x3E, 0x73, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xF7, 0x83, 0xCF, 0x87,
  0x8E, 0x02, 0x18, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7D, 0xF7, 0x9E,
  0x79, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x80, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x3E, 0x78, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x3F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xE0, 0xFC, 0x3F, 0x9F,
  0xF7, 0xFF, 0xFF, 0xDC, 0xFB, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7E, 0xFE, 0x30, 0x3E,
  0x20, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF1,
  0xFF, 0xF9, 0xFF, 0xF3, 0xE7, 0xF2, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0xE7, 0xFF, 0xFF, 0xEF,
  0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C,
  0x3C, 0x7C, 0x78, 0x7C, 0x78, 0x7C, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0x84, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFB, 0xF8, 0xF7, 0xFC, 0xFF,
  0xFE, 0xFE, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x78, 0x3E, 0x7C, 0x7C, 0x3F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3E, 0xFC, 0x7C, 0x7E, 0xF8,
  0x1E, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7E, 0xFC, 0xF8,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xDE, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x23, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0xF7,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xF8, 0x79, 0xF7,
  0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDE, 0x79, 0xEF,
  0x3C, 0xF0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x03, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x40, 0x00, 0x3F, 0xF3, 0xFF,
  0xE7, 0xFF, 0xDF, 0x3F, 0x20, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07,
  0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x30, 0x38, 0xF0, 0xFF, 0x9E, 0xF1, 0xFF,
  0xC7, 0x78, 0xF1, 0xE3, 0xB8, 0xF0, 0xF1, 0xDC, 0x70, 0x78, 0xFE, 0x38,
  0x3C, 0x7F, 0x1C, 0x1E, 0x3F, 0x8E, 0x0F, 0x1D, 0xC7, 0x07, 0x9E, 0xE3,
  0xC7, 0xCE, 0x70, 0xFF, 0xFF, 0x3C, 0x3F, 0x3F, 0x0E, 0x06, 0x04, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x01, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xE0,
  0x07, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE1, 0xE0, 0x1E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00,
  0x7C, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF,
  0xFC, 0xF0, 0xFE, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0x07,
  0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x13, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x3F, 0xBC, 0x07, 0xEF, 0x00, 0xFB,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0xF0, 0x1F, 0xBC, 0x0F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFF, 0xBE, 0x7F, 0x00, 0x9F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x81, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xBF, 0xFF, 0xBF, 0xDF, 0x86, 0x00,
  0xF0, 0x0F, 0xFC, 0x07, 0xCF, 0x03, 0xE3, 0xC1, 0xF8, 0xF0, 0x7C, 0x3C,
  0x3E, 0x0F, 0x1F, 0x03, 0xCF, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x7C, 0x0F, 0x0F, 0x83, 0xC3, 0xE0,
  0xF0, 0x7C, 0x3C, 0x1F, 0x8F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x1F, 0xBC,
  0x03, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFB, 0xC0,
  0xEF, 0xF7, 0x83, 0xDF, 0xEF, 0x07, 0xBF, 0xCE, 0x0E, 0x7F, 0x9E, 0x3C,
  0xFF, 0x3C, 0x79, 0xFE, 0x38, 0xE3, 0xFC, 0x7B, 0xC7, 0xF8, 0xF7, 0x8F,
  0xF1, 0xEE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xE0, 0xFF,
  0x07, 0xC1, 0xFE, 0x0F, 0x83, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFD, 0xF0, 0x7F, 0xBE,
  0x0F, 0xF3, 0xE1, 0xFE, 0x7C, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF, 0x0F,
  0x9F, 0xE0, 0xFB, 0xFC, 0x1F, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7, 0xE0, 0x3E,
  0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xDF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xF0, 0x3F, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE1, 0xFF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xBF, 0xC7, 0xE0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x80, 0x3E, 0x7C, 0x03, 0xF3,
  0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03,
  0xE7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3E, 0x78, 0x7E, 0x3F,
  0xFF, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x0F, 0x9E, 0x07, 0xEF, 0x01, 0xF7, 0x80,
  0x7C, 0x0F, 0xF8, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0x8F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC,
  0x3F, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01,
  0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0,
  0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x9F, 0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x3F, 0x01, 0xF7, 0x80, 0xFC, 0x07, 0x9E,
  0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0, 0x7F, 0x83, 0xE3, 0xC1,
  0xFE, 0x0F, 0x0F, 0x07, 0xF8, 0x3C, 0x3E, 0x1C, 0xE1, 0xF0, 0xF8, 0xF3,
  0xC7, 0xC1, 0xE3, 0xCF, 0x1E, 0x07, 0x8F, 0x3C, 0x78, 0x1F, 0x78, 0x73,
  0xE0, 0x7D, 0xE1, 0xEF, 0x80, 0xF7, 0x87, 0xBC, 0x03, 0xDE, 0x1E, 0xF0,
  0x0F, 0x70, 0x3B, 0xC0, 0x3D, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C,
  0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0xF8,
  0x07, 0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x3F, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xEF,
  0x80, 0xFD, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3E, 0x03,
  0xC7, 0xC0, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0xFF, 0xFF,
  0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0x80,
  0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xF0, 0x1E, 0x70,
  0x1C, 0x78, 0x3C, 0x38, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3E, 0x0F, 0x81, 0xE0, 0x78,
  0x0F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0xE1, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x3F, 0x8F, 0xFF, 0x3F, 0xFE, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x8F, 0xDF, 0xFF, 0xBF, 0xE7, 0x3F, 0x8E, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8,
  0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xF3, 0xF8, 0x07, 0xF8, 0x7F, 0xF3,
  0xFF, 0xCF, 0xFE, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x05, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xCF, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x78, 0x0F, 0x7C, 0x0F, 0x7C, 0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x1F, 0xEF,
  0x0F, 0xC7, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1F,
  0x7C, 0x0F, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x03, 0xE0, 0xFF, 0x1F, 0xF3, 0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x0F, 0xCF, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0x7F, 0x7C, 0x1F, 0x7C, 0x0F,
  0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C, 0x0F,
  0x7C, 0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F,
  0x00, 0x1F, 0x40, 0x1F, 0x78, 0x7F, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x37, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF3, 0xFF, 0xF7,
  0xFB, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xF8, 0x3F, 0x7C, 0x3F, 0x3E,
  0x3F, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xDF, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xE7, 0xC1,
  0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x7F, 0x3D,
  0xFF, 0x3F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x07,
  0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1E,
  0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0xF8,
  0x1E, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF8, 0x1E, 0x07, 0xC0, 0xF1, 0xF8, 0xF7, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xE7, 0xE7, 0xC1,
  0xF3, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE,
  0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xF1, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0xF1, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB,
  0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0xCF, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0x7F, 0x7C,
  0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78,
  0x0F, 0x7C, 0x0F, 0x7C, 0x1F, 0x7F, 0x7F, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F,
  0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xE1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0xDF, 0xFC, 0xF0, 0x6F, 0x80, 0x7E,
  0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x0E, 0x03, 0xC0, 0x78, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE4, 0xFF, 0x8F, 0xF0, 0xFE,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFE, 0xFF, 0x7F, 0xFF, 0x7F, 0xEF, 0x1F, 0xCF, 0xF8, 0x07,
  0xDE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0x78, 0xF8, 0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x03, 0xDE, 0x0F, 0xC1, 0xF7, 0xC3, 0xF0, 0x7D, 0xF0,
  0xFE, 0x1E, 0x3C, 0x3F, 0x8F, 0x8F, 0x1E, 0xE3, 0xE3, 0xE7, 0xB8, 0xF0,
  0xF9, 0xCF, 0x3C, 0x1E, 0x73, 0xDF, 0x07, 0xBC, 0x77, 0xC1, 0xEF, 0x1D,
  0xE0, 0x3F, 0x87, 0x78, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xDF,
  0x87, 0xE3, 0xE1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xE1, 0xF1, 0xF0, 0x3E, 0xFC, 0x0F, 0xC0,
  0xF8, 0x07, 0xDE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F,
  0x87, 0xC1, 0xE1, 0xE0, 0x78, 0xF8, 0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xF7,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x4F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0xFC, 0x1F, 0x87, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x3F, 0x8F, 0xE1, 0xF0, 0x3F, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7F, 0x07, 0xE0, 0xFC, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0xE0, 0xFE, 0x07, 0xC3, 0xF8, 0xFC, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x87, 0xF0, 0xFE, 0x1F, 0x83,
  0xC0, 0x00, 0x00, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0x06, 0x00,
};

const GFXglyph NotoSans_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 22, 9, 2, -22 },
  { 15, 11, 8, 15, 2, -22 },
  { 26, 18, 22, 20, 1, -22 },
  { 76, 16, 26, 18, 1, -24 },
  { 128, 26, 22, 28, 1, -22 },
  { 200, 22, 22, 23, 1, -22 },
  { 261, 4, 8, 8, 2, -22 },
  { 265, 9, 27, 11, 1, -22 },
  { 296, 8, 27, 11, 1, -22 },
  { 323, 15, 15, 17, 1, -24 },
  { 352, 15, 15, 18, 1, -18 },
  { 381, 6, 8, 9, 1, -4 },
  { 387, 8, 4, 10, 1, -10 },
  { 391, 5, 5, 9, 2, -5 },
  { 395, 13, 22, 13, 0, -22 },
  { 431, 16, 22, 18, 1, -22 },
  { 475, 11, 22, 18, 2, -22 },
  { 506, 16, 22, 18, 1, -22 },
  { 550, 15, 22, 18, 1, -22 },
  { 592, 16, 22, 18, 1, -22 },
  { 636, 14, 22, 18, 2, -22 },
  { 675, 16, 22, 18, 1, -22 },
  { 719, 16, 22, 18, 1, -22 },
  { 763, 16, 22, 18, 1, -22 },
  { 807, 16, 22, 18, 1, -22 },
  { 851, 5, 17, 9, 2, -17 },
  { 862, 6, 21, 9, 1, -17 },
  { 878, 15, 16, 18, 1, -19 },
  { 908, 15, 10, 18, 1, -16 },
  { 927, 15, 16, 18, 1, -19 },
  { 957, 14, 22, 15, 0, -22 },
  { 996, 25, 24, 28, 1, -22 },
  { 1071, 21, 22, 21, 0, -22 },
  { 1129, 16, 22, 21, 3, -22 },
  { 1173, 17, 22, 20, 2, -22 },
  { 1220, 18, 22, 23, 3, -22 },
  { 1270, 13, 22, 17, 3, -22 },
  { 1306, 12, 22, 17, 3, -22 },
  { 1339, 18, 22, 22, 2, -22 },
  { 1389, 18, 22, 24, 3, -22 },
  { 1439, 10, 22, 12, 1, -22 },
  { 1467, 9, 29, 10, -2, -22 },
  { 1500, 18, 22, 21, 3, -22 },
  { 1550, 13, 22, 17, 3, -22 },
  { 1586, 23, 22, 29, 3, -22 },
  { 1650, 19, 22, 25, 3, -22 },
  { 1703, 21, 22, 25, 2, -22 },
  { 1761, 15, 22, 19, 3, -22 },
  { 1803, 21, 27, 25, 2, -22 },
  { 1874, 17, 22, 20, 3, -22 },
  { 1921, 15, 22, 17, 1, -22 },
  { 1963, 16, 22, 18, 1, -22 },
  { 2007, 18, 22, 23, 3, -22 },
  { 2057, 20, 22, 20, 0, -22 },
  { 2112, 30, 22, 30, 0, -22 },
  { 2195, 21, 22, 21, 0, -22 },
  { 2253, 19, 22, 19, 0, -22 },
  { 2306, 16, 22, 18, 1, -22 },
  { 2350, 7, 27, 10, 2, -22 },
  { 2374, 13, 22, 13, 0, -22 },
  { 2410, 7, 27, 10, 1, -22 },
  { 2434, 16, 14, 18, 1, -22 },
  { 2462, 13, 2, 13, 0, 3 },
  { 2466, 9, 5, 11, 1, -24 },
  { 2472, 15, 17, 19, 1, -17 },
  { 2504, 16, 24, 20, 2, -24 },
  { 2552, 14, 17, 16, 1, -17 },
  { 2582, 16, 24, 20, 1, -24 },
  { 2630, 16, 17, 19, 1, -17 },
  { 2664, 12, 24, 12, 1, -24 },
  { 2700, 16, 24, 20, 1, -17 },
  { 2748, 16, 24, 20, 2, -24 },
  { 2796, 5, 24, 9, 2, -24 },
  { 2811, 9, 31, 9, -2, -24 },
  { 2846, 17, 24, 19, 2, -24 },
  { 2897, 5, 24, 9, 2, -24 },
  { 2912, 26, 17, 30, 2, -17 },
  { 2968, 16, 17, 20, 2, -17 },
  { 3002, 17, 17, 19, 1, -17 },
  { 3039, 16, 24, 20, 2, -17 },
  { 3087, 16, 24, 20, 1, -17 },
  { 3135, 11, 17, 14, 2, -17 },
  { 3159, 13, 17, 16, 1, -17 },
  { 3187, 11, 21, 13, 1, -21 },
  { 3216, 16, 17, 20, 2, -17 },
  { 3250, 18, 17, 18, 0, -17 },
  { 3289, 26, 17, 27, 0, -17 },
  { 3345, 18, 17, 18, 0, -17 },
  { 3384, 18, 24, 18, 0, -17 },
  { 3438, 13, 17, 15, 1, -17 },
  { 3466, 11, 27, 12, 0, -22 },
  { 3504, 3, 30, 17, 7, -23 },
  { 3516, 11, 27, 12, 1, -22 },
  { 3554, 15, 6, 18, 1, -14 },
};

const GFXfont NotoSans_Bold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold31pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_BOLD31PT7B_H_
