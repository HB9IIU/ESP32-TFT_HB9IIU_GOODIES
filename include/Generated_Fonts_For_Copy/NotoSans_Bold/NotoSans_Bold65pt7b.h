#ifndef _NOTOSANS_BOLD65PT7B_H_
#define _NOTOSANS_BOLD65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFC, 0xFF, 0x07, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xDF,
  0xE0, 0xFF, 0xBF, 0xC1, 0xFF, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFE,
  0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xDF, 0xF8, 0xFF, 0xC7,
  0xC0, 0xF0, 0xFF, 0xC7, 0xC0, 0x10, 0xFF, 0x87, 0xC0, 0x00, 0xFF, 0x87,
  0xC0, 0x00, 0xFF, 0xC7, 0xC0, 0x00, 0xFF, 0xE7, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xDF, 0xFE, 0x00, 0x07, 0xC7, 0xFE, 0x00, 0x07, 0xC3, 0xFF, 0x00, 0x07,
  0xC3, 0xFF, 0x80, 0x07, 0xC3, 0xFF, 0xE0, 0x07, 0xC3, 0xFE, 0xFC, 0x07,
  0xC7, 0xFE, 0xFF, 0xC7, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0x40,
  0x07, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0x87, 0xF8,
  0x7F, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xF3, 0xFE,
  0x3F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF0, 0x3F, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xC7, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x9F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x60, 0x0F, 0xE0, 0x0C, 0xF8,
  0x1F, 0xC0, 0xF9, 0xFF, 0x1F, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x0F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F, 0xEF, 0xF0,
  0xFF, 0xCF, 0xC1, 0xFF, 0x8F, 0x03, 0xFF, 0x0C, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xF0, 0x07, 0xFF, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0xE0, 0x00, 0x7F, 0xE0,
  0x40, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x1F,
  0xFE, 0x07, 0x80, 0x07, 0xFF, 0x01, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF6, 0x00, 0x00, 0x3F,
  0xFB, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0x01, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE3, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xC3, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xDF, 0x00, 0x07, 0xFF, 0xBF, 0xF0, 0x7F, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF1, 0xFF,
  0xF8, 0x0F, 0xF9, 0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0x83, 0xFD, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0x80, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x3F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0x9F,
  0xE0, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x0F, 0xF8, 0x00, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x0F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF,
  0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x3F, 0xCF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x3F,
  0xC1, 0xE0, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0xFF, 0xE7, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x0F, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0,
  0x3F, 0xF8, 0x78, 0x00, 0x7F, 0xE0, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFC, 0x1F,
  0xE0, 0x1F, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0xFE,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0xFE, 0x03, 0xFC, 0x07,
  0xFE, 0x1F, 0xCF, 0xF0, 0x3F, 0xE1, 0xFF, 0xE3, 0xFC, 0x7F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x80,
  0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0xE0, 0x00,
  0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x00,
  0xFF, 0xFB, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xE0, 0x03, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF0, 0x00, 0x78, 0x1F, 0xFE, 0x00, 0x01,
  0x83, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0C, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0xE3, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x00, 0x7F,
  0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xE0,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x03, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xF3,
  0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFF, 0x3F, 0xE0, 0x00,
  0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0x81, 0xFF, 0xF0, 0x00, 0x02,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFF, 0x3F,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xF8, 0x00,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x01,
  0xFF, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xDF, 0xFF,
  0xEF, 0xF0, 0x00, 0x1F, 0xEF, 0xFF, 0xF7, 0xF8, 0x00, 0x0F, 0xF7, 0xFF,
  0xFB, 0xFE, 0x00, 0x0F, 0xF3, 0xFF, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFF,
  0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFF, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF,
  0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x7F, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0x8F,
  0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3,
  0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x7F,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xDF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x3F, 0xF3,
  0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80,
  0x0F, 0xFE, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xEF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0x80,
  0x03, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xF1,
  0xFF, 0xC0, 0x07, 0x87, 0xFE, 0x00, 0x02, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xA0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF8,
  0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF1, 0xFF, 0xF0, 0x07, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xEF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF,
  0x9F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xEF,
  0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00,
  0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x0F, 0xFF, 0x03, 0x80, 0x0F, 0xFE, 0x04, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0x7F, 0xFF, 0xF9, 0xFE, 0x7F, 0xFF, 0xE1, 0xFC, 0x7F, 0xFF, 0x83,
  0xF8, 0x3F, 0xFC, 0x07, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xFF, 0x01, 0xFF,
  0x1F, 0xFF, 0xC0, 0xFF, 0x9F, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x80,
  0x0F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0xC1, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x01, 0xC1, 0xFF, 0xC0, 0x02,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x04, 0x7F, 0xF8, 0x01, 0xE3, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x07,
  0xFC, 0x07, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xFC,
  0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF,
  0x7F, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xF7,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x81, 0x80, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x3F,
  0xC0, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xEF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x90, 0x00, 0x01, 0xFF, 0xCF, 0x00, 0x01,
  0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF,
  0xFC, 0x7F, 0xDF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xC0,
  0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB,
  0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF,
  0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE0, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x87, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F,
  0xCF, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0xFF, 0xC0, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x83, 0xFF,
  0xF0, 0x3F, 0xC3, 0xFF, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xE0,
  0x3F, 0xC3, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF8, 0x0F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x7F,
  0xF0, 0x01, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xCF, 0xFF, 0xF8,
  0x3F, 0xE3, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xC0,
  0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xEF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xF8, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF,
  0xE0, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFE, 0x7F, 0xC0,
  0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF0, 0x00, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFE, 0x00,
  0xF8, 0xFF, 0x80, 0x03, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xD0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x30, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xDF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0x7F, 0x80, 0xFF, 0x81, 0xFF,
  0x01, 0xFC, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF3, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFF, 0x00, 0xFF, 0x83, 0xF8, 0x7F, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xE1,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x80, 0x1F, 0xF1,
  0xFC, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xF0, 0x3F, 0x9F, 0xF8, 0x01,
  0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x03, 0xF9, 0xFF,
  0x00, 0x0F, 0xFB, 0xF8, 0x0F, 0xE7, 0xFC, 0x00, 0x3F, 0xEF, 0xE0, 0x1F,
  0x9F, 0xE0, 0x00, 0xFF, 0xBF, 0x80, 0x7F, 0x7F, 0x80, 0x01, 0xFE, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xEF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x02, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFD, 0x00, 0x00, 0xFF, 0xE2,
  0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Bold65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 11, 47, 18, 4, -46 },
  { 66, 23, 16, 31, 4, -46 },
  { 112, 40, 46, 42, 1, -46 },
  { 342, 32, 53, 37, 3, -49 },
  { 554, 55, 48, 59, 2, -47 },
  { 884, 46, 48, 49, 3, -47 },
  { 1160, 9, 16, 17, 4, -46 },
  { 1178, 17, 56, 22, 3, -46 },
  { 1297, 17, 56, 22, 2, -46 },
  { 1416, 31, 30, 35, 2, -49 },
  { 1533, 31, 32, 37, 3, -39 },
  { 1657, 13, 16, 19, 2, -8 },
  { 1683, 17, 8, 21, 2, -21 },
  { 1700, 11, 11, 18, 4, -10 },
  { 1716, 27, 47, 27, 0, -47 },
  { 1875, 33, 48, 37, 2, -47 },
  { 2073, 23, 46, 37, 4, -46 },
  { 2206, 33, 47, 37, 2, -47 },
  { 2400, 33, 48, 37, 2, -47 },
  { 2598, 35, 46, 37, 1, -46 },
  { 2800, 31, 47, 37, 3, -46 },
  { 2983, 33, 48, 37, 2, -47 },
  { 3181, 33, 46, 37, 2, -46 },
  { 3371, 33, 48, 37, 2, -47 },
  { 3569, 33, 48, 37, 2, -47 },
  { 3767, 11, 37, 18, 4, -36 },
  { 3818, 13, 44, 19, 2, -36 },
  { 3890, 31, 35, 37, 3, -41 },
  { 4026, 31, 20, 37, 3, -33 },
  { 4104, 31, 35, 37, 3, -41 },
  { 4240, 30, 48, 31, 0, -47 },
  { 4420, 52, 52, 58, 3, -47 },
  { 4758, 45, 47, 45, 0, -47 },
  { 5023, 34, 46, 43, 6, -46 },
  { 5219, 36, 48, 42, 4, -47 },
  { 5435, 38, 46, 48, 6, -46 },
  { 5654, 27, 46, 36, 6, -46 },
  { 5810, 26, 46, 36, 6, -46 },
  { 5960, 38, 48, 47, 4, -47 },
  { 6188, 38, 46, 50, 6, -46 },
  { 6407, 21, 46, 25, 2, -46 },
  { 6528, 21, 60, 22, -5, -46 },
  { 6686, 37, 46, 43, 6, -46 },
  { 6899, 28, 46, 36, 6, -46 },
  { 7060, 49, 46, 61, 6, -46 },
  { 7342, 41, 46, 53, 6, -46 },
  { 7578, 44, 48, 51, 4, -47 },
  { 7842, 32, 46, 40, 6, -46 },
  { 8026, 44, 58, 51, 4, -47 },
  { 8345, 37, 46, 43, 6, -46 },
  { 8558, 30, 48, 36, 3, -47 },
  { 8738, 35, 46, 38, 1, -46 },
  { 8940, 38, 47, 49, 6, -46 },
  { 9164, 42, 46, 42, 0, -46 },
  { 9406, 63, 46, 63, 0, -46 },
  { 9769, 43, 46, 44, 0, -46 },
  { 10017, 41, 46, 41, 0, -46 },
  { 10253, 34, 46, 38, 2, -46 },
  { 10449, 15, 56, 22, 5, -46 },
  { 10554, 27, 47, 27, 0, -47 },
  { 10713, 15, 56, 22, 2, -46 },
  { 10818, 35, 30, 37, 1, -47 },
  { 10950, 27, 4, 27, 0, 6 },
  { 10964, 18, 11, 24, 3, -50 },
  { 10989, 31, 37, 39, 3, -36 },
  { 11133, 33, 50, 41, 5, -49 },
  { 11340, 29, 37, 34, 3, -36 },
  { 11475, 33, 50, 41, 3, -49 },
  { 11682, 33, 37, 39, 3, -36 },
  { 11835, 27, 50, 25, 1, -50 },
  { 12004, 33, 52, 41, 3, -36 },
  { 12219, 33, 49, 42, 5, -49 },
  { 12422, 11, 49, 19, 4, -49 },
  { 12490, 18, 65, 19, -3, -49 },
  { 12637, 35, 49, 40, 5, -49 },
  { 12852, 10, 49, 19, 5, -49 },
  { 12914, 54, 36, 63, 5, -36 },
  { 13157, 33, 36, 42, 5, -36 },
  { 13306, 35, 37, 41, 3, -36 },
  { 13468, 33, 52, 41, 5, -36 },
  { 13683, 33, 52, 41, 3, -36 },
  { 13898, 23, 36, 29, 5, -36 },
  { 14002, 27, 37, 33, 3, -36 },
  { 14127, 25, 44, 28, 1, -43 },
  { 14265, 32, 36, 42, 5, -35 },
  { 14409, 37, 35, 37, 0, -35 },
  { 14571, 54, 35, 56, 1, -35 },
  { 14808, 37, 35, 38, 0, -35 },
  { 14970, 37, 51, 37, 0, -35 },
  { 15206, 28, 35, 32, 2, -35 },
  { 15329, 22, 56, 26, 1, -46 },
  { 15483, 7, 64, 36, 14, -49 },
  { 15539, 22, 56, 26, 3, -46 },
  { 15693, 31, 11, 37, 3, -28 },
};

const GFXfont NotoSans_Bold65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold65pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_BOLD65PT7B_H_
