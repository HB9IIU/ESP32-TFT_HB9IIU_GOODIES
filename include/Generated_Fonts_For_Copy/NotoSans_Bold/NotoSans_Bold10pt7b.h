#ifndef _NOTOSANS_BOLD10PT7B_H_
#define _NOTOSANS_BOLD10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xB4, 0x28, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x23, 0xFA, 0xC3,
  0x97, 0xE6, 0x20, 0x62, 0x7A, 0x3F, 0x0D, 0x61, 0x68, 0xBC, 0x8C, 0x78,
  0x48, 0x78, 0x72, 0xDE, 0xCC, 0x7F, 0xC0, 0x69, 0x6D, 0x92, 0x20, 0xCD,
  0x92, 0x5A, 0xC0, 0x21, 0x3E, 0x65, 0x80, 0x21, 0x3E, 0x42, 0x00, 0x70,
  0xE0, 0xC0, 0x32, 0x26, 0x44, 0xC0, 0x7A, 0x73, 0x9C, 0xA5, 0xC0, 0x7E,
  0x92, 0x48, 0xFA, 0x42, 0x23, 0x23, 0xE0, 0xFA, 0x46, 0xE0, 0xC7, 0xE0,
  0x18, 0xE3, 0x96, 0xFF, 0xF1, 0x80, 0x7A, 0x1C, 0xF0, 0xCF, 0xC0, 0x3A,
  0x35, 0xFC, 0xA5, 0xE0, 0xF8, 0x46, 0x23, 0x11, 0x80, 0x7A, 0x5E, 0xEC,
  0xE5, 0xE0, 0x7E, 0x72, 0xF2, 0x8D, 0xC0, 0xCC, 0x50, 0x1C, 0x09, 0xB0,
  0x60, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0xEC, 0x00, 0xF0, 0xC4, 0x46, 0x11,
  0x80, 0x3E, 0x30, 0x97, 0x4E, 0xBF, 0x52, 0xD9, 0x88, 0x38, 0x38, 0x50,
  0xA3, 0x67, 0xC8, 0xB1, 0x80, 0xFC, 0xE7, 0xE8, 0xCF, 0xC0, 0x7E, 0x21,
  0x08, 0x65, 0xE0, 0xFA, 0x28, 0xE3, 0x8E, 0x6F, 0x00, 0xF8, 0x8F, 0x88,
  0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x7E, 0x21, 0x38, 0xE5, 0xE0, 0x8E, 0x38,
  0xFF, 0x8E, 0x38, 0xC0, 0xF6, 0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0xE0,
  0x9E, 0x4B, 0x38, 0xB2, 0x68, 0xC0, 0x88, 0x88, 0x88, 0xF0, 0xC7, 0xC7,
  0xA7, 0xAB, 0xAB, 0xBB, 0x93, 0xC7, 0x9A, 0x6D, 0x96, 0x78, 0xC0, 0x7B,
  0x38, 0x61, 0x87, 0x37, 0x80, 0xF4, 0xE7, 0xE8, 0x42, 0x00, 0x7B, 0x38,
  0x61, 0x87, 0x37, 0x86, 0x0C, 0xF2, 0x69, 0xBC, 0xB2, 0x68, 0xC0, 0x7A,
  0x18, 0xE1, 0xC7, 0xC0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x8E, 0x38,
  0xE3, 0x8F, 0x37, 0x80, 0xC6, 0x99, 0x33, 0x42, 0x87, 0x0C, 0x00, 0xCC,
  0xF3, 0x25, 0xC9, 0x56, 0x77, 0x1C, 0xC3, 0x30, 0xCC, 0xD0, 0xE1, 0x83,
  0x8D, 0xB1, 0x80, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x00, 0xF8, 0x61, 0x0C,
  0x61, 0x0F, 0xC0, 0xEA, 0xAA, 0xC0, 0xC4, 0x46, 0x23, 0x10, 0xED, 0xB6,
  0xDB, 0xE0, 0x21, 0x95, 0x90, 0xF0, 0xC4, 0x33, 0xC2, 0xFC, 0xBC, 0x84,
  0x29, 0xE9, 0xCE, 0x7E, 0x13, 0xD1, 0x84, 0xBC, 0x0C, 0x32, 0xDF, 0x4F,
  0x34, 0xDF, 0x31, 0xE4, 0xBF, 0x41, 0xE0, 0x37, 0x6F, 0x66, 0x66, 0x21,
  0xF4, 0xF3, 0x4D, 0xF0, 0xDE, 0x84, 0x29, 0xF9, 0xCE, 0x73, 0xDF, 0x24,
  0x12, 0x49, 0x3C, 0x84, 0x23, 0x2A, 0x72, 0xD3, 0xFF, 0x22, 0xFF, 0x99,
  0x99, 0x99, 0x99, 0x27, 0xE7, 0x39, 0xCC, 0x31, 0xE4, 0xF3, 0x4D, 0xE0,
  0x27, 0xE7, 0x39, 0xFA, 0x10, 0x21, 0xF4, 0xF3, 0x4D, 0xF0, 0xC3, 0x3E,
  0x49, 0x00, 0x2B, 0xB8, 0x61, 0xF8, 0x44, 0xF4, 0x44, 0x70, 0x9C, 0xE7,
  0x3F, 0x80, 0xCD, 0x67, 0x8C, 0x30, 0xD9, 0x5F, 0x57, 0x56, 0x26, 0xDD,
  0xC3, 0x1E, 0xCC, 0xCD, 0x27, 0x8C, 0x30, 0x8E, 0x00, 0xF9, 0x98, 0x8F,
  0x80, 0x36, 0x66, 0xC6, 0x67, 0x30, 0xFF, 0xC0, 0xC6, 0x66, 0x36, 0x6E,
  0x80, 0xF8,
};

const GFXglyph NotoSans_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 5, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 5, 9, 6, 0, -8 },
  { 15, 9, 7, 9, 0, -7 },
  { 23, 8, 7, 8, 0, -7 },
  { 30, 1, 2, 3, 1, -7 },
  { 31, 3, 9, 3, 0, -7 },
  { 35, 3, 9, 3, 0, -7 },
  { 39, 5, 5, 5, 0, -8 },
  { 43, 5, 5, 6, 0, -6 },
  { 47, 2, 2, 3, 0, -1 },
  { 48, 3, 1, 3, 0, -3 },
  { 49, 1, 2, 3, 1, -2 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 5, 7, 6, 0, -7 },
  { 59, 3, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 6, 7, 6, 0, -7 },
  { 78, 5, 7, 6, 0, -7 },
  { 83, 5, 7, 6, 0, -7 },
  { 88, 5, 7, 6, 0, -7 },
  { 93, 5, 7, 6, 0, -7 },
  { 98, 5, 7, 6, 0, -7 },
  { 103, 1, 6, 3, 1, -6 },
  { 104, 2, 7, 3, 0, -6 },
  { 106, 5, 5, 6, 0, -6 },
  { 110, 5, 3, 6, 0, -5 },
  { 112, 5, 5, 6, 0, -6 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 9, 8, 9, 0, -7 },
  { 130, 7, 7, 7, 0, -7 },
  { 137, 5, 7, 7, 1, -7 },
  { 142, 5, 7, 6, 1, -7 },
  { 147, 6, 7, 7, 1, -7 },
  { 153, 4, 7, 6, 1, -7 },
  { 157, 4, 7, 5, 1, -7 },
  { 161, 5, 7, 7, 1, -7 },
  { 166, 6, 7, 8, 1, -7 },
  { 172, 4, 7, 4, 0, -7 },
  { 176, 3, 9, 3, -1, -7 },
  { 180, 6, 7, 7, 1, -7 },
  { 186, 4, 7, 6, 1, -7 },
  { 190, 8, 7, 9, 1, -7 },
  { 197, 6, 7, 8, 1, -7 },
  { 203, 6, 7, 8, 1, -7 },
  { 209, 5, 7, 6, 1, -7 },
  { 214, 6, 9, 8, 1, -7 },
  { 221, 6, 7, 7, 1, -7 },
  { 227, 5, 7, 6, 0, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 6, 7, 8, 1, -7 },
  { 244, 7, 7, 7, 0, -7 },
  { 251, 10, 7, 10, 0, -7 },
  { 260, 7, 7, 7, 0, -7 },
  { 267, 6, 7, 6, 0, -7 },
  { 273, 6, 7, 6, 0, -7 },
  { 279, 2, 9, 3, 1, -7 },
  { 282, 4, 7, 4, 0, -7 },
  { 286, 3, 9, 3, 0, -7 },
  { 290, 5, 4, 6, 0, -7 },
  { 293, 4, 1, 4, 0, 1 },
  { 294, 3, 2, 4, 0, -8 },
  { 295, 5, 6, 6, 0, -6 },
  { 299, 5, 8, 6, 1, -8 },
  { 304, 5, 6, 5, 0, -6 },
  { 308, 6, 8, 6, 0, -8 },
  { 314, 6, 6, 6, 0, -6 },
  { 319, 4, 8, 4, 0, -8 },
  { 323, 6, 8, 6, 0, -6 },
  { 329, 5, 8, 7, 1, -8 },
  { 334, 1, 8, 3, 1, -8 },
  { 335, 3, 10, 3, -1, -8 },
  { 339, 5, 8, 6, 1, -8 },
  { 344, 1, 8, 3, 1, -8 },
  { 345, 8, 6, 10, 1, -6 },
  { 351, 5, 6, 7, 1, -6 },
  { 355, 6, 6, 6, 0, -6 },
  { 360, 5, 8, 6, 1, -6 },
  { 365, 6, 8, 6, 0, -6 },
  { 371, 3, 6, 4, 1, -6 },
  { 374, 5, 6, 5, 0, -6 },
  { 378, 4, 7, 4, 0, -7 },
  { 382, 5, 5, 7, 1, -5 },
  { 386, 6, 5, 6, 0, -5 },
  { 390, 8, 5, 9, 0, -5 },
  { 395, 6, 5, 6, 0, -5 },
  { 399, 6, 7, 6, 0, -5 },
  { 405, 5, 5, 5, 0, -5 },
  { 409, 4, 9, 4, 0, -7 },
  { 414, 1, 10, 6, 2, -8 },
  { 416, 4, 9, 4, 0, -7 },
  { 421, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_Bold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold10pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_BOLD10PT7B_H_
