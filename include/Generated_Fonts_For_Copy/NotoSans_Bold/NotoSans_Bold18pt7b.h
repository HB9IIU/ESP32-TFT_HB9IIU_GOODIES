#ifndef _NOTOSANS_BOLD18PT7B_H_
#define _NOTOSANS_BOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0xEF, 0xDB, 0xB6, 0x6C, 0xC0, 0x0C,
  0xC1, 0x98, 0x36, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xD8, 0xFF, 0xE6,
  0x60, 0xCC, 0x19, 0x83, 0x60, 0x08, 0x04, 0x1F, 0xDF, 0xEC, 0x97, 0x43,
  0xE0, 0xFC, 0x0F, 0x05, 0xE2, 0xFF, 0xEF, 0xE0, 0x40, 0x20, 0x70, 0x71,
  0xF0, 0xC3, 0x73, 0x06, 0x66, 0x0C, 0xD8, 0x1B, 0xB7, 0x3E, 0xDF, 0x39,
  0xB7, 0x06, 0x66, 0x1C, 0xCC, 0x31, 0xB8, 0xC3, 0xE3, 0x83, 0xC0, 0x3E,
  0x03, 0xF8, 0x18, 0xC0, 0xC6, 0x07, 0x70, 0x1F, 0x01, 0xF1, 0xDF, 0xCE,
  0xE7, 0xE7, 0x1F, 0x38, 0xF1, 0xFF, 0xC7, 0xE7, 0x80, 0xFF, 0xEC, 0x3B,
  0x99, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0xCE, 0x31, 0xC7, 0xCE, 0x67, 0x33,
  0x33, 0x33, 0x33, 0x76, 0xEC, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3C, 0x7C,
  0x66, 0x24, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18,
  0x00, 0xFF, 0x60, 0xFF, 0xC0, 0x7F, 0x80, 0x06, 0x1C, 0x30, 0x61, 0xC3,
  0x06, 0x1C, 0x30, 0xE1, 0xC3, 0x0E, 0x00, 0x3C, 0x3F, 0x39, 0xDC, 0x6C,
  0x36, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xB9, 0xCF, 0xE3, 0xE0, 0x0C, 0xF7,
  0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3E, 0x7F, 0xB9, 0xC8,
  0x60, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0x7E,
  0x7F, 0x91, 0xC0, 0x60, 0x71, 0xF0, 0xF0, 0x1E, 0x03, 0x01, 0xE1, 0xDF,
  0xEF, 0xE0, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x0E, 0xC3, 0x31, 0x8C,
  0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x7F, 0xE0, 0xE0, 0xE0,
  0xFE, 0xFF, 0x07, 0x03, 0x03, 0x87, 0xFF, 0xFC, 0x1F, 0x1F, 0x9C, 0x1C,
  0x0C, 0x06, 0xF3, 0xFD, 0xC7, 0xC3, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xFF,
  0xFF, 0xF0, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x38, 0x00, 0x3E, 0x7F, 0xB9, 0xDC, 0x6E, 0x73, 0xF0, 0xF1,
  0xFE, 0xE3, 0x61, 0xF0, 0xFF, 0xE7, 0xE0, 0x3C, 0x7F, 0x39, 0xD8, 0x6C,
  0x3E, 0x1F, 0xFE, 0xFF, 0x13, 0x01, 0x81, 0xDF, 0xCF, 0xC0, 0xFF, 0x80,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x60, 0x01, 0x83, 0xC7, 0x8F, 0x0E,
  0x07, 0xC0, 0xF8, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x79, 0xF1, 0xE0, 0x80, 0x00, 0x7E,
  0xFF, 0x47, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x18, 0x00, 0x18, 0x38, 0x38,
  0x07, 0xC0, 0x7F, 0xC3, 0x01, 0x98, 0xE3, 0xE7, 0xEF, 0x33, 0xBD, 0xCC,
  0xF6, 0x33, 0xDC, 0xCF, 0x3F, 0xFC, 0x73, 0x98, 0x00, 0x38, 0x60, 0x7F,
  0x80, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xD8, 0x1D, 0x81, 0x9C, 0x39, 0xC3,
  0x8E, 0x3F, 0xE7, 0xFE, 0x70, 0x76, 0x07, 0xE0, 0x70, 0xFE, 0x7F, 0xB1,
  0xF8, 0x7C, 0x3F, 0xFB, 0xF9, 0x8F, 0xC3, 0xE1, 0xF0, 0xFF, 0xEF, 0xE0,
  0x1F, 0x8F, 0xF7, 0x89, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x84, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0xCC, 0x7B, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x7B, 0xFC, 0xFE, 0x00, 0xFF, 0xFF,
  0x06, 0x0C, 0x1F, 0xFF, 0xE0, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x0F, 0xE7,
  0xF9, 0xE1, 0x38, 0x0E, 0x01, 0xC0, 0x39, 0xFF, 0x3F, 0xE0, 0xFC, 0x1D,
  0xC3, 0x9F, 0xF1, 0xFC, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0xFF, 0xDC, 0xE7,
  0x39, 0xCE, 0x73, 0x9D, 0xFF, 0x80, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x9F, 0xFE, 0xE0, 0xC1, 0xF0, 0xEC, 0x73, 0x38, 0xDC, 0x37,
  0x0F, 0xC3, 0xF0, 0xCE, 0x31, 0xCC, 0x73, 0x0E, 0xC1, 0xC0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x8D, 0xEC, 0x6F, 0x63, 0x7B, 0xB3, 0xCD,
  0x9E, 0x6C, 0xF3, 0xC7, 0x8E, 0x3C, 0x71, 0x80, 0xE0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x3D, 0xC7, 0xB8, 0xF3, 0x9E, 0x73, 0xC7, 0x78, 0x6F, 0x0F, 0xE0,
  0xFC, 0x1E, 0x1F, 0x83, 0xFE, 0x78, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7F, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0x80, 0xFC, 0xFF,
  0xCF, 0xC3, 0xC3, 0xC7, 0xFF, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F,
  0x83, 0xFE, 0x78, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x07, 0x78, 0xE3, 0xFE, 0x1F, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0xFC,
  0x3F, 0xCC, 0x73, 0x0E, 0xC3, 0x31, 0xCF, 0xE3, 0xF0, 0xCE, 0x31, 0xCC,
  0x73, 0x0E, 0xC3, 0xC0, 0x3E, 0x7F, 0xE2, 0xE0, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0x03, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x3D,
  0xFE, 0x3F, 0x00, 0xE0, 0x7E, 0x06, 0x60, 0xE7, 0x0E, 0x70, 0xC3, 0x1C,
  0x39, 0xC3, 0x98, 0x1B, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE1,
  0xC1, 0xF0, 0xE1, 0xD8, 0x78, 0xEC, 0x3C, 0x77, 0x36, 0x33, 0x9B, 0x38,
  0xCD, 0xDC, 0x6E, 0x6E, 0x3F, 0x36, 0x1F, 0x1B, 0x07, 0x8F, 0x83, 0xC3,
  0xC1, 0xE1, 0xC0, 0xF0, 0xF7, 0x0E, 0x39, 0xC3, 0x9C, 0x1F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x83, 0x9C, 0x39, 0xC7, 0x0E, 0xE0, 0x70, 0xE0,
  0xEE, 0x1D, 0xC7, 0x1C, 0xC3, 0xB8, 0x3E, 0x07, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7F, 0xDF, 0xF0, 0x18, 0x0E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFF, 0xE0, 0xC1, 0x83, 0x83,
  0x07, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x60, 0xFF, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x33,
  0x0C, 0xC6, 0x1B, 0x87, 0xFE, 0xE3, 0x8E, 0x3E, 0x3F, 0x90, 0xC0, 0x77,
  0xFF, 0xDF, 0x8F, 0xCF, 0xFF, 0xBD, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xEF, 0x3F, 0xEF, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1B, 0xCE, 0xFF, 0xBB,
  0xC0, 0x3F, 0x7E, 0xF2, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0x7F, 0x3E, 0x03,
  0x81, 0xC0, 0xE0, 0x73, 0xBB, 0xFF, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x77, 0xFB, 0xEC, 0x3E, 0x3F, 0xB8, 0xFC, 0x7F, 0xFF, 0xFF, 0x81, 0xC1,
  0x7F, 0x1F, 0x80, 0x0E, 0x3F, 0x3A, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0xBF, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F,
  0x8F, 0xC7, 0x7F, 0xBF, 0xC0, 0xF0, 0x7F, 0xF7, 0xF0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0xF7, 0xFF, 0xCF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0C, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x19, 0xCE, 0x03, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE1, 0xF8, 0xEE, 0x73, 0xB8, 0xFC, 0x3F, 0x8F, 0x73, 0x9C, 0xE3, 0xB8,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0x3D, 0xFF, 0xFF, 0xCF,
  0x3F, 0x1C, 0x3E, 0x38, 0x7C, 0x70, 0xF8, 0xE1, 0xF1, 0xC3, 0xE3, 0x87,
  0xC7, 0x0C, 0xEF, 0x7F, 0xFC, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x1F, 0x0F, 0x8F, 0xC7, 0x7F,
  0x1F, 0x00, 0xEF, 0x3F, 0xEF, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1B, 0xCE,
  0xFF, 0xBB, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3D, 0xBF, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0xBF, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0xCF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7F, 0xFF, 0x0F,
  0x0F, 0xC7, 0xC3, 0xC3, 0xFF, 0xF8, 0x10, 0x61, 0xFF, 0xF3, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xF8, 0xF0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x8F, 0xC7, 0x7F, 0xBE, 0xC0, 0xE1, 0xD8, 0x77, 0x19, 0xCE, 0x33, 0x8E,
  0xC3, 0xF0, 0x78, 0x1E, 0x03, 0x80, 0xE3, 0x86, 0xC7, 0x9D, 0x8F, 0x3B,
  0xB6, 0x67, 0x6D, 0xC6, 0xDB, 0x8D, 0x9E, 0x1A, 0x3C, 0x1C, 0x78, 0x38,
  0xF0, 0xE1, 0xDC, 0xE3, 0xB8, 0xFC, 0x1E, 0x07, 0x83, 0xF0, 0xEE, 0x73,
  0xB8, 0x70, 0xE1, 0xD8, 0x77, 0x19, 0xCE, 0x33, 0x8E, 0xC1, 0xF0, 0x7C,
  0x1E, 0x03, 0x80, 0xC0, 0x70, 0x78, 0x1E, 0x00, 0xFF, 0xFC, 0x38, 0xE3,
  0x87, 0x1C, 0x70, 0xFF, 0xFC, 0x0C, 0x71, 0x86, 0x18, 0x63, 0xBC, 0xF0,
  0xE1, 0x86, 0x18, 0x61, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x87,
  0x1C, 0x71, 0xC7, 0x0F, 0x3D, 0xC7, 0x1C, 0x71, 0xCE, 0x30, 0x70, 0xFF,
  0xE3, 0xC0,
};

const GFXglyph NotoSans_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 9, 1, -13 },
  { 11, 11, 13, 12, 0, -13 },
  { 29, 9, 15, 10, 1, -14 },
  { 46, 15, 13, 16, 1, -13 },
  { 71, 13, 13, 14, 1, -13 },
  { 93, 3, 5, 5, 1, -13 },
  { 95, 5, 16, 6, 1, -13 },
  { 105, 4, 16, 6, 1, -13 },
  { 113, 8, 9, 10, 1, -14 },
  { 122, 9, 9, 10, 1, -11 },
  { 133, 3, 4, 5, 1, -2 },
  { 135, 5, 2, 6, 0, -6 },
  { 137, 3, 3, 5, 1, -3 },
  { 139, 7, 13, 7, 0, -13 },
  { 151, 9, 13, 10, 1, -13 },
  { 166, 6, 13, 10, 1, -13 },
  { 176, 9, 13, 10, 1, -13 },
  { 191, 9, 13, 10, 1, -13 },
  { 206, 10, 13, 10, 0, -13 },
  { 223, 8, 13, 10, 1, -13 },
  { 236, 9, 13, 10, 1, -13 },
  { 251, 10, 13, 10, 0, -13 },
  { 268, 9, 13, 10, 1, -13 },
  { 283, 9, 13, 10, 1, -13 },
  { 298, 3, 10, 5, 1, -10 },
  { 302, 3, 12, 5, 1, -10 },
  { 307, 9, 9, 10, 1, -11 },
  { 318, 9, 5, 10, 1, -9 },
  { 324, 9, 9, 10, 1, -11 },
  { 335, 8, 13, 9, 0, -13 },
  { 348, 14, 14, 16, 1, -13 },
  { 373, 12, 13, 12, 0, -13 },
  { 393, 9, 13, 12, 2, -13 },
  { 408, 10, 13, 12, 1, -13 },
  { 425, 10, 13, 13, 2, -13 },
  { 442, 7, 13, 10, 2, -13 },
  { 454, 7, 13, 10, 2, -13 },
  { 466, 11, 13, 13, 1, -13 },
  { 484, 10, 13, 14, 2, -13 },
  { 501, 5, 13, 7, 1, -13 },
  { 510, 5, 17, 6, -1, -13 },
  { 521, 10, 13, 12, 2, -13 },
  { 538, 7, 13, 10, 2, -13 },
  { 550, 13, 13, 17, 2, -13 },
  { 572, 11, 13, 15, 2, -13 },
  { 590, 12, 13, 14, 1, -13 },
  { 610, 8, 13, 11, 2, -13 },
  { 623, 12, 16, 14, 1, -13 },
  { 647, 10, 13, 12, 2, -13 },
  { 664, 8, 13, 10, 1, -13 },
  { 677, 10, 13, 10, 0, -13 },
  { 694, 10, 13, 14, 2, -13 },
  { 711, 12, 13, 12, 0, -13 },
  { 731, 17, 13, 17, 0, -13 },
  { 759, 12, 13, 12, 0, -13 },
  { 779, 11, 13, 11, 0, -13 },
  { 797, 10, 13, 10, 0, -13 },
  { 814, 5, 16, 6, 1, -13 },
  { 824, 7, 13, 7, 0, -13 },
  { 836, 5, 16, 6, 0, -13 },
  { 846, 10, 8, 10, 0, -13 },
  { 856, 7, 1, 7, 0, 2 },
  { 857, 5, 3, 7, 1, -14 },
  { 859, 9, 10, 11, 1, -10 },
  { 871, 10, 14, 11, 1, -14 },
  { 889, 8, 10, 9, 1, -10 },
  { 899, 9, 14, 11, 1, -14 },
  { 915, 9, 10, 11, 1, -10 },
  { 927, 8, 14, 7, 0, -14 },
  { 941, 9, 14, 11, 1, -10 },
  { 957, 9, 14, 12, 1, -14 },
  { 973, 3, 14, 5, 1, -14 },
  { 979, 5, 18, 5, -1, -14 },
  { 991, 10, 14, 11, 1, -14 },
  { 1009, 3, 14, 5, 1, -14 },
  { 1015, 15, 10, 18, 1, -10 },
  { 1034, 9, 10, 12, 1, -10 },
  { 1046, 9, 10, 11, 1, -10 },
  { 1058, 10, 14, 11, 1, -10 },
  { 1076, 9, 14, 11, 1, -10 },
  { 1092, 7, 10, 8, 1, -10 },
  { 1101, 7, 10, 9, 1, -10 },
  { 1110, 7, 12, 8, 0, -12 },
  { 1121, 9, 10, 12, 1, -10 },
  { 1133, 10, 10, 10, 0, -10 },
  { 1146, 15, 10, 15, 0, -10 },
  { 1165, 10, 10, 10, 0, -10 },
  { 1178, 10, 14, 10, 0, -10 },
  { 1196, 7, 10, 9, 1, -10 },
  { 1205, 6, 16, 7, 0, -13 },
  { 1217, 2, 18, 10, 4, -14 },
  { 1222, 6, 16, 7, 1, -13 },
  { 1234, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_Bold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold18pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_BOLD18PT7B_H_
