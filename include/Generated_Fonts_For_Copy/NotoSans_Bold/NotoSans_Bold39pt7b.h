#ifndef _NOTOSANS_BOLD39PT7B_H_
#define _NOTOSANS_BOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x1E, 0x7E, 0xFF, 0xFF,
  0xFB, 0xE1, 0x00, 0xFC, 0x7F, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D,
  0xF1, 0xF7, 0xC7, 0xDE, 0x1F, 0x78, 0x7D, 0xE1, 0xF0, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x01, 0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFC, 0xFC, 0xC3, 0x9F, 0x18, 0x03, 0xE3, 0x00, 0x7E, 0x60, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x6F, 0xF0, 0x0C, 0x7E, 0x01, 0x8F, 0xE0, 0x31,
  0xFF, 0xC6, 0x7E, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x1F, 0xF0, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xE0, 0x0F, 0xFF,
  0x01, 0xF0, 0x07, 0x8F, 0x80, 0xF0, 0x07, 0xC3, 0xC0, 0xF8, 0x03, 0xE1,
  0xE0, 0xF8, 0x01, 0xF0, 0xF0, 0x7C, 0x00, 0xF8, 0x78, 0x7C, 0x00, 0x7C,
  0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x3E, 0x00, 0x1F, 0x0F, 0x1E, 0x3F, 0x07,
  0x8F, 0x9F, 0x3F, 0xE3, 0xFF, 0xCF, 0x3F, 0xF0, 0xFF, 0xCF, 0x9F, 0xFC,
  0x7F, 0xCF, 0x9F, 0x1E, 0x0F, 0xC7, 0xCF, 0x8F, 0x80, 0x07, 0xC7, 0x87,
  0xC0, 0x03, 0xC3, 0xC3, 0xE0, 0x03, 0xE1, 0xE1, 0xF0, 0x01, 0xE0, 0xF0,
  0xF8, 0x01, 0xF0, 0x78, 0x7C, 0x00, 0xF0, 0x3E, 0x3E, 0x00, 0xF8, 0x1F,
  0x1F, 0x00, 0xF8, 0x07, 0xDF, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x00,
  0xFF, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xE7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0x8F, 0xFE, 0x03, 0xF3, 0xFF, 0xE0, 0xFC,
  0xFF, 0xFE, 0x1F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF0, 0x7E, 0xFC, 0x7E, 0x07,
  0xFF, 0x8F, 0xC0, 0x7F, 0xE1, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE,
  0x7F, 0x07, 0xFF, 0x07, 0xF0, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79,
  0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x81, 0xE0, 0x5E, 0x38, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0xF8, 0x3F, 0x1F, 0x80,
  0xC1, 0xC0, 0x08, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0x78,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF,
  0xEF, 0x84, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F,
  0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0,
  0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF9, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x03,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xBF, 0x7C,
  0xFC, 0xE3, 0xF1, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xFC,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xE0,
  0xFE, 0x18, 0x07, 0xE1, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0x80, 0xFE, 0x10,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xEF, 0xC3, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF7, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xB0, 0x07, 0xF7, 0xE7, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFC, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x7E, 0x07, 0xDF, 0xF8, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xDF, 0xEF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x07,
  0xE3, 0xFD, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC,
  0x3F, 0xDF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0x9F, 0xC7, 0xE0, 0xFE, 0x7C, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0xFE,
  0x7E, 0x07, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xF1, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFB, 0xF0, 0xFF, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC2, 0x0F, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xEF,
  0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF,
  0xFF, 0xEF, 0x84, 0x00, 0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x3E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8C,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x01, 0xF8,
  0x3E, 0x3C, 0x1F, 0xFE, 0x3C, 0xF8, 0x7F, 0xFC, 0x7D, 0xE1, 0xFF, 0xF8,
  0x7F, 0xC3, 0xE0, 0xF0, 0xFF, 0x8F, 0x81, 0xE1, 0xFE, 0x1E, 0x07, 0xC3,
  0xFC, 0x3C, 0x0F, 0x87, 0xF8, 0xF8, 0x1F, 0x0F, 0xF1, 0xF0, 0x3E, 0x1F,
  0xE1, 0xE0, 0x7C, 0x3F, 0xC3, 0xC0, 0xF8, 0xF7, 0x87, 0xC3, 0xF1, 0xEF,
  0x8F, 0xFF, 0xFF, 0x9F, 0x0F, 0xFD, 0xFF, 0x1E, 0x0F, 0xF1, 0xFC, 0x3E,
  0x03, 0x00, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x00,
  0xC3, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0x81, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0xFE,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xDF, 0x80, 0x7F, 0xBF, 0x01, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFC, 0x03, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xE7,
  0xF0, 0x0F, 0xCF, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xEF, 0x80,
  0x7F, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0x83, 0xF8,
  0x3E, 0x1F, 0xC0, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0xC0, 0x3E,
  0xFE, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xF0, 0x3E, 0x0F, 0xE0,
  0xF8, 0x1F, 0x83, 0xE0, 0x7F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF8, 0xF8,
  0x07, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0xBE, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xDF,
  0x00, 0x7F, 0xFE, 0xF8, 0x03, 0xDF, 0xFF, 0xC0, 0x3E, 0xFF, 0xDE, 0x01,
  0xF7, 0xFE, 0xF8, 0x0F, 0x3F, 0xF7, 0xC0, 0xF9, 0xFF, 0x9E, 0x07, 0xCF,
  0xFC, 0xF8, 0x3E, 0x7F, 0xE7, 0xC1, 0xE3, 0xFF, 0x3E, 0x1F, 0x1F, 0xF8,
  0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0x87, 0xFE, 0x3E, 0x7C, 0x3F, 0xF0, 0xFB,
  0xE1, 0xFF, 0x87, 0xDE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83,
  0xFF, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xFE,
  0x07, 0xE0, 0x3F, 0xF0, 0x3F, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xE0, 0x1F, 0xF7, 0xF0, 0x1F, 0xFB, 0xF0,
  0x1F, 0xF9, 0xF8, 0x1F, 0xF9, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFE,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x1F,
  0x9F, 0xF8, 0x1F, 0xDF, 0xF8, 0x0F, 0xDF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0xFF, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7E, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xC1, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xCF, 0xC0,
  0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFC,
  0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF,
  0x80, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07,
  0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x80,
  0x7E, 0x7E, 0x01, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xF8, 0x07, 0xC3, 0xE0,
  0x3F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC0, 0xFC, 0x3F, 0x03, 0xFF, 0x03,
  0xF0, 0xFC, 0x0F, 0x7C, 0x0F, 0x81, 0xF0, 0x7D, 0xF0, 0x7E, 0x07, 0xC1,
  0xF3, 0xE1, 0xF8, 0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x7E, 0x1F, 0x3E, 0x1F,
  0x00, 0xF8, 0xF8, 0xF8, 0x7C, 0x03, 0xE3, 0xE1, 0xF3, 0xF0, 0x0F, 0xCF,
  0x87, 0xCF, 0xC0, 0x3F, 0x3E, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x7C, 0xF8,
  0x01, 0xF7, 0xC0, 0xF7, 0xE0, 0x07, 0xDF, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x8F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xCF, 0xC0,
  0x07, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00,
  0x79, 0xE0, 0x0F, 0x9E, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x78,
  0x3E, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x03, 0xE7, 0xC0, 0x1E, 0x78, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x30, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xF7, 0xFF, 0x3E, 0x7F, 0xC7, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3C, 0x0F, 0xCF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF,
  0xFB, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF9, 0xFF, 0x8F, 0x8F, 0xE0,
  0x00, 0x70, 0x03, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8,
  0x39, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0x3F, 0xCF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0x83, 0xF0, 0xFF, 0x3F,
  0x1F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF7, 0xF9, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xF9, 0xF0,
  0xFF, 0x1F, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x2F, 0xF0, 0x38, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0x1F,
  0x1F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFB, 0xF0,
  0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF4, 0x00, 0x7E,
  0x7E, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x1C, 0x0F,
  0xCF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE,
  0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE1, 0xFE, 0x7F, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xBF,
  0x03, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xF8,
  0x1F, 0x9F, 0x80, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7F, 0x7E, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x01, 0xC0, 0xF9, 0xFF, 0x0F, 0xFC, 0xFB,
  0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x18, 0x0F, 0x8F, 0xF8,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07,
  0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF8,
  0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x1C, 0x0F, 0x8F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF, 0xF9, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xCF, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x1F, 0x1F,
  0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xF7, 0xF8, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFB, 0xF0, 0xFF,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x04, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0xC7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xFC, 0xF1,
  0xFE, 0x1E, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xF8, 0x0F, 0x9F, 0x81, 0xFE, 0x07,
  0xCF, 0xC0, 0xFF, 0x07, 0xE3, 0xE0, 0xFF, 0x83, 0xF1, 0xF8, 0x7B, 0xC1,
  0xF0, 0xFC, 0x3D, 0xF1, 0xF8, 0x3E, 0x1E, 0x78, 0xFC, 0x1F, 0x1F, 0x3C,
  0x7C, 0x0F, 0xCF, 0x1E, 0x3E, 0x07, 0xE7, 0x8F, 0xBF, 0x01, 0xF3, 0xC7,
  0xDF, 0x80, 0xFB, 0xE1, 0xEF, 0x80, 0x7D, 0xE0, 0xF7, 0xC0, 0x1F, 0xF0,
  0x7B, 0xE0, 0x0F, 0xF8, 0x3D, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x07,
  0xE1, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF8, 0x1F,
  0xC7, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0xFE, 0x01,
  0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x8F, 0x80, 0x7E,
  0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0x3F, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xFE, 0x1F, 0xF0, 0xFE,
  0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC3, 0xFE, 0x3F, 0xE1, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0x20,
  0x00, 0x00,
};

const GFXglyph NotoSans_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 29, 11, 2, -28 },
  { 27, 14, 10, 19, 2, -28 },
  { 45, 23, 28, 25, 1, -28 },
  { 126, 19, 32, 22, 2, -30 },
  { 202, 33, 28, 35, 1, -28 },
  { 318, 27, 28, 29, 2, -28 },
  { 413, 6, 10, 10, 2, -28 },
  { 421, 10, 34, 13, 2, -28 },
  { 464, 11, 34, 13, 1, -28 },
  { 511, 19, 19, 21, 1, -30 },
  { 557, 19, 19, 22, 2, -23 },
  { 603, 8, 10, 11, 1, -5 },
  { 613, 10, 5, 12, 1, -13 },
  { 620, 7, 7, 11, 2, -6 },
  { 627, 16, 28, 16, 0, -28 },
  { 683, 20, 28, 22, 1, -28 },
  { 753, 14, 28, 22, 2, -28 },
  { 802, 20, 28, 22, 1, -28 },
  { 872, 20, 28, 22, 1, -28 },
  { 942, 21, 28, 22, 1, -28 },
  { 1016, 19, 28, 22, 2, -28 },
  { 1083, 20, 28, 22, 1, -28 },
  { 1153, 20, 28, 22, 1, -28 },
  { 1223, 20, 28, 22, 1, -28 },
  { 1293, 20, 28, 22, 1, -28 },
  { 1363, 7, 23, 11, 2, -22 },
  { 1384, 8, 27, 11, 1, -22 },
  { 1411, 19, 20, 22, 2, -24 },
  { 1459, 19, 12, 22, 2, -20 },
  { 1488, 19, 20, 22, 2, -24 },
  { 1536, 18, 29, 19, 0, -28 },
  { 1602, 31, 31, 35, 2, -28 },
  { 1723, 27, 28, 27, 0, -28 },
  { 1818, 21, 28, 26, 3, -28 },
  { 1892, 22, 28, 25, 2, -28 },
  { 1969, 23, 28, 29, 3, -28 },
  { 2050, 16, 28, 22, 4, -28 },
  { 2106, 15, 28, 21, 4, -28 },
  { 2159, 23, 28, 28, 2, -28 },
  { 2240, 22, 28, 30, 4, -28 },
  { 2317, 13, 28, 15, 1, -28 },
  { 2363, 12, 36, 13, -3, -28 },
  { 2417, 22, 28, 26, 4, -28 },
  { 2494, 18, 28, 22, 3, -28 },
  { 2557, 29, 28, 37, 4, -28 },
  { 2659, 24, 28, 32, 4, -28 },
  { 2743, 27, 28, 31, 2, -28 },
  { 2838, 20, 28, 24, 3, -28 },
  { 2908, 27, 35, 31, 2, -28 },
  { 3027, 23, 28, 26, 3, -28 },
  { 3108, 18, 28, 21, 2, -28 },
  { 3171, 21, 28, 23, 1, -28 },
  { 3245, 23, 28, 29, 3, -28 },
  { 3326, 25, 28, 25, 0, -28 },
  { 3414, 38, 28, 38, 0, -28 },
  { 3547, 26, 28, 26, 0, -28 },
  { 3638, 24, 28, 24, 0, -28 },
  { 3722, 21, 28, 23, 1, -28 },
  { 3796, 9, 34, 13, 3, -28 },
  { 3835, 16, 28, 16, 0, -28 },
  { 3891, 9, 34, 13, 1, -28 },
  { 3930, 20, 18, 22, 1, -28 },
  { 3975, 16, 2, 16, 0, 4 },
  { 3979, 11, 6, 14, 2, -30 },
  { 3988, 19, 22, 23, 2, -22 },
  { 4041, 20, 30, 25, 3, -30 },
  { 4116, 17, 22, 20, 2, -22 },
  { 4163, 20, 30, 25, 2, -30 },
  { 4238, 19, 22, 23, 2, -22 },
  { 4291, 16, 30, 15, 1, -30 },
  { 4351, 20, 31, 25, 2, -22 },
  { 4429, 20, 30, 25, 3, -30 },
  { 4504, 6, 30, 12, 3, -30 },
  { 4527, 11, 39, 12, -2, -30 },
  { 4581, 21, 30, 24, 3, -30 },
  { 4660, 6, 30, 12, 3, -30 },
  { 4683, 32, 22, 38, 3, -22 },
  { 4771, 20, 22, 25, 3, -22 },
  { 4826, 21, 22, 24, 2, -22 },
  { 4884, 20, 31, 25, 3, -22 },
  { 4962, 20, 31, 25, 2, -22 },
  { 5040, 14, 22, 17, 3, -22 },
  { 5079, 16, 22, 20, 2, -22 },
  { 5123, 15, 26, 17, 1, -26 },
  { 5172, 19, 21, 25, 3, -21 },
  { 5222, 22, 21, 22, 0, -21 },
  { 5280, 33, 21, 33, 0, -21 },
  { 5367, 22, 21, 23, 0, -21 },
  { 5425, 22, 30, 22, 0, -21 },
  { 5508, 17, 21, 19, 1, -21 },
  { 5553, 13, 34, 15, 1, -28 },
  { 5609, 4, 39, 21, 9, -30 },
  { 5629, 13, 34, 15, 2, -28 },
  { 5685, 19, 7, 22, 2, -17 },
};

const GFXfont NotoSans_Bold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold39pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_BOLD39PT7B_H_
