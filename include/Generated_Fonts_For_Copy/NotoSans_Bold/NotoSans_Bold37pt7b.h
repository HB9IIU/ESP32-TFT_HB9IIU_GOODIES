#ifndef _NOTOSANS_BOLD37PT7B_H_
#define _NOTOSANS_BOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7C, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xFD, 0xF0, 0xFC, 0xFF, 0xC7,
  0xFE, 0x3E, 0xF1, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x78,
  0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF3, 0xF7, 0x3C, 0xF9, 0xC1, 0x3E, 0x70, 0x0F, 0xDC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1D, 0xFC, 0x07, 0x3F, 0x81, 0xCF, 0xF8,
  0x73, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0x00, 0xFF, 0x80, 0x3C, 0x03, 0xFF, 0x80, 0xF8, 0x07,
  0x8F, 0x01, 0xE0, 0x1F, 0x1E, 0x07, 0x80, 0x3E, 0x3E, 0x1F, 0x00, 0x78,
  0x7C, 0x3C, 0x00, 0xF0, 0xF8, 0xF8, 0x01, 0xE1, 0xF1, 0xE0, 0x03, 0xE3,
  0xE7, 0xC0, 0x07, 0xC7, 0x8F, 0x1F, 0x87, 0x8F, 0x3E, 0x7F, 0x8F, 0xFE,
  0x79, 0xFF, 0x8F, 0xF9, 0xE7, 0xDF, 0x0F, 0xE7, 0xCF, 0x9F, 0x07, 0x0F,
  0x1E, 0x1E, 0x00, 0x3E, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x78, 0x01, 0xF0,
  0xF0, 0xF0, 0x03, 0xC1, 0xE1, 0xE0, 0x0F, 0x83, 0xC3, 0xC0, 0x1E, 0x07,
  0x8F, 0x80, 0x78, 0x0F, 0x9F, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xC0, 0x0F,
  0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x1F, 0x8F, 0xFF, 0x07, 0xE1, 0xFF, 0xF0, 0xFC, 0x7F,
  0x7F, 0x1F, 0x0F, 0xC7, 0xF7, 0xE1, 0xF0, 0x7F, 0xF8, 0x7E, 0x07, 0xFF,
  0x07, 0xC0, 0x7F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xE3, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xF0, 0x1F, 0xF8, 0x7F,
  0x80, 0xFF, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F,
  0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x1C, 0x78, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xCF, 0x83,
  0xF3, 0xF0, 0x78, 0x78, 0x06, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0x1E, 0x7C, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x1F, 0x1F,
  0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0xFC, 0xFC,
  0x1F, 0x8F, 0xC7, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0xBF, 0xFF,
  0xFB, 0xEF, 0x9F, 0x30, 0xF9, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7C, 0x1F, 0x86,
  0x03, 0xF0, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x70, 0x1F, 0x84, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xBC, 0x07, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3D, 0xF0, 0x07, 0xDF, 0x00, 0xF9, 0xF0, 0x0F, 0x1F, 0x01, 0xF1,
  0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xF8, 0x3E, 0xFF,
  0x8F, 0xBF, 0xF9, 0xFF, 0xFF, 0xBF, 0xC3, 0xF7, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x0F,
  0x8F, 0xC7, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC7, 0xF1, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7E, 0x0F,
  0xC7, 0xE1, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0x1F, 0xCF, 0x81, 0xFB, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x83, 0xF3, 0xFF, 0xFE,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x3F, 0x9F, 0x03,
  0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xF7, 0xE0, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xDF, 0x1F, 0xF3,
  0xC0, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x11, 0xFF, 0xFF, 0xFD, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0x7C, 0x18, 0x7D, 0xFB, 0xF7, 0xE7, 0xC2, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFB, 0xF7, 0xCF,
  0x9E, 0x3C, 0xF9, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0x80, 0xFC, 0x80, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0xFC, 0x1E, 0x7C, 0x1F,
  0xFC, 0xFB, 0xC3, 0xFF, 0xE3, 0xDE, 0x1F, 0xFF, 0x1F, 0xE1, 0xF0, 0x78,
  0xFF, 0x1F, 0x07, 0xC3, 0xF8, 0xF8, 0x3E, 0x1F, 0xC7, 0x81, 0xF0, 0xFE,
  0x3C, 0x0F, 0x0F, 0xF1, 0xE0, 0x78, 0x7F, 0x8F, 0x03, 0xC3, 0xFC, 0x7C,
  0x3F, 0x3F, 0xE1, 0xFF, 0xFF, 0xEF, 0x0F, 0xFD, 0xFE, 0x3C, 0x3F, 0xCF,
  0xE1, 0xE0, 0x7C, 0x1E, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFC, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFC, 0x3F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xEF, 0xC3, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE0, 0x70, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x08, 0xFF, 0xCF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFC, 0x1F, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0xFC, 0x0F, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x80, 0xC3,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF3, 0xFE, 0x1F, 0xC7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0xFF, 0x87, 0xC0, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E,
  0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0x80,
  0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xFB, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x7F, 0xEF, 0x00,
  0x7B, 0xFF, 0x78, 0x07, 0xFF, 0xFB, 0xE0, 0x3D, 0xFF, 0xDF, 0x01, 0xEF,
  0xFE, 0x78, 0x1F, 0x7F, 0xF3, 0xE0, 0xF3, 0xFF, 0x9F, 0x07, 0x9F, 0xFC,
  0x78, 0x7C, 0xFF, 0xE3, 0xE3, 0xC7, 0xFF, 0x1F, 0x1E, 0x3F, 0xF8, 0x79,
  0xF1, 0xFF, 0xC3, 0xEF, 0x0F, 0xFE, 0x1F, 0x78, 0x7F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x83, 0xFC, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0x07, 0xFF,
  0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFB, 0xF0, 0x1F, 0xF9,
  0xF8, 0x1F, 0xF9, 0xF8, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8,
  0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x1F, 0x9F, 0xF8,
  0x1F, 0x9F, 0xF8, 0x0F, 0xDF, 0xF8, 0x0F, 0xDF, 0xF8, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1, 0xFC,
  0x07, 0xF8, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1, 0xFC,
  0x07, 0xF8, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xC1, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x1F, 0x9F, 0x80, 0xFE, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x03, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF0, 0x73, 0xF0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE1, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xFF,
  0x1F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0,
  0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x07,
  0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0xE0, 0xFC, 0x3F, 0x07, 0xBE, 0x0F, 0xC1,
  0xF0, 0x79, 0xE0, 0xF8, 0x1F, 0x0F, 0x9E, 0x0F, 0x81, 0xF0, 0xF9, 0xF1,
  0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0xF8, 0xF1, 0xF1, 0xF0, 0x0F, 0x9F,
  0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0xBE, 0x00,
  0x7D, 0xE0, 0xFB, 0xE0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x7B,
  0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE3,
  0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3E, 0x01, 0xE3, 0xC0, 0x78, 0x7C, 0x0F,
  0x07, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0xF8,
  0x03, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x20, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x10, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xE0, 0x7E, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x7E, 0x1F, 0xEF,
  0xFF, 0xFD, 0xFF, 0xEF, 0x9F, 0xF9, 0xF1, 0xFE, 0x3E, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC1, 0x80, 0xF9, 0xFE, 0x1F, 0x7F, 0xE3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xE1, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF8,
  0x1F, 0xBF, 0x03, 0xF7, 0xF0, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xEF,
  0xFC, 0x78, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xFE, 0x1F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7F, 0x06, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x01,
  0x7F, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x18, 0x3F, 0x0F, 0xE7, 0xE7, 0xFE, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF8, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7F, 0xCF, 0x87, 0xF1, 0xF0, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7F, 0xBF, 0x9F, 0x83, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE1, 0xF8, 0x43, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0x00,
  0x01, 0xFC, 0x7C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0x7E, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFB, 0xF0, 0xFE, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x40, 0x0F, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x40, 0xF9, 0xFF, 0x3E, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFB, 0xEF, 0xFE, 0xF8, 0x00, 0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x07, 0xC0,
  0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0x8F,
  0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xEF,
  0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0x83, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0,
  0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xC7, 0xE0, 0xF8, 0x3F, 0x0F, 0x83,
  0xF8, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x0F, 0xEF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x01, 0x03, 0xC7, 0xF8, 0x7F,
  0xCF, 0xBF, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFC,
  0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03,
  0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC,
  0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01,
  0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7C,
  0x00, 0x18, 0x3C, 0x7F, 0xCF, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB,
  0xE0, 0x3F, 0x7E, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x10, 0x1E, 0x3F, 0xC3, 0xEF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7D,
  0xFF, 0x8F, 0x9F, 0xC1, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x7C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFB, 0xF0, 0xFE, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x37, 0x8F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0x00, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xE7, 0xDF, 0x01,
  0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x84, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07,
  0xFC, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0x3C, 0x7F, 0x8F, 0xFC, 0x01,
  0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE3, 0xE0, 0x3E, 0x1F,
  0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F,
  0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0xF8, 0x1F, 0xC0, 0xFD, 0xF8,
  0x3F, 0xC1, 0xFB, 0xF0, 0x7F, 0x83, 0xE3, 0xE0, 0xFF, 0x07, 0xC7, 0xC3,
  0xDE, 0x1F, 0x8F, 0xC7, 0xBE, 0x3E, 0x0F, 0x8F, 0x3C, 0x7C, 0x1F, 0x1E,
  0x78, 0xF8, 0x3E, 0x78, 0xF3, 0xF0, 0x7E, 0xF1, 0xE7, 0xC0, 0x7D, 0xE1,
  0xEF, 0x80, 0xFB, 0xC3, 0xDF, 0x01, 0xF7, 0x87, 0xBC, 0x01, 0xFE, 0x0F,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF9,
  0xF8, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xEF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F,
  0x03, 0xF1, 0xF8, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x9F, 0x80, 0xFD, 0xFC,
  0x03, 0xF0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x07,
  0xE3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F,
  0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x8F, 0xF8, 0xFF, 0x0F, 0x80, 0xFE,
  0x0F, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x7F, 0xC3, 0xF0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x7E, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1E, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xA0, 0x0F, 0x80,
};

const GFXglyph NotoSans_Bold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 9, 18, 2, -26 },
  { 36, 22, 26, 24, 1, -26 },
  { 108, 18, 30, 21, 2, -28 },
  { 176, 31, 27, 33, 1, -27 },
  { 281, 27, 27, 28, 1, -27 },
  { 373, 6, 9, 10, 2, -26 },
  { 380, 10, 32, 13, 1, -26 },
  { 420, 10, 32, 13, 1, -26 },
  { 460, 18, 17, 20, 1, -28 },
  { 499, 18, 18, 21, 2, -22 },
  { 540, 7, 9, 11, 1, -4 },
  { 548, 10, 4, 12, 1, -12 },
  { 553, 6, 6, 10, 2, -6 },
  { 558, 15, 27, 15, 0, -27 },
  { 609, 19, 27, 21, 1, -27 },
  { 674, 13, 26, 21, 2, -26 },
  { 717, 19, 27, 21, 1, -27 },
  { 782, 19, 27, 21, 1, -27 },
  { 847, 20, 26, 21, 1, -26 },
  { 912, 17, 26, 21, 2, -26 },
  { 968, 19, 27, 21, 1, -27 },
  { 1033, 19, 26, 21, 1, -26 },
  { 1095, 19, 27, 21, 1, -27 },
  { 1160, 19, 27, 21, 1, -27 },
  { 1225, 6, 21, 10, 2, -21 },
  { 1241, 7, 26, 11, 1, -21 },
  { 1264, 18, 19, 21, 2, -23 },
  { 1307, 18, 11, 21, 2, -19 },
  { 1332, 18, 19, 21, 2, -23 },
  { 1375, 17, 27, 18, 0, -27 },
  { 1433, 29, 30, 33, 2, -27 },
  { 1542, 26, 27, 26, 0, -27 },
  { 1630, 20, 26, 25, 3, -26 },
  { 1695, 21, 27, 24, 2, -27 },
  { 1766, 22, 26, 27, 3, -26 },
  { 1838, 16, 26, 21, 3, -26 },
  { 1890, 15, 26, 20, 3, -26 },
  { 1939, 22, 27, 27, 2, -27 },
  { 2014, 22, 26, 28, 3, -26 },
  { 2086, 12, 26, 14, 1, -26 },
  { 2125, 12, 34, 12, -3, -26 },
  { 2176, 22, 26, 25, 3, -26 },
  { 2248, 17, 26, 21, 3, -26 },
  { 2304, 29, 26, 35, 3, -26 },
  { 2399, 24, 26, 30, 3, -26 },
  { 2477, 25, 27, 29, 2, -27 },
  { 2562, 18, 26, 23, 3, -26 },
  { 2621, 25, 33, 29, 2, -27 },
  { 2725, 21, 26, 24, 3, -26 },
  { 2794, 17, 27, 20, 2, -27 },
  { 2852, 20, 26, 21, 1, -26 },
  { 2917, 22, 26, 28, 3, -26 },
  { 2989, 24, 26, 24, 0, -26 },
  { 3067, 36, 26, 36, 0, -26 },
  { 3184, 25, 26, 25, 0, -26 },
  { 3266, 23, 26, 23, 0, -26 },
  { 3341, 20, 26, 21, 1, -26 },
  { 3406, 8, 32, 12, 3, -26 },
  { 3438, 15, 27, 15, 0, -27 },
  { 3489, 9, 32, 12, 1, -26 },
  { 3525, 19, 18, 21, 1, -27 },
  { 3568, 15, 3, 15, 0, 3 },
  { 3574, 11, 6, 14, 1, -28 },
  { 3583, 19, 21, 22, 1, -21 },
  { 3633, 19, 28, 23, 3, -28 },
  { 3700, 16, 21, 19, 2, -21 },
  { 3742, 19, 28, 23, 2, -28 },
  { 3809, 18, 21, 22, 2, -21 },
  { 3857, 15, 28, 14, 1, -28 },
  { 3910, 19, 30, 23, 2, -21 },
  { 3982, 18, 28, 24, 3, -28 },
  { 4045, 6, 28, 11, 3, -28 },
  { 4066, 11, 37, 11, -2, -28 },
  { 4117, 20, 28, 23, 3, -28 },
  { 4187, 5, 28, 11, 3, -28 },
  { 4205, 30, 21, 36, 3, -21 },
  { 4284, 18, 21, 24, 3, -21 },
  { 4332, 19, 21, 23, 2, -21 },
  { 4382, 19, 30, 23, 3, -21 },
  { 4454, 19, 30, 23, 2, -21 },
  { 4526, 13, 21, 17, 3, -21 },
  { 4561, 15, 21, 19, 2, -21 },
  { 4601, 14, 25, 16, 1, -25 },
  { 4645, 18, 20, 24, 3, -20 },
  { 4690, 21, 20, 21, 0, -20 },
  { 4743, 31, 20, 32, 0, -20 },
  { 4821, 21, 20, 21, 0, -20 },
  { 4874, 21, 29, 21, 0, -20 },
  { 4951, 16, 20, 18, 1, -20 },
  { 4991, 12, 32, 15, 1, -26 },
  { 5039, 4, 36, 20, 8, -28 },
  { 5057, 13, 32, 15, 1, -26 },
  { 5109, 18, 6, 21, 2, -16 },
};

const GFXfont NotoSans_Bold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold37pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_BOLD37PT7B_H_
