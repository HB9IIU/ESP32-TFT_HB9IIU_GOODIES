#ifndef _NOTOSANS_BOLD60PT7B_H_
#define _NOTOSANS_BOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0xFE,
  0x0F, 0x00, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0xFF,
  0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F,
  0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0xF1, 0xFC, 0x7F, 0xC7, 0x80,
  0xE3, 0xFE, 0x3C, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0xFF, 0x8F, 0x00, 0x07,
  0xFC, 0x78, 0x00, 0x3F, 0xFB, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xBF, 0xFC, 0x00,
  0x3C, 0x7F, 0xE0, 0x01, 0xE1, 0xFF, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x78,
  0x7F, 0xF0, 0x03, 0xC3, 0xFF, 0xF8, 0x1E, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC,
  0x0F, 0xF0, 0xFF, 0x1F, 0xC3, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF1, 0xFF,
  0xF8, 0x7F, 0xBF, 0xE3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF9, 0xFE, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x0F, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF0,
  0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x7F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF3,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x02,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x40, 0x1F, 0x80, 0x33, 0xE0, 0xFC, 0x0F, 0xBF, 0xE7, 0xE7, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x01,
  0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0x0F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x83,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x03,
  0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F,
  0xDF, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F,
  0xF7, 0xF8, 0xFF, 0xBF, 0x87, 0xFC, 0xF8, 0x3F, 0xE3, 0x01, 0xFF, 0x10,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xF8, 0x7C, 0x00, 0x3F, 0xE0,
  0xE0, 0x00, 0xFF, 0x81, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xFC, 0x0E, 0x00,
  0x1F, 0xF8, 0x20, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xBE, 0x00, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x7F, 0x3F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0x00, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF4, 0x00, 0x01, 0xFF, 0xB0, 0x00, 0x1F, 0xFD,
  0xF8, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x8F, 0xFF,
  0x01, 0xFE, 0x7F, 0xFF, 0x0F, 0xFB, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0xBF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07,
  0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x02, 0xD0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xCF, 0xF0, 0x3F,
  0xFC, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x81, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x0F, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFE, 0x3F, 0x83, 0xC0, 0x1F, 0xC3, 0xFE, 0x3F, 0xE7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x3F, 0xE3, 0xFE, 0x1F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x3F,
  0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0x1C, 0x00, 0x3F, 0xE2,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0xFE, 0x3F, 0x80,
  0xFF, 0xFF, 0xF0, 0x7E, 0x3F, 0x01, 0xFF, 0xFF, 0xF0, 0x7E, 0x7F, 0x03,
  0xFF, 0x0F, 0xE0, 0x7F, 0x7F, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0x7E, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x3F, 0xFE, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFC, 0xFE, 0x07,
  0xF8, 0x7F, 0xF1, 0xFC, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x03,
  0xFF, 0xFD, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xF9, 0xFF, 0xF0, 0x7F, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFC,
  0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0x00, 0x0E, 0x07, 0xFF, 0x00, 0x00, 0x81, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x1F,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0x81, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF7, 0xFC,
  0x01, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF,
  0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x70, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x1F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x9F,
  0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF7, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFE, 0xFF, 0xFF, 0x7F, 0x80, 0x03,
  0xFB, 0xFF, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xFF, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0xFF, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3,
  0xFF, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xFF, 0xF1, 0xFC, 0x00, 0xFE, 0x3F,
  0xFF, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xFF,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xFE,
  0x1F, 0xE1, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x0F,
  0xF3, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0x3F, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xFF,
  0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0xF8,
  0x07, 0xFE, 0x3F, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xFF, 0xE0,
  0x03, 0xFF, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFF,
  0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0x03,
  0xF8, 0x7F, 0xC0, 0x07, 0x8F, 0xFC, 0x00, 0x08, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0xF8, 0x00, 0x3F, 0xEF,
  0xF0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFE, 0x03, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xCF, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFC, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x3F,
  0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0xE0,
  0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x03,
  0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xF0,
  0x00, 0x07, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0x83, 0xFF, 0x80, 0xF0, 0x07, 0xFE, 0x02, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x80,
  0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD,
  0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF,
  0xF0, 0x7F, 0x07, 0xFF, 0x81, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE3, 0xFF, 0xE0, 0x7F, 0xCF, 0xFF, 0xE0,
  0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x01,
  0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0xFF,
  0x0F, 0xF0, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3C, 0x7F, 0xF0, 0x01, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x9F, 0xFE,
  0x01, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF,
  0xF8, 0xFF, 0x83, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF, 0xFB, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x83,
  0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0x8F, 0xF0, 0x7F, 0xFE, 0x1F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x03,
  0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0xC3, 0xFF, 0xE0, 0x3F,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFE, 0x0C, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xC3, 0xFC, 0x1F,
  0xFF, 0xCF, 0xF8, 0x7F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0xC3,
  0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x70, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x8C, 0x00, 0x03, 0xFF, 0x1F, 0x00,
  0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xE3, 0xFF, 0xF0, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x81, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x1E, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0x1F, 0xF8, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF,
  0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x03,
  0xFF, 0x01, 0xFE, 0x1F, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0,
  0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x05, 0x80, 0x00, 0xFF, 0x03,
  0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0x07, 0xFD, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x1F,
  0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF,
  0xF0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xF8, 0x7F, 0xC7,
  0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x00, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0xCF,
  0xF8, 0x7F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0xFC,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x70, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xF1, 0xFF, 0x00, 0x38,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x02, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xC0, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xFE, 0x7F, 0x87, 0xFF, 0xF0, 0xFF,
  0x03, 0xFF, 0xC1, 0xFE, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xF9,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0x9F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xF0, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0x7F, 0x01,
  0xFE, 0x0F, 0xF8, 0x1F, 0xDF, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF3, 0xF0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7E, 0x3F,
  0x83, 0xFC, 0x07, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xE3,
  0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xF8, 0x7E, 0x1F, 0xE0, 0x0F, 0xF8, 0xFC,
  0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x07, 0xF3, 0xFE, 0x00, 0x7F, 0x9F,
  0xC1, 0xFC, 0xFF, 0x80, 0x1F, 0xE7, 0xF0, 0x3F, 0x3F, 0xC0, 0x07, 0xF9,
  0xF8, 0x0F, 0xCF, 0xF0, 0x00, 0xFF, 0x7E, 0x03, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0x80, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0B,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x80, 0x03, 0xFF, 0xC4, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_Bold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 44, 17, 3, -43 },
  { 62, 21, 16, 29, 4, -43 },
  { 104, 36, 43, 39, 1, -43 },
  { 298, 29, 49, 34, 3, -46 },
  { 476, 50, 44, 54, 2, -43 },
  { 751, 43, 44, 45, 2, -43 },
  { 988, 8, 16, 16, 4, -43 },
  { 1004, 17, 52, 20, 2, -43 },
  { 1115, 16, 52, 20, 2, -43 },
  { 1219, 29, 28, 33, 2, -46 },
  { 1321, 29, 29, 34, 3, -36 },
  { 1427, 11, 15, 17, 2, -7 },
  { 1448, 15, 8, 19, 2, -20 },
  { 1463, 11, 10, 17, 3, -9 },
  { 1477, 25, 43, 25, 0, -43 },
  { 1612, 30, 45, 34, 2, -44 },
  { 1781, 21, 43, 34, 4, -43 },
  { 1894, 30, 43, 34, 2, -43 },
  { 2056, 30, 44, 34, 2, -43 },
  { 2221, 32, 43, 34, 1, -43 },
  { 2393, 29, 44, 34, 3, -43 },
  { 2553, 30, 44, 34, 2, -43 },
  { 2718, 30, 43, 34, 2, -43 },
  { 2880, 30, 44, 34, 2, -43 },
  { 3045, 30, 44, 34, 2, -43 },
  { 3210, 11, 34, 17, 3, -33 },
  { 3257, 12, 41, 17, 2, -33 },
  { 3319, 29, 32, 34, 3, -38 },
  { 3435, 29, 18, 34, 3, -30 },
  { 3501, 29, 32, 34, 3, -38 },
  { 3617, 27, 44, 29, 0, -43 },
  { 3766, 48, 48, 54, 3, -43 },
  { 4054, 42, 43, 42, 0, -43 },
  { 4280, 32, 43, 40, 5, -43 },
  { 4452, 34, 44, 39, 3, -43 },
  { 4639, 36, 43, 44, 5, -43 },
  { 4833, 25, 43, 34, 5, -43 },
  { 4968, 25, 43, 33, 5, -43 },
  { 5103, 36, 44, 43, 3, -43 },
  { 5301, 36, 43, 46, 5, -43 },
  { 5495, 19, 43, 23, 2, -43 },
  { 5598, 18, 56, 20, -4, -43 },
  { 5724, 35, 43, 40, 5, -43 },
  { 5913, 27, 43, 34, 5, -43 },
  { 6059, 46, 43, 57, 5, -43 },
  { 6307, 38, 43, 49, 5, -43 },
  { 6512, 41, 45, 47, 3, -44 },
  { 6743, 30, 43, 37, 5, -43 },
  { 6905, 41, 54, 47, 3, -44 },
  { 7182, 34, 43, 39, 5, -43 },
  { 7365, 28, 44, 33, 3, -43 },
  { 7519, 32, 43, 35, 1, -43 },
  { 7691, 35, 44, 45, 5, -43 },
  { 7884, 39, 43, 39, 0, -43 },
  { 8094, 58, 43, 58, 0, -43 },
  { 8406, 40, 43, 40, 0, -43 },
  { 8621, 38, 43, 38, 0, -43 },
  { 8826, 32, 43, 35, 1, -43 },
  { 8998, 14, 52, 20, 4, -43 },
  { 9089, 25, 43, 25, 0, -43 },
  { 9224, 15, 52, 20, 1, -43 },
  { 9322, 32, 28, 34, 1, -43 },
  { 9434, 25, 4, 25, 0, 5 },
  { 9447, 18, 10, 22, 2, -46 },
  { 9470, 30, 34, 36, 2, -33 },
  { 9598, 31, 47, 38, 4, -46 },
  { 9781, 26, 34, 31, 3, -33 },
  { 9892, 31, 47, 38, 3, -46 },
  { 10075, 30, 34, 36, 3, -33 },
  { 10203, 25, 46, 23, 1, -46 },
  { 10347, 31, 47, 38, 3, -33 },
  { 10530, 31, 46, 39, 4, -46 },
  { 10709, 10, 46, 18, 4, -46 },
  { 10767, 17, 60, 18, -3, -46 },
  { 10895, 32, 46, 37, 5, -46 },
  { 11079, 9, 46, 18, 4, -46 },
  { 11131, 50, 33, 59, 4, -33 },
  { 11338, 31, 33, 39, 4, -33 },
  { 11466, 32, 34, 38, 3, -33 },
  { 11602, 31, 47, 38, 4, -33 },
  { 11785, 31, 47, 38, 3, -33 },
  { 11968, 22, 33, 27, 4, -33 },
  { 12059, 25, 34, 30, 3, -33 },
  { 12166, 23, 41, 26, 1, -40 },
  { 12284, 31, 34, 39, 4, -33 },
  { 12416, 34, 33, 34, 0, -33 },
  { 12557, 50, 33, 51, 1, -33 },
  { 12764, 34, 33, 35, 0, -33 },
  { 12905, 34, 47, 34, 0, -33 },
  { 13105, 26, 33, 30, 2, -33 },
  { 13213, 20, 52, 24, 1, -43 },
  { 13343, 7, 59, 33, 13, -45 },
  { 13395, 21, 52, 24, 2, -43 },
  { 13532, 29, 10, 34, 3, -26 },
};

const GFXfont NotoSans_Bold60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold60pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_BOLD60PT7B_H_
