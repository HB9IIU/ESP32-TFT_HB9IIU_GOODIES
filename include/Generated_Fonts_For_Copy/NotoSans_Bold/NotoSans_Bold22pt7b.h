#ifndef _NOTOSANS_BOLD22PT7B_H_
#define _NOTOSANS_BOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x76, 0x60, 0x0F, 0xFF, 0xF7, 0xE7, 0x67,
  0x67, 0x67, 0x67, 0x07, 0x30, 0x19, 0xC0, 0x67, 0x01, 0x98, 0x0E, 0x61,
  0xFF, 0xF7, 0xFF, 0xC3, 0x38, 0x0C, 0xC3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x19, 0xC0, 0x66, 0x01, 0x98, 0x0E, 0x60, 0x04, 0x00, 0x80, 0xFE, 0x3F,
  0xEF, 0xFD, 0xC8, 0x3D, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x02, 0xF8,
  0x5F, 0xEF, 0xBF, 0xF3, 0xF8, 0x04, 0x00, 0x80, 0x38, 0x0E, 0x3F, 0x07,
  0x0E, 0xE1, 0x83, 0x38, 0xE0, 0xC6, 0x30, 0x31, 0x9C, 0x0C, 0xEE, 0x73,
  0xBB, 0xBE, 0x7D, 0xDD, 0xCE, 0x66, 0x70, 0x39, 0x8C, 0x0C, 0x63, 0x07,
  0x18, 0xC1, 0x87, 0x70, 0xE1, 0xF8, 0x70, 0x3E, 0x1F, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x1E, 0xF7, 0x9C, 0xF3, 0xFC, 0xE1, 0xF8, 0xF0, 0xF8, 0xFF, 0xF8,
  0x7F, 0xFC, 0x3F, 0x9F, 0xFE, 0x66, 0x66, 0x1C, 0xE3, 0x1C, 0x73, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0xC0, 0xE3, 0x87,
  0x1C, 0x38, 0xE3, 0x86, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x71, 0xCE,
  0x00, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xFF, 0xFF, 0xF1, 0xE0, 0xFC, 0x73,
  0x1C, 0xE1, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x77, 0xEE, 0xEC, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C,
  0x0E, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x1F, 0x07, 0xF1, 0xFF,
  0x78, 0xEE, 0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xEF, 0x1C, 0xF7, 0x9F, 0xE0, 0xF8, 0x07, 0x0F, 0x1F, 0x7F, 0xF7, 0x67,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0x0F,
  0xF3, 0xFF, 0x30, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xF3, 0xFF,
  0x20, 0xE0, 0x1C, 0x03, 0x81, 0xE1, 0xF8, 0x3F, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x1F, 0xCF, 0xBF, 0xF7, 0xF8, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x0F, 0xC0, 0xDC, 0x1D, 0xC3, 0x9C, 0x31, 0xC7, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07,
  0x00, 0xE0, 0x1F, 0xC7, 0xFC, 0x7F, 0xC0, 0x38, 0x07, 0x80, 0xF8, 0x1D,
  0xEF, 0xBF, 0xE7, 0xF8, 0x07, 0xC3, 0xF8, 0xFF, 0x3C, 0x07, 0x01, 0xC0,
  0x3B, 0xE7, 0xFE, 0xFB, 0xDC, 0x3F, 0x83, 0xF0, 0x7F, 0x1E, 0xF7, 0x9F,
  0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0xC0,
  0x1F, 0x0F, 0xF1, 0xFF, 0x70, 0xEE, 0x1C, 0xE3, 0x9F, 0xE1, 0xF8, 0x3F,
  0x8E, 0x7B, 0x87, 0xF0, 0x7E, 0x0F, 0xE3, 0x9F, 0xF1, 0xFC, 0x1E, 0x0F,
  0xF3, 0xFF, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xFF, 0xEF, 0xDC,
  0x67, 0x00, 0xE0, 0x3C, 0x9F, 0x1F, 0xC3, 0xF0, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x7E, 0xEE, 0xC0, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x18, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x7E,
  0x3E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x3F, 0x3F, 0xE7, 0xFD, 0x07, 0x01,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x70, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xE0, 0xF0, 0xE0, 0x0C, 0x70,
  0xF3, 0x98, 0xFE, 0x6E, 0x71, 0x9F, 0x98, 0x67, 0xCE, 0x19, 0xF3, 0x8E,
  0x7C, 0xE3, 0x9B, 0x9D, 0xEE, 0xE7, 0xEF, 0x1C, 0x21, 0x07, 0x00, 0x00,
  0xF8, 0x70, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x77, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x78,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE7, 0x83, 0xCE, 0x03, 0x9C, 0x07, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE3, 0xCF,
  0xF8, 0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xEF, 0xFE, 0xFF, 0xCF,
  0xF8, 0x07, 0xE1, 0xFF, 0x3F, 0xF7, 0xC1, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xFF, 0x3F, 0xF0,
  0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xEE, 0x0F, 0x70, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x0F, 0x7F, 0xF3,
  0xFF, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xF8, 0x27, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x0E, 0xE0, 0x77, 0x83,
  0x9F, 0xFC, 0x7F, 0xE1, 0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xF1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0xBF, 0xFF, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x3F, 0xFF, 0xE7, 0x00, 0xE0, 0x7F, 0x07, 0xB8, 0x79, 0xC7, 0x8E, 0x38,
  0x73, 0x83, 0xBC, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x39, 0xE1, 0xC7, 0x8E,
  0x1C, 0x70, 0xF3, 0x83, 0xDC, 0x0F, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC1,
  0xBF, 0xE0, 0xDF, 0xB0, 0xEF, 0xDC, 0x67, 0xEE, 0x33, 0xF3, 0x39, 0xF9,
  0xD8, 0xFC, 0xEC, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x0F, 0xC7, 0x87,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFE, 0x1F, 0xB8, 0x7E, 0xF1,
  0xF9, 0xC7, 0xE7, 0x9F, 0x8F, 0x7E, 0x1D, 0xF8, 0x7F, 0xE0, 0xFF, 0x83,
  0xFE, 0x07, 0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE7,
  0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7B, 0x80, 0xF7, 0x83, 0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0xFE, 0x1F,
  0xF3, 0xFF, 0x70, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1E, 0xFF, 0xDF, 0xF3,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xC1, 0xE7, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7B, 0x80, 0xF7, 0x83, 0xC7, 0xFF, 0x87, 0xFE,
  0x07, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFE, 0x0F,
  0xF8, 0xFF, 0xCE, 0x1E, 0xE1, 0xEE, 0x1E, 0xE1, 0xEF, 0xFC, 0xFF, 0x8F,
  0xF0, 0xE7, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0x1F, 0x1F,
  0xF7, 0xFF, 0xC2, 0xE0, 0x3C, 0x07, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xFF, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFF, 0x07, 0x3F, 0xF9, 0xFF, 0x83, 0xF8, 0xE0, 0x1F, 0xC0, 0x77,
  0x03, 0xDC, 0x0E, 0x78, 0x38, 0xE1, 0xE3, 0x87, 0x0F, 0x1C, 0x1C, 0xF0,
  0x73, 0x81, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0,
  0xE0, 0x70, 0x3F, 0x83, 0xC1, 0xDC, 0x3E, 0x1E, 0xE1, 0xF0, 0xE7, 0x0F,
  0x87, 0x38, 0x6E, 0x38, 0xE7, 0x71, 0xC7, 0x3B, 0x9C, 0x39, 0xCC, 0xE1,
  0xCC, 0x77, 0x07, 0xE3, 0xB8, 0x3F, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0x83,
  0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0xF0, 0x3C, 0xF0, 0x78, 0xE1, 0xE1,
  0xE3, 0x81, 0xEF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0xF7, 0x83, 0xC7, 0x07, 0x0F, 0x1E, 0x0F, 0x78, 0x1F,
  0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x8E, 0x1C, 0x3C, 0xE0, 0x73, 0x81, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0xFE, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0xFF, 0xFE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFE, 0x06, 0x00, 0x60, 0x0F,
  0x00, 0xF0, 0x1D, 0x81, 0x9C, 0x38, 0xC3, 0x0E, 0x70, 0x6E, 0x07, 0xFF,
  0x80, 0xF1, 0xE3, 0x83, 0x3F, 0x8F, 0xF8, 0xC7, 0x00, 0xF0, 0x1E, 0xFF,
  0xFF, 0x7F, 0x0F, 0xE1, 0xFE, 0x7F, 0xFB, 0xBE, 0x70, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0x9E, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xFE, 0xF7, 0xFE, 0xCF, 0x80, 0x1F, 0xCF, 0xE7,
  0x9B, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1F, 0x67, 0xF8, 0x7E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x7D, 0xDF, 0xFB, 0xDF, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1, 0xDE, 0xFB, 0xFF, 0x3E, 0x60,
  0x1F, 0x8F, 0xF9, 0xE7, 0xF8, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x08, 0xFF, 0x0F, 0xE0, 0x0F, 0xC7, 0xE3, 0xF8, 0xF0, 0x3C, 0x1F,
  0xCF, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0x3E, 0xEF, 0xFD, 0xE7, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x87, 0xF0, 0xEF, 0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0xD8, 0xFB,
  0xFE, 0x7F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F,
  0xF7, 0xDF, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xE0, 0x6F, 0x70, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70,
  0x18, 0xF1, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xEF, 0xFB, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x1E, 0xE3, 0xCE, 0x78, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F, 0xF0, 0xF7,
  0x0E, 0x78, 0xE3, 0xCE, 0x1E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xCF, 0x9F, 0x3F, 0xFF, 0xEF, 0xBF, 0x7F, 0x87, 0x8F, 0xE1,
  0xE1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70,
  0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xCF, 0x9F, 0xFB, 0xEF, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xF0, 0x1F, 0x87,
  0xFC, 0x79, 0xEF, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xE7,
  0x9E, 0x3F, 0xC1, 0xF8, 0xCF, 0x9F, 0xFB, 0xCF, 0x70, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0x7B, 0xFF, 0x77, 0xCE, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x3E, 0xEF, 0xFD, 0xE7, 0xF8, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x87, 0xF0, 0xEF, 0x3D, 0xFF, 0x9F, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0xCF, 0xFE, 0xFE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0xFF, 0xF8, 0x5C, 0x0F, 0x83, 0xF0, 0xFE,
  0x0F, 0x03, 0xE3, 0xFF, 0xFF, 0xC0, 0x18, 0x0C, 0x0E, 0x0F, 0xFF, 0xF9,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC9, 0xFC, 0x7E, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE,
  0xFF, 0xFB, 0xBF, 0x70, 0xF0, 0x7B, 0x83, 0x9C, 0x3C, 0xF1, 0xC3, 0x8E,
  0x1C, 0xE0, 0xF7, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0xE1, 0xEE, 0x3E, 0x39, 0xC7, 0xC7, 0x38, 0xD9, 0xE7, 0xBB, 0x38,
  0x77, 0x77, 0x0E, 0xCE, 0xE1, 0xD8, 0xD8, 0x1B, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x0F, 0x00, 0xF0, 0xF3, 0xC7, 0x0F, 0x78, 0x3B, 0x81,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF8, 0x3D, 0xC1, 0xCF, 0x1E, 0x3D, 0xE0,
  0xF0, 0xF0, 0x7B, 0x83, 0x9C, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0xE0, 0x77,
  0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x02,
  0x78, 0x0F, 0x80, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xE0, 0xE0,
  0xF0, 0x70, 0x70, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0x0F, 0x1F, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF8, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE3, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3C, 0x3C, 0x79, 0xE3, 0x87, 0x0E, 0x1C, 0x79, 0xE3,
  0xC0, 0x30, 0x3F, 0xCF, 0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 11, 1, -16 },
  { 15, 14, 16, 14, 0, -16 },
  { 43, 11, 18, 13, 1, -17 },
  { 68, 18, 16, 20, 1, -16 },
  { 104, 16, 16, 17, 1, -16 },
  { 136, 4, 6, 6, 1, -16 },
  { 139, 6, 19, 7, 1, -16 },
  { 154, 6, 19, 7, 1, -16 },
  { 169, 10, 11, 12, 1, -17 },
  { 183, 11, 11, 13, 1, -13 },
  { 199, 4, 6, 6, 1, -3 },
  { 202, 5, 2, 7, 1, -7 },
  { 204, 4, 3, 6, 1, -3 },
  { 206, 9, 16, 9, 0, -16 },
  { 224, 11, 16, 13, 1, -16 },
  { 246, 8, 16, 13, 1, -16 },
  { 262, 11, 16, 13, 1, -16 },
  { 284, 11, 16, 13, 1, -16 },
  { 306, 12, 16, 13, 0, -16 },
  { 330, 11, 16, 13, 1, -16 },
  { 352, 11, 16, 13, 1, -16 },
  { 374, 11, 16, 13, 1, -16 },
  { 396, 11, 16, 13, 1, -16 },
  { 418, 11, 16, 13, 1, -16 },
  { 440, 4, 12, 6, 1, -12 },
  { 446, 4, 15, 6, 1, -12 },
  { 454, 11, 12, 13, 1, -14 },
  { 471, 11, 7, 13, 1, -11 },
  { 481, 11, 12, 13, 1, -14 },
  { 498, 10, 16, 11, 0, -16 },
  { 518, 18, 18, 20, 1, -16 },
  { 559, 15, 16, 15, 0, -16 },
  { 589, 12, 16, 15, 2, -16 },
  { 613, 12, 16, 14, 1, -16 },
  { 637, 13, 16, 16, 2, -16 },
  { 663, 9, 16, 12, 2, -16 },
  { 681, 9, 16, 12, 2, -16 },
  { 699, 13, 16, 16, 1, -16 },
  { 725, 13, 16, 17, 2, -16 },
  { 751, 7, 16, 9, 1, -16 },
  { 765, 7, 21, 7, -2, -16 },
  { 784, 13, 16, 15, 2, -16 },
  { 810, 10, 16, 12, 2, -16 },
  { 830, 17, 16, 21, 2, -16 },
  { 864, 14, 16, 18, 2, -16 },
  { 892, 15, 16, 17, 1, -16 },
  { 922, 11, 16, 14, 2, -16 },
  { 944, 15, 20, 17, 1, -16 },
  { 982, 12, 16, 14, 2, -16 },
  { 1006, 10, 16, 12, 1, -16 },
  { 1026, 12, 16, 13, 0, -16 },
  { 1050, 13, 16, 17, 2, -16 },
  { 1076, 14, 16, 14, 0, -16 },
  { 1104, 21, 16, 21, 0, -16 },
  { 1146, 15, 16, 15, 0, -16 },
  { 1176, 14, 16, 14, 0, -16 },
  { 1204, 11, 16, 13, 1, -16 },
  { 1226, 5, 19, 7, 2, -16 },
  { 1238, 9, 16, 9, 0, -16 },
  { 1256, 5, 19, 7, 1, -16 },
  { 1268, 12, 10, 13, 0, -16 },
  { 1283, 9, 1, 9, 0, 2 },
  { 1285, 6, 4, 8, 1, -17 },
  { 1288, 11, 12, 13, 1, -12 },
  { 1305, 11, 17, 14, 2, -17 },
  { 1329, 10, 12, 11, 1, -12 },
  { 1344, 11, 17, 14, 1, -17 },
  { 1368, 11, 12, 13, 1, -12 },
  { 1385, 10, 17, 9, 0, -17 },
  { 1407, 11, 17, 14, 1, -12 },
  { 1431, 11, 17, 14, 2, -17 },
  { 1455, 4, 17, 7, 1, -17 },
  { 1464, 6, 22, 7, -1, -17 },
  { 1481, 12, 17, 14, 2, -17 },
  { 1507, 3, 17, 7, 2, -17 },
  { 1514, 18, 12, 21, 2, -12 },
  { 1541, 11, 12, 14, 2, -12 },
  { 1558, 12, 12, 14, 1, -12 },
  { 1576, 11, 17, 14, 2, -12 },
  { 1600, 11, 17, 14, 1, -12 },
  { 1624, 8, 12, 10, 2, -12 },
  { 1636, 9, 12, 11, 1, -12 },
  { 1650, 9, 15, 10, 0, -15 },
  { 1667, 11, 12, 14, 2, -12 },
  { 1684, 13, 12, 13, 0, -12 },
  { 1704, 19, 12, 19, 0, -12 },
  { 1733, 13, 12, 13, 0, -12 },
  { 1753, 13, 17, 13, 0, -12 },
  { 1781, 9, 12, 11, 1, -12 },
  { 1795, 8, 19, 9, 0, -16 },
  { 1814, 2, 22, 12, 5, -17 },
  { 1820, 7, 19, 9, 1, -16 },
  { 1837, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_Bold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold22pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_BOLD22PT7B_H_
