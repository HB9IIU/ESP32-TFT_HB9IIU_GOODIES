#ifndef _NOTOSANS_BOLD55PT7B_H_
#define _NOTOSANS_BOLD55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x38, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0,
  0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x3F, 0xE7, 0x8F, 0xCF, 0xF8, 0xF0, 0x11, 0xFE, 0x1E,
  0x00, 0x3F, 0xE3, 0xC0, 0x07, 0xFC, 0x78, 0x00, 0x7F, 0xCF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xBF,
  0xF0, 0x00, 0xF1, 0xFE, 0x00, 0x1E, 0x3F, 0xE0, 0x03, 0xC7, 0xFF, 0x00,
  0x78, 0xFF, 0xFC, 0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x03,
  0xF8, 0x7F, 0x1F, 0xC7, 0xFF, 0x07, 0xE1, 0xF8, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFF, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7E, 0x3F, 0xDF, 0xE1, 0xFF, 0xE3, 0xF8, 0xFE, 0x1F, 0x83, 0xFF,
  0x0F, 0xC3, 0xF0, 0x7E, 0x03, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x00, 0x01,
  0xF8, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xFE, 0x00, 0x7F,
  0x83, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x1F, 0xFB,
  0xFE, 0x07, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F,
  0xC3, 0xFE, 0x03, 0xFE, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xF8,
  0x03, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xE0, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF9, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x0A, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x02, 0x00, 0xFC, 0x02,
  0xF8, 0x3F, 0x07, 0xBF, 0xCF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0x03, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE,
  0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1C, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0,
  0x7F, 0xCF, 0xF8, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F,
  0xDF, 0xE0, 0x0F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0x7F, 0xCF, 0xF3, 0xF1, 0xFF, 0x3E, 0x1F, 0xF1, 0xC1,
  0xFF, 0x08, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0x00, 0x7F, 0xC1,
  0xE0, 0x03, 0xFC, 0x08, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFC, 0x07, 0xFE, 0x1C, 0x00, 0x7F, 0xC1, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF7, 0xF8,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF1, 0xFE, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x84, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFB, 0x80, 0x07, 0xFE, 0xFE, 0x07, 0xFF, 0xBF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x80,
  0x07, 0xF0, 0xFF, 0xC0, 0xFF, 0x3F, 0xFE, 0x0F, 0xF7, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x3F,
  0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF, 0xDF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF, 0xF0, 0x0F, 0xFB, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF,
  0x8F, 0xE0, 0x7F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x38, 0x04, 0x07, 0xF0, 0xFF,
  0x3F, 0xE7, 0xFE, 0xFF, 0xDF, 0xF1, 0xFE, 0x1F, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x7E, 0x03, 0xFF, 0x18, 0x00, 0x7F, 0x88, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC1, 0xF8, 0x03, 0xFF, 0xC0, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0x0F, 0xE3,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7E, 0x7F, 0x07, 0xFF, 0xFF, 0x07, 0xE7, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x3F, 0x03, 0xFF, 0xC1, 0xFE,
  0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x03,
  0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xFF, 0xC3, 0xF8, 0x03, 0xF0,
  0x3F, 0xFC, 0x3F, 0x80, 0x3F, 0x03, 0xFF, 0xC3, 0xF8, 0x03, 0xF0, 0x3E,
  0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xEF, 0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0xFC,
  0x1F, 0x80, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x0F, 0xF0, 0xFC, 0xFC, 0x1F,
  0xE1, 0xFF, 0x9F, 0xCF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF,
  0xEF, 0xFF, 0x87, 0xE0, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0x01, 0xFF, 0x83,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFC, 0x07, 0xFF, 0x9F, 0xE0, 0x07,
  0xFE, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xF3, 0xFC,
  0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xDF, 0xE0, 0x03, 0xFE, 0xFF,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x81,
  0xFC, 0x1F, 0xFC, 0x00, 0x70, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x04, 0x1F, 0xFC,
  0x00, 0x38, 0x3F, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x68, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x07,
  0xFE, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFC, 0x1F, 0xFE,
  0x00, 0x0C, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0x1F, 0xFC,
  0x00, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xB0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xDD, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0,
  0x02, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xDF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x01, 0xFF, 0xFF, 0xFB, 0xF8,
  0x00, 0x7E, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0x9F, 0xC0, 0x0F,
  0xEF, 0xFF, 0xE7, 0xF0, 0x03, 0xF3, 0xFF, 0xF9, 0xFC, 0x01, 0xFC, 0xFF,
  0xFE, 0x3F, 0x00, 0x7F, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F, 0x8F, 0xFF, 0xE3,
  0xF8, 0x0F, 0xE3, 0xFF, 0xF8, 0x7E, 0x03, 0xF8, 0xFF, 0xFE, 0x1F, 0xC0,
  0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xFF, 0xE1, 0xFC, 0x1F, 0xC3,
  0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF,
  0x83, 0xF8, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x3F, 0x03, 0xFF, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFB, 0xFE, 0x00,
  0x7F, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xFC, 0x7F,
  0x80, 0x3F, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFE,
  0x1F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xC1, 0xFF, 0xFC, 0x07, 0xFC,
  0x3F, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xFE, 0x00,
  0xFF, 0x8F, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xFF,
  0x00, 0x1F, 0xF7, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF7, 0xF8, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF,
  0xE0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x03, 0xFF,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F,
  0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x7F,
  0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0xFF,
  0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFC, 0xFF, 0x80,
  0x0E, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x00, 0x28, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0x40,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xBF, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x7E, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF0, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x80, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x03, 0xFC, 0xFE, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF,
  0xF0, 0x00, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3C, 0x03, 0xFF, 0x04, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFF, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xF3, 0xFF, 0xFC, 0xFE, 0x3F, 0xFF, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x02,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF3, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xE7, 0xFF, 0xF0, 0xFE, 0x3F,
  0xFE, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xF0, 0x3C, 0x7F, 0xE0, 0x04,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x06, 0x7F, 0xF0, 0x3E,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0x81, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0x0F, 0xFF,
  0xEF, 0xF1, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xF0, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFF, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xEF, 0xF1, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xF0, 0x7F,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFE, 0x7F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x02, 0x7F, 0xF0, 0x03, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xDE,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0x07, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xC0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xCF, 0xF0, 0x7F,
  0xF9, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE4, 0x00, 0x03, 0xFE, 0x70,
  0x00, 0x7F, 0xE7, 0xF8, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0C, 0x00, 0xFF, 0x0F, 0xFE,
  0x0F, 0xF3, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xEF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x3C, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x80, 0x00, 0x78, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0xEF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0xCF, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x83,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x80, 0xFF,
  0x0F, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x00, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0,
  0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x03, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xC0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFE, 0x3F,
  0xFF, 0x0F, 0xE7, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9,
  0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x0F, 0xE0, 0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x0F, 0xF7,
  0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE,
  0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x0F, 0xF3, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xF0, 0x7F, 0x07, 0xFF, 0xCF, 0xF0, 0xFF, 0xFE, 0xFF,
  0x1F, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFE,
  0x07, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0xE0,
  0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF,
  0x1F, 0xFF, 0xCF, 0xF0, 0x7F, 0xF9, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0xC0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x3F, 0x3F, 0xC0, 0x1C,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x87, 0xFF, 0xF8, 0x00, 0x54, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x04, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x1F, 0xFF,
  0xC7, 0xF0, 0x7F, 0xF0, 0x7F, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x9F,
  0xE0, 0x1F, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0x0F, 0xF0,
  0x3F, 0x7E, 0x07, 0xF8, 0x3F, 0xC0, 0xFD, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xF7, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0x8F, 0xC1, 0xFE, 0x07, 0xF8, 0x7E,
  0x3F, 0x0F, 0xF0, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xE3,
  0xF0, 0xFF, 0x00, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x03, 0xFC, 0xFC, 0x1F,
  0x9F, 0xE0, 0x0F, 0xF3, 0xF0, 0x7E, 0x7F, 0x80, 0x1F, 0xCF, 0xC1, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x07, 0xE7, 0xF0, 0x01, 0xFD, 0xF8, 0x0F, 0xDF,
  0xC0, 0x07, 0xF7, 0xE0, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x80, 0x0D, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x80, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_Bold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 40, 16, 3, -39 },
  { 46, 20, 14, 26, 3, -39 },
  { 81, 33, 39, 36, 1, -39 },
  { 242, 27, 45, 31, 2, -42 },
  { 394, 46, 41, 50, 2, -40 },
  { 630, 39, 41, 41, 2, -40 },
  { 830, 8, 14, 15, 3, -39 },
  { 844, 15, 48, 19, 2, -39 },
  { 934, 14, 48, 19, 2, -39 },
  { 1018, 26, 26, 30, 2, -42 },
  { 1103, 27, 27, 31, 2, -33 },
  { 1195, 10, 13, 16, 2, -6 },
  { 1212, 14, 7, 18, 2, -18 },
  { 1225, 9, 9, 15, 3, -8 },
  { 1236, 23, 40, 23, 0, -40 },
  { 1351, 27, 41, 31, 2, -40 },
  { 1490, 20, 39, 31, 3, -39 },
  { 1588, 28, 40, 31, 2, -40 },
  { 1728, 27, 41, 31, 2, -40 },
  { 1867, 30, 39, 31, 1, -39 },
  { 2014, 26, 40, 31, 3, -39 },
  { 2144, 28, 41, 31, 2, -40 },
  { 2288, 29, 39, 31, 1, -39 },
  { 2430, 27, 41, 31, 2, -40 },
  { 2569, 27, 41, 31, 2, -40 },
  { 2708, 9, 32, 15, 3, -31 },
  { 2744, 11, 38, 16, 2, -31 },
  { 2797, 27, 29, 31, 2, -34 },
  { 2895, 27, 17, 31, 2, -28 },
  { 2953, 27, 29, 31, 2, -34 },
  { 3051, 25, 41, 26, 0, -40 },
  { 3180, 44, 44, 49, 3, -40 },
  { 3422, 38, 39, 38, 0, -39 },
  { 3608, 29, 39, 37, 5, -39 },
  { 3750, 31, 41, 35, 3, -40 },
  { 3909, 32, 39, 40, 5, -39 },
  { 4065, 23, 39, 31, 5, -39 },
  { 4178, 22, 39, 30, 5, -39 },
  { 4286, 32, 41, 40, 3, -40 },
  { 4450, 32, 39, 42, 5, -39 },
  { 4606, 18, 39, 21, 2, -39 },
  { 4694, 17, 51, 18, -4, -39 },
  { 4803, 32, 39, 37, 5, -39 },
  { 4959, 24, 39, 31, 5, -39 },
  { 5076, 42, 39, 52, 5, -39 },
  { 5281, 35, 39, 45, 5, -39 },
  { 5452, 37, 41, 44, 3, -40 },
  { 5642, 27, 39, 34, 5, -39 },
  { 5774, 37, 49, 44, 3, -40 },
  { 6001, 31, 39, 36, 5, -39 },
  { 6153, 25, 41, 30, 3, -40 },
  { 6282, 30, 39, 32, 1, -39 },
  { 6429, 32, 40, 42, 5, -39 },
  { 6589, 36, 39, 36, 0, -39 },
  { 6765, 53, 39, 53, 0, -39 },
  { 7024, 37, 39, 37, 0, -39 },
  { 7205, 34, 39, 34, 0, -39 },
  { 7371, 30, 39, 32, 1, -39 },
  { 7518, 13, 48, 18, 4, -39 },
  { 7596, 23, 40, 23, 0, -40 },
  { 7711, 13, 48, 18, 1, -39 },
  { 7789, 29, 25, 31, 1, -39 },
  { 7880, 23, 4, 23, 0, 5 },
  { 7892, 16, 9, 20, 2, -42 },
  { 7910, 27, 32, 33, 2, -31 },
  { 8018, 28, 43, 35, 4, -42 },
  { 8169, 24, 32, 28, 3, -31 },
  { 8265, 28, 43, 35, 3, -42 },
  { 8416, 27, 32, 33, 3, -31 },
  { 8524, 23, 42, 21, 1, -42 },
  { 8645, 28, 44, 35, 3, -31 },
  { 8799, 28, 42, 36, 4, -42 },
  { 8946, 9, 42, 16, 4, -42 },
  { 8994, 16, 55, 16, -3, -42 },
  { 9104, 30, 42, 34, 4, -42 },
  { 9262, 8, 42, 16, 4, -42 },
  { 9304, 46, 31, 54, 4, -31 },
  { 9483, 28, 31, 36, 4, -31 },
  { 9592, 29, 32, 34, 3, -31 },
  { 9708, 28, 44, 35, 4, -31 },
  { 9862, 28, 44, 35, 3, -31 },
  { 10016, 20, 31, 25, 4, -31 },
  { 10094, 22, 32, 28, 3, -31 },
  { 10182, 21, 37, 24, 1, -36 },
  { 10280, 28, 31, 36, 4, -30 },
  { 10389, 31, 30, 31, 0, -30 },
  { 10506, 46, 30, 47, 1, -30 },
  { 10679, 32, 30, 32, 0, -30 },
  { 10799, 31, 43, 31, 0, -30 },
  { 10966, 23, 30, 27, 2, -30 },
  { 11053, 18, 48, 22, 1, -39 },
  { 11161, 6, 54, 30, 12, -42 },
  { 11202, 19, 48, 22, 2, -39 },
  { 11316, 27, 9, 31, 2, -24 },
};

const GFXfont NotoSans_Bold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold55pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_BOLD55PT7B_H_
