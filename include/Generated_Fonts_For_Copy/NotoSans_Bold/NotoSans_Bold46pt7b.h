#ifndef _NOTOSANS_BOLD46PT7B_H_
#define _NOTOSANS_BOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x3E, 0x3E, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x0C, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFE, 0x71, 0xE3,
  0xF8, 0xE0, 0x47, 0xF1, 0xC0, 0x0F, 0xE3, 0x80, 0x1F, 0xE7, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1C, 0xFE, 0x00, 0x38, 0xFF, 0x00, 0x71, 0xFB, 0x80, 0xE7,
  0xF7, 0xF1, 0xDF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x01,
  0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x1F, 0x81, 0xF0, 0x00,
  0xFC, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C,
  0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xF1, 0xF8, 0x00,
  0x0F, 0x87, 0xE3, 0xE1, 0xFC, 0x1F, 0x0F, 0x8F, 0xCF, 0xFC, 0x3F, 0x3F,
  0x1F, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C, 0x7F, 0xFC, 0x7F, 0xF9, 0xF9, 0xFD,
  0xF8, 0x7F, 0xE3, 0xE3, 0xF1, 0xF0, 0x3F, 0x8F, 0xC7, 0xC3, 0xF0, 0x00,
  0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x7E,
  0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x00,
  0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x07, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFC, 0x1F, 0xFE, 0x00, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0x0F, 0xF7, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFF, 0x3F, 0x87, 0xF8, 0x7F, 0xDF, 0xC3, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFC, 0x07, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE7, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xF7, 0xDF, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x18, 0x1F, 0x03, 0x3F, 0x3E, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7C, 0x1F, 0x00, 0x38, 0x38, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7C,
  0x3E, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7F, 0x0C, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE,
  0x7E, 0x01, 0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0x7C, 0x7F,
  0x38, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x0F, 0x80, 0xFF, 0x1C, 0x00, 0xFE, 0x10, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFE, 0x3F, 0xE3,
  0x80, 0x3F, 0x84, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0x7F, 0x00, 0x3E, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x0F,
  0xE0, 0x1F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0x80,
  0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xBF, 0x07, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC7, 0xFC, 0x1F, 0x9F, 0xFC, 0x3F, 0x7F, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x07, 0xF7,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xFE,
  0x3F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF1,
  0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x7F, 0xC7, 0xF0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03,
  0xF7, 0xF8, 0x0F, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC,
  0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x7F, 0x00, 0xFF, 0x7F, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7E, 0x07, 0xFC, 0x7E, 0x00, 0x60, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x08, 0x7F, 0x7F,
  0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7F, 0x0C,
  0x06, 0x0F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0x87, 0xFC, 0xE0, 0x0F, 0xE4, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x18, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0x0F, 0x8F, 0x81, 0xFF, 0xFC, 0x7C,
  0x7C, 0x1F, 0xFF, 0xE1, 0xF7, 0xE1, 0xFF, 0xFE, 0x0F, 0xBE, 0x1F, 0xC1,
  0xF0, 0x7D, 0xF0, 0xFC, 0x0F, 0x83, 0xFF, 0x87, 0xC0, 0x7C, 0x1F, 0xF8,
  0x7E, 0x03, 0xE0, 0xFF, 0xC3, 0xF0, 0x1F, 0x07, 0xFE, 0x1F, 0x00, 0xF8,
  0x3F, 0xF0, 0xF8, 0x07, 0xC1, 0xFF, 0x87, 0xE0, 0x3E, 0x0F, 0xFC, 0x3F,
  0x03, 0xF0, 0xFB, 0xE0, 0xF8, 0x1F, 0x87, 0xDF, 0x87, 0xF3, 0xFE, 0x7C,
  0x7C, 0x1F, 0xFF, 0xFF, 0xE3, 0xE0, 0xFF, 0xF7, 0xFE, 0x1F, 0x83, 0xFF,
  0x1F, 0xE0, 0x7C, 0x03, 0xE0, 0x3C, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x38, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0xC7, 0xFF, 0xC7, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xE7,
  0xF0, 0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFB, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0xDF, 0xC0, 0x1F, 0xF3, 0xF8, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF8, 0x01, 0xFC, 0xFF, 0x80,
  0x3F, 0x9F, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE3,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x83, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x8F, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xDF,
  0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xE0,
  0x0F, 0xE7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x83,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01,
  0xFE, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFD, 0xF0,
  0x01, 0xF7, 0xFF, 0xBF, 0x00, 0x3E, 0xFF, 0xF7, 0xE0, 0x0F, 0xDF, 0xFE,
  0xFC, 0x01, 0xFB, 0xFF, 0xCF, 0x80, 0x3E, 0x7F, 0xF9, 0xF8, 0x0F, 0xCF,
  0xFF, 0x3F, 0x01, 0xF9, 0xFF, 0xE3, 0xE0, 0x3E, 0x3F, 0xFC, 0x7E, 0x0F,
  0xC7, 0xFF, 0x8F, 0xC1, 0xF8, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0xFE, 0x1F,
  0x8F, 0xC3, 0xFF, 0xC3, 0xF1, 0xF8, 0x7F, 0xF8, 0x7E, 0x3E, 0x0F, 0xFF,
  0x07, 0xEF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xBE, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xE0, 0x0F,
  0xFF, 0x7F, 0x80, 0x7F, 0xF9, 0xFE, 0x03, 0xFF, 0xC7, 0xF0, 0x1F, 0xFE,
  0x3F, 0xC0, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0x87, 0xF8, 0x3F, 0xFC, 0x1F,
  0xC1, 0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0x03, 0xFC, 0x7F, 0xF8, 0x0F, 0xE3,
  0xFF, 0xC0, 0x7F, 0x9F, 0xFE, 0x01, 0xFC, 0xFF, 0xF0, 0x0F, 0xF7, 0xFF,
  0x80, 0x3F, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03,
  0xFC, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xBF, 0x81, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F,
  0xBF, 0x80, 0xFF, 0x7F, 0x1F, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8,
  0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xCF,
  0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xF0, 0x07, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFA, 0x00, 0x0F, 0xEF, 0x00, 0x3F,
  0xBF, 0xC7, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xFC, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xC0,
  0x07, 0xF7, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xE0, 0x07,
  0xE7, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0xC3, 0xF8,
  0x07, 0xFF, 0x01, 0xFC, 0x1F, 0x80, 0xFD, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F,
  0xDF, 0x01, 0xFC, 0x1F, 0xC0, 0xF9, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x9F,
  0x83, 0xF8, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0,
  0x07, 0xE3, 0xF0, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x07,
  0xF3, 0xF0, 0x7E, 0x7E, 0x00, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0x03, 0xF7,
  0xE0, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x03, 0xEF, 0xE0, 0x03, 0xF7, 0xC0,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF9,
  0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80,
  0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xBF, 0xF0, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0x3F, 0xFC, 0x7C, 0x7F, 0xE1, 0xF0, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x02, 0x00, 0xFE, 0x3F, 0xE0, 0xFE, 0x7F, 0xF0, 0xFE,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFC, 0x7F, 0xF0, 0xFC, 0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F,
  0xC0, 0xE7, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0x7F, 0xE0,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x7F, 0x07, 0xFC, 0x7F, 0x0F, 0xFF,
  0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFC, 0x7F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7E,
  0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x23, 0xFC, 0x01, 0xC7, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xE1, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x07, 0xFC, 0x3F, 0x0F, 0xFF, 0x7F, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80,
  0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0x7F, 0x0F, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x30, 0x01, 0xFE, 0x3F, 0xDF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x06, 0x00, 0xFE, 0x3F,
  0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0x00, 0x00, 0x00, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x01, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F,
  0xF8, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xDF, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0xC7, 0xE0, 0x3F, 0xC3, 0xF0,
  0x3F, 0xC1, 0xF8, 0x3F, 0xC0, 0xFC, 0x3F, 0xC0, 0x7E, 0x3F, 0xC0, 0x3F,
  0x3F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xC0,
  0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0, 0xFF, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0xE1, 0xF8, 0x07, 0xF8, 0xFC, 0x01, 0xFE, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x02, 0x00, 0x06, 0x01, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xF3, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xE0, 0xFF, 0x7F, 0xC0,
  0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0x00, 0xFC, 0x3F,
  0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0xFC, 0x3F, 0xE0, 0xFC, 0x7F, 0xF0, 0xFE, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x81, 0xFE, 0xFF,
  0xC3, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFE,
  0xFF, 0xF0, 0xFE, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x3F, 0x0F, 0xFF, 0x7F, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x7E, 0x1F, 0xFF, 0x1F, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0x1F, 0xBF, 0x80, 0x67, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x87, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x87, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x3F, 0x0F, 0xFC, 0x3F, 0xFE, 0x00,
  0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87,
  0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xF8, 0x1F, 0xC7, 0xF0, 0x3D, 0xF0,
  0x3F, 0x0F, 0xE0, 0xFB, 0xE0, 0xFE, 0x0F, 0xC1, 0xF7, 0xC1, 0xFC, 0x1F,
  0xC3, 0xE7, 0xC3, 0xF0, 0x3F, 0x8F, 0xCF, 0x87, 0xE0, 0x7F, 0x1F, 0x1F,
  0x1F, 0xC0, 0x7E, 0x3E, 0x3E, 0x3F, 0x80, 0xFE, 0x7C, 0x7E, 0x7E, 0x01,
  0xFC, 0xF8, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0xFB, 0xF8, 0x03, 0xF7, 0xC1,
  0xF7, 0xE0, 0x07, 0xEF, 0x83, 0xEF, 0xC0, 0x0F, 0xDF, 0x03, 0xDF, 0x80,
  0x0F, 0xBC, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xCF, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x0F,
  0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF9, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x01, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x07, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8,
  0x01, 0xFF, 0xA0, 0x00, 0x20,
};

const GFXglyph NotoSans_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 34, 13, 2, -33 },
  { 35, 16, 12, 22, 3, -33 },
  { 59, 28, 33, 30, 1, -33 },
  { 175, 23, 38, 26, 2, -35 },
  { 285, 39, 33, 41, 1, -33 },
  { 446, 33, 33, 35, 2, -33 },
  { 583, 6, 12, 12, 3, -33 },
  { 592, 12, 40, 16, 2, -33 },
  { 652, 13, 40, 16, 1, -33 },
  { 717, 23, 22, 25, 1, -35 },
  { 781, 22, 22, 26, 2, -27 },
  { 842, 9, 11, 13, 1, -5 },
  { 855, 12, 6, 15, 1, -15 },
  { 864, 8, 8, 13, 2, -7 },
  { 872, 19, 33, 19, 0, -33 },
  { 951, 23, 33, 26, 2, -33 },
  { 1046, 16, 33, 26, 3, -33 },
  { 1112, 23, 33, 26, 2, -33 },
  { 1207, 22, 33, 26, 2, -33 },
  { 1298, 25, 33, 26, 1, -33 },
  { 1402, 22, 33, 26, 2, -33 },
  { 1493, 23, 33, 26, 2, -33 },
  { 1588, 24, 33, 26, 1, -33 },
  { 1687, 23, 33, 26, 2, -33 },
  { 1782, 24, 33, 26, 1, -33 },
  { 1881, 8, 27, 13, 2, -26 },
  { 1908, 9, 32, 13, 1, -26 },
  { 1944, 22, 24, 26, 2, -29 },
  { 2010, 22, 14, 26, 2, -23 },
  { 2049, 22, 24, 26, 2, -29 },
  { 2115, 21, 34, 22, 0, -33 },
  { 2205, 37, 37, 41, 2, -33 },
  { 2377, 32, 33, 32, 0, -33 },
  { 2509, 24, 33, 31, 4, -33 },
  { 2608, 25, 33, 30, 3, -33 },
  { 2712, 27, 33, 34, 4, -33 },
  { 2824, 19, 33, 26, 4, -33 },
  { 2903, 19, 33, 25, 4, -33 },
  { 2982, 27, 33, 33, 3, -33 },
  { 3094, 27, 33, 35, 4, -33 },
  { 3206, 15, 33, 18, 1, -33 },
  { 3268, 14, 43, 15, -3, -33 },
  { 3344, 27, 33, 31, 4, -33 },
  { 3456, 20, 33, 26, 4, -33 },
  { 3539, 35, 33, 43, 4, -33 },
  { 3684, 29, 33, 37, 4, -33 },
  { 3804, 31, 33, 36, 3, -33 },
  { 3932, 23, 33, 29, 4, -33 },
  { 4027, 31, 41, 36, 3, -33 },
  { 4186, 26, 33, 30, 4, -33 },
  { 4294, 22, 33, 25, 2, -33 },
  { 4385, 25, 33, 27, 1, -33 },
  { 4489, 27, 33, 35, 4, -33 },
  { 4601, 30, 33, 30, 0, -33 },
  { 4725, 44, 33, 44, 0, -33 },
  { 4907, 31, 33, 31, 0, -33 },
  { 5035, 29, 33, 29, 0, -33 },
  { 5155, 25, 33, 27, 1, -33 },
  { 5259, 11, 40, 15, 3, -33 },
  { 5314, 19, 33, 19, 0, -33 },
  { 5393, 11, 40, 15, 1, -33 },
  { 5448, 24, 21, 26, 1, -33 },
  { 5511, 19, 3, 19, 0, 4 },
  { 5519, 13, 7, 17, 2, -35 },
  { 5531, 22, 26, 28, 2, -26 },
  { 5603, 24, 35, 29, 3, -35 },
  { 5708, 20, 26, 24, 2, -26 },
  { 5773, 24, 35, 29, 2, -35 },
  { 5878, 23, 26, 27, 2, -26 },
  { 5953, 19, 35, 18, 1, -35 },
  { 6037, 24, 37, 29, 2, -26 },
  { 6148, 24, 35, 30, 3, -35 },
  { 6253, 8, 35, 14, 3, -35 },
  { 6288, 13, 46, 14, -2, -35 },
  { 6363, 25, 35, 29, 4, -35 },
  { 6473, 7, 35, 14, 3, -35 },
  { 6504, 39, 26, 45, 3, -26 },
  { 6631, 24, 26, 30, 3, -26 },
  { 6709, 25, 26, 29, 2, -26 },
  { 6791, 24, 37, 29, 3, -26 },
  { 6902, 24, 37, 29, 2, -26 },
  { 7013, 17, 26, 21, 3, -26 },
  { 7069, 19, 26, 23, 2, -26 },
  { 7131, 17, 30, 20, 1, -30 },
  { 7195, 24, 25, 30, 3, -25 },
  { 7270, 26, 25, 26, 0, -25 },
  { 7352, 39, 25, 39, 0, -25 },
  { 7474, 26, 25, 27, 0, -25 },
  { 7556, 26, 36, 26, 0, -25 },
  { 7673, 20, 25, 23, 1, -25 },
  { 7736, 15, 40, 18, 1, -33 },
  { 7811, 5, 45, 25, 10, -35 },
  { 7840, 15, 40, 18, 2, -33 },
  { 7915, 22, 8, 26, 2, -20 },
};

const GFXfont NotoSans_Bold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold46pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_BOLD46PT7B_H_
