#ifndef _NOTOSANS_BOLD24PT7B_H_
#define _NOTOSANS_BOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x70, 0x02, 0xFF, 0x70, 0xF3, 0xB9,
  0xDC, 0xEE, 0x77, 0x3B, 0x9C, 0x06, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x98,
  0x0C, 0x63, 0xFF, 0xFF, 0xFF, 0xC7, 0x38, 0x1C, 0xC0, 0x63, 0x0F, 0xFF,
  0xBF, 0xFE, 0x39, 0xC0, 0xE6, 0x03, 0x18, 0x0C, 0xE0, 0x73, 0x80, 0x06,
  0x00, 0x60, 0x3F, 0xF7, 0xFE, 0xFF, 0xEF, 0x60, 0xF6, 0x0F, 0xE0, 0x7F,
  0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x06, 0xF8, 0x6F, 0xFF, 0xEF, 0xFE, 0x7F,
  0x80, 0x60, 0x06, 0x00, 0x7C, 0x07, 0x0F, 0xE0, 0xE0, 0xE7, 0x0E, 0x0E,
  0x71, 0xC0, 0xE7, 0x18, 0x0E, 0x73, 0x80, 0xE7, 0x71, 0x0E, 0x77, 0x7C,
  0xFE, 0xEF, 0xE7, 0xCE, 0xE7, 0x01, 0xCE, 0x70, 0x1C, 0xE7, 0x03, 0x8E,
  0x70, 0x30, 0xE7, 0x07, 0x0E, 0x70, 0xE0, 0x7E, 0x0E, 0x03, 0xC0, 0x1F,
  0xC0, 0x1F, 0xF0, 0x0F, 0x78, 0x0F, 0x1C, 0x07, 0x8E, 0x01, 0xCF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0x3F, 0xC7, 0xBC, 0xF3, 0x9E, 0x3F,
  0xCF, 0x0F, 0xC7, 0x83, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xCF, 0x80,
  0xF7, 0x77, 0x77, 0x1C, 0xE3, 0x9C, 0x71, 0xCE, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8F, 0x1C, 0x71, 0xE3, 0x8F, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x38, 0xE7, 0x1C, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x67, 0x3F, 0xFF, 0xFF, 0xC7, 0xC0, 0xD8, 0x3B, 0x8F,
  0x38, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x77, 0xFE, 0xEE, 0xFF,
  0xFF, 0xC0, 0x2F, 0xF7, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x00, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x1E, 0xF0, 0xEF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xE7, 0x1E, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0x07, 0x87, 0xC7, 0xEF, 0xFF, 0xFB, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80,
  0x3F, 0x87, 0xFE, 0xFF, 0xE6, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0x8F, 0xFE, 0x7F, 0xE4, 0x1E, 0x00, 0xE0, 0x1E, 0x03,
  0xC1, 0xF8, 0x1F, 0x81, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x1F, 0xFF,
  0xEF, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0x70, 0x73, 0x83, 0x9C, 0x38, 0xE3, 0x87, 0x1C, 0x39, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC7, 0x00, 0x70, 0x07, 0x00, 0x7F, 0x87, 0xFC, 0x7F, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x0F, 0xE1,
  0xFE, 0x3F, 0xE7, 0x80, 0x70, 0x0F, 0x00, 0xE7, 0xCE, 0xFE, 0xFF, 0xEF,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F, 0xE3, 0xFE, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x00, 0x3F, 0x87, 0xFE, 0x79, 0xEF, 0x0E, 0xF0, 0xE7, 0x1E, 0x7F,
  0xC3, 0xF8, 0x3F, 0x87, 0xFE, 0xF1, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFB,
  0xE7, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xFC, 0xFF, 0xEF, 0x1E, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0x02, 0xFF,
  0x70, 0x7F, 0xF2, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xEE, 0x00, 0x10, 0x07,
  0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x3F, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00,
  0x7F, 0x9F, 0xF9, 0xFF, 0xA0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x18, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x1E, 0x00, 0xE3, 0x0F, 0x8E,
  0xE3, 0xF9, 0xD8, 0xF3, 0x1F, 0x38, 0x63, 0xE7, 0x0C, 0x7C, 0xE3, 0x8F,
  0x9C, 0x71, 0xF3, 0x8E, 0x7E, 0x3F, 0xFC, 0xC7, 0xCF, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x1E, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0xC0, 0x39,
  0xE0, 0x3C, 0x70, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xFF, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x80, 0xFF,
  0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0x78, 0x7B, 0xC7, 0xDF, 0xFC,
  0xFF, 0xE7, 0x9F, 0xBC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xDF,
  0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0x02, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x23, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3, 0xFF,
  0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF, 0x3F,
  0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0x01, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x3F, 0xF0, 0xFF, 0xC3, 0xF7, 0x01, 0xDE, 0x07, 0x78, 0x1D, 0xF0, 0x73,
  0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1C, 0xFF,
  0xFF, 0x7C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0xFE,
  0xFC, 0xF8, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0x3C, 0x78, 0xF3, 0xC3, 0xDE,
  0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0x3C, 0x3C, 0xF0, 0xF1,
  0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xEE, 0x0F, 0xFB, 0x83, 0xFE, 0xE1, 0xDF,
  0xB8, 0x77, 0xE7, 0x1D, 0xF9, 0xCE, 0x7E, 0x73, 0x9F, 0x8E, 0xE7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xC0, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7E, 0xE0, 0xFD, 0xE1, 0xF9, 0xE3,
  0xF3, 0xC7, 0xE3, 0xCF, 0xC7, 0x9F, 0x87, 0xBF, 0x07, 0x7E, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3E, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xE0,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x8F, 0xFE, 0xFF,
  0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xE0, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xFE,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0xF8, 0xFF, 0xC3, 0xFE,
  0x0F, 0x3C, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0,
  0x7C, 0x3F, 0xCF, 0xFD, 0xFF, 0xF8, 0x2F, 0x01, 0xE0, 0x1F, 0x03, 0xF8,
  0x3F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x83, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0xF0,
  0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x38, 0x3C, 0x3C,
  0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x38, 0x1F,
  0xE0, 0xF8, 0x3D, 0xC1, 0xF0, 0x7B, 0x83, 0xE0, 0xE7, 0x87, 0xE1, 0xCF,
  0x1D, 0xC7, 0x8E, 0x3B, 0x8F, 0x1C, 0x77, 0x1C, 0x3C, 0xE7, 0x38, 0x7B,
  0x8E, 0xF0, 0x77, 0x1D, 0xE0, 0xEE, 0x3B, 0x81, 0xDC, 0x37, 0x03, 0xF0,
  0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0xF8, 0x1F,
  0x78, 0x3E, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x79,
  0xE0, 0xF1, 0xE3, 0xC3, 0xC7, 0x83, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0x80, 0xF0, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xE0, 0x1F,
  0x01, 0xF0, 0x3B, 0x83, 0x98, 0x31, 0xC7, 0x0C, 0x60, 0xEE, 0x06, 0xE0,
  0x70, 0xFF, 0xFF, 0xF0, 0xF8, 0x70, 0x78, 0x7F, 0xC3, 0xFE, 0x39, 0xE0,
  0x0F, 0x00, 0xF1, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFB, 0xF7,
  0xF7, 0x7E, 0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFC,
  0xFF, 0xEF, 0xFE, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0xFE, 0xFF, 0xEE, 0xFC, 0x1F, 0xE7, 0xF9, 0xFF, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x05, 0xFF, 0x1F, 0xE1, 0xFC,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x73, 0xF7, 0x7F, 0xF7, 0xFF,
  0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0xF7, 0xFF,
  0x7F, 0xF1, 0xF7, 0x1F, 0xC3, 0xFE, 0x79, 0xF7, 0x07, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0xE3, 0xFE, 0x1F, 0xE0, 0x0F,
  0xC7, 0xF1, 0xEC, 0xF0, 0x3C, 0x1F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x3F, 0x77,
  0xFF, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x8F, 0x7F, 0xF7, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x76, 0x0F, 0x7F, 0xE7,
  0xFE, 0x1F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFC,
  0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xEF, 0xE0, 0x0E, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0x1C, 0x3C, 0x70, 0x00, 0x03, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xDF, 0xBE, 0x78,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x7B, 0x87, 0x9C,
  0x78, 0xE7, 0x87, 0x78, 0x3B, 0x81, 0xFE, 0x0F, 0xF8, 0x79, 0xE3, 0x8F,
  0x1C, 0x3C, 0xE0, 0xF7, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xEF, 0xCF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE,
  0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xF0, 0xEF, 0xCF,
  0xFE, 0xFF, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0x7C, 0xE0,
  0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0x9F, 0xFC,
  0x7F, 0xC1, 0xFC, 0x00, 0xEF, 0xCF, 0xFE, 0xFF, 0xEF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xEF, 0xFE, 0xEF, 0xCE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x3F, 0x77, 0xFF,
  0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x8F,
  0x7F, 0xF7, 0xFF, 0x1F, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x3F, 0xDF, 0xFF, 0x1B, 0xC0, 0xF8, 0x1F, 0xC3, 0xF8,
  0x3F, 0x03, 0xE0, 0x7F, 0x7F, 0xFE, 0xFF, 0x00, 0x38, 0x1C, 0x0E, 0x1F,
  0xFF, 0xFF, 0xFD, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFC,
  0xFE, 0x3F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xFF, 0xFF, 0xF7, 0x7E, 0x70, 0xF0, 0x3D,
  0xC1, 0xE7, 0x87, 0x9E, 0x1C, 0x38, 0xF0, 0xF3, 0xC1, 0xCE, 0x07, 0x78,
  0x1D, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0xF0, 0x77,
  0x0F, 0x8F, 0x70, 0xF8, 0xF7, 0x9F, 0x8E, 0x39, 0xD8, 0xE3, 0x9D, 0xDE,
  0x39, 0x9D, 0xC3, 0xF9, 0xDC, 0x1F, 0x8D, 0xC1, 0xF8, 0xDC, 0x1F, 0x0F,
  0x80, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x7D, 0xE1, 0xE3, 0xCF, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0xF3, 0x83,
  0xCF, 0x1E, 0x1E, 0xF0, 0x7C, 0xF0, 0x3D, 0xC1, 0xE7, 0x87, 0x9E, 0x1C,
  0x38, 0xF0, 0xF3, 0xC1, 0xCE, 0x07, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x7E, 0x01, 0xF0,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x03, 0x81, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x87, 0xC7, 0xE3,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x7E, 0x3C, 0x1F, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0x07, 0xE1, 0xF0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x3C, 0x1F, 0x0F, 0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8,
  0xF8, 0xE0, 0xFE, 0x3F, 0xFF, 0x87, 0xE8, 0x08,
};

const GFXglyph NotoSans_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 7, 1, -17 },
  { 10, 9, 6, 12, 1, -17 },
  { 17, 14, 17, 16, 1, -17 },
  { 47, 12, 19, 14, 1, -18 },
  { 76, 20, 17, 22, 1, -17 },
  { 119, 17, 17, 18, 1, -17 },
  { 156, 4, 6, 6, 1, -17 },
  { 159, 6, 21, 8, 1, -17 },
  { 175, 6, 21, 8, 1, -17 },
  { 191, 11, 11, 13, 1, -18 },
  { 207, 12, 11, 14, 1, -14 },
  { 224, 4, 6, 7, 1, -3 },
  { 227, 6, 3, 8, 1, -8 },
  { 230, 4, 4, 7, 1, -4 },
  { 232, 10, 17, 10, 0, -17 },
  { 254, 12, 17, 14, 1, -17 },
  { 280, 9, 17, 14, 1, -17 },
  { 300, 12, 17, 14, 1, -17 },
  { 326, 12, 17, 14, 1, -17 },
  { 352, 13, 17, 14, 0, -17 },
  { 380, 12, 17, 14, 1, -17 },
  { 406, 12, 17, 14, 1, -17 },
  { 432, 12, 17, 14, 1, -17 },
  { 458, 12, 17, 14, 1, -17 },
  { 484, 12, 17, 14, 1, -17 },
  { 510, 4, 13, 7, 1, -13 },
  { 517, 4, 16, 7, 1, -13 },
  { 525, 12, 13, 14, 1, -15 },
  { 545, 12, 7, 14, 1, -12 },
  { 556, 12, 13, 14, 1, -15 },
  { 576, 11, 17, 11, 0, -17 },
  { 600, 19, 19, 22, 1, -17 },
  { 646, 17, 17, 17, 0, -17 },
  { 683, 13, 17, 16, 2, -17 },
  { 711, 14, 17, 15, 1, -17 },
  { 741, 14, 17, 18, 2, -17 },
  { 771, 10, 17, 13, 2, -17 },
  { 793, 10, 17, 13, 2, -17 },
  { 815, 14, 17, 17, 1, -17 },
  { 845, 14, 17, 18, 2, -17 },
  { 875, 8, 17, 9, 1, -17 },
  { 892, 8, 22, 8, -2, -17 },
  { 914, 14, 17, 16, 2, -17 },
  { 944, 11, 17, 13, 2, -17 },
  { 968, 18, 17, 23, 2, -17 },
  { 1007, 15, 17, 20, 2, -17 },
  { 1039, 17, 17, 19, 1, -17 },
  { 1076, 12, 17, 15, 2, -17 },
  { 1102, 17, 21, 19, 1, -17 },
  { 1147, 14, 17, 16, 2, -17 },
  { 1177, 11, 17, 13, 1, -17 },
  { 1201, 13, 17, 14, 0, -17 },
  { 1229, 14, 17, 18, 2, -17 },
  { 1259, 16, 17, 16, 0, -17 },
  { 1293, 23, 17, 23, 0, -17 },
  { 1342, 16, 17, 16, 0, -17 },
  { 1376, 15, 17, 15, 0, -17 },
  { 1408, 12, 17, 14, 1, -17 },
  { 1434, 5, 21, 8, 2, -17 },
  { 1448, 10, 17, 10, 0, -17 },
  { 1470, 5, 21, 8, 1, -17 },
  { 1484, 12, 11, 14, 1, -17 },
  { 1501, 10, 2, 10, 0, 2 },
  { 1504, 7, 3, 9, 1, -18 },
  { 1507, 12, 13, 14, 1, -13 },
  { 1527, 12, 18, 15, 2, -18 },
  { 1554, 11, 13, 12, 1, -13 },
  { 1572, 12, 18, 15, 1, -18 },
  { 1599, 12, 13, 14, 1, -13 },
  { 1619, 10, 18, 9, 0, -18 },
  { 1642, 12, 19, 15, 1, -13 },
  { 1671, 12, 18, 16, 2, -18 },
  { 1698, 4, 18, 7, 2, -18 },
  { 1707, 7, 24, 7, -1, -18 },
  { 1728, 13, 18, 15, 2, -18 },
  { 1758, 3, 18, 7, 2, -18 },
  { 1765, 20, 13, 23, 2, -13 },
  { 1798, 12, 13, 16, 2, -13 },
  { 1818, 13, 13, 15, 1, -13 },
  { 1840, 12, 19, 15, 2, -13 },
  { 1869, 12, 19, 15, 1, -13 },
  { 1898, 8, 13, 11, 2, -13 },
  { 1911, 10, 13, 12, 1, -13 },
  { 1928, 9, 16, 10, 1, -16 },
  { 1946, 12, 13, 16, 2, -13 },
  { 1966, 14, 13, 14, 0, -13 },
  { 1989, 20, 13, 21, 0, -13 },
  { 2022, 14, 13, 14, 0, -13 },
  { 2045, 14, 19, 14, 0, -13 },
  { 2079, 10, 13, 12, 1, -13 },
  { 2096, 9, 21, 9, 0, -17 },
  { 2120, 3, 23, 13, 5, -18 },
  { 2129, 8, 21, 9, 1, -17 },
  { 2150, 12, 4, 14, 1, -10 },
};

const GFXfont NotoSans_Bold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold24pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_BOLD24PT7B_H_
