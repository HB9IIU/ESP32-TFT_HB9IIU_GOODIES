#ifndef _NOTOSANS_BOLD20PT7B_H_
#define _NOTOSANS_BOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xE6, 0x60, 0x0E, 0xFE, 0xEF, 0xCF, 0x9B, 0x36,
  0x60, 0x06, 0x60, 0xEE, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x1D, 0xC1,
  0x98, 0xFF, 0xFF, 0xFF, 0x19, 0x81, 0xB8, 0x33, 0x03, 0x30, 0x08, 0x07,
  0x87, 0xFB, 0xFE, 0xE8, 0x3A, 0x0F, 0x81, 0xFC, 0x1F, 0x82, 0xF0, 0x9F,
  0x2F, 0xFF, 0xBF, 0xC0, 0x80, 0x20, 0x78, 0x38, 0xFC, 0x30, 0xCC, 0x70,
  0xCC, 0x60, 0xCC, 0xC0, 0xCC, 0xCC, 0xFD, 0xBF, 0x7B, 0xB3, 0x03, 0x33,
  0x07, 0x33, 0x06, 0x33, 0x0E, 0x33, 0x0C, 0x3F, 0x18, 0x1E, 0x3F, 0x01,
  0xFE, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x80, 0xFC, 0x03, 0xC3, 0x9F, 0x8E,
  0xE7, 0x3B, 0x8F, 0xCE, 0x1F, 0x3C, 0x78, 0x7F, 0xF0, 0xFC, 0xF0, 0xFF,
  0xB6, 0x39, 0x9C, 0xCE, 0x73, 0x98, 0xC6, 0x39, 0xCE, 0x31, 0xC6, 0x38,
  0xE3, 0x1C, 0x63, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x19, 0xCC, 0xE0, 0x1C,
  0x0E, 0x26, 0x3F, 0xFF, 0xF8, 0xE0, 0xD8, 0xEE, 0x22, 0x00, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xEC, 0xFF, 0xFE, 0xEF, 0xE0, 0x07, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0x08, 0x0F, 0xC7, 0xFB, 0xCE,
  0xE3, 0xB8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0x73, 0x9F,
  0xC3, 0xE0, 0x0E, 0x3D, 0xFF, 0xF6, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC0, 0x7F, 0x3F, 0xE6, 0x39, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xE4,
  0x38, 0x0E, 0x03, 0x8F, 0xC3, 0xC0, 0xFE, 0x03, 0x80, 0xF0, 0x3E, 0x1E,
  0xFF, 0xBF, 0x80, 0x03, 0x80, 0xF0, 0x1E, 0x06, 0xC1, 0xF8, 0x37, 0x0C,
  0xE3, 0x9C, 0x63, 0x9F, 0xFF, 0xFF, 0x81, 0xC0, 0x38, 0x07, 0x00, 0x7F,
  0x9F, 0xE6, 0x01, 0x80, 0xE0, 0x3F, 0xCF, 0xF9, 0x1E, 0x03, 0x80, 0xF0,
  0x3B, 0x1E, 0xFF, 0x3F, 0x80, 0x1F, 0x8F, 0xE7, 0x03, 0x80, 0xE0, 0x3F,
  0xCF, 0xFB, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0xCE, 0x7F, 0x8F, 0xC0, 0xFF,
  0xFF, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1E, 0x00, 0x7F, 0x3F, 0xEE, 0x3B, 0x8E, 0xF3, 0x9F,
  0xC3, 0xE1, 0xFC, 0xE3, 0xB8, 0x7E, 0x1F, 0x8F, 0xFF, 0x9F, 0xC0, 0x7F,
  0x3F, 0xEE, 0x3B, 0x8E, 0xE1, 0xF8, 0x7E, 0x3F, 0xFF, 0x3D, 0x80, 0x60,
  0x38, 0x1C, 0x7F, 0x1F, 0x00, 0xEF, 0xE0, 0x00, 0x00, 0xEF, 0xE0, 0xEF,
  0xE0, 0x00, 0x00, 0x0E, 0xEE, 0xCC, 0x00, 0x40, 0x30, 0x3C, 0x3C, 0x3C,
  0x3C, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0C, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x7C, 0x7C, 0xFC, 0x38, 0x08, 0x00, 0x7F, 0x7F, 0xD0, 0xE0, 0x70, 0x38,
  0x38, 0x38, 0x38, 0x18, 0x00, 0x00, 0x03, 0x83, 0xC0, 0xE0, 0x0F, 0xF0,
  0x1F, 0x7C, 0x38, 0x0E, 0x71, 0xE6, 0x67, 0xF3, 0xEE, 0x33, 0xCC, 0x33,
  0xCC, 0x73, 0xCC, 0x73, 0xCE, 0x76, 0xC7, 0xFE, 0x63, 0x9C, 0x70, 0x00,
  0x3C, 0x30, 0x1F, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xF0, 0x1C, 0xC0, 0x73, 0x81, 0xCE, 0x0E, 0x1C, 0x3F, 0xF0, 0xFF, 0xC7,
  0xFF, 0x9C, 0x0E, 0x70, 0x3B, 0x80, 0xF0, 0xFF, 0x3F, 0xEE, 0x3F, 0x87,
  0xE1, 0xFF, 0xEF, 0xF3, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xFF, 0xBF,
  0xC0, 0x1F, 0xE7, 0xFD, 0xE1, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3E, 0x33, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xFC,
  0xE3, 0xEE, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0xF3,
  0xFE, 0x7C, 0x27, 0x00, 0xF0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE3, 0xFF,
  0x07, 0x70, 0x77, 0xC7, 0x3F, 0xF1, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xFF, 0xF0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xEE, 0xFB, 0xC0, 0xE1, 0xFC, 0x7B, 0x8E, 0x73, 0x8E, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xEF, 0x1C, 0xE3, 0x8E, 0x71, 0xEE, 0x1D, 0xC1,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1F, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFE, 0xC1,
  0xFD, 0x87, 0xFB, 0x8D, 0xF3, 0x1B, 0xF6, 0x77, 0xEE, 0xCF, 0xDD, 0x9F,
  0x9F, 0x3F, 0x3C, 0x7E, 0x78, 0xFC, 0x71, 0xC0, 0xF0, 0x3F, 0x83, 0xF8,
  0x3D, 0xC3, 0xDC, 0x3C, 0xE3, 0xCF, 0x3E, 0x73, 0xE7, 0xBE, 0x3B, 0xE1,
  0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0x02, 0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x1E,
  0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03,
  0x9C, 0x0E, 0x7C, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0x3F, 0xEE, 0x3B,
  0x8F, 0xE3, 0xF8, 0xEF, 0xFB, 0xFC, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x02, 0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0,
  0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0x9C, 0x0E, 0x7C,
  0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0xFF, 0x1F,
  0xF3, 0x8E, 0x70, 0xEE, 0x1D, 0xC7, 0x3F, 0xE7, 0xF0, 0xFF, 0x1C, 0xE3,
  0x8E, 0x71, 0xEE, 0x1D, 0xC3, 0xC0, 0x3F, 0xBF, 0xF8, 0x5C, 0x0F, 0x03,
  0xC1, 0xF8, 0x3E, 0x07, 0x81, 0xC0, 0xFC, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF,
  0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0xF7, 0xFC,
  0x7F, 0x00, 0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70,
  0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x03,
  0x80, 0xE0, 0xE0, 0xFC, 0x1E, 0x1D, 0xC3, 0xC3, 0xB8, 0xF8, 0xE7, 0x1B,
  0x1C, 0xE3, 0x73, 0x8E, 0xEE, 0x71, 0xDC, 0xCC, 0x3B, 0x1B, 0x87, 0x63,
  0xF0, 0x6C, 0x7E, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x1C, 0x1E, 0x00, 0xF0,
  0x7B, 0xC3, 0x8E, 0x38, 0x3B, 0xC1, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0xC0, 0xEE, 0x0F, 0x38, 0x71, 0xE7, 0x07, 0x78, 0x3C, 0xF0, 0x7B,
  0x87, 0x9E, 0x38, 0x73, 0x81, 0xDC, 0x0F, 0xC0, 0x3E, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x7F, 0xEF, 0xFC,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9F, 0xF8, 0xE0, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C,
  0x1C, 0x0C, 0x0E, 0x0E, 0x07, 0x07, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x0E, 0x01, 0xC0, 0x7C, 0x0D, 0x83, 0xB8,
  0x63, 0x0C, 0x73, 0x06, 0xE0, 0xE0, 0xFF, 0xF0, 0xE1, 0xC0, 0x3F, 0x1F,
  0xE2, 0x38, 0x07, 0x1F, 0xDF, 0xFE, 0x1F, 0x8F, 0xE3, 0xFF, 0xF7, 0xDC,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xF9, 0xFF, 0xBE, 0x77, 0x8F, 0xF0,
  0xFC, 0x1F, 0xC3, 0xF8, 0xFF, 0x1D, 0xFF, 0xBB, 0xE0, 0x1F, 0xBF, 0x9C,
  0x5C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF1, 0x3F, 0x8F, 0xC0, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x3D, 0xDF, 0xFF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xF3, 0xDF, 0xF3, 0xCC, 0x3F, 0x1F, 0xE7, 0x1F, 0x87, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0x70, 0x9F, 0xE3, 0xF8, 0x1F, 0x9F, 0x8E, 0x07, 0x07,
  0xF7, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x3C, 0xDF, 0xFF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF,
  0xF3, 0xDC, 0x07, 0x01, 0xDF, 0xF7, 0xF8, 0xF8, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0xF9, 0xFF, 0xBE, 0x77, 0x8F, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0xEF, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0xF1, 0x80, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x3B, 0xEF, 0xBC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xF9, 0xEE,
  0x73, 0xB8, 0xDC, 0x3F, 0x0F, 0xE3, 0xBC, 0xE7, 0xB8, 0xEE, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF, 0x9F, 0x7F, 0xFF, 0xFE, 0xF9, 0xFE,
  0x3C, 0x7F, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3,
  0xF0, 0xE1, 0xF8, 0x70, 0xE0, 0xEF, 0x9F, 0xFB, 0xE7, 0x78, 0xFF, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0x3F, 0x0F, 0xF1,
  0xCF, 0x70, 0xEE, 0x1D, 0xC3, 0xF8, 0x77, 0x0E, 0x71, 0xCF, 0xF0, 0xFC,
  0x00, 0xEF, 0x9F, 0xFB, 0xE7, 0x78, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xDF, 0xFB, 0xBE, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3C,
  0xDF, 0xFF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3,
  0xDC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xE7, 0xEF, 0xFE, 0xF0, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0xE2, 0xE0, 0xFC, 0x7E,
  0x1F, 0x07, 0x87, 0xFF, 0xFE, 0x18, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0x73, 0xEF, 0xFC, 0xFB, 0x80, 0xE0, 0xEE,
  0x1D, 0xC7, 0xB8, 0xE3, 0x9C, 0x73, 0x0E, 0xE0, 0xDC, 0x1F, 0x01, 0xE0,
  0x38, 0x00, 0xE1, 0xC3, 0xB8, 0xF1, 0xDC, 0xD9, 0xCE, 0x6C, 0xE7, 0x36,
  0x71, 0xDB, 0xB0, 0xFC, 0xF8, 0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07,
  0x8F, 0x00, 0xF0, 0xEF, 0x38, 0xEF, 0x0F, 0xC1, 0xF0, 0x1E, 0x07, 0xC1,
  0xFC, 0x39, 0xCE, 0x3B, 0xC3, 0x80, 0xE0, 0xEE, 0x1D, 0xC3, 0xB8, 0xE3,
  0x9C, 0x73, 0x06, 0xE0, 0xFC, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0xF8, 0x1F, 0x03, 0x80, 0xFF, 0xFF, 0x07, 0x0E, 0x1C, 0x3C, 0x38, 0x70,
  0xE0, 0xFF, 0xFF, 0x1E, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x7C, 0xE1, 0xF0,
  0x60, 0xC1, 0x83, 0x07, 0x0F, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x0C, 0x1F, 0x0E, 0x7C, 0xC3,
  0x87, 0x0E, 0x1C, 0x78, 0xE0, 0x70, 0x7F, 0xFD, 0xFE, 0x0C,
};

const GFXglyph NotoSans_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 6, 1, -14 },
  { 8, 7, 5, 10, 1, -14 },
  { 13, 12, 14, 13, 0, -14 },
  { 34, 10, 16, 11, 1, -15 },
  { 54, 16, 14, 18, 1, -14 },
  { 82, 14, 14, 15, 1, -14 },
  { 107, 3, 5, 5, 1, -14 },
  { 109, 5, 17, 7, 1, -14 },
  { 120, 5, 17, 7, 1, -14 },
  { 131, 9, 9, 11, 1, -15 },
  { 142, 10, 10, 11, 1, -12 },
  { 155, 3, 5, 6, 1, -2 },
  { 157, 5, 3, 6, 1, -7 },
  { 159, 4, 3, 6, 1, -3 },
  { 161, 8, 14, 8, 0, -14 },
  { 175, 10, 15, 11, 1, -15 },
  { 194, 7, 14, 11, 1, -14 },
  { 207, 10, 14, 11, 1, -14 },
  { 225, 10, 14, 11, 1, -14 },
  { 243, 11, 14, 11, 0, -14 },
  { 263, 10, 14, 11, 1, -14 },
  { 281, 10, 14, 11, 1, -14 },
  { 299, 10, 14, 11, 1, -14 },
  { 317, 10, 14, 11, 1, -14 },
  { 335, 10, 14, 11, 1, -14 },
  { 353, 4, 11, 6, 1, -11 },
  { 359, 4, 14, 6, 1, -11 },
  { 366, 10, 11, 11, 1, -13 },
  { 380, 10, 6, 11, 1, -10 },
  { 388, 10, 11, 11, 1, -13 },
  { 402, 9, 14, 10, 0, -14 },
  { 418, 16, 16, 18, 1, -14 },
  { 450, 14, 14, 14, 0, -14 },
  { 475, 10, 14, 13, 2, -14 },
  { 493, 11, 14, 13, 1, -14 },
  { 513, 12, 14, 15, 2, -14 },
  { 534, 8, 14, 11, 2, -14 },
  { 548, 8, 14, 11, 2, -14 },
  { 562, 12, 14, 14, 1, -14 },
  { 583, 12, 14, 15, 2, -14 },
  { 604, 6, 14, 8, 1, -14 },
  { 615, 6, 18, 7, -1, -14 },
  { 629, 11, 14, 13, 2, -14 },
  { 649, 9, 14, 11, 2, -14 },
  { 665, 15, 14, 19, 2, -14 },
  { 692, 12, 14, 16, 2, -14 },
  { 713, 14, 15, 16, 1, -15 },
  { 740, 10, 14, 12, 2, -14 },
  { 758, 14, 18, 16, 1, -15 },
  { 790, 11, 14, 13, 2, -14 },
  { 810, 9, 14, 11, 1, -14 },
  { 826, 11, 14, 12, 0, -14 },
  { 846, 11, 14, 15, 2, -14 },
  { 866, 13, 14, 13, 0, -14 },
  { 889, 19, 14, 19, 0, -14 },
  { 923, 13, 14, 13, 0, -14 },
  { 946, 13, 14, 13, 0, -14 },
  { 969, 11, 14, 12, 0, -14 },
  { 989, 5, 17, 7, 1, -14 },
  { 1000, 8, 14, 8, 0, -14 },
  { 1014, 5, 17, 7, 0, -14 },
  { 1025, 11, 9, 11, 0, -14 },
  { 1038, 8, 1, 8, 0, 2 },
  { 1039, 6, 3, 7, 1, -15 },
  { 1042, 10, 11, 12, 1, -11 },
  { 1056, 11, 15, 13, 1, -15 },
  { 1077, 9, 11, 10, 1, -11 },
  { 1090, 10, 15, 13, 1, -15 },
  { 1109, 10, 11, 12, 1, -11 },
  { 1123, 9, 15, 8, 0, -15 },
  { 1140, 10, 16, 13, 1, -11 },
  { 1160, 11, 15, 13, 1, -15 },
  { 1181, 4, 15, 6, 1, -15 },
  { 1189, 6, 20, 6, -1, -15 },
  { 1204, 10, 15, 12, 2, -15 },
  { 1223, 3, 15, 6, 1, -15 },
  { 1229, 17, 11, 20, 1, -11 },
  { 1253, 11, 11, 13, 1, -11 },
  { 1269, 11, 11, 13, 1, -11 },
  { 1285, 11, 16, 13, 1, -11 },
  { 1307, 10, 16, 13, 1, -11 },
  { 1327, 8, 11, 9, 1, -11 },
  { 1338, 8, 11, 10, 1, -11 },
  { 1349, 8, 13, 9, 0, -13 },
  { 1362, 11, 11, 13, 1, -11 },
  { 1378, 11, 11, 11, 0, -11 },
  { 1394, 17, 11, 17, 0, -11 },
  { 1418, 11, 11, 12, 0, -11 },
  { 1434, 11, 16, 11, 0, -11 },
  { 1456, 8, 11, 10, 1, -11 },
  { 1467, 7, 17, 8, 0, -14 },
  { 1482, 3, 20, 11, 4, -15 },
  { 1490, 7, 17, 8, 1, -14 },
  { 1505, 10, 4, 11, 1, -9 },
};

const GFXfont NotoSans_Bold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold20pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_BOLD20PT7B_H_
