#ifndef _NOTOSANS_BOLD58PT7B_H_
#define _NOTOSANS_BOLD58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0x7F, 0x87, 0x80, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xEF, 0x3F, 0x87, 0xFC, 0x78, 0x1C, 0x3F, 0xC3, 0xC0, 0x03, 0xFE,
  0x1E, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x7F, 0xC7, 0x80, 0x03, 0xFF, 0xBC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7B, 0xFF, 0x80, 0x03, 0xCF, 0xFC, 0x00, 0x1E, 0x3F,
  0xE0, 0x00, 0xF1, 0xFF, 0x40, 0x07, 0x8F, 0xFB, 0xC0, 0x3C, 0x7F, 0xDF,
  0xE1, 0xEF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x1F,
  0xF0, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xFC, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F,
  0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x8F, 0xF3, 0xF8, 0x3F, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x0F, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0xBF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x08, 0x01, 0xF8, 0x02, 0x78, 0x1F, 0x01, 0xEF, 0xF1, 0xF1,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x87, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0xFF, 0xBF, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE,
  0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0x9F, 0xF3,
  0xF0, 0xFF, 0x8F, 0x07, 0xFC, 0x30, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x3F,
  0xF0, 0xF8, 0x00, 0xFF, 0x83, 0x00, 0x07, 0xFC, 0x10, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xFC, 0x1E, 0x00, 0x3F, 0xF0, 0x40, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xBC, 0x00, 0x1F, 0xFD, 0xFF, 0x1F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F,
  0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x08, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x80, 0x00, 0x7F, 0xEF,
  0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x04,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xFE, 0x03, 0xF9, 0xFF, 0xFC,
  0x3F, 0xDF, 0xFF, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0xCF, 0xFC,
  0x0F, 0xFC, 0x7F, 0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7,
  0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x1F, 0xF0,
  0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xF7, 0xFF, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xE7, 0xF8, 0x7F, 0xFE, 0x3F, 0xC0, 0xFF,
  0xE1, 0xFC, 0x00, 0x30, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x30, 0x3F, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFD, 0xFE, 0x1E, 0x00, 0x1F, 0x87, 0xF8, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xCF, 0xF9, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFF, 0x1C, 0x00, 0x7F, 0xC4, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFF, 0xC3, 0xF8, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xE3, 0xF0, 0x1F, 0xFF,
  0xFC, 0x1F, 0xDF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xFE, 0x1F,
  0xC0, 0xFD, 0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xFF, 0xE0, 0xFF, 0x00, 0xFC,
  0x0F, 0xFF, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0,
  0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x01, 0xFC, 0x0F,
  0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xFF,
  0x07, 0xF0, 0x0F, 0xF0, 0x7E, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFB, 0xF0,
  0x3F, 0xC1, 0xFF, 0x0F, 0xCF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x03, 0xFF, 0xF3, 0xFF, 0xC1, 0xFC, 0x07,
  0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x03,
  0x00, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE1, 0xFF, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFD,
  0xFF, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0x7F,
  0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFC, 0xFF, 0x80,
  0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0x00, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE3, 0xFC,
  0x1F, 0xFE, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0x04, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x06, 0x1F, 0xFF, 0x00, 0x3E,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0x07,
  0xFF, 0x80, 0x00, 0x41, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xF7,
  0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F,
  0xDF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00,
  0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0xF0,
  0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xA0, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x03, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xF7, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xFF, 0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0xFF,
  0x3F, 0x80, 0x0F, 0xEF, 0xFF, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0x3F,
  0x80, 0x1F, 0xCF, 0xFF, 0xF1, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0x1F, 0xC0,
  0x3F, 0x8F, 0xFF, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F,
  0x8F, 0xFF, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F,
  0xFF, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFF, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0x80, 0x0F, 0xFF,
  0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xFC, 0x7F, 0xC0,
  0x1F, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xF8,
  0x7F, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xFC, 0x07,
  0xFE, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xC7, 0xFF,
  0xF8, 0x03, 0xFE, 0x3F, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0xFE, 0x00, 0x7F,
  0xCF, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x58, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF0, 0x1F, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x00,
  0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF,
  0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x5F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0xFF, 0xC0, 0x0F, 0x1F, 0xF0,
  0x00, 0x23, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xDE, 0x00, 0x0F, 0xFB, 0xF8,
  0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x1F,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE3, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F,
  0x81, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xC0, 0x70,
  0x03, 0xFE, 0x02, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFC, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF,
  0x0F, 0xE0, 0xFF, 0xE0, 0x7F, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF9, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF8, 0x07, 0xFE,
  0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0x0F, 0xF1,
  0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1C, 0x7F,
  0xE0, 0x02, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0x7F, 0xF0, 0x07, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xE3, 0xFC, 0x3F, 0xFF, 0x9F,
  0xE3, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xF8, 0x7F,
  0xFF, 0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0x07, 0xF0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF3, 0xFE,
  0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x61, 0xFF, 0xC0, 0x1F,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF8,
  0xFE, 0x3F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0x87,
  0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0x00, 0x10,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x98, 0x00, 0x0F, 0xFC, 0xFC, 0x01, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x3F, 0xFE, 0x0F, 0xF9, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xDF, 0xE0,
  0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00,
  0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0x3F, 0xC7, 0xFE,
  0x00, 0x7F, 0x9F, 0xF8, 0x00, 0xFF, 0x7F, 0xE0, 0x01, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xFC, 0x07,
  0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF8, 0x7F, 0x80, 0x1F, 0xF8, 0xFF, 0x00, 0x3F, 0xF1, 0xFE,
  0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x3F, 0xFE, 0x0F, 0xF3, 0xFF, 0xFE,
  0x3F, 0xDF, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x3F, 0xFC,
  0x0F, 0xF1, 0xFF, 0xF8, 0x3F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF8, 0x07, 0xFE, 0xFF,
  0xF0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF,
  0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x80, 0x40, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x1F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0xEF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0x87, 0xFF, 0xF3, 0xFC, 0x1F,
  0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0x00, 0x10, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xF8, 0xFF, 0x00, 0x18, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xC7, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0x8F, 0xFF, 0xF9,
  0xFC, 0x3F, 0xFF, 0x8F, 0xE0, 0x7F, 0xF0, 0x3F, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x7E, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7E, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x7E, 0x07, 0xF8,
  0x1F, 0xE0, 0xFC, 0x7F, 0x0F, 0xF8, 0x1F, 0xF0, 0xFC, 0x7F, 0x0F, 0xF0,
  0x0F, 0xF1, 0xFC, 0x3F, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x3F, 0x0F, 0xF0,
  0x0F, 0xF1, 0xF8, 0x3F, 0x9F, 0xE0, 0x0F, 0xF1, 0xF8, 0x3F, 0x9F, 0xE0,
  0x07, 0xF9, 0xF8, 0x1F, 0x9F, 0xE0, 0x07, 0xFB, 0xF8, 0x1F, 0x9F, 0xE0,
  0x07, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0x03, 0xFB, 0xF0, 0x1F, 0xBF, 0xC0,
  0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x09, 0xFF,
  0xF0, 0x01, 0xDF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xDC, 0x00, 0xFF, 0xFC,
  0xC0, 0x00, 0xFF, 0xC0,
};

const GFXglyph NotoSans_Bold58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 42, 16, 3, -41 },
  { 54, 20, 15, 28, 4, -41 },
  { 92, 35, 41, 37, 1, -41 },
  { 272, 29, 47, 33, 2, -44 },
  { 443, 49, 43, 52, 2, -42 },
  { 707, 42, 43, 44, 2, -42 },
  { 933, 8, 15, 15, 4, -41 },
  { 948, 16, 50, 20, 2, -41 },
  { 1048, 15, 50, 20, 2, -41 },
  { 1142, 28, 27, 31, 2, -44 },
  { 1237, 29, 29, 33, 2, -35 },
  { 1343, 11, 14, 17, 2, -7 },
  { 1363, 15, 7, 19, 2, -19 },
  { 1377, 10, 10, 16, 3, -9 },
  { 1390, 24, 42, 24, 0, -42 },
  { 1516, 29, 43, 33, 2, -42 },
  { 1672, 21, 41, 33, 3, -41 },
  { 1780, 29, 42, 33, 2, -42 },
  { 1933, 29, 43, 33, 2, -42 },
  { 2089, 31, 41, 33, 1, -41 },
  { 2248, 28, 42, 33, 3, -41 },
  { 2395, 29, 43, 33, 2, -42 },
  { 2551, 29, 41, 33, 2, -41 },
  { 2700, 29, 43, 33, 2, -42 },
  { 2856, 29, 43, 33, 2, -42 },
  { 3012, 10, 33, 16, 3, -32 },
  { 3054, 11, 39, 17, 2, -32 },
  { 3108, 29, 30, 33, 2, -36 },
  { 3217, 29, 17, 33, 2, -29 },
  { 3279, 29, 30, 33, 2, -36 },
  { 3388, 26, 43, 28, 0, -42 },
  { 3528, 46, 47, 52, 3, -42 },
  { 3799, 40, 42, 40, 0, -42 },
  { 4009, 31, 41, 39, 5, -41 },
  { 4168, 32, 43, 37, 3, -42 },
  { 4340, 34, 41, 42, 5, -41 },
  { 4515, 24, 41, 32, 5, -41 },
  { 4638, 24, 41, 32, 5, -41 },
  { 4761, 34, 43, 42, 3, -42 },
  { 4944, 34, 41, 44, 5, -41 },
  { 5119, 19, 41, 23, 2, -41 },
  { 5217, 18, 53, 19, -4, -41 },
  { 5337, 34, 41, 39, 5, -41 },
  { 5512, 26, 41, 32, 5, -41 },
  { 5646, 44, 41, 55, 5, -41 },
  { 5872, 37, 41, 47, 5, -41 },
  { 6062, 40, 43, 46, 3, -42 },
  { 6277, 29, 41, 36, 5, -41 },
  { 6426, 40, 52, 46, 3, -42 },
  { 6686, 33, 41, 38, 5, -41 },
  { 6856, 27, 43, 32, 3, -42 },
  { 7002, 31, 41, 33, 1, -41 },
  { 7161, 34, 42, 44, 5, -41 },
  { 7340, 38, 41, 38, 0, -41 },
  { 7535, 56, 41, 56, 0, -41 },
  { 7822, 39, 41, 39, 0, -41 },
  { 8022, 36, 41, 36, 0, -41 },
  { 8207, 31, 41, 34, 1, -41 },
  { 8366, 14, 50, 19, 4, -41 },
  { 8454, 24, 42, 24, 0, -42 },
  { 8580, 14, 50, 19, 1, -41 },
  { 8668, 31, 27, 33, 1, -42 },
  { 8773, 24, 4, 24, 0, 5 },
  { 8785, 17, 9, 21, 2, -44 },
  { 8805, 29, 33, 35, 2, -32 },
  { 8925, 30, 45, 37, 4, -44 },
  { 9094, 25, 33, 30, 3, -32 },
  { 9198, 29, 45, 37, 3, -44 },
  { 9362, 29, 33, 35, 3, -32 },
  { 9482, 24, 44, 22, 1, -44 },
  { 9614, 29, 46, 37, 3, -32 },
  { 9781, 30, 44, 38, 4, -44 },
  { 9946, 9, 44, 17, 4, -44 },
  { 9996, 16, 58, 17, -3, -44 },
  { 10112, 31, 44, 36, 5, -44 },
  { 10283, 9, 44, 17, 4, -44 },
  { 10333, 48, 32, 57, 4, -32 },
  { 10525, 30, 32, 38, 4, -32 },
  { 10645, 30, 33, 36, 3, -32 },
  { 10769, 30, 46, 37, 4, -32 },
  { 10942, 29, 46, 37, 3, -32 },
  { 11109, 21, 32, 26, 4, -32 },
  { 11193, 24, 33, 29, 3, -32 },
  { 11292, 22, 39, 25, 1, -38 },
  { 11400, 29, 33, 38, 4, -32 },
  { 11520, 33, 32, 33, 0, -32 },
  { 11652, 48, 32, 50, 1, -32 },
  { 11844, 33, 32, 34, 0, -32 },
  { 11976, 33, 46, 33, 0, -32 },
  { 12166, 25, 32, 29, 2, -32 },
  { 12266, 20, 50, 23, 1, -41 },
  { 12391, 6, 57, 32, 13, -44 },
  { 12434, 20, 50, 23, 2, -41 },
  { 12559, 29, 9, 33, 2, -25 },
};

const GFXfont NotoSans_Bold58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold58pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_BOLD58PT7B_H_
