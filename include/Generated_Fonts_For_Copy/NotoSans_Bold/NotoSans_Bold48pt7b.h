#ifndef _NOTOSANS_BOLD48PT7B_H_
#define _NOTOSANS_BOLD48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7E, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x01, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE1, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0x38, 0x78,
  0xFE, 0x38, 0x08, 0xFE, 0x38, 0x00, 0xFE, 0x38, 0x00, 0xFF, 0x38, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x39, 0xFE, 0x00, 0x38, 0xFF, 0x00, 0x38, 0x7F,
  0xC0, 0x38, 0xFE, 0xF0, 0x38, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xFC,
  0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x3E, 0x1F, 0xC0, 0xFC, 0x7E, 0x3F, 0x1F,
  0xF0, 0x7E, 0x3F, 0x3F, 0x1F, 0xFC, 0x1F, 0xFF, 0x9F, 0x9F, 0xFF, 0x0F,
  0xFF, 0x9F, 0x8F, 0xFF, 0xC3, 0xFF, 0x8F, 0xCF, 0xC7, 0xE0, 0xFF, 0x8F,
  0xC7, 0xE1, 0xF0, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xF0,
  0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x1F, 0x80,
  0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x03, 0xF1,
  0xF8, 0x00, 0x7C, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x83, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xF8, 0x07, 0xF0,
  0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0xDF, 0xE0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF0, 0x7F, 0x9F, 0xC3, 0xFC, 0x0F, 0xFF, 0xF0, 0xFE, 0x01, 0xFF,
  0xF8, 0x3F, 0x80, 0x3F, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFE, 0x03,
  0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x03, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x3C, 0x0E, 0x7F, 0x3C,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xF0, 0x03, 0x81, 0xC0, 0x00, 0x81, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0x87, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xC7, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xEF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xBF, 0x9F, 0xDF,
  0x0F, 0xE7, 0x07, 0xF1, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC,
  0x3E, 0x01, 0xFE, 0x18, 0x01, 0xFE, 0x10, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x07, 0xFC, 0x38, 0x01, 0xFC,
  0x10, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x80, 0x01, 0xFE,
  0xC0, 0x03, 0xFE, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7D, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0x9F, 0xC0, 0x07, 0xE7, 0xF0,
  0x03, 0xF3, 0xFC, 0x01, 0xF8, 0xFF, 0x00, 0x7E, 0x3F, 0xC0, 0x3F, 0x0F,
  0xF0, 0x1F, 0x83, 0xFC, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0xC1, 0xF8,
  0x0F, 0xF0, 0x7E, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x60, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xEF, 0xF3, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0xFE, 0xFF, 0xF0, 0xFD,
  0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F,
  0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x83,
  0xFC, 0x3F, 0xEF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x7F, 0x83, 0xFC, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFE, 0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xC7, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7E, 0x0F, 0xFE,
  0x7E, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x20, 0x3F,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x38, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x0E, 0x07, 0xE3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0,
  0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xF0, 0x7F, 0xCE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x7E,
  0x07, 0xFF, 0xC3, 0xF1, 0xF8, 0x1F, 0xFF, 0xC3, 0xE3, 0xE0, 0x7F, 0xFF,
  0x87, 0xCF, 0xC1, 0xFF, 0xFF, 0x0F, 0x9F, 0x87, 0xF0, 0x7E, 0x1F, 0xBE,
  0x0F, 0xC0, 0xFC, 0x1F, 0x7C, 0x3F, 0x01, 0xF8, 0x3F, 0xF8, 0x7E, 0x03,
  0xF0, 0x7F, 0xF0, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xF0, 0x0F, 0x81, 0xFF,
  0xC3, 0xE0, 0x1F, 0x07, 0xFF, 0x07, 0xC0, 0x3E, 0x0F, 0xBF, 0x0F, 0x80,
  0xFC, 0x1F, 0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0xFC, 0x3F, 0x07, 0xF8, 0xF8,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF1, 0xF0, 0x7F, 0xFD, 0xFF, 0xC3, 0xF0, 0x7F,
  0xF3, 0xFF, 0x03, 0xE0, 0x7F, 0xC1, 0xFC, 0x07, 0xE0, 0x1C, 0x00, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x04, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x83,
  0xFF, 0xCF, 0xE0, 0x0F, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xBF,
  0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xF8, 0x07, 0xFC, 0xFE,
  0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x03,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xC3, 0xF8, 0xFF, 0xC0, 0x0C, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xF8, 0x03, 0xFF, 0x1F, 0xC0, 0x0F, 0xFC, 0xFE, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x01,
  0xFF, 0x3F, 0x80, 0x1F, 0xF1, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x0F, 0xC3, 0xFF, 0x80,
  0x0C, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F,
  0xF0, 0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC3, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x83, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x1F,
  0xFF, 0xFD, 0xF8, 0x00, 0xFF, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xFF, 0xBF,
  0x00, 0x3E, 0xFF, 0xFD, 0xF8, 0x03, 0xF7, 0xFF, 0xEF, 0xC0, 0x1F, 0xBF,
  0xFF, 0x3E, 0x00, 0xF9, 0xFF, 0xF9, 0xF8, 0x0F, 0xCF, 0xFF, 0xCF, 0xC0,
  0x7E, 0x7F, 0xFE, 0x7E, 0x03, 0xE3, 0xFF, 0xF1, 0xF8, 0x3F, 0x1F, 0xFF,
  0x8F, 0xC1, 0xF8, 0xFF, 0xFC, 0x7E, 0x0F, 0x87, 0xFF, 0xE1, 0xF8, 0xFC,
  0x3F, 0xFF, 0x0F, 0xC7, 0xE1, 0xFF, 0xF8, 0x7E, 0x3E, 0x0F, 0xFF, 0xC1,
  0xFB, 0xF0, 0x7F, 0xFE, 0x0F, 0xDF, 0x83, 0xFF, 0xF0, 0x7E, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0x80, 0x7F, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFE, 0x00,
  0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xF3, 0xF8, 0x07,
  0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0x8F, 0xF0, 0x3F,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xE0, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF,
  0xF8, 0x1F, 0xC3, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0xE0, 0x3F, 0xCF, 0xFF,
  0xC0, 0x7F, 0x9F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0x00, 0xFF, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0,
  0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x03, 0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x07, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE1, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC,
  0xFE, 0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xF8, 0xFE, 0x3F, 0xC0, 0x18, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF6, 0x00, 0x0F, 0xEF, 0x80, 0x3F, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF7, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xE3, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC1,
  0xFC, 0x07, 0xEF, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xCF, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0x0F, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x00, 0x7F, 0x1F,
  0x87, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0,
  0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x03,
  0xF3, 0xF8, 0x00, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xE0, 0x1F,
  0xBF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xC0, 0x7F,
  0x84, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x7C, 0x3F, 0xE0, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x83, 0xC0, 0x3F, 0xCF, 0xFC, 0x1F, 0xEF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x83, 0xFE,
  0xFF, 0x80, 0xFF, 0x7F, 0xC0, 0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xF7, 0xFE, 0x07, 0xFB, 0xFF, 0xCF, 0xFD, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0x7F, 0xFE, 0x3F, 0x9F, 0xFE, 0x1F,
  0x83, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x83, 0xCF, 0xF8, 0x02,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0x9F, 0xF8,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x78, 0x1F, 0xC0, 0xFF, 0x8F,
  0xE1, 0xFF, 0xE7, 0xF1, 0xFF, 0xFB, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x07, 0xFD,
  0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF,
  0xC3, 0xFF, 0xC7, 0xE0, 0x7F, 0x83, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x02, 0x3F, 0xE0,
  0x1E, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xF0, 0x40, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x0F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF,
  0xF7, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0x87, 0xFE, 0xFF,
  0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF9, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x87, 0xFF, 0x9F, 0xC0, 0xFF,
  0x8F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x60, 0x01, 0xFE, 0x3F, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xC0, 0x3F, 0xC7,
  0xFE, 0x1F, 0xEF, 0xFF, 0x8F, 0xEF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xC3, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x08, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x00, 0x20, 0x07,
  0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFC, 0x7F,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x0C, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xFB, 0xF8,
  0x07, 0xFC, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x83,
  0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE7, 0xF8,
  0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xF9, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80,
  0x3F, 0xCF, 0xE0, 0x0F, 0xFB, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x07,
  0xC0, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x7E, 0x1F, 0xFC, 0x3F, 0x9F, 0xFF, 0x1F, 0xDF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFD, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF1, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFB,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x7F, 0x1F, 0xF8, 0x3F, 0x9F,
  0xFE, 0x1F, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0x87, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0x7F, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xEF, 0xFC, 0x0F, 0xF7, 0xFF, 0x9F,
  0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xBF,
  0xFC, 0x3F, 0xC7, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x0F,
  0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xFB,
  0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF,
  0x87, 0xFF, 0x9F, 0xC0, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xBF, 0x07,
  0xFF, 0xC3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0xFC,
  0xFE, 0x00, 0xCF, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x0C, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x3F, 0xF7, 0xFE, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0x1F, 0xFF, 0x1F, 0x83,
  0xFF, 0x0F, 0xC0, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00,
  0x7F, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xBF, 0x80, 0x7F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xBE,
  0x07, 0xF0, 0xFE, 0x07, 0xDF, 0x03, 0xF8, 0x3F, 0x83, 0xEF, 0x81, 0xF8,
  0x1F, 0xC3, 0xF7, 0xE1, 0xFC, 0x0F, 0xE1, 0xF1, 0xF0, 0xFE, 0x03, 0xF0,
  0xF8, 0xF8, 0x7F, 0x01, 0xFC, 0x7C, 0x7C, 0x7F, 0x00, 0xFE, 0x7E, 0x3F,
  0x3F, 0x80, 0x7F, 0x3F, 0x0F, 0x9F, 0xC0, 0x1F, 0x9F, 0x07, 0xCF, 0xC0,
  0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0x07, 0xF7, 0xC1, 0xF7, 0xF0, 0x01, 0xFB,
  0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F,
  0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xBF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F,
  0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE,
  0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x02, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFE, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x02, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0x40, 0x01, 0xF8,
};

const GFXglyph NotoSans_Bold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 35, 14, 3, -34 },
  { 36, 17, 12, 23, 3, -34 },
  { 62, 29, 34, 31, 1, -34 },
  { 186, 24, 39, 27, 2, -36 },
  { 303, 41, 35, 43, 1, -35 },
  { 483, 34, 35, 36, 2, -35 },
  { 632, 7, 12, 13, 3, -34 },
  { 643, 13, 42, 16, 2, -34 },
  { 712, 13, 42, 16, 1, -34 },
  { 781, 24, 22, 26, 1, -36 },
  { 847, 23, 24, 27, 2, -29 },
  { 916, 10, 12, 14, 1, -6 },
  { 931, 13, 6, 15, 1, -16 },
  { 941, 8, 8, 13, 3, -7 },
  { 949, 20, 35, 20, 0, -35 },
  { 1037, 24, 35, 27, 2, -35 },
  { 1142, 17, 34, 27, 3, -34 },
  { 1215, 24, 35, 27, 2, -35 },
  { 1320, 24, 35, 27, 2, -35 },
  { 1425, 26, 34, 27, 1, -34 },
  { 1536, 23, 34, 27, 2, -34 },
  { 1634, 24, 35, 27, 2, -35 },
  { 1739, 25, 34, 27, 1, -34 },
  { 1846, 24, 35, 27, 2, -35 },
  { 1951, 24, 35, 27, 2, -35 },
  { 2056, 8, 28, 13, 3, -27 },
  { 2084, 10, 33, 14, 1, -27 },
  { 2126, 23, 25, 27, 2, -30 },
  { 2198, 23, 14, 27, 2, -24 },
  { 2239, 23, 25, 27, 2, -30 },
  { 2311, 22, 36, 23, 0, -35 },
  { 2410, 39, 39, 43, 2, -35 },
  { 2601, 33, 34, 33, 0, -34 },
  { 2742, 26, 34, 32, 4, -34 },
  { 2853, 26, 35, 31, 3, -35 },
  { 2967, 29, 34, 35, 4, -34 },
  { 3091, 20, 34, 27, 4, -34 },
  { 3176, 20, 34, 26, 4, -34 },
  { 3261, 28, 35, 35, 3, -35 },
  { 3384, 28, 34, 37, 4, -34 },
  { 3503, 15, 34, 19, 2, -34 },
  { 3567, 16, 44, 16, -4, -34 },
  { 3655, 28, 34, 32, 4, -34 },
  { 3774, 21, 34, 27, 4, -34 },
  { 3864, 37, 34, 45, 4, -34 },
  { 4022, 31, 34, 39, 4, -34 },
  { 4154, 32, 35, 38, 3, -35 },
  { 4294, 24, 34, 30, 4, -34 },
  { 4396, 32, 43, 38, 3, -35 },
  { 4568, 28, 34, 31, 4, -34 },
  { 4687, 23, 35, 26, 2, -35 },
  { 4788, 26, 34, 28, 1, -34 },
  { 4899, 28, 34, 36, 4, -34 },
  { 5018, 31, 34, 31, 0, -34 },
  { 5150, 46, 34, 46, 0, -34 },
  { 5346, 32, 34, 32, 0, -34 },
  { 5482, 30, 34, 30, 0, -34 },
  { 5610, 26, 34, 28, 1, -34 },
  { 5721, 12, 42, 16, 3, -34 },
  { 5784, 20, 35, 20, 0, -35 },
  { 5872, 12, 42, 16, 1, -34 },
  { 5935, 25, 22, 27, 1, -34 },
  { 6004, 20, 4, 20, 0, 4 },
  { 6014, 14, 8, 18, 2, -37 },
  { 6028, 23, 27, 29, 2, -27 },
  { 6106, 25, 36, 30, 3, -36 },
  { 6219, 21, 27, 25, 2, -27 },
  { 6290, 25, 36, 30, 2, -36 },
  { 6403, 24, 27, 29, 2, -27 },
  { 6484, 20, 37, 19, 1, -37 },
  { 6577, 25, 39, 30, 2, -27 },
  { 6699, 25, 36, 31, 3, -36 },
  { 6812, 8, 37, 14, 3, -37 },
  { 6849, 14, 49, 14, -3, -37 },
  { 6935, 26, 36, 30, 4, -36 },
  { 7052, 8, 36, 14, 3, -36 },
  { 7088, 40, 27, 47, 3, -27 },
  { 7223, 25, 27, 31, 3, -27 },
  { 7308, 26, 27, 30, 2, -27 },
  { 7396, 25, 39, 30, 3, -27 },
  { 7518, 25, 39, 30, 2, -27 },
  { 7640, 18, 27, 21, 3, -27 },
  { 7701, 20, 27, 24, 2, -27 },
  { 7769, 18, 32, 21, 1, -32 },
  { 7841, 25, 26, 31, 3, -26 },
  { 7923, 27, 26, 27, 0, -26 },
  { 8011, 41, 26, 41, 0, -26 },
  { 8145, 28, 26, 28, 0, -26 },
  { 8236, 27, 38, 27, 0, -26 },
  { 8365, 21, 26, 24, 1, -26 },
  { 8434, 16, 42, 19, 1, -34 },
  { 8518, 5, 47, 26, 11, -36 },
  { 8548, 16, 42, 19, 2, -34 },
  { 8632, 23, 8, 27, 2, -21 },
};

const GFXfont NotoSans_Bold48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold48pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_BOLD48PT7B_H_
