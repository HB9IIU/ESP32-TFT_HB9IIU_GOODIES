#ifndef _NOTOSANS_BOLD25PT7B_H_
#define _NOTOSANS_BOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x01, 0xDF, 0xFB,
  0x80, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x07, 0x38, 0x0C, 0x60,
  0x38, 0xC0, 0x73, 0x80, 0xE7, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0xE0, 0x39, 0xC0, 0x73, 0x87, 0xFF, 0xEF, 0xFF, 0xC7, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x31, 0xC0, 0x63, 0x00, 0x06, 0x00, 0x60, 0x1F, 0xE7, 0xFF,
  0xFF, 0xEF, 0x62, 0xF6, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x06, 0xF0, 0x67, 0xC6, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x06, 0x00, 0x60,
  0x3C, 0x03, 0x83, 0xF0, 0x38, 0x3B, 0xC3, 0x81, 0xCE, 0x1C, 0x0E, 0x71,
  0xC0, 0x73, 0x8E, 0x03, 0x9C, 0xE0, 0x1C, 0xE7, 0x78, 0xE7, 0x77, 0xF3,
  0xF3, 0xBB, 0x8F, 0x3B, 0x8E, 0x03, 0x9C, 0x70, 0x1C, 0xE3, 0x81, 0xC7,
  0x1C, 0x0E, 0x38, 0xE0, 0xE0, 0xEE, 0x07, 0x07, 0xF0, 0x70, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xE3, 0xC0, 0x38, 0xF0, 0x0E,
  0x38, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x87, 0x9F, 0xE1, 0xE7, 0xBC,
  0xF3, 0xC7, 0xBC, 0xF0, 0xFE, 0x3C, 0x1F, 0x8F, 0x87, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xF1, 0xF0, 0xFF, 0xFF, 0xF8, 0x1E, 0x38, 0xE1, 0xC7,
  0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1,
  0xE1, 0xC1, 0xC3, 0xC0, 0xE1, 0xC7, 0x0E, 0x38, 0xF1, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0x9E, 0x73, 0x80, 0x0E, 0x00, 0xE0,
  0x0E, 0x08, 0x62, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF0, 0x3B, 0x83, 0x9C,
  0x79, 0xC1, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x7B, 0x9D, 0xEE,
  0x70, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0x03, 0x83, 0xC7,
  0xE7, 0xFF, 0xBB, 0x9C, 0x8E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1F, 0x87, 0xFE, 0xFF, 0xE7, 0x1F,
  0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFE,
  0x7F, 0xE6, 0x1F, 0x00, 0xF0, 0x0F, 0x01, 0xE1, 0xFC, 0x1F, 0x01, 0xFE,
  0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xEF,
  0x07, 0x3C, 0x1C, 0xF0, 0xE3, 0xC7, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE7, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFC, 0x7F, 0xE7, 0xFF, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xFF, 0xFE, 0xFF, 0xC7, 0xF8, 0x07,
  0xE1, 0xFE, 0x3F, 0xE7, 0xC0, 0x78, 0x07, 0x00, 0xF1, 0x0E, 0xFE, 0xFF,
  0xFF, 0xDF, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0x78, 0xF7, 0xFF, 0x3F,
  0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F, 0xF0,
  0xF7, 0x0F, 0x79, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x7B, 0xEF, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x7F,
  0xEF, 0x1F, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xF1, 0xF7, 0xFF, 0x7F,
  0x71, 0xE7, 0x00, 0xF0, 0x0E, 0x01, 0xE7, 0xFC, 0x7F, 0x87, 0xF0, 0x77,
  0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xB8, 0x77, 0xFE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF7, 0x3B, 0xDC, 0xE0, 0x00, 0x10, 0x03, 0x00, 0xF0,
  0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x07, 0xE1, 0xF8, 0xFE, 0x0F, 0x80, 0xC0, 0x08,
  0x00, 0x3F, 0x9F, 0xF9, 0xFF, 0xB0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x1E,
  0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x87, 0xC1, 0xC0, 0x1E,
  0x38, 0x00, 0xE7, 0x0F, 0xE7, 0x73, 0xFE, 0x76, 0x38, 0xE3, 0xE7, 0x0E,
  0x3E, 0x70, 0xE3, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x9E, 0x7E, 0x3F,
  0xFE, 0x71, 0xF3, 0xC7, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xEE,
  0x00, 0x77, 0x80, 0x7B, 0xC0, 0x3C, 0xE0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F,
  0x0E, 0x07, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0x87, 0xFF, 0xBF, 0xFD,
  0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xBC,
  0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x86, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xE0, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xE7, 0x87, 0xEF, 0x07, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xDE, 0x0F, 0xBC,
  0x3E, 0x7F, 0xFC, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF1, 0xF0, 0x67, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFB, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xCF, 0x87, 0x9F,
  0xFF, 0x1F, 0xFE, 0x0F, 0xF8, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFE, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7E, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFE, 0xFE, 0xFC, 0xF0, 0x3F, 0xE0, 0xFB,
  0xC3, 0xE7, 0x87, 0x8F, 0x1E, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x07, 0x9E, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x78, 0x3C, 0xF0, 0x7D, 0xE0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFE, 0xE0, 0x7F, 0xDC, 0x1D, 0xFF, 0x83, 0xBF,
  0xB8, 0x77, 0xF7, 0x1C, 0xFE, 0xE3, 0x9F, 0xDE, 0x73, 0xF9, 0xDC, 0x7F,
  0x3B, 0x8F, 0xE7, 0xF1, 0xFC, 0x7C, 0x3F, 0x8F, 0x87, 0xF1, 0xF0, 0xFE,
  0x1C, 0x1C, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x07,
  0xEF, 0x07, 0xE7, 0x87, 0xF7, 0x87, 0xF3, 0xC7, 0xF3, 0xC7, 0xF1, 0xE7,
  0xF0, 0xF7, 0xF0, 0xF7, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0xC0,
  0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x7C, 0xF8, 0x7C, 0x7F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0x1F, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xF7, 0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B,
  0xE0, 0x7C, 0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0x3C, 0x7C, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xFF, 0xF3, 0xFF,
  0x0F, 0xFC, 0x3C, 0xF0, 0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0,
  0x7B, 0xC0, 0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xE7, 0x86, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0xC0, 0xFF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xDE, 0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0,
  0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70,
  0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x70, 0x3C, 0x0F, 0x78, 0x7E, 0x0E,
  0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x38, 0x7F, 0x1E, 0x38, 0xF7, 0x1C,
  0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x1C, 0xE7, 0xBC, 0x1D, 0xE3, 0xB8,
  0x1F, 0xC3, 0xB8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x3C, 0x0F, 0x0F, 0x07,
  0x83, 0xC7, 0x81, 0xE7, 0x80, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0xF3, 0xE0,
  0xF8, 0xF0, 0x78, 0x3C, 0x78, 0x1F, 0x7C, 0x07, 0xC0, 0xF0, 0x1F, 0x78,
  0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0, 0xF0, 0x1C, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xF8, 0x1C, 0xE0, 0xE7, 0x0E,
  0x1C, 0x70, 0xE3, 0x03, 0xB8, 0x1D, 0xC0, 0x70, 0xFF, 0xFF, 0xF0, 0xF8,
  0x70, 0x70, 0x70, 0x0F, 0x87, 0xFE, 0x3F, 0xF2, 0x0F, 0x00, 0xF0, 0x1F,
  0x3F, 0xF7, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x7F, 0x73, 0xE7,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x79, 0xC3, 0xFF, 0x9F,
  0xFE, 0xF8, 0xF7, 0x87, 0xBC, 0x1D, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xDE, 0x1E, 0xFF, 0xF7, 0xFF, 0x39, 0xF0, 0x0F, 0xC7, 0xFD, 0xFF, 0xBE,
  0x2F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0xBF, 0xF3,
  0xFE, 0x3F, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x87,
  0x3C, 0xFF, 0xEF, 0xFF, 0x78, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xEF, 0x0F, 0x7F, 0xF9, 0xFF, 0xC7, 0xCE, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xF0, 0xE7, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0x80, 0x1E, 0x04, 0xFF, 0xE3, 0xFF, 0x07, 0xF0, 0x0F, 0xE3, 0xF8,
  0x7F, 0x0F, 0x01, 0xC0, 0x7F, 0xBF, 0xF7, 0xFE, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x39, 0xFD, 0xDF, 0xFE, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xBC, 0x01,
  0xE0, 0x0F, 0x40, 0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x3C, 0xEF, 0xEF, 0xFF, 0xF8, 0xFF, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x70, 0xEF, 0xF4, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x3C, 0x78, 0x40, 0x03, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xFF, 0x7E, 0xF8, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xEF, 0x0F, 0x3C, 0x78,
  0xF3, 0xC3, 0xDE, 0x0F, 0xF0, 0x3B, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0x3C,
  0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC3, 0xC7, 0x7F, 0x7F, 0xBF,
  0xFF, 0xFD, 0xF1, 0xF1, 0xEF, 0x0F, 0x87, 0xF8, 0x78, 0x3F, 0xC3, 0xC1,
  0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1,
  0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3C, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF,
  0x8F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xDE, 0x1E, 0xFF, 0xE3,
  0xFF, 0x07, 0xE0, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xF1, 0xEF, 0x0F, 0x78,
  0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xFF, 0xEF, 0xFE,
  0x7B, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00,
  0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xDE, 0x1E, 0xFF, 0xF3, 0xFF, 0x8F, 0xBC, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xE3, 0xF7, 0xFF,
  0xFF, 0xFF, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x80, 0x1F, 0x8F, 0xFB, 0xFF, 0x78, 0x2F, 0x01, 0xF8, 0x1F, 0xC1, 0xFE,
  0x07, 0xC0, 0x3E, 0x07, 0x7F, 0xEF, 0xFD, 0xFF, 0x00, 0x18, 0x1C, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFD, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xFE, 0x7F, 0x1F, 0x80, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x7F,
  0xF3, 0xF7, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0x9E, 0x1E, 0x38, 0x78, 0xF1,
  0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x78, 0x7B, 0x87, 0xC3, 0xDE, 0x3E, 0x1E, 0xF1,
  0xF8, 0xE7, 0x8D, 0xCF, 0x1C, 0xEE, 0x78, 0xF7, 0x73, 0x87, 0xB9, 0xDC,
  0x1D, 0x8F, 0xE0, 0xEC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0x80, 0xF0,
  0x7C, 0x07, 0x83, 0xC0, 0xF8, 0x3D, 0xE1, 0xE3, 0xC7, 0x8F, 0xBC, 0x1F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x83, 0xEF, 0x0F,
  0x1E, 0x78, 0x7B, 0xE0, 0xF0, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0x9E, 0x1E,
  0x38, 0x78, 0xF1, 0xC3, 0xCF, 0x07, 0x3C, 0x1E, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x01, 0xFC,
  0x07, 0xE0, 0x1E, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x01, 0xE0, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x87, 0xC3, 0xE3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x3E, 0x3E,
  0x1F, 0x0F, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xF0, 0xF8,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xF8, 0xF8, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x1F, 0x0F, 0x3F, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF0, 0x7C, 0x1F, 0xFB, 0xFF, 0xF8, 0x3F,
};

const GFXglyph NotoSans_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 8, 7, 12, 2, -18 },
  { 20, 15, 18, 16, 1, -18 },
  { 54, 12, 20, 14, 1, -19 },
  { 84, 21, 18, 23, 1, -18 },
  { 132, 18, 18, 19, 1, -18 },
  { 173, 3, 7, 7, 2, -18 },
  { 176, 7, 22, 8, 1, -18 },
  { 196, 6, 22, 8, 1, -18 },
  { 213, 12, 12, 14, 1, -19 },
  { 231, 12, 12, 14, 1, -15 },
  { 249, 5, 6, 7, 1, -3 },
  { 253, 6, 3, 8, 1, -8 },
  { 256, 5, 4, 7, 1, -4 },
  { 259, 10, 18, 10, 0, -18 },
  { 282, 12, 18, 14, 1, -18 },
  { 309, 9, 18, 14, 1, -18 },
  { 330, 12, 18, 14, 1, -18 },
  { 357, 12, 18, 14, 1, -18 },
  { 384, 14, 18, 14, 0, -18 },
  { 416, 12, 18, 14, 1, -18 },
  { 443, 12, 18, 14, 1, -18 },
  { 470, 12, 18, 14, 1, -18 },
  { 497, 12, 18, 14, 1, -18 },
  { 524, 12, 18, 14, 1, -18 },
  { 551, 5, 14, 7, 1, -14 },
  { 560, 5, 17, 7, 1, -14 },
  { 571, 12, 14, 14, 1, -16 },
  { 592, 12, 8, 14, 1, -13 },
  { 604, 12, 14, 14, 1, -16 },
  { 625, 11, 18, 12, 0, -18 },
  { 650, 20, 20, 22, 1, -18 },
  { 700, 17, 18, 17, 0, -18 },
  { 739, 13, 18, 17, 2, -18 },
  { 769, 14, 18, 16, 1, -18 },
  { 801, 15, 18, 18, 2, -18 },
  { 835, 11, 18, 14, 2, -18 },
  { 860, 10, 18, 14, 2, -18 },
  { 883, 15, 18, 18, 1, -18 },
  { 917, 15, 18, 19, 2, -18 },
  { 951, 8, 18, 10, 1, -18 },
  { 969, 8, 23, 8, -2, -18 },
  { 992, 15, 18, 17, 2, -18 },
  { 1026, 11, 18, 14, 2, -18 },
  { 1051, 19, 18, 24, 2, -18 },
  { 1094, 16, 18, 20, 2, -18 },
  { 1130, 17, 18, 20, 1, -18 },
  { 1169, 12, 18, 16, 2, -18 },
  { 1196, 17, 22, 20, 1, -18 },
  { 1243, 14, 18, 16, 2, -18 },
  { 1275, 12, 18, 14, 1, -18 },
  { 1302, 14, 18, 14, 0, -18 },
  { 1334, 15, 18, 19, 2, -18 },
  { 1368, 16, 18, 16, 0, -18 },
  { 1404, 24, 18, 24, 0, -18 },
  { 1458, 17, 18, 17, 0, -18 },
  { 1497, 16, 18, 16, 0, -18 },
  { 1533, 13, 18, 14, 1, -18 },
  { 1563, 6, 22, 8, 2, -18 },
  { 1580, 10, 18, 10, 0, -18 },
  { 1603, 6, 22, 8, 1, -18 },
  { 1620, 13, 12, 14, 1, -18 },
  { 1640, 10, 2, 10, 0, 2 },
  { 1643, 7, 4, 9, 1, -19 },
  { 1647, 12, 14, 15, 1, -14 },
  { 1668, 13, 19, 16, 2, -19 },
  { 1699, 11, 14, 13, 1, -14 },
  { 1719, 13, 19, 16, 1, -19 },
  { 1750, 13, 14, 15, 1, -14 },
  { 1773, 11, 19, 10, 0, -19 },
  { 1800, 13, 20, 16, 1, -14 },
  { 1833, 12, 19, 16, 2, -19 },
  { 1862, 4, 19, 7, 2, -19 },
  { 1872, 7, 25, 7, -1, -19 },
  { 1894, 14, 19, 16, 2, -19 },
  { 1928, 4, 19, 7, 2, -19 },
  { 1938, 21, 14, 24, 2, -14 },
  { 1975, 12, 14, 16, 2, -14 },
  { 1996, 13, 14, 16, 1, -14 },
  { 2019, 13, 20, 16, 2, -14 },
  { 2052, 13, 20, 16, 1, -14 },
  { 2085, 9, 14, 11, 2, -14 },
  { 2101, 11, 14, 13, 1, -14 },
  { 2121, 9, 17, 11, 1, -17 },
  { 2141, 12, 14, 16, 2, -14 },
  { 2162, 14, 14, 14, 0, -14 },
  { 2187, 21, 14, 21, 0, -14 },
  { 2224, 14, 14, 14, 0, -14 },
  { 2249, 14, 20, 14, 0, -14 },
  { 2284, 11, 14, 12, 1, -14 },
  { 2304, 9, 22, 10, 0, -18 },
  { 2329, 2, 25, 14, 6, -19 },
  { 2336, 8, 22, 10, 1, -18 },
  { 2358, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_Bold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold25pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_BOLD25PT7B_H_
