#ifndef _NOTOSANS_BOLD44PT7B_H_
#define _NOTOSANS_BOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x00, 0x00,
  0x00, 0x1C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xC0, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00,
  0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x73, 0xE7, 0xF3,
  0x81, 0x3F, 0x1C, 0x01, 0xFC, 0xE0, 0x0F, 0xF7, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x39, 0xFC, 0x01, 0xC7, 0xE0,
  0x0E, 0x3F, 0xC0, 0x71, 0xFF, 0xC3, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0x3E, 0x00,
  0x7F, 0xF8, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x00, 0x3E, 0x3F, 0x01,
  0xF0, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0xF8, 0x00, 0xFC,
  0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x87, 0xE0,
  0x01, 0xF8, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE3, 0xF0, 0x00, 0x3E, 0x1F,
  0x1F, 0x1F, 0xC1, 0xF1, 0xF9, 0xF1, 0xFF, 0x8F, 0xDF, 0x8F, 0x9F, 0xFE,
  0x3F, 0xFC, 0xF8, 0xFF, 0xF1, 0xFF, 0xCF, 0xCF, 0xCF, 0xC7, 0xFC, 0x7C,
  0x7C, 0x3E, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x0F, 0x80,
  0x03, 0xF1, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7E,
  0x1F, 0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x0F,
  0xC0, 0x7C, 0x3E, 0x00, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x0F, 0xFF,
  0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0xFE, 0x1F, 0xFE, 0x03, 0xF8, 0x7F, 0xFE, 0x07, 0xF1,
  0xFF, 0xFE, 0x0F, 0xE3, 0xF9, 0xFE, 0x3F, 0x8F, 0xE1, 0xFE, 0x7F, 0x1F,
  0xC1, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xE0, 0xFE,
  0x01, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xF9, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE,
  0xFB, 0xE7, 0x80, 0x07, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x01, 0x01,
  0xE0, 0x27, 0xC7, 0x8F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7D, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x80, 0x78,
  0x78, 0x00, 0x40, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x7E,
  0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0xC7, 0xF0,
  0x7F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE,
  0x7E, 0x03, 0xF9, 0xFC, 0x1F, 0xC7, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7E,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFE, 0x7E, 0xF0, 0xFC, 0xC1, 0xF9, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC7, 0xE0, 0x7F, 0x8E, 0x00, 0xFE, 0x10, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xE0, 0x1F, 0xC4, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xEF, 0xE0, 0x0F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80,
  0x7C, 0x7F, 0x01, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0x83, 0xF8, 0x3E,
  0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3C, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xF9, 0xC3, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x7F, 0x83, 0xF7, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80,
  0xFE, 0x7E, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xE1, 0xFC,
  0x3F, 0xDF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xC3, 0xFC, 0xFE, 0x03,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xEF, 0xE0, 0x3F, 0xBF, 0xF7, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xE0, 0xFE, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFD, 0xFC, 0x01, 0xFB,
  0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0xDF,
  0xC0, 0x7F, 0xBF, 0xC3, 0xFF, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFB, 0xF0, 0x7F, 0xF7, 0xE0, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7E, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7E, 0x08, 0x3F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x38, 0x07,
  0xF2, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x10, 0x07, 0xC7, 0xE0, 0x7F,
  0xF8, 0xF8, 0xF8, 0x3F, 0xFF, 0x0F, 0xBF, 0x0F, 0xFF, 0xE1, 0xF7, 0xC3,
  0xFE, 0xFC, 0x3E, 0xF8, 0x7E, 0x0F, 0x83, 0xDE, 0x1F, 0x81, 0xF0, 0x7F,
  0xC3, 0xE0, 0x3E, 0x0F, 0xF8, 0x7C, 0x07, 0xC1, 0xFF, 0x0F, 0x80, 0xF8,
  0x3F, 0xE1, 0xF0, 0x1F, 0x07, 0xFC, 0x3E, 0x03, 0xE1, 0xFF, 0x87, 0xC0,
  0xFC, 0x3F, 0xF0, 0xF8, 0x1F, 0x87, 0xBE, 0x1F, 0x87, 0xF1, 0xF7, 0xC1,
  0xFF, 0xFF, 0xFC, 0x7C, 0x3F, 0xFD, 0xFF, 0x8F, 0x83, 0xFF, 0x1F, 0xE1,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0x80,
  0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xFB,
  0xF0, 0x07, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC0, 0x38,
  0x7F, 0xC0, 0x04, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x87,
  0xFE, 0x07, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x01,
  0xFF, 0x8F, 0xC0, 0x1F, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0xBF,
  0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xFC,
  0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC0, 0x18, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x80,
  0x1F, 0xBF, 0xE0, 0x0F, 0xCF, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE1,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xE8, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC,
  0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F,
  0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xCF, 0xE0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFE, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3E, 0xFF, 0xFF, 0x80,
  0x0F, 0xBF, 0xFF, 0xF0, 0x03, 0xEF, 0xFF, 0x7C, 0x01, 0xF7, 0xFF, 0xDF,
  0x00, 0x7D, 0xFF, 0xF7, 0xE0, 0x1F, 0x7F, 0xFC, 0xF8, 0x0F, 0x9F, 0xFF,
  0x3E, 0x03, 0xE7, 0xFF, 0xCF, 0xC0, 0xF9, 0xFF, 0xF3, 0xF0, 0x7C, 0x7F,
  0xFC, 0x7C, 0x1F, 0x1F, 0xFF, 0x1F, 0x87, 0xC7, 0xFF, 0xC7, 0xE3, 0xE1,
  0xFF, 0xF0, 0xF8, 0xF8, 0x7F, 0xFC, 0x3E, 0x3E, 0x1F, 0xFF, 0x0F, 0xDF,
  0x87, 0xFF, 0xC1, 0xF7, 0xC1, 0xFF, 0xF0, 0x7D, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0x01, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0x01, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xDF, 0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xCF, 0xE0, 0x3F, 0xFC, 0x7F,
  0x03, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0x3F, 0x83, 0xFF, 0xC3, 0xFC, 0x3F,
  0xFC, 0x1F, 0xC3, 0xFF, 0xC0, 0xFE, 0x3F, 0xFC, 0x0F, 0xE3, 0xFF, 0xC0,
  0x7F, 0x3F, 0xFC, 0x07, 0xF3, 0xFF, 0xC0, 0x3F, 0xBF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x3F,
  0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0xCF, 0xC0, 0x0F,
  0xE7, 0xE0, 0x07, 0xFB, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x01,
  0xEF, 0xE0, 0x02, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x9F, 0xF0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xE1,
  0xF8, 0x07, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xEF, 0x81, 0xFC, 0x0F, 0xC0, 0xF9,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE7, 0xE0,
  0xFC, 0x03, 0xF0, 0xFC, 0x7C, 0x3F, 0x80, 0x7E, 0x1F, 0x8F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xE1, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x3F, 0x1F, 0x80, 0x1F,
  0x9F, 0x83, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x7E, 0xFC, 0x00, 0x7E, 0x7C,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x1F,
  0x7E, 0x00, 0x1F, 0xFE, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF9, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xF8, 0xFF, 0x86, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0x7C, 0xFF, 0xE3, 0xE3, 0xFE, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x83,
  0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xE0, 0xFF, 0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07,
  0xF7, 0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0x7F, 0xFC,
  0x7E, 0x7F, 0xF0, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0x81, 0x9F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x05, 0xFF, 0x03, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF1, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xBF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xFC, 0x1F, 0xF7,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x87, 0xFF, 0x3F, 0x07,
  0xF8, 0x7E, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x3F, 0xC7, 0xF9, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0xDF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x7E, 0x1F, 0xFC, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xDF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0x83, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF2, 0x00, 0x0F, 0xE7, 0x00, 0x3F,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x00, 0xA0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x0F, 0xEF, 0xFF,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x01, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xE7, 0xFF, 0x8F, 0xFF, 0x3F, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x83, 0xFF,
  0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFC,
  0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFF,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8,
  0x3F, 0xE3, 0xF3, 0xFF, 0xCF, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xF1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0xFC, 0x3F, 0xC1, 0xF9, 0xFF, 0xC3, 0xF7, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xF0, 0x7F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7E,
  0xFE, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xBF, 0xF8, 0x7F, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x7E, 0x1F, 0xFC,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F,
  0xDF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xFD, 0xFE,
  0x0F, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xC3, 0xFF,
  0xBF, 0x83, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0x1F, 0xBF,
  0x00, 0x4F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x87, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0x1F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFD, 0xF1, 0xFF, 0xE7, 0xC3,
  0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xDF,
  0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFB, 0xF0, 0x0F,
  0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x80, 0xFE, 0xFE, 0x07, 0xFC, 0x07, 0xE3,
  0xF0, 0x3F, 0xF0, 0x3F, 0x1F, 0x81, 0xFF, 0x83, 0xF8, 0xFE, 0x0F, 0x7C,
  0x1F, 0x83, 0xF0, 0xFB, 0xE0, 0xFC, 0x1F, 0x87, 0xCF, 0x8F, 0xE0, 0xFC,
  0x3E, 0x7C, 0x7E, 0x07, 0xF1, 0xE3, 0xE3, 0xF0, 0x1F, 0x9F, 0x1F, 0x1F,
  0x80, 0xFC, 0xF8, 0x7D, 0xFC, 0x07, 0xE7, 0xC3, 0xEF, 0xC0, 0x1F, 0x3E,
  0x1F, 0x7E, 0x00, 0xFD, 0xE0, 0xFB, 0xF0, 0x07, 0xFF, 0x03, 0xDF, 0x00,
  0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x9F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x1F, 0xDF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xF7,
  0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE1, 0xFC, 0x07, 0xF9, 0xFE, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF,
  0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0x07, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x83, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x0B, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFA,
  0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 15, 11, 21, 3, -31 },
  { 54, 26, 31, 28, 1, -31 },
  { 155, 21, 36, 25, 2, -33 },
  { 250, 37, 32, 40, 1, -32 },
  { 398, 31, 32, 33, 2, -32 },
  { 522, 6, 11, 12, 3, -31 },
  { 531, 12, 38, 15, 2, -31 },
  { 588, 12, 38, 15, 1, -31 },
  { 645, 22, 20, 24, 1, -33 },
  { 700, 21, 21, 25, 2, -26 },
  { 756, 9, 11, 13, 1, -5 },
  { 769, 12, 6, 14, 1, -15 },
  { 778, 8, 8, 12, 2, -7 },
  { 786, 18, 32, 18, 0, -32 },
  { 858, 22, 32, 25, 2, -32 },
  { 946, 15, 31, 25, 3, -31 },
  { 1005, 22, 32, 25, 2, -32 },
  { 1093, 21, 32, 25, 2, -32 },
  { 1177, 23, 31, 25, 1, -31 },
  { 1267, 21, 31, 25, 2, -31 },
  { 1349, 22, 32, 25, 2, -32 },
  { 1437, 23, 31, 25, 1, -31 },
  { 1527, 22, 32, 25, 2, -32 },
  { 1615, 23, 32, 25, 1, -32 },
  { 1707, 8, 25, 12, 2, -24 },
  { 1732, 9, 30, 13, 1, -24 },
  { 1766, 21, 24, 25, 2, -28 },
  { 1829, 21, 13, 25, 2, -22 },
  { 1864, 21, 24, 25, 2, -28 },
  { 1927, 20, 33, 21, 0, -32 },
  { 2010, 35, 36, 40, 2, -32 },
  { 2168, 30, 32, 30, 0, -32 },
  { 2288, 23, 31, 29, 4, -31 },
  { 2378, 25, 32, 28, 2, -32 },
  { 2478, 26, 31, 32, 4, -31 },
  { 2579, 18, 31, 25, 4, -31 },
  { 2649, 18, 31, 24, 4, -31 },
  { 2719, 25, 32, 32, 3, -32 },
  { 2819, 26, 31, 34, 4, -31 },
  { 2920, 15, 31, 17, 1, -31 },
  { 2979, 14, 40, 15, -3, -31 },
  { 3049, 25, 31, 29, 4, -31 },
  { 3146, 19, 31, 25, 4, -31 },
  { 3220, 34, 31, 41, 4, -31 },
  { 3352, 28, 31, 36, 4, -31 },
  { 3461, 30, 32, 35, 2, -32 },
  { 3581, 21, 31, 27, 4, -31 },
  { 3663, 30, 39, 35, 2, -32 },
  { 3810, 25, 31, 29, 4, -31 },
  { 3907, 20, 32, 24, 2, -32 },
  { 3987, 24, 31, 25, 1, -31 },
  { 4080, 26, 31, 33, 4, -31 },
  { 4181, 29, 31, 29, 0, -31 },
  { 4294, 43, 31, 43, 0, -31 },
  { 4461, 29, 31, 29, 0, -31 },
  { 4574, 28, 31, 28, 0, -31 },
  { 4683, 23, 31, 25, 1, -31 },
  { 4773, 10, 38, 15, 3, -31 },
  { 4821, 18, 32, 18, 0, -32 },
  { 4893, 10, 38, 15, 1, -31 },
  { 4941, 23, 21, 25, 1, -32 },
  { 5002, 18, 3, 18, 0, 4 },
  { 5009, 12, 7, 16, 2, -34 },
  { 5020, 21, 24, 26, 2, -24 },
  { 5083, 23, 33, 28, 3, -33 },
  { 5178, 19, 24, 23, 2, -24 },
  { 5235, 23, 33, 28, 2, -33 },
  { 5330, 22, 24, 26, 2, -24 },
  { 5396, 18, 34, 17, 1, -34 },
  { 5473, 23, 35, 28, 2, -24 },
  { 5574, 22, 33, 29, 3, -33 },
  { 5665, 7, 33, 13, 3, -33 },
  { 5694, 12, 44, 13, -2, -33 },
  { 5760, 24, 33, 27, 3, -33 },
  { 5859, 7, 33, 13, 3, -33 },
  { 5888, 37, 24, 43, 3, -24 },
  { 5999, 22, 24, 29, 3, -24 },
  { 6065, 23, 24, 28, 2, -24 },
  { 6134, 23, 35, 28, 3, -24 },
  { 6235, 23, 35, 28, 2, -24 },
  { 6336, 16, 24, 20, 3, -24 },
  { 6384, 18, 24, 22, 2, -24 },
  { 6438, 17, 29, 19, 1, -29 },
  { 6500, 22, 24, 29, 3, -24 },
  { 6566, 25, 24, 25, 0, -24 },
  { 6641, 37, 24, 38, 0, -24 },
  { 6752, 25, 24, 25, 0, -24 },
  { 6827, 25, 35, 25, 0, -24 },
  { 6937, 19, 24, 22, 1, -24 },
  { 6994, 15, 38, 17, 1, -31 },
  { 7066, 4, 43, 24, 10, -33 },
  { 7088, 15, 38, 17, 2, -31 },
  { 7160, 21, 7, 25, 2, -19 },
};

const GFXfont NotoSans_Bold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold44pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_BOLD44PT7B_H_
