#ifndef _NOTOSANS_BOLD6PT7B_H_
#define _NOTOSANS_BOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xA0, 0x6F, 0xF6, 0x5F, 0x1E, 0xD7, 0x4E, 0xB0, 0x63, 0x2D,
  0xF0, 0x80, 0x6A, 0x40, 0xD5, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x56, 0xF6, 0xB0, 0xD5, 0xE5, 0x70, 0xEC, 0xF0, 0x6F, 0x90, 0xFC,
  0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xF0, 0xA0, 0xB0, 0x39,
  0x80, 0xFC, 0x8F, 0x00, 0xE9, 0x20, 0x7F, 0xF7, 0xE0, 0x66, 0x79, 0xFA,
  0xE0, 0x78, 0x86, 0xF6, 0xE0, 0xFB, 0xFA, 0x7A, 0x97, 0xBE, 0xD0, 0xD7,
  0xF8, 0xFB, 0x50, 0xAB, 0x9B, 0xFD, 0xBF, 0xD0, 0x79, 0x97, 0xFA, 0x79,
  0x97, 0x10, 0xFB, 0x50, 0xF8, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0x96, 0x66,
  0xB6, 0xE7, 0x92, 0xF6, 0x69, 0xB6, 0x44, 0xE9, 0x70, 0xEA, 0xC0, 0x95,
  0xD5, 0xC0, 0x54, 0xC0, 0xC0, 0xFF, 0x80, 0x88, 0xE9, 0xE0, 0xF1, 0x80,
  0x27, 0xD6, 0xFD, 0x80, 0x6B, 0x24, 0xF5, 0xF0, 0x93, 0xDA, 0xB8, 0xBC,
  0x89, 0xAE, 0xB0, 0xF8, 0xFD, 0x6A, 0xF6, 0x80, 0xF5, 0x80, 0xE9, 0xE8,
  0xF5, 0x90, 0xF2, 0x00, 0xEF, 0x80, 0x75, 0xB5, 0x80, 0xAD, 0x00, 0xAE,
  0xD4, 0xEA, 0x80, 0xAD, 0x60, 0xEB, 0x80, 0x59, 0x40, 0xFC, 0xD5, 0x80,
  0xE0,
};

const GFXglyph NotoSans_Bold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 5, 4, 5, 0, -4 },
  { 13, 1, 1, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 2, 5, 2, 0, -4 },
  { 18, 3, 3, 3, 0, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 2, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 1, 3, 2, 0, -3 },
  { 46, 1, 4, 2, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 5, 4, 5, 0, -4 },
  { 57, 4, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 1, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 1, -4 },
  { 65, 2, 4, 3, 1, -4 },
  { 66, 2, 4, 3, 1, -4 },
  { 67, 4, 4, 4, 0, -4 },
  { 69, 3, 4, 5, 1, -4 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 1, 5, 2, 0, -4 },
  { 73, 3, 4, 4, 1, -4 },
  { 75, 2, 4, 3, 1, -4 },
  { 76, 4, 4, 6, 1, -4 },
  { 78, 3, 4, 5, 1, -4 },
  { 80, 4, 4, 5, 0, -4 },
  { 82, 2, 4, 4, 1, -4 },
  { 83, 4, 5, 5, 0, -4 },
  { 86, 3, 4, 4, 1, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 5, 1, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 6, 4, 6, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 2, 5, 2, 0, -4 },
  { 107, 2, 4, 2, 0, -4 },
  { 108, 2, 5, 2, 0, -4 },
  { 110, 3, 2, 3, 0, -4 },
  { 111, 2, 1, 2, 0, 0 },
  { 112, 2, 1, 2, 0, -5 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 3, 5, 4, 0, -5 },
  { 122, 3, 3, 4, 0, -3 },
  { 124, 3, 5, 2, 0, -5 },
  { 126, 3, 4, 4, 0, -3 },
  { 128, 3, 5, 4, 0, -5 },
  { 130, 1, 5, 2, 0, -5 },
  { 131, 1, 6, 2, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 1, 5, 2, 0, -5 },
  { 136, 5, 3, 6, 0, -3 },
  { 138, 3, 3, 4, 0, -3 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 4, 4, 4, 0, -3 },
  { 144, 3, 4, 4, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 2, 4, 3, 0, -4 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 5, 3, 5, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 3, 4, 3, 0, -3 },
  { 161, 3, 3, 3, 0, -3 },
  { 163, 2, 5, 2, 0, -4 },
  { 165, 1, 6, 3, 1, -5 },
  { 166, 2, 5, 2, 0, -4 },
  { 168, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Bold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold6pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_BOLD6PT7B_H_
