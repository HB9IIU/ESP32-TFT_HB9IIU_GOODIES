#ifndef _NOTOSANS_BOLD11PT7B_H_
#define _NOTOSANS_BOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8B, 0xBA, 0xA0, 0x14, 0x69, 0xF9, 0x42, 0x9F, 0xDA, 0x2C,
  0x11, 0xFD, 0x1C, 0x3C, 0x7F, 0xCC, 0x10, 0x63, 0x34, 0x8D, 0x43, 0x56,
  0x6A, 0x86, 0xB1, 0x2C, 0xCE, 0x38, 0x6C, 0x68, 0x38, 0x7B, 0xCE, 0x6E,
  0x7B, 0xE0, 0x2D, 0x2D, 0x92, 0x64, 0xCD, 0x92, 0x4B, 0x78, 0x33, 0xB7,
  0x9E, 0x50, 0x10, 0x41, 0x3F, 0x10, 0x40, 0x70, 0xFC, 0xB0, 0x19, 0x8C,
  0x46, 0x31, 0x18, 0x39, 0xA4, 0xF3, 0xCD, 0x36, 0xDE, 0x3F, 0xB3, 0x33,
  0x33, 0x7B, 0xB0, 0xC2, 0x18, 0xC6, 0x3F, 0xF9, 0x30, 0xCE, 0x38, 0x38,
  0xFE, 0x18, 0x62, 0x9A, 0x4B, 0xF0, 0x82, 0xF7, 0xA1, 0xE9, 0x8E, 0x7E,
  0x39, 0x84, 0x3E, 0xCF, 0x36, 0xDE, 0xFF, 0xF0, 0x86, 0x10, 0xC3, 0x18,
  0x79, 0x34, 0xDE, 0x7B, 0x3C, 0xDE, 0x79, 0xAC, 0xF3, 0x7C, 0x31, 0x9C,
  0xE0, 0xB0, 0x68, 0x00, 0xB0, 0x04, 0x76, 0x38, 0x1C, 0x10, 0xFF, 0xF0,
  0x3F, 0x81, 0x81, 0x87, 0x72, 0x00, 0xF6, 0xC6, 0x62, 0x00, 0x8C, 0x3C,
  0x43, 0x9D, 0xA5, 0xA5, 0xAD, 0x9A, 0xC2, 0x3C, 0x18, 0x38, 0x3C, 0x2C,
  0x64, 0x7E, 0x46, 0xC3, 0xFB, 0x6C, 0xFE, 0xFB, 0x3C, 0xFE, 0x7F, 0xAC,
  0x20, 0x83, 0x0C, 0x5E, 0xF3, 0xFC, 0xF1, 0xC7, 0x3D, 0xFE, 0xFF, 0xF1,
  0xEF, 0x63, 0x1F, 0xFF, 0xCC, 0xFC, 0xCC, 0x3F, 0x9C, 0x20, 0x9F, 0x3C,
  0xDF, 0xC7, 0x1C, 0x7F, 0xFF, 0x1C, 0x71, 0xF6, 0x66, 0x66, 0x6F, 0x33,
  0x33, 0x33, 0x33, 0x3E, 0xCF, 0x6D, 0x3C, 0xF3, 0x6D, 0xB3, 0xC6, 0x31,
  0x8C, 0x63, 0x1F, 0xC3, 0xE3, 0xA7, 0xA5, 0xB5, 0x9D, 0x99, 0x99, 0xC7,
  0xCE, 0x9D, 0xB9, 0xF3, 0x63, 0xC3, 0x79, 0xDB, 0x1C, 0x38, 0x78, 0xF3,
  0xBE, 0xF7, 0xF3, 0xBF, 0xE3, 0x18, 0x79, 0xDB, 0x1C, 0x38, 0x78, 0xF3,
  0xBE, 0x0C, 0x0C, 0xF3, 0x6C, 0xB6, 0xF3, 0x6D, 0xB3, 0x7D, 0xA4, 0x1C,
  0x38, 0x3C, 0xFE, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0xDE, 0xC7, 0x8D, 0x13, 0x66, 0xC5, 0x0E, 0x1C, 0xCC, 0x79,
  0x89, 0x3B, 0x25, 0x67, 0xAC, 0xF5, 0x0C, 0xE1, 0x8C, 0xC6, 0xD8, 0xB1,
  0xC3, 0x85, 0x9B, 0x63, 0xC6, 0x99, 0xB1, 0xC3, 0x82, 0x04, 0x08, 0xFF,
  0xF1, 0x84, 0x31, 0x84, 0x3F, 0xEA, 0xAA, 0xB0, 0xC2, 0x10, 0xC2, 0x18,
  0xC3, 0xED, 0xB6, 0xDB, 0x7C, 0x30, 0xC3, 0x92, 0xCC, 0xF8, 0xF0, 0x79,
  0x33, 0xD3, 0xCD, 0xF0, 0x84, 0x2F, 0xB8, 0xC7, 0x77, 0x7D, 0x88, 0xDF,
  0x18, 0xFB, 0xB8, 0xC7, 0x7D, 0xF6, 0xFF, 0x0C, 0xBC, 0x7B, 0x3C, 0xC6,
  0x31, 0x8C, 0xEE, 0xE3, 0x1D, 0xF4, 0x7F, 0x60, 0x84, 0x2F, 0xBC, 0xC6,
  0x31, 0xCA, 0xAA, 0x30, 0x22, 0x22, 0x22, 0x2E, 0xC0, 0xC3, 0x0D, 0xEC,
  0xA3, 0xCD, 0xB3, 0xFF, 0xBF, 0xEE, 0xF2, 0x71, 0x38, 0x9C, 0x4C, 0xBE,
  0xF3, 0x18, 0xC4, 0xF6, 0xE3, 0x1D, 0xB8, 0xBE, 0xE3, 0x1D, 0xDE, 0x10,
  0x80, 0xEE, 0xE3, 0x1D, 0xF4, 0x63, 0x18, 0xBD, 0xC8, 0x88, 0x7E, 0x1C,
  0x79, 0xBC, 0x6F, 0x66, 0x66, 0x70, 0x8C, 0x63, 0x1D, 0xFC, 0xCD, 0x36,
  0x9E, 0x38, 0xC0, 0xCC, 0xAE, 0xD5, 0x6E, 0xA7, 0x71, 0x98, 0xCD, 0xE3,
  0x8E, 0x6B, 0x30, 0xCD, 0x36, 0x9E, 0x38, 0xC3, 0x38, 0xC0, 0xF8, 0xCC,
  0xC4, 0x7C, 0x32, 0x22, 0xEE, 0x22, 0x33, 0xFF, 0xFF, 0xFC, 0xC6, 0x66,
  0x33, 0x66, 0x6C, 0x66, 0xF0,
};

const GFXglyph NotoSans_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 8, 3, 1, -8 },
  { 3, 4, 3, 5, 1, -8 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 6, 9, 6, 0, -8 },
  { 19, 10, 8, 10, 0, -8 },
  { 29, 8, 8, 8, 0, -8 },
  { 37, 1, 3, 3, 1, -8 },
  { 38, 3, 10, 4, 0, -8 },
  { 42, 3, 10, 4, 0, -8 },
  { 46, 6, 5, 6, 0, -8 },
  { 50, 6, 6, 6, 0, -7 },
  { 55, 2, 2, 3, 0, -1 },
  { 56, 3, 2, 4, 0, -4 },
  { 57, 2, 2, 3, 1, -2 },
  { 58, 5, 8, 5, 0, -8 },
  { 63, 6, 8, 6, 0, -8 },
  { 69, 4, 8, 6, 1, -8 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 6, 8, 6, 0, -8 },
  { 85, 6, 8, 6, 0, -8 },
  { 91, 5, 8, 6, 1, -8 },
  { 96, 6, 8, 6, 0, -8 },
  { 102, 6, 8, 6, 0, -8 },
  { 108, 6, 8, 6, 0, -8 },
  { 114, 6, 8, 6, 0, -8 },
  { 120, 2, 6, 3, 1, -6 },
  { 122, 3, 7, 3, 0, -6 },
  { 125, 6, 6, 6, 0, -7 },
  { 130, 6, 4, 6, 0, -6 },
  { 133, 6, 6, 6, 0, -7 },
  { 138, 5, 8, 5, 0, -8 },
  { 143, 8, 9, 10, 1, -8 },
  { 152, 8, 8, 8, 0, -8 },
  { 160, 6, 8, 7, 1, -8 },
  { 166, 6, 8, 7, 1, -8 },
  { 172, 6, 8, 8, 1, -8 },
  { 178, 5, 8, 6, 1, -8 },
  { 183, 4, 8, 6, 1, -8 },
  { 187, 6, 8, 8, 1, -8 },
  { 193, 6, 8, 8, 1, -8 },
  { 199, 4, 8, 4, 0, -8 },
  { 203, 4, 10, 4, -1, -8 },
  { 208, 6, 8, 7, 1, -8 },
  { 214, 5, 8, 6, 1, -8 },
  { 219, 8, 8, 10, 1, -8 },
  { 227, 7, 8, 9, 1, -8 },
  { 234, 7, 8, 9, 1, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 7, 10, 9, 1, -8 },
  { 255, 6, 8, 7, 1, -8 },
  { 261, 6, 8, 6, 0, -8 },
  { 267, 6, 8, 6, 0, -8 },
  { 273, 6, 8, 8, 1, -8 },
  { 279, 7, 8, 7, 0, -8 },
  { 286, 11, 8, 11, 0, -8 },
  { 297, 7, 8, 7, 0, -8 },
  { 304, 7, 8, 7, 0, -8 },
  { 311, 6, 8, 6, 0, -8 },
  { 317, 2, 10, 4, 1, -8 },
  { 320, 5, 8, 5, 0, -8 },
  { 325, 3, 10, 4, 0, -8 },
  { 329, 6, 5, 6, 0, -8 },
  { 333, 5, 1, 5, 0, 1 },
  { 334, 4, 1, 4, 0, -8 },
  { 335, 6, 6, 7, 0, -6 },
  { 340, 5, 8, 7, 1, -8 },
  { 345, 4, 6, 6, 1, -6 },
  { 348, 5, 8, 7, 1, -8 },
  { 353, 5, 6, 7, 1, -6 },
  { 357, 5, 8, 4, 0, -8 },
  { 362, 5, 9, 7, 1, -6 },
  { 368, 5, 8, 7, 1, -8 },
  { 373, 2, 8, 3, 1, -8 },
  { 375, 4, 11, 3, -1, -8 },
  { 381, 6, 8, 7, 1, -8 },
  { 387, 1, 8, 3, 1, -8 },
  { 388, 9, 6, 11, 1, -6 },
  { 395, 5, 6, 7, 1, -6 },
  { 399, 5, 6, 7, 1, -6 },
  { 403, 5, 9, 7, 1, -6 },
  { 409, 5, 9, 7, 1, -6 },
  { 415, 4, 6, 5, 1, -6 },
  { 418, 5, 6, 6, 0, -6 },
  { 422, 4, 7, 5, 0, -7 },
  { 426, 5, 6, 7, 1, -6 },
  { 430, 6, 6, 6, 0, -6 },
  { 435, 9, 6, 9, 0, -6 },
  { 442, 6, 6, 6, 0, -6 },
  { 447, 6, 9, 6, 0, -6 },
  { 454, 5, 6, 5, 0, -6 },
  { 458, 4, 10, 4, 0, -8 },
  { 463, 2, 11, 6, 2, -8 },
  { 466, 4, 10, 4, 0, -8 },
  { 471, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Bold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold11pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_BOLD11PT7B_H_
