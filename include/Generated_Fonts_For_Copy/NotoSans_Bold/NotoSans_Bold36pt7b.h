#ifndef _NOTOSANS_BOLD36PT7B_H_
#define _NOTOSANS_BOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x33, 0xFF, 0xFF, 0xFD, 0xF0, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xF7, 0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x1E, 0x78, 0x73,
  0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0E, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x0F, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFD, 0xF3, 0x84, 0xF9, 0xC0, 0x7C, 0xE0, 0x3F, 0x70, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0xEF, 0xC0, 0x73, 0xF0, 0x39, 0xFC, 0x1D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFC, 0x7F, 0xFC, 0x02, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1F, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0x7C, 0x07, 0xFE, 0x01, 0xE0,
  0x1F, 0xFC, 0x0F, 0x80, 0xF8, 0xF0, 0x3C, 0x03, 0xE3, 0xC1, 0xF0, 0x0F,
  0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xC3,
  0xC7, 0x80, 0x0F, 0x0F, 0x3E, 0x3C, 0x3E, 0x3C, 0xF3, 0xFC, 0x7F, 0xF7,
  0xCF, 0xF9, 0xFF, 0x9E, 0x7F, 0xE3, 0xFC, 0xF9, 0xE3, 0xC3, 0xE3, 0xCF,
  0x8F, 0x00, 0x1E, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0xF0, 0x03, 0xC3, 0xC3,
  0xC0, 0x0F, 0x0F, 0x0F, 0x00, 0x78, 0x3E, 0x3C, 0x03, 0xE0, 0x78, 0xF0,
  0x0F, 0x01, 0xE7, 0xC0, 0x7C, 0x07, 0xFE, 0x01, 0xE0, 0x0F, 0xF8, 0x0F,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xEF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0x87, 0xFE, 0x07,
  0xE3, 0xFF, 0xC1, 0xF1, 0xFD, 0xF8, 0xFC, 0x7E, 0x3F, 0x3E, 0x1F, 0x07,
  0xFF, 0x8F, 0xC0, 0xFF, 0xC3, 0xF0, 0x1F, 0xF0, 0x7E, 0x03, 0xF8, 0x1F,
  0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xBF,
  0x01, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x03,
  0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1,
  0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x04, 0x1E, 0x0B, 0xCE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF8, 0x01, 0xFE, 0x01, 0xEF, 0x01, 0xF7, 0xC0, 0xF9,
  0xF0, 0xF8, 0xF8, 0x1C, 0x30, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x1E,
  0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x33, 0xFF, 0xFF, 0xFD,
  0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0x3F, 0x9F, 0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3F, 0x7C, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E,
  0x0F, 0x8F, 0xC7, 0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x9F, 0xFF, 0xFB,
  0xEF, 0xBF, 0x79, 0xF9, 0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0x03, 0xF1, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3E, 0x3F, 0x8C, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1E,
  0xF8, 0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1,
  0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF8, 0x81, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xF7, 0x03, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF,
  0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xE0, 0x8F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x0E, 0x07, 0x9F, 0xE3, 0xEF, 0xFC, 0xFF, 0xFF, 0xBF, 0xEF, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x1F, 0x7E, 0x0F, 0xCF, 0xC7, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E,
  0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7E, 0x0F, 0x8F, 0xCF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF1,
  0xFC, 0xFE, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xDF, 0x03, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F,
  0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xDF, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x1F, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F,
  0xFF, 0xFF, 0xDF, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x1E, 0x78,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7E, 0x7F, 0x20, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0x87, 0x83, 0xFE, 0x3E, 0x78, 0x3F, 0xF8, 0xF3,
  0xC3, 0xFF, 0xC7, 0xBC, 0x3E, 0x1E, 0x1D, 0xE3, 0xE0, 0xF0, 0xFF, 0x1E,
  0x07, 0x87, 0xF8, 0xF0, 0x3C, 0x3F, 0xC7, 0x81, 0xE1, 0xFE, 0x3C, 0x0F,
  0x0E, 0xF1, 0xE0, 0xF8, 0xF7, 0x8F, 0x07, 0xC7, 0xBC, 0x7C, 0x7F, 0x79,
  0xE1, 0xFF, 0xFF, 0xCF, 0x87, 0xF9, 0xFC, 0x3C, 0x1F, 0x07, 0x81, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x7F, 0xDF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8,
  0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xFB, 0xF0,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xF8, 0x04, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x23, 0xFC, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xBF, 0x1F, 0xC0, 0x19, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF3, 0xF0, 0x0F,
  0x9F, 0xE0, 0x7C, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFF, 0x01, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x01,
  0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC,
  0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xDF, 0xFB, 0xC0,
  0x3D, 0xFF, 0xBE, 0x07, 0xDF, 0xFB, 0xE0, 0x79, 0xFF, 0x9E, 0x07, 0x9F,
  0xF9, 0xE0, 0xF9, 0xFF, 0x9F, 0x0F, 0x1F, 0xF8, 0xF0, 0xF1, 0xFF, 0x8F,
  0x1F, 0x1F, 0xF8, 0xF9, 0xE1, 0xFF, 0x8F, 0x9E, 0x1F, 0xF8, 0x7B, 0xE1,
  0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x83, 0xFC, 0x1F, 0xF8,
  0x3F, 0x81, 0xFF, 0x83, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF0,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFB, 0xF0, 0x3F, 0xF3, 0xE0, 0x7F, 0xE7, 0xE0, 0xFF, 0xC7, 0xE1, 0xFF,
  0x8F, 0xC3, 0xFF, 0x0F, 0xC7, 0xFE, 0x1F, 0x8F, 0xFC, 0x1F, 0x9F, 0xF8,
  0x1F, 0xBF, 0xF0, 0x3F, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xE3, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xEF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFC,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE,
  0x3F, 0xE3, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x0F,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC,
  0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7E, 0xFC, 0x06, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0xC3, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xC7,
  0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF8,
  0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0xFD, 0xF0, 0x0F, 0xE0,
  0x1F, 0x3E, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0xFC, 0xFC, 0x0F,
  0xF0, 0x1F, 0x8F, 0x81, 0xFF, 0x03, 0xE1, 0xF0, 0x3D, 0xE0, 0x7C, 0x3E,
  0x07, 0xBC, 0x0F, 0x87, 0xE1, 0xF7, 0x83, 0xE0, 0x7C, 0x3E, 0xF8, 0x7C,
  0x0F, 0x87, 0x9F, 0x0F, 0x81, 0xF0, 0xF1, 0xE1, 0xF0, 0x3E, 0x3E, 0x3C,
  0x7C, 0x03, 0xE7, 0xC7, 0xCF, 0x80, 0x7C, 0xF0, 0xF9, 0xF0, 0x0F, 0x9E,
  0x0F, 0x3E, 0x01, 0xF7, 0xC1, 0xEF, 0x80, 0x1E, 0xF8, 0x3F, 0xF0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xEF, 0xC0,
  0x07, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x81, 0xF8,
  0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x01, 0xDE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x0F, 0x1E, 0x01, 0xF7, 0xC0, 0x1E,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x03, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x0E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFC, 0x1F, 0x7C, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF,
  0x3C, 0x7F, 0x8F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0xFB, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFB, 0xFC, 0xFE, 0xFC, 0x1F, 0xBE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3C,
  0xFF, 0x8F, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE,
  0x7F, 0x1C, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x02, 0x7F, 0x06,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x1F, 0x1F, 0x1F, 0xF7, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFC, 0xFF, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD, 0xF0, 0xFE, 0x3C, 0x03, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBF, 0x03, 0xEF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x06, 0x7F, 0xFF, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x40, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE1, 0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xF9, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xC1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F,
  0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0x7C, 0x3F, 0x9F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFD, 0x80, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0xFB,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFC, 0x7F, 0xFF, 0xDF, 0x38, 0x00, 0x1F,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xC0, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xF1, 0xE0,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x03, 0xF3,
  0xE0, 0xFC, 0x7C, 0x3F, 0x0F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3E, 0xFC, 0x07,
  0xDF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xC0, 0xFC, 0xF8, 0x1F, 0x9F,
  0x01, 0xFB, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xFC,
  0x0F, 0xC3, 0xCF, 0xF8, 0xFF, 0xCF, 0x7F, 0xF7, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0x3F, 0xF3, 0xFB, 0xF0, 0x7F, 0x07, 0xEF, 0xC0, 0xFC, 0x0F,
  0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF,
  0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0xE0,
  0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0, 0x3F, 0xF8, 0x0F,
  0x80, 0xFF, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0xFC, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xFF, 0xFE, 0xFF, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xE1, 0xF9, 0xF8, 0x1F,
  0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xBF, 0x03, 0xF3, 0xF0, 0x7E,
  0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0xF8,
  0x3C, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x3F, 0xBF, 0x07, 0xEF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xBF, 0xE3, 0xE7, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0x3F,
  0x9F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0xFF,
  0x8F, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0x83, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xF9, 0xFF,
  0xF7, 0xFF, 0xEF, 0x81, 0x9F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0,
  0x3E, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x11, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0x7C, 0x7F, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03,
  0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xFC, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x7D, 0xF0, 0x3F, 0x81, 0xF7, 0xC0, 0xFE,
  0x07, 0xDF, 0x83, 0xF8, 0x3F, 0x3E, 0x1F, 0xE0, 0xF8, 0xF8, 0x7B, 0xC3,
  0xE3, 0xE1, 0xEF, 0x0F, 0x8F, 0xC7, 0xBC, 0x7C, 0x1F, 0x3C, 0xF1, 0xF0,
  0x7C, 0xF1, 0xE7, 0xC1, 0xF3, 0xC7, 0x9F, 0x03, 0xCF, 0x1E, 0xF8, 0x0F,
  0xB8, 0x7B, 0xE0, 0x3F, 0xE0, 0xEF, 0x80, 0xFF, 0x83, 0xBC, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1,
  0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7E, 0x03, 0xF1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xFD, 0xFC, 0x07, 0xF0, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x03, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x07, 0xF0,
  0xFF, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x83, 0xF0, 0xFF, 0x0F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x00,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0xC3, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x1E, 0x00, 0x1C, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8,
};

const GFXglyph NotoSans_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 10, 17, 2, -26 },
  { 38, 21, 26, 23, 1, -26 },
  { 107, 17, 29, 21, 2, -27 },
  { 169, 30, 26, 32, 1, -26 },
  { 267, 26, 26, 27, 1, -26 },
  { 352, 5, 10, 10, 2, -26 },
  { 359, 10, 32, 12, 1, -26 },
  { 399, 10, 32, 12, 1, -26 },
  { 439, 17, 16, 20, 1, -27 },
  { 473, 17, 17, 21, 2, -21 },
  { 510, 7, 9, 10, 1, -4 },
  { 518, 9, 5, 12, 1, -12 },
  { 524, 6, 6, 10, 2, -6 },
  { 529, 15, 26, 15, 0, -26 },
  { 578, 18, 26, 21, 1, -26 },
  { 637, 13, 26, 21, 2, -26 },
  { 680, 18, 26, 21, 1, -26 },
  { 739, 18, 26, 21, 1, -26 },
  { 798, 19, 26, 21, 1, -26 },
  { 860, 17, 26, 21, 2, -26 },
  { 916, 18, 26, 21, 1, -26 },
  { 975, 18, 26, 21, 1, -26 },
  { 1034, 18, 26, 21, 1, -26 },
  { 1093, 18, 26, 21, 1, -26 },
  { 1152, 6, 20, 10, 2, -20 },
  { 1167, 7, 25, 10, 1, -20 },
  { 1189, 17, 19, 21, 2, -23 },
  { 1230, 17, 11, 21, 2, -18 },
  { 1254, 17, 19, 21, 2, -23 },
  { 1295, 16, 26, 17, 0, -26 },
  { 1347, 29, 29, 32, 2, -26 },
  { 1453, 25, 26, 25, 0, -26 },
  { 1535, 19, 26, 24, 3, -26 },
  { 1597, 20, 26, 23, 2, -26 },
  { 1662, 21, 26, 26, 3, -26 },
  { 1731, 15, 26, 20, 3, -26 },
  { 1780, 15, 26, 20, 3, -26 },
  { 1829, 21, 26, 26, 2, -26 },
  { 1898, 21, 26, 28, 3, -26 },
  { 1967, 12, 26, 14, 1, -26 },
  { 2006, 12, 34, 12, -3, -26 },
  { 2057, 21, 26, 24, 3, -26 },
  { 2126, 16, 26, 20, 3, -26 },
  { 2178, 28, 26, 34, 3, -26 },
  { 2269, 23, 26, 29, 3, -26 },
  { 2344, 24, 26, 28, 2, -26 },
  { 2422, 18, 26, 22, 3, -26 },
  { 2481, 24, 32, 28, 2, -26 },
  { 2577, 21, 26, 24, 3, -26 },
  { 2646, 16, 26, 20, 2, -26 },
  { 2698, 19, 26, 21, 1, -26 },
  { 2760, 21, 26, 27, 3, -26 },
  { 2829, 23, 26, 23, 0, -26 },
  { 2904, 35, 26, 35, 0, -26 },
  { 3018, 24, 26, 24, 0, -26 },
  { 3096, 23, 26, 23, 0, -26 },
  { 3171, 19, 26, 21, 1, -26 },
  { 3233, 8, 32, 12, 3, -26 },
  { 3265, 15, 26, 15, 0, -26 },
  { 3314, 8, 32, 12, 1, -26 },
  { 3346, 19, 17, 21, 1, -26 },
  { 3387, 15, 3, 15, 0, 3 },
  { 3393, 11, 6, 13, 1, -28 },
  { 3402, 18, 20, 22, 1, -20 },
  { 3447, 18, 27, 23, 3, -27 },
  { 3508, 16, 20, 19, 2, -20 },
  { 3548, 18, 27, 23, 2, -27 },
  { 3609, 18, 20, 21, 2, -20 },
  { 3654, 15, 28, 14, 1, -28 },
  { 3707, 18, 29, 23, 2, -20 },
  { 3773, 18, 27, 23, 3, -27 },
  { 3834, 6, 27, 11, 2, -27 },
  { 3855, 10, 36, 11, -2, -27 },
  { 3900, 19, 27, 22, 3, -27 },
  { 3965, 5, 27, 11, 3, -27 },
  { 3982, 30, 20, 35, 3, -20 },
  { 4057, 18, 20, 23, 3, -20 },
  { 4102, 19, 20, 23, 2, -20 },
  { 4150, 18, 29, 23, 3, -20 },
  { 4216, 18, 29, 23, 2, -20 },
  { 4282, 13, 20, 16, 3, -20 },
  { 4315, 15, 20, 18, 2, -20 },
  { 4353, 13, 24, 16, 1, -24 },
  { 4392, 18, 20, 23, 3, -20 },
  { 4437, 21, 20, 21, 0, -20 },
  { 4490, 30, 20, 31, 0, -20 },
  { 4565, 21, 20, 21, 0, -20 },
  { 4618, 21, 29, 21, 0, -20 },
  { 4695, 16, 20, 18, 1, -20 },
  { 4735, 12, 32, 14, 1, -26 },
  { 4783, 4, 35, 20, 8, -27 },
  { 4801, 13, 32, 14, 1, -26 },
  { 4853, 17, 6, 21, 2, -16 },
};

const GFXfont NotoSans_Bold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold36pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_BOLD36PT7B_H_
