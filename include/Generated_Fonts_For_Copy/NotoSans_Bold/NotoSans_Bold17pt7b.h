#ifndef _NOTOSANS_BOLD17PT7B_H_
#define _NOTOSANS_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0x0B, 0xF0, 0xCF, 0x3C, 0xF3, 0x0D, 0x81, 0xB0,
  0x26, 0x3F, 0xF7, 0xFE, 0x36, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0xD8,
  0x1B, 0x00, 0x10, 0x3C, 0xFF, 0xF6, 0xD0, 0xF0, 0x7C, 0x1E, 0x17, 0x93,
  0xFF, 0xFE, 0x10, 0x10, 0xF0, 0x63, 0x63, 0x0D, 0x8C, 0x36, 0x60, 0xDB,
  0x03, 0x6D, 0xEF, 0x6D, 0xC1, 0xB3, 0x0C, 0xCC, 0x33, 0x31, 0x8F, 0x8E,
  0x1E, 0x3E, 0x07, 0xF0, 0x67, 0x06, 0x60, 0x7E, 0x03, 0xC6, 0xFC, 0xEE,
  0xEE, 0xC7, 0xCE, 0x38, 0xFF, 0xC7, 0xEF, 0xFF, 0x36, 0x6C, 0xCC, 0xCC,
  0xCC, 0xCE, 0x66, 0x30, 0xC6, 0x67, 0x33, 0x33, 0x33, 0x76, 0x6C, 0xC0,
  0x1C, 0x06, 0x12, 0x2F, 0xFB, 0xE0, 0xF0, 0xDC, 0xE4, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0xFB, 0x60, 0xFF, 0xFE, 0x5F, 0x80, 0x0E,
  0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x70, 0xC1, 0x87, 0x00, 0x7C, 0xFE,
  0xE7, 0xC7, 0xC7, 0xC3, 0xC3, 0xC7, 0xC7, 0xE7, 0x7E, 0x3C, 0x1C, 0xF7,
  0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x7E, 0xFE, 0x47, 0x07, 0x07,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0xFE, 0xFE, 0x87, 0x07, 0x0E,
  0x38, 0x3E, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0x07, 0x07, 0x83, 0xC3, 0x63,
  0xF1, 0xB9, 0x9D, 0xFF, 0xFF, 0x83, 0x81, 0xC0, 0xE0, 0xFE, 0xFE, 0xE0,
  0xE0, 0xFC, 0xFE, 0x4F, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0x3E, 0x7E, 0xE0,
  0xC0, 0xDC, 0xFF, 0xE7, 0xC3, 0xC3, 0xE7, 0x7E, 0x3E, 0xFF, 0xFF, 0xC0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0x7E,
  0xFF, 0xC7, 0xE7, 0x7E, 0x3C, 0x7E, 0xE7, 0xC3, 0xC3, 0xFF, 0x7E, 0x7C,
  0xFE, 0xC7, 0xC7, 0xC3, 0xE7, 0xFF, 0x73, 0x07, 0x0E, 0xFE, 0xF8, 0xFC,
  0x00, 0x17, 0xE0, 0xFC, 0x00, 0x07, 0xDB, 0x00, 0x01, 0x03, 0x0F, 0x3C,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x3C, 0xF0, 0xC0, 0x7E, 0xFF, 0x47, 0x07,
  0x0E, 0x1C, 0x18, 0x30, 0x00, 0x10, 0x38, 0x38, 0x0F, 0xC1, 0xE3, 0x9C,
  0x0E, 0xCF, 0xBC, 0xEC, 0xEC, 0x67, 0x63, 0x3B, 0x1B, 0xDD, 0xDE, 0x7B,
  0x98, 0x00, 0xE0, 0x81, 0xFC, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB8,
  0x19, 0x83, 0x98, 0x39, 0xC3, 0xFC, 0x7F, 0xE7, 0x0E, 0x60, 0xEE, 0x07,
  0xFF, 0x7F, 0xF8, 0xFC, 0x7E, 0x3F, 0xF3, 0xFF, 0xC3, 0xE1, 0xF1, 0xFF,
  0xFF, 0xE0, 0x1F, 0xBF, 0xDC, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x5F, 0xE3, 0xF0, 0xFF, 0x1F, 0xF3, 0x8F, 0x70, 0xEE, 0x0D, 0xC1,
  0xF8, 0x3F, 0x06, 0xE1, 0xDC, 0x7B, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0x06,
  0x0C, 0x1F, 0xBF, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0xC3,
  0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x1F, 0xCF, 0xE7, 0x07, 0x80, 0xE0, 0x39,
  0xFE, 0x7F, 0x87, 0xE1, 0xDC, 0x77, 0xFC, 0x7F, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0xFF, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0xFF, 0xDC,
  0xE7, 0x39, 0xCE, 0x73, 0xBF, 0xF0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x33, 0xFF, 0xD8, 0xC3, 0xE3, 0xB3, 0x99, 0x8D, 0xC7, 0xC3, 0xF1,
  0x98, 0xCE, 0x63, 0xB1, 0xD8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x1B, 0xEC, 0xDF, 0x66, 0xFB, 0x77, 0xCF, 0x3E, 0x79, 0xF3, 0xCF,
  0x8C, 0x70, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xD8, 0xF7, 0x3C, 0xEF, 0x3B,
  0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0x3F, 0x87, 0xFC, 0x70, 0xEE, 0x0E, 0xE0,
  0x6E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0xE7, 0x1E, 0x7F, 0xC1, 0xF8, 0xFE,
  0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x3B, 0xFD, 0xF8, 0xE0, 0x70, 0x38, 0x1C,
  0x00, 0x3F, 0x87, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x6E,
  0x06, 0xE0, 0xE7, 0x1E, 0x7F, 0xC1, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0xFE, 0x3F, 0xCE, 0x3B, 0x8E, 0xE3, 0xBF, 0xCF, 0xE3, 0x98, 0xE7, 0x38,
  0xEE, 0x3B, 0x87, 0x7F, 0xFE, 0xE2, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07,
  0x87, 0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xDC, 0x77, 0xFC, 0xFC, 0xE0, 0xEC, 0x19, 0x83,
  0x38, 0xE3, 0x18, 0x63, 0x0E, 0xE0, 0xD8, 0x1B, 0x03, 0x60, 0x38, 0x07,
  0x00, 0xE1, 0xC3, 0xE1, 0xC3, 0x63, 0xC7, 0x63, 0xC7, 0x73, 0x66, 0x73,
  0x66, 0x36, 0x6E, 0x36, 0x6C, 0x36, 0x3C, 0x3E, 0x3C, 0x1C, 0x3C, 0x1C,
  0x38, 0xF0, 0xEE, 0x38, 0xE6, 0x0D, 0xC1, 0xF0, 0x1C, 0x03, 0xC0, 0xF8,
  0x3B, 0x86, 0x39, 0xC7, 0x70, 0x70, 0xE1, 0xEE, 0x39, 0xC6, 0x1D, 0xC3,
  0xB0, 0x3E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F,
  0xBF, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x30, 0x38, 0x3F, 0xFF,
  0xF0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0xC1, 0x83,
  0x83, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0xF0, 0x0C, 0x0E, 0x07, 0x86, 0xC3, 0x33, 0x19, 0x87,
  0x83, 0xFE, 0xE3, 0x86, 0x7E, 0x67, 0x07, 0x3F, 0xFF, 0xC7, 0xC7, 0xFF,
  0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xF7, 0xFB, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFF, 0xED, 0xE0, 0x7F, 0xFF, 0x86, 0x0C, 0x1C, 0x38, 0xBF, 0x3E,
  0x03, 0x81, 0xC0, 0xE0, 0x77, 0xFF, 0xFF, 0x8F, 0x87, 0xC3, 0xF1, 0xF8,
  0xFF, 0xF7, 0xB8, 0x7E, 0xF7, 0xE3, 0xFF, 0xFF, 0xC0, 0xE0, 0x7F, 0x3F,
  0x1E, 0x7C, 0xC1, 0x8F, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x00,
  0x7F, 0xFF, 0xF8, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xFF, 0x7B, 0x81, 0xA1,
  0xDF, 0xEF, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xF7, 0xFF, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x38, 0xFD, 0x0F, 0xFF, 0xFF, 0xFE, 0x39,
  0xC4, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xB9, 0xCE, 0xE3, 0xF0, 0xFC, 0x3F, 0x8E, 0x73,
  0x8C, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xDF, 0x7F, 0xFF, 0xFE,
  0x38, 0xF8, 0xE3, 0xE3, 0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xE3, 0x8C,
  0xDF, 0x7F, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x7E,
  0x7F, 0xB8, 0xF8, 0x7C, 0x3F, 0x1F, 0x8C, 0xFE, 0x3E, 0x00, 0xFF, 0x7F,
  0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E,
  0x00, 0x7F, 0xFF, 0xF8, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xFF, 0x7B, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0xDF, 0xFF, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0xFF,
  0xCB, 0x07, 0xC7, 0xC3, 0xE3, 0xFF, 0xFC, 0x30, 0x63, 0xFF, 0xF3, 0x06,
  0x0C, 0x18, 0x30, 0x7C, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8E, 0xFF, 0x7D, 0x80, 0xE1, 0xD8, 0xE7, 0x39, 0xCC, 0x37, 0x0F, 0xC1,
  0xE0, 0x78, 0x1C, 0x00, 0xE3, 0x8D, 0x9E, 0x76, 0x79, 0xDD, 0xB6, 0x36,
  0xD8, 0xD3, 0xE3, 0xCF, 0x0F, 0x1C, 0x1C, 0x70, 0xF3, 0xDC, 0xC3, 0xF0,
  0x78, 0x1E, 0x0F, 0x83, 0x71, 0xCE, 0xE1, 0xC0, 0xE1, 0xD8, 0xE7, 0x38,
  0xCC, 0x33, 0x0F, 0xC1, 0xE0, 0x78, 0x0C, 0x07, 0x01, 0xC1, 0xE0, 0x70,
  0x00, 0xFF, 0xFC, 0x71, 0xC3, 0x0E, 0x38, 0x7F, 0xFE, 0x1C, 0xF3, 0x8E,
  0x38, 0xEF, 0x38, 0x30, 0xE3, 0x8E, 0x38, 0x70, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE7, 0x18, 0xC6, 0x31, 0xE7, 0x73, 0x18, 0xC6, 0x73, 0x00,
  0xF9, 0xBF,
};

const GFXglyph NotoSans_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 6, 4, 8, 1, -12 },
  { 9, 11, 12, 11, 0, -12 },
  { 26, 8, 14, 10, 1, -13 },
  { 40, 14, 12, 15, 1, -12 },
  { 61, 12, 12, 13, 1, -12 },
  { 79, 2, 4, 5, 1, -12 },
  { 80, 4, 15, 6, 1, -12 },
  { 88, 4, 15, 6, 1, -12 },
  { 96, 9, 8, 9, 0, -13 },
  { 105, 8, 8, 10, 1, -10 },
  { 113, 3, 4, 5, 1, -2 },
  { 115, 5, 3, 5, 0, -6 },
  { 117, 3, 3, 5, 1, -3 },
  { 119, 7, 12, 7, 0, -12 },
  { 130, 8, 12, 10, 1, -12 },
  { 142, 6, 12, 10, 1, -12 },
  { 151, 8, 12, 10, 1, -12 },
  { 163, 8, 12, 10, 1, -12 },
  { 175, 9, 12, 10, 0, -12 },
  { 189, 8, 12, 10, 1, -12 },
  { 201, 8, 12, 10, 1, -12 },
  { 213, 9, 12, 10, 0, -12 },
  { 227, 8, 12, 10, 1, -12 },
  { 239, 8, 12, 10, 1, -12 },
  { 251, 3, 9, 5, 1, -9 },
  { 255, 3, 11, 5, 1, -9 },
  { 260, 8, 9, 10, 1, -11 },
  { 269, 8, 6, 10, 1, -9 },
  { 275, 8, 9, 10, 1, -11 },
  { 284, 8, 12, 8, 0, -12 },
  { 296, 13, 13, 15, 1, -12 },
  { 318, 12, 12, 12, 0, -12 },
  { 336, 9, 12, 11, 1, -12 },
  { 350, 9, 12, 11, 1, -12 },
  { 364, 11, 12, 12, 1, -12 },
  { 381, 7, 12, 10, 2, -12 },
  { 392, 6, 12, 9, 2, -12 },
  { 401, 10, 12, 12, 1, -12 },
  { 416, 9, 12, 13, 2, -12 },
  { 430, 5, 12, 7, 1, -12 },
  { 438, 5, 16, 6, -1, -12 },
  { 448, 9, 12, 11, 2, -12 },
  { 462, 8, 12, 10, 1, -12 },
  { 474, 13, 12, 16, 2, -12 },
  { 494, 10, 12, 14, 2, -12 },
  { 509, 12, 12, 13, 1, -12 },
  { 527, 9, 12, 11, 1, -12 },
  { 541, 12, 15, 13, 1, -12 },
  { 564, 10, 12, 11, 1, -12 },
  { 579, 8, 12, 9, 1, -12 },
  { 591, 9, 12, 10, 0, -12 },
  { 605, 10, 12, 13, 1, -12 },
  { 620, 11, 12, 11, 0, -12 },
  { 637, 16, 12, 16, 0, -12 },
  { 661, 11, 12, 11, 0, -12 },
  { 678, 11, 12, 11, 0, -12 },
  { 695, 9, 12, 10, 0, -12 },
  { 709, 4, 15, 6, 1, -12 },
  { 717, 7, 12, 7, 0, -12 },
  { 728, 4, 15, 6, 0, -12 },
  { 736, 9, 8, 10, 0, -12 },
  { 745, 7, 1, 7, 0, 2 },
  { 746, 5, 3, 6, 1, -13 },
  { 748, 8, 9, 10, 1, -9 },
  { 757, 9, 13, 11, 1, -13 },
  { 772, 7, 9, 9, 1, -9 },
  { 780, 9, 13, 11, 1, -13 },
  { 795, 8, 9, 10, 1, -9 },
  { 804, 7, 13, 7, 0, -13 },
  { 816, 9, 13, 11, 1, -9 },
  { 831, 9, 13, 11, 1, -13 },
  { 846, 3, 13, 5, 1, -13 },
  { 851, 5, 17, 5, -1, -13 },
  { 862, 10, 13, 11, 1, -13 },
  { 879, 3, 13, 5, 1, -13 },
  { 884, 14, 9, 17, 1, -9 },
  { 900, 9, 9, 11, 1, -9 },
  { 911, 9, 9, 11, 1, -9 },
  { 922, 9, 13, 11, 1, -9 },
  { 937, 9, 13, 11, 1, -9 },
  { 952, 6, 9, 8, 1, -9 },
  { 959, 7, 9, 9, 1, -9 },
  { 967, 7, 11, 7, 0, -11 },
  { 977, 9, 9, 11, 1, -9 },
  { 988, 10, 9, 10, 0, -9 },
  { 1000, 14, 9, 15, 0, -9 },
  { 1016, 10, 9, 10, 0, -9 },
  { 1028, 10, 13, 10, 0, -9 },
  { 1045, 7, 9, 8, 1, -9 },
  { 1053, 6, 15, 7, 0, -12 },
  { 1065, 2, 17, 9, 4, -13 },
  { 1070, 5, 15, 7, 1, -12 },
  { 1080, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_Bold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold17pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_BOLD17PT7B_H_
