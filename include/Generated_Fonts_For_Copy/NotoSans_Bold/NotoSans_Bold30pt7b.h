#ifndef _NOTOSANS_BOLD30PT7B_H_
#define _NOTOSANS_BOLD30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x67,
  0xBF, 0xFF, 0x00, 0xF3, 0xFE, 0x7B, 0xCF, 0x78, 0xEF, 0x1D, 0xE3, 0xBC,
  0x70, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x78, 0x07, 0x1C,
  0x01, 0xC7, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xE0,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF,
  0xBE, 0x67, 0x7C, 0xC0, 0xF9, 0x80, 0xFB, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xDF, 0x01, 0x9F, 0x83, 0x7F, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0x83, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x1F, 0x80, 0x78, 0x1F, 0xE0, 0x38, 0x1E, 0x78, 0x3C,
  0x0F, 0x3C, 0x3C, 0x07, 0x9E, 0x1C, 0x03, 0xC7, 0x1E, 0x01, 0xC3, 0x8E,
  0x00, 0xF3, 0xCF, 0x00, 0x79, 0xE7, 0x3F, 0x3C, 0xF7, 0xBF, 0xCF, 0xF3,
  0x9F, 0xE3, 0xF3, 0xDE, 0x78, 0x63, 0xCF, 0x3C, 0x01, 0xC7, 0x8E, 0x01,
  0xE3, 0xC7, 0x00, 0xE1, 0xE7, 0x80, 0xF0, 0xF3, 0xC0, 0x70, 0x79, 0xE0,
  0x78, 0x1F, 0xE0, 0x38, 0x0F, 0xF0, 0x3C, 0x03, 0xF0, 0x03, 0xC0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x8F, 0xF8, 0x3C, 0x7F, 0xF1, 0xF1, 0xF7, 0xE7, 0xCF,
  0x8F, 0xFE, 0x3E, 0x1F, 0xF8, 0xF8, 0x3F, 0xC3, 0xF0, 0x7E, 0x07, 0xF7,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x38, 0x3C,
  0x3C, 0x1E, 0x0E, 0x0F, 0xF0, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0xC3, 0x8F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0x01,
  0xFE, 0x0F, 0x3C, 0x3C, 0xF8, 0x21, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x7D, 0xE7, 0x9E, 0xF3, 0xCE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x67, 0xFF,
  0xFF, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x07,
  0x80, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x78, 0x3E, 0xF8, 0x79, 0xFB, 0xF1, 0xFF,
  0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0xFF, 0xFE,
  0xF7, 0x3C, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0xE1,
  0xFF, 0xE7, 0xFF, 0xE7, 0x87, 0xC6, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE3, 0x07, 0xC4,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x3F, 0xE0, 0x7F, 0x00, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F,
  0xC3, 0xF7, 0xFF, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0x78, 0x0F, 0x78, 0x0E, 0x78,
  0x1E, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3D, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7D, 0xF3, 0xFB,
  0xFF, 0xE7, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x78, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE3, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF1, 0xF1, 0xEF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1E, 0xF8, 0x7D, 0xF9, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3E, 0x1E, 0x3E, 0xF8, 0x7F, 0xE0, 0x3F,
  0x80, 0xFF, 0x83, 0xFF, 0x8F, 0x8F, 0xBE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFB, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0x80,
  0x3F, 0xC0, 0xFF, 0xE3, 0xFF, 0xCF, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFB, 0xFF, 0xF7, 0xFD, 0xE7, 0xFB,
  0xC1, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF9, 0x0F, 0xE3, 0xFF, 0x87,
  0xFE, 0x0F, 0xF0, 0x00, 0x67, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x7F, 0xFF, 0xF0, 0x31, 0xF7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xDE, 0x79, 0xEF, 0x3C, 0xE0, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x01,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00,
  0x07, 0x81, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x70, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFC, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0xFE,
  0x3C, 0x70, 0xFF, 0x8E, 0x78, 0xFF, 0xC7, 0x38, 0xF0, 0xE3, 0x9C, 0x70,
  0x71, 0xFE, 0x78, 0x38, 0xFF, 0x3C, 0x1C, 0x77, 0x9E, 0x1E, 0x3B, 0xCF,
  0x0F, 0x1C, 0xE3, 0xCF, 0x9E, 0x71, 0xFF, 0xFE, 0x3C, 0x7F, 0x7E, 0x1E,
  0x06, 0x0C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x02, 0x00, 0x7F, 0x3F, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x78,
  0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xE0, 0x1E,
  0x0F, 0x01, 0xF0, 0x78, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80,
  0x1F, 0x7C, 0x00, 0x7C, 0xFF, 0xF1, 0xFF, 0xFB, 0xFF, 0xF7, 0x83, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF,
  0xE7, 0xFF, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xF8, 0x07, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0x06, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0x7F, 0xFE, 0x3F, 0xFE,
  0x1F, 0xFE, 0x07, 0xFE, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x1F,
  0xEF, 0x03, 0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3E, 0xF0, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF0, 0x33, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0F, 0x7C, 0x07, 0xBF, 0x03, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3F, 0xF8, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x78, 0xFF, 0xFF, 0xF7, 0xF8, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0xCF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3F, 0xFF, 0xFF, 0x7F, 0x3F, 0x00, 0xF0,
  0x1F, 0xF8, 0x1F, 0x3C, 0x1F, 0x9E, 0x0F, 0x8F, 0x0F, 0x87, 0x8F, 0x83,
  0xCF, 0x81, 0xE7, 0xC0, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xBF, 0x07, 0x8F, 0x83, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x7C, 0x78,
  0x1F, 0x3C, 0x0F, 0x9E, 0x03, 0xEF, 0x01, 0xF8, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0xE0, 0x1D, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFB, 0x81, 0xDF, 0xF7, 0x87, 0xBF, 0xEF, 0x0F, 0x7F,
  0xCE, 0x1C, 0xFF, 0x9E, 0x79, 0xFF, 0x3C, 0xF3, 0xFE, 0x79, 0xC7, 0xFC,
  0x77, 0x8F, 0xF8, 0xFF, 0x1F, 0xF1, 0xFC, 0x3F, 0xE1, 0xF8, 0x7F, 0xC3,
  0xF0, 0xFF, 0x87, 0xC1, 0xFF, 0x07, 0x83, 0xE0, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFD, 0xE0,
  0x7F, 0xBE, 0x0F, 0xF3, 0xE1, 0xFE, 0x7C, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8,
  0xFF, 0x0F, 0x9F, 0xE0, 0xFB, 0xFC, 0x1F, 0x7F, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xC0,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xBC, 0x7F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x1F, 0x8F, 0x07,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0x8F, 0x83, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x0F, 0x9E, 0x03, 0xEF, 0x01, 0xF8, 0x03,
  0xC0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x39, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xF1,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xE0,
  0xF8, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F,
  0x9E, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xDE, 0x03, 0xE0, 0x3C, 0xF0, 0x3F, 0x81,
  0xE7, 0xC1, 0xFC, 0x1F, 0x1E, 0x0E, 0xE0, 0xF8, 0xF0, 0x77, 0x07, 0x87,
  0x87, 0xBC, 0x3C, 0x3E, 0x3D, 0xE3, 0xE0, 0xF1, 0xEF, 0x1E, 0x07, 0x9E,
  0x38, 0xF0, 0x3C, 0xF1, 0xE7, 0x81, 0xE7, 0x8F, 0x3C, 0x07, 0xBC, 0x7B,
  0xC0, 0x3D, 0xC1, 0xDE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0,
  0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xE0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x7C,
  0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xEF, 0x80,
  0xF8, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xCF,
  0x80, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x7F, 0xFF, 0xFC, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0xB8,
  0x0E, 0x38, 0x3C, 0x70, 0x70, 0x71, 0xE0, 0xE3, 0x80, 0xE7, 0x01, 0xFE,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x01,
  0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE1, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x0F, 0xDF, 0xFF, 0xBF, 0xEF, 0x3F, 0x9E, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xE0, 0xFB, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xFE, 0x7E, 0xFF,
  0xFC, 0xF7, 0xF8, 0xF3, 0xF0, 0x01, 0xC0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE,
  0x7E, 0x11, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x05, 0xFC, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07,
  0x1F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C,
  0x1F, 0x7E, 0x7F, 0x3F, 0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0x01, 0xC0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E,
  0x0E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x07, 0xE1, 0xFF, 0x1F, 0xE3,
  0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0x00, 0x1F, 0xCF, 0x3F, 0xEF,
  0x7F, 0xFF, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x40, 0x3E, 0x7C, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x38, 0x7D, 0xFC, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0x80, 0x77, 0xFF, 0xF2, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x20, 0x00,
  0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xF7, 0xFF,
  0xEF, 0xF7, 0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x7E, 0xF8, 0x7E, 0x7C, 0x3E,
  0x3E, 0x3E, 0x1F, 0x3E, 0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE7,
  0xC1, 0xF3, 0xE0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x38, 0x79, 0xFC,
  0x7F, 0x3D, 0xFF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF0, 0xFF, 0xC1,
  0xF0, 0x7F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC,
  0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xFF, 0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x7F,
  0xC1, 0xF0, 0x3F, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07,
  0x80, 0x00, 0xE1, 0xE7, 0xFB, 0xDF, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0x01, 0xC0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x7C, 0x1F, 0x78, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E,
  0x3E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0xE0, 0xF3, 0xF8, 0xF7,
  0xFC, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xFE, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFB, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x1F, 0xCF, 0x3F,
  0xEF, 0x7F, 0xFF, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x7F, 0x3F,
  0xFF, 0x3F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x7F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x81, 0xFF, 0xDF, 0xFC,
  0xFF, 0xEF, 0x81, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xDF, 0xFE, 0x7F, 0xC0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0x27, 0xFC,
  0x7F, 0x87, 0xF0, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC7, 0xEF, 0xFF, 0xDF, 0xFF, 0x8F, 0xC7, 0xF8, 0x0F, 0xBC,
  0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xF1, 0xF0, 0x78, 0xF8,
  0x3C, 0x78, 0x1F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xEF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xBC, 0x1F,
  0x87, 0xDE, 0x0F, 0xC3, 0xEF, 0x8F, 0xE1, 0xE3, 0xC7, 0x78, 0xF1, 0xE3,
  0xBC, 0xF8, 0xF9, 0xCE, 0x78, 0x3D, 0xE7, 0x3C, 0x1E, 0xF3, 0x9E, 0x0F,
  0x71, 0xFF, 0x07, 0xB8, 0x7F, 0x01, 0xDC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x9F,
  0x0F, 0x8F, 0x8F, 0x83, 0xEF, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xEF, 0x83, 0xE3,
  0xE1, 0xF0, 0xF9, 0xF0, 0x7D, 0xF8, 0x1F, 0xF8, 0x0F, 0xBC, 0x07, 0x9F,
  0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78,
  0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x0B,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0,
  0xFC, 0x3F, 0x87, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x7F, 0x0F, 0x81, 0xFC, 0x1F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xF8, 0x7F, 0x07, 0xE0, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F,
  0x0F, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x3F, 0x03, 0xC3, 0xF1, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x8F, 0xE3, 0xF0, 0xFC, 0x30, 0x00, 0x3E, 0x03, 0xFF, 0x9F, 0xFF,
  0xFE, 0x1F, 0xF8, 0x0F, 0x80,
};

const GFXglyph NotoSans_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 21, 8, 2, -21 },
  { 15, 11, 7, 14, 2, -21 },
  { 25, 18, 21, 19, 1, -21 },
  { 73, 15, 25, 17, 1, -23 },
  { 120, 25, 22, 27, 1, -22 },
  { 189, 22, 22, 23, 1, -22 },
  { 250, 4, 7, 8, 2, -21 },
  { 254, 8, 26, 10, 1, -21 },
  { 280, 8, 26, 10, 1, -21 },
  { 306, 14, 14, 16, 1, -23 },
  { 331, 15, 15, 17, 1, -18 },
  { 360, 6, 7, 9, 1, -3 },
  { 366, 8, 4, 10, 1, -10 },
  { 370, 5, 5, 8, 2, -5 },
  { 374, 12, 22, 12, 0, -22 },
  { 407, 15, 22, 17, 1, -22 },
  { 449, 10, 21, 17, 2, -21 },
  { 476, 15, 22, 17, 1, -22 },
  { 518, 15, 22, 17, 1, -22 },
  { 560, 16, 21, 17, 1, -21 },
  { 602, 15, 21, 17, 1, -21 },
  { 642, 15, 22, 17, 1, -22 },
  { 684, 15, 21, 17, 1, -21 },
  { 724, 15, 22, 17, 1, -22 },
  { 766, 15, 22, 17, 1, -22 },
  { 808, 5, 17, 8, 2, -17 },
  { 819, 6, 21, 9, 1, -17 },
  { 835, 15, 16, 17, 1, -19 },
  { 865, 15, 9, 17, 1, -15 },
  { 882, 15, 16, 17, 1, -19 },
  { 912, 14, 22, 14, 0, -22 },
  { 951, 25, 24, 27, 1, -22 },
  { 1026, 21, 22, 21, 0, -22 },
  { 1084, 15, 21, 20, 3, -21 },
  { 1124, 16, 22, 19, 2, -22 },
  { 1168, 17, 21, 22, 3, -21 },
  { 1213, 12, 21, 17, 3, -21 },
  { 1245, 12, 21, 16, 3, -21 },
  { 1277, 17, 22, 22, 2, -22 },
  { 1324, 17, 21, 23, 3, -21 },
  { 1369, 10, 21, 12, 1, -21 },
  { 1396, 9, 27, 10, -2, -21 },
  { 1427, 17, 21, 20, 3, -21 },
  { 1472, 13, 21, 17, 3, -21 },
  { 1507, 23, 21, 28, 3, -21 },
  { 1568, 19, 21, 24, 3, -21 },
  { 1618, 20, 22, 24, 2, -22 },
  { 1673, 14, 21, 19, 3, -21 },
  { 1710, 20, 27, 24, 2, -22 },
  { 1778, 17, 21, 20, 3, -21 },
  { 1823, 14, 22, 17, 1, -22 },
  { 1862, 16, 21, 17, 1, -21 },
  { 1904, 17, 21, 23, 3, -21 },
  { 1949, 20, 21, 20, 0, -21 },
  { 2002, 29, 21, 29, 0, -21 },
  { 2079, 20, 21, 20, 0, -21 },
  { 2132, 19, 21, 19, 0, -21 },
  { 2182, 16, 21, 17, 1, -21 },
  { 2224, 7, 26, 10, 2, -21 },
  { 2247, 12, 22, 12, 0, -22 },
  { 2280, 7, 26, 10, 1, -21 },
  { 2303, 15, 14, 17, 1, -22 },
  { 2330, 12, 2, 12, 0, 3 },
  { 2333, 9, 5, 11, 1, -23 },
  { 2339, 15, 17, 18, 1, -17 },
  { 2371, 16, 23, 19, 2, -23 },
  { 2417, 14, 17, 15, 1, -17 },
  { 2447, 16, 23, 19, 1, -23 },
  { 2493, 16, 17, 18, 1, -17 },
  { 2527, 12, 23, 12, 1, -23 },
  { 2562, 16, 24, 19, 1, -17 },
  { 2610, 15, 23, 20, 2, -23 },
  { 2654, 5, 23, 9, 2, -23 },
  { 2669, 9, 30, 9, -2, -23 },
  { 2703, 17, 23, 19, 2, -23 },
  { 2752, 5, 23, 9, 2, -23 },
  { 2767, 25, 17, 29, 2, -17 },
  { 2821, 15, 17, 20, 2, -17 },
  { 2853, 16, 17, 19, 1, -17 },
  { 2887, 16, 24, 19, 2, -17 },
  { 2935, 16, 24, 19, 1, -17 },
  { 2983, 11, 17, 13, 2, -17 },
  { 3007, 13, 17, 15, 1, -17 },
  { 3035, 11, 20, 13, 1, -20 },
  { 3063, 15, 16, 20, 2, -16 },
  { 3093, 17, 16, 17, 0, -16 },
  { 3127, 25, 16, 26, 0, -16 },
  { 3177, 17, 16, 17, 0, -16 },
  { 3211, 17, 23, 17, 0, -16 },
  { 3260, 13, 16, 15, 1, -16 },
  { 3286, 11, 26, 12, 0, -21 },
  { 3322, 3, 30, 17, 7, -23 },
  { 3334, 10, 26, 12, 1, -21 },
  { 3367, 15, 5, 17, 1, -13 },
};

const GFXfont NotoSans_Bold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold30pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_BOLD30PT7B_H_
