#ifndef _NOTOSANS_BOLD28PT7B_H_
#define _NOTOSANS_BOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF3,
  0xFC, 0xFF, 0x3F, 0x8E, 0xE3, 0xB8, 0xEE, 0x38, 0x07, 0x9C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0,
  0x03, 0x00, 0x0C, 0x01, 0xFF, 0x0F, 0xFF, 0x7F, 0xFB, 0xEC, 0xEF, 0x30,
  0x3E, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0D,
  0xF0, 0x33, 0xE0, 0xCF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0x07, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x3E, 0x01, 0xE0, 0xFE, 0x03, 0x83, 0xDE,
  0x0E, 0x07, 0x1C, 0x1C, 0x0E, 0x38, 0x70, 0x1C, 0x71, 0xE0, 0x38, 0xE3,
  0x80, 0x71, 0xCF, 0x00, 0xE3, 0x9C, 0xF9, 0xEF, 0x7B, 0xF9, 0xFC, 0xEF,
  0x79, 0xF3, 0x9C, 0x70, 0x07, 0x38, 0xE0, 0x1C, 0x71, 0xC0, 0x78, 0xE3,
  0x80, 0xE1, 0xC7, 0x03, 0xC3, 0x8E, 0x07, 0x07, 0xBC, 0x1E, 0x07, 0xF0,
  0x78, 0x07, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x1E, 0x3F, 0xC3, 0xE7, 0xFE, 0x3C, 0xF9, 0xF3, 0xCF,
  0x8F, 0xFC, 0xF8, 0x7F, 0x8F, 0x83, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFE, 0x3F, 0xFF, 0xFE, 0xEE, 0xE0, 0x0F, 0x1E, 0x3C,
  0x3C, 0x38, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x0F, 0xF0, 0xE1, 0xE1,
  0xE3, 0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1E,
  0x3C, 0x71, 0xE3, 0xC7, 0x1E, 0x78, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x0E,
  0x1F, 0x77, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC0, 0xEF, 0x0F, 0x38,
  0xF1, 0xE0, 0x88, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7B, 0xDE, 0xEF, 0x73, 0x80, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF,
  0x1F, 0x3E, 0x78, 0x7B, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDE, 0x1E, 0x7C,
  0xF8, 0xFF, 0xC3, 0xFF, 0x03, 0xF0, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0xFF,
  0xFD, 0xF6, 0x7D, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x9E, 0x3E, 0x20, 0x78, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7, 0xFF, 0x9C,
  0x3E, 0x20, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x1F, 0xE0, 0x7E, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0xFB,
  0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x78, 0x78, 0x70, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF1, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0xE0, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xE1,
  0xFF, 0x8F, 0xC0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0xF8, 0xF7, 0xF3,
  0xFF, 0xEF, 0xC7, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x0F,
  0x7C, 0x7C, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E,
  0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x8F, 0xFC, 0x3F, 0xE0, 0x3F, 0x03,
  0xFE, 0x1F, 0x7E, 0x78, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7D,
  0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x3E, 0x3E,
  0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xE3, 0xF7, 0xFF,
  0xDF, 0xEF, 0x1F, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF1, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0x6F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x33, 0xDE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x77, 0xB9,
  0xC0, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x0F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xC7, 0xFF,
  0x9F, 0xFC, 0xE1, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xDF, 0xC0, 0xF8, 0x03, 0xC1, 0xC0, 0x03, 0x87, 0x07, 0xE3, 0x9E,
  0x3F, 0xE7, 0x38, 0xFF, 0xC7, 0x73, 0xC3, 0x8F, 0xE7, 0x07, 0x1F, 0x8E,
  0x0E, 0x3F, 0x1C, 0x1C, 0x7E, 0x38, 0x79, 0xDC, 0x70, 0xF3, 0x9C, 0xFF,
  0xFF, 0x38, 0xFE, 0xFC, 0x78, 0x70, 0xF0, 0x70, 0x00, 0x00, 0xF8, 0x01,
  0x00, 0xFE, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x7C, 0x3C,
  0x0F, 0x07, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x3E,
  0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0xFC, 0x00, 0xF0, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0xC7, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x3E, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0xF7, 0xC3, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xFB, 0xF8, 0xE7, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x1C, 0x7F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x7E,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F,
  0x0E, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C,
  0x0F, 0x7E, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8,
  0x7B, 0xFD, 0xFE, 0xFE, 0x7C, 0x00, 0xF0, 0x3F, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0,
  0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x3F, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xF7, 0x03, 0xFF, 0xB8,
  0x1D, 0xFD, 0xE0, 0xEF, 0xEF, 0x0F, 0x7F, 0x38, 0x73, 0xF9, 0xE3, 0x9F,
  0xCF, 0x3C, 0xFE, 0x39, 0xC7, 0xF1, 0xCE, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F,
  0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x3C, 0x1F, 0xC1, 0xE0, 0xF0,
  0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0x78,
  0x3F, 0xBE, 0x1F, 0xCF, 0x0F, 0xE7, 0xC7, 0xF1, 0xE3, 0xF8, 0xF9, 0xFC,
  0x3E, 0x7E, 0x0F, 0x3F, 0x07, 0xDF, 0x81, 0xEF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0x1F, 0xC7, 0xC0, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3D, 0xF0, 0x07, 0xBE, 0x01, 0xF3, 0xE0, 0x7E, 0x7F, 0x1F, 0x87,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xFC, 0x3F, 0x1F, 0xC7, 0xC0, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3D, 0xF0, 0x07, 0xBE, 0x01, 0xF3, 0xE0, 0x7E, 0x7F, 0x1F, 0x87, 0xFF,
  0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xF9, 0xFC, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0x1F, 0xF1,
  0xFF, 0xDF, 0xFE, 0xF8, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1E, 0x7E, 0x3F, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0x79, 0xE0,
  0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E,
  0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xCF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0xF0, 0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x3D, 0xE0, 0x7C, 0x0F, 0x3C,
  0x0F, 0x81, 0xE7, 0x83, 0xF8, 0x3C, 0xF0, 0x77, 0x07, 0x8F, 0x0E, 0xE1,
  0xE1, 0xE1, 0xDC, 0x3C, 0x3C, 0x7B, 0xC7, 0x87, 0x8F, 0x78, 0xF0, 0x79,
  0xC7, 0x3C, 0x0F, 0x38, 0xF7, 0x81, 0xEF, 0x1E, 0xF0, 0x3D, 0xE3, 0xDE,
  0x03, 0xB8, 0x3B, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xCF,
  0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x0F, 0x81, 0xF1, 0xE0, 0x1F, 0x7C, 0x01,
  0xEF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x3E,
  0x0F, 0x07, 0x81, 0xF1, 0xF0, 0x1F, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xDE,
  0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x81, 0xF3,
  0xC0, 0x3D, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0xFF, 0xFF, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x7F, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x77, 0x81, 0xCE, 0x0E, 0x3C, 0x38, 0x71, 0xC1, 0xE7, 0x03, 0xB8, 0x0F,
  0xE0, 0x1C, 0xFF, 0xF0, 0xFC, 0x3C, 0x1E, 0x07, 0x01, 0x00, 0xFF, 0xC3,
  0xFF, 0x8F, 0xFE, 0x10, 0x7C, 0x00, 0xF0, 0x0F, 0xCF, 0xFF, 0x7F, 0xFF,
  0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xF7, 0xFB, 0xCF, 0xC7,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC3, 0x0F, 0x7F,
  0x3F, 0xFE, 0xFF, 0xFB, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xBF, 0xFE, 0xF3,
  0xE0, 0x01, 0x80, 0x7F, 0xCF, 0xFC, 0x7F, 0xE7, 0xC1, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xE3, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x47, 0xC7, 0xEF, 0x9F, 0xEF, 0x7F, 0xFE, 0xF8, 0x7D, 0xE0, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x3E, 0xF8,
  0xFD, 0xFF, 0xF9, 0xFE, 0xF1, 0xF9, 0xE0, 0x01, 0x00, 0x7F, 0xC3, 0xFF,
  0x9F, 0xBF, 0x78, 0x3D, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x0C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x0F,
  0xE3, 0xFC, 0xFF, 0x1E, 0x03, 0xC0, 0x78, 0x3F, 0xF7, 0xFE, 0xFF, 0xC7,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x02, 0x00, 0x3F, 0x3C, 0xFF, 0x7B, 0xFF, 0xF7,
  0xC3, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7B, 0xC1, 0xF7, 0xC7, 0xEF, 0xFF, 0xCF, 0xF7, 0x8F, 0xDF, 0x00, 0x3E,
  0x00, 0x7D, 0x00, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x03, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC2, 0x0F, 0x7F,
  0x3F, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3C, 0xF7, 0xFC, 0xC0, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x00, 0x1E, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0xFE, 0xFE, 0xFC, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x0F, 0x78, 0x3C, 0xF0, 0xF1,
  0xE3, 0xE3, 0xCF, 0x87, 0xBE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7C,
  0xF0, 0xF1, 0xF1, 0xE1, 0xF3, 0xC1, 0xF7, 0x83, 0xEF, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80,
  0x41, 0xEF, 0xE3, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE3,
  0xFF, 0x0F, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F,
  0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFE,
  0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8, 0x1E, 0x0F, 0x00, 0x83, 0xDF, 0xCF,
  0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0x01, 0x00, 0x1F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xF7, 0xC3,
  0xC7, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xF8, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xBC, 0xF8, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x02,
  0x00, 0x3F, 0x3C, 0xFF, 0x7B, 0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xC7, 0xEF,
  0xFF, 0xCF, 0xFF, 0x8F, 0xDF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0x07, 0x03, 0xFF, 0x7F, 0xEF, 0xDE, 0xF0, 0x0F, 0x80,
  0x7E, 0x07, 0xF8, 0x3F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0xFF, 0xFE,
  0xFF, 0xE7, 0xF8, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF1, 0x3F,
  0xCF, 0xF1, 0xFC, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x3F,
  0xFF, 0xFD, 0xFF, 0xF3, 0xF9, 0xC0, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0xF8, 0x3E, 0x1F, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E,
  0x3C, 0xFE, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x3C, 0x3C, 0xE7, 0x38,
  0x1E, 0xE7, 0x78, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x81, 0xE0, 0xFC, 0x1F, 0x3C,
  0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC1,
  0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC7, 0xE3,
  0xF0, 0xF8, 0x3F, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x3F, 0x0F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xF8, 0x3F, 0x07, 0xC7, 0xF1, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x3F, 0x0F, 0xC3, 0xE0, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE,
};

const GFXglyph NotoSans_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 20, 8, 2, -20 },
  { 11, 10, 7, 13, 2, -20 },
  { 20, 16, 20, 18, 1, -20 },
  { 60, 14, 23, 16, 1, -21 },
  { 101, 23, 20, 25, 1, -20 },
  { 159, 20, 20, 21, 1, -20 },
  { 209, 4, 7, 7, 2, -20 },
  { 213, 8, 24, 9, 1, -20 },
  { 237, 7, 24, 9, 1, -20 },
  { 258, 13, 13, 15, 1, -21 },
  { 280, 14, 14, 16, 1, -17 },
  { 305, 5, 7, 8, 1, -3 },
  { 310, 7, 3, 9, 1, -9 },
  { 313, 4, 4, 8, 2, -4 },
  { 315, 11, 20, 12, 0, -20 },
  { 343, 14, 20, 16, 1, -20 },
  { 378, 10, 20, 16, 2, -20 },
  { 403, 14, 20, 16, 1, -20 },
  { 438, 14, 20, 16, 1, -20 },
  { 473, 16, 20, 16, 0, -20 },
  { 513, 14, 20, 16, 1, -20 },
  { 548, 14, 20, 16, 1, -20 },
  { 583, 14, 20, 16, 1, -20 },
  { 618, 14, 20, 16, 1, -20 },
  { 653, 14, 20, 16, 1, -20 },
  { 688, 4, 16, 8, 2, -16 },
  { 696, 5, 20, 8, 1, -16 },
  { 709, 14, 15, 16, 1, -18 },
  { 736, 14, 8, 16, 1, -14 },
  { 750, 14, 15, 16, 1, -18 },
  { 777, 13, 20, 13, 0, -20 },
  { 810, 23, 22, 25, 1, -20 },
  { 874, 19, 20, 19, 0, -20 },
  { 922, 15, 20, 19, 2, -20 },
  { 960, 15, 20, 18, 2, -20 },
  { 998, 17, 20, 21, 2, -20 },
  { 1041, 11, 20, 16, 3, -20 },
  { 1069, 11, 20, 15, 3, -20 },
  { 1097, 16, 20, 20, 2, -20 },
  { 1137, 16, 20, 21, 3, -20 },
  { 1177, 9, 20, 11, 1, -20 },
  { 1200, 9, 26, 9, -2, -20 },
  { 1230, 16, 20, 19, 3, -20 },
  { 1270, 13, 20, 16, 2, -20 },
  { 1303, 21, 20, 26, 3, -20 },
  { 1356, 17, 20, 23, 3, -20 },
  { 1399, 19, 20, 22, 2, -20 },
  { 1447, 14, 20, 17, 2, -20 },
  { 1482, 19, 25, 22, 2, -20 },
  { 1542, 16, 20, 18, 2, -20 },
  { 1582, 13, 20, 15, 1, -20 },
  { 1615, 15, 20, 16, 1, -20 },
  { 1653, 17, 20, 21, 2, -20 },
  { 1696, 18, 20, 18, 0, -20 },
  { 1741, 27, 20, 27, 0, -20 },
  { 1809, 19, 20, 19, 0, -20 },
  { 1857, 18, 20, 18, 0, -20 },
  { 1902, 15, 20, 16, 1, -20 },
  { 1940, 7, 24, 9, 2, -20 },
  { 1961, 11, 20, 12, 0, -20 },
  { 1989, 6, 24, 9, 1, -20 },
  { 2007, 14, 13, 16, 1, -20 },
  { 2030, 12, 1, 12, 0, 3 },
  { 2032, 8, 4, 10, 1, -21 },
  { 2036, 14, 16, 17, 1, -16 },
  { 2064, 14, 21, 18, 2, -21 },
  { 2101, 13, 16, 14, 1, -16 },
  { 2127, 15, 21, 18, 1, -21 },
  { 2167, 14, 16, 17, 1, -16 },
  { 2195, 11, 21, 11, 1, -21 },
  { 2224, 15, 23, 18, 1, -16 },
  { 2268, 14, 21, 18, 2, -21 },
  { 2305, 5, 21, 8, 2, -21 },
  { 2319, 8, 28, 8, -1, -21 },
  { 2347, 15, 21, 17, 2, -21 },
  { 2387, 4, 21, 8, 2, -21 },
  { 2398, 23, 16, 27, 2, -16 },
  { 2444, 14, 16, 18, 2, -16 },
  { 2472, 15, 16, 18, 1, -16 },
  { 2502, 14, 23, 18, 2, -16 },
  { 2543, 15, 23, 18, 1, -16 },
  { 2587, 10, 16, 13, 2, -16 },
  { 2607, 12, 16, 14, 1, -16 },
  { 2631, 10, 19, 12, 1, -19 },
  { 2655, 14, 15, 18, 2, -15 },
  { 2682, 16, 15, 16, 0, -15 },
  { 2712, 24, 15, 24, 0, -15 },
  { 2757, 16, 15, 16, 0, -15 },
  { 2787, 16, 22, 16, 0, -15 },
  { 2831, 12, 15, 14, 1, -15 },
  { 2854, 10, 24, 11, 0, -20 },
  { 2884, 3, 27, 15, 6, -21 },
  { 2895, 10, 24, 11, 1, -20 },
  { 2925, 14, 4, 16, 1, -12 },
};

const GFXfont NotoSans_Bold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold28pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_BOLD28PT7B_H_
