#ifndef _NOTOSANS_BOLD72PT7B_H_
#define _NOTOSANS_BOLD72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xE0, 0xF8, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8,
  0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0xDF,
  0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF,
  0x9F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9, 0xFF, 0x01, 0xFE, 0x7F, 0xC0,
  0x7F, 0x9F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xC7, 0xFF,
  0x8F, 0x80, 0xF8, 0xFF, 0xE1, 0xF0, 0x03, 0x1F, 0xFC, 0x3E, 0x00, 0x03,
  0xFF, 0x87, 0xC0, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0x00,
  0x01, 0xFF, 0xF3, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFB, 0xFF, 0xF0, 0x00, 0x1F, 0x1F, 0xFE, 0x00,
  0x03, 0xE1, 0xFF, 0xC0, 0x00, 0x7C, 0x1F, 0xF8, 0x00, 0x0F, 0x83, 0xFF,
  0xC0, 0x01, 0xF0, 0x7F, 0xFE, 0x00, 0x3E, 0x1F, 0xFF, 0xFC, 0x07, 0xC7,
  0xFF, 0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1C, 0x00, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE,
  0x1F, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0x87, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE1,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xC0,
  0x3F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xE0,
  0x0F, 0xE0, 0x0F, 0x3F, 0x81, 0xFC, 0x0F, 0xE7, 0xFF, 0x3F, 0x9F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x87,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x3F, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0,
  0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xDF, 0xFE, 0x7F, 0xF3, 0xFE, 0x1F, 0xFC, 0xFF, 0x07, 0xFF, 0x1F, 0x81,
  0xFF, 0xC3, 0xC0, 0x7F, 0xF0, 0x60, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xC1, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0x00,
  0x01, 0xFF, 0xC0, 0x60, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFC, 0x01, 0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0xFF, 0x06, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xF3, 0xFF,
  0x80, 0x00, 0x3F, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0xC0, 0x00, 0x07, 0xFF, 0xBE, 0x00, 0x07, 0xFF, 0xCF, 0xF8, 0x07,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xFF, 0x0F,
  0xFD, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xF8,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x0F,
  0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xF0, 0x03, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF,
  0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0xFF,
  0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x05, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF0,
  0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xBF,
  0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x1F,
  0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFD, 0xFF,
  0x07, 0xFF, 0xFF, 0xDF, 0xF8, 0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x20, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x3F, 0xE1, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xE3, 0xFE, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0xCF,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0,
  0xFF, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0x87, 0xC0, 0x00, 0xFF, 0xE1,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x0F, 0xF7, 0xF8, 0x0F, 0xF8,
  0x01, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x7F,
  0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xDF, 0xE0, 0x7F, 0x80, 0x07, 0xF8,
  0x07, 0xF7, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE7,
  0xF0, 0x1F, 0xE0, 0x07, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x83, 0xFC, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F,
  0xFD, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0x01, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF7,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x9F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x07,
  0xFF, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xBF,
  0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF,
  0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x0F,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF3, 0xFF, 0x80, 0x07, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xF8,
  0x0F, 0xFF, 0xC0, 0x00, 0x78, 0x1F, 0xFF, 0x80, 0x00, 0x18, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0C, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0x00, 0x00,
  0x08, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00,
  0x0F, 0xFD, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xFF, 0xFB, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xFF, 0xF7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xEF,
  0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFF,
  0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0x9F, 0xFF, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0,
  0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF1, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xFE, 0xFF, 0xE0,
  0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xFE, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xDF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xF1,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0x80, 0x7F, 0x87, 0xFF, 0x80, 0x03, 0xE1, 0xFF, 0xC0, 0x00, 0x10,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0xF0, 0x00, 0x7F, 0xFB,
  0xFF, 0xE0, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xF7,
  0xFF, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0x8F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x7F, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFE, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x3F, 0xFC, 0x04, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F,
  0xC3, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x1F, 0xFF,
  0xE0, 0x3F, 0xF9, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xE7, 0xFF, 0xC0,
  0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xF0, 0x01,
  0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xFE, 0x00, 0xFF, 0xFB, 0xFF,
  0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00,
  0x78, 0x3F, 0xFE, 0x00, 0x08, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x02, 0x3F, 0xFE, 0x00,
  0x0E, 0x1F, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xE7, 0xFE, 0x0F, 0xFF, 0xFF,
  0xBF, 0xF0, 0xFF, 0xFF, 0xFD, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x01, 0xFF,
  0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0,
  0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE,
  0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0x00,
  0x7F, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF7,
  0xFE, 0x0F, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0x80, 0x7F,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x03, 0xFF,
  0x3F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xCF, 0xFE, 0x00,
  0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0x03,
  0xFF, 0xE0, 0x00, 0x78, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F,
  0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF,
  0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF,
  0xE7, 0xFF, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xBF, 0xF0,
  0x7F, 0xFF, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x60, 0x00,
  0x03, 0xFF, 0xC3, 0xE0, 0x00, 0x3F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xF8,
  0x3F, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x07,
  0xFF, 0xBF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x1F, 0x07, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xDE, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x02, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF,
  0x80, 0x01, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF,
  0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x87, 0xFE, 0x00, 0x07,
  0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFF, 0xBF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFD,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xEF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x3F, 0xFD,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xFC,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F,
  0xFD, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00,
  0x7F, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x87,
  0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xFF, 0x01,
  0xFF, 0x8F, 0xFF, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F,
  0xFD, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8,
  0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xFF,
  0x7F, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFF, 0xE0,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0xC3, 0xFE,
  0x07, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x03, 0xFF,
  0xBF, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xE0,
  0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF9,
  0xFF, 0x81, 0xFF, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0xE0, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0xE3, 0xFF, 0x80, 0x03, 0x8F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x03, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00,
  0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xBF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xF9, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F,
  0xFC, 0x00, 0x3F, 0xF1, 0xFC, 0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFC, 0x07, 0xF9, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x03,
  0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0x80, 0x3F, 0xDF, 0xF0, 0x00, 0x0F,
  0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xDF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xFE,
  0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00,
  0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3B, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x23,
  0xFF, 0xF8, 0x00, 0x0D, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xDC, 0x00,
  0x0F, 0xFF, 0xF2, 0x00, 0x00, 0x7F, 0xF8, 0x40, 0x00, 0x00, 0x38, 0x00,
};

const GFXglyph NotoSans_Bold72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 12, 52, 20, 4, -51 },
  { 79, 26, 18, 34, 4, -51 },
  { 138, 43, 51, 47, 2, -51 },
  { 413, 35, 59, 41, 3, -55 },
  { 672, 61, 53, 65, 2, -52 },
  { 1077, 51, 53, 54, 3, -52 },
  { 1415, 11, 18, 19, 4, -51 },
  { 1440, 19, 62, 24, 3, -51 },
  { 1588, 20, 62, 24, 2, -51 },
  { 1743, 35, 34, 39, 2, -55 },
  { 1892, 35, 35, 41, 3, -43 },
  { 2046, 14, 17, 21, 2, -8 },
  { 2076, 19, 9, 23, 2, -24 },
  { 2098, 12, 12, 20, 4, -11 },
  { 2116, 30, 52, 30, 0, -52 },
  { 2311, 36, 53, 41, 3, -52 },
  { 2550, 26, 51, 41, 4, -51 },
  { 2716, 36, 52, 41, 3, -52 },
  { 2950, 35, 53, 41, 3, -52 },
  { 3182, 39, 51, 41, 1, -51 },
  { 3431, 34, 52, 41, 4, -51 },
  { 3652, 36, 53, 41, 3, -52 },
  { 3891, 37, 51, 41, 2, -51 },
  { 4127, 36, 53, 41, 3, -52 },
  { 4366, 37, 53, 41, 2, -52 },
  { 4612, 12, 41, 20, 4, -40 },
  { 4674, 14, 49, 21, 2, -40 },
  { 4760, 35, 38, 41, 3, -45 },
  { 4927, 35, 21, 41, 3, -36 },
  { 5019, 35, 38, 41, 3, -45 },
  { 5186, 33, 53, 34, 0, -52 },
  { 5405, 58, 58, 65, 3, -52 },
  { 5826, 50, 52, 50, 0, -52 },
  { 6151, 38, 51, 48, 6, -51 },
  { 6394, 40, 53, 46, 4, -52 },
  { 6659, 43, 51, 53, 6, -51 },
  { 6934, 30, 51, 40, 6, -51 },
  { 7126, 30, 51, 40, 6, -51 },
  { 7318, 42, 53, 52, 4, -52 },
  { 7597, 43, 51, 55, 6, -51 },
  { 7872, 24, 51, 28, 2, -51 },
  { 8025, 22, 66, 24, -5, -51 },
  { 8207, 42, 51, 48, 6, -51 },
  { 8475, 32, 51, 40, 6, -51 },
  { 8679, 55, 51, 68, 6, -51 },
  { 9030, 46, 51, 59, 6, -51 },
  { 9324, 49, 53, 57, 4, -52 },
  { 9649, 36, 51, 45, 6, -51 },
  { 9879, 49, 64, 57, 4, -52 },
  { 10271, 41, 51, 47, 6, -51 },
  { 10533, 34, 53, 40, 3, -52 },
  { 10759, 39, 51, 42, 1, -51 },
  { 11008, 42, 52, 54, 6, -51 },
  { 11281, 47, 51, 47, 0, -51 },
  { 11581, 70, 51, 70, 0, -51 },
  { 12028, 48, 51, 48, 0, -51 },
  { 12334, 45, 51, 45, 0, -51 },
  { 12621, 38, 51, 42, 2, -51 },
  { 12864, 17, 62, 24, 5, -51 },
  { 12996, 29, 52, 30, 0, -52 },
  { 13185, 17, 62, 24, 2, -51 },
  { 13317, 38, 34, 41, 2, -52 },
  { 13479, 30, 5, 30, 0, 6 },
  { 13498, 20, 11, 26, 3, -55 },
  { 13526, 35, 41, 43, 3, -40 },
  { 13706, 37, 56, 46, 5, -55 },
  { 13965, 32, 41, 37, 3, -40 },
  { 14129, 37, 56, 46, 3, -55 },
  { 14388, 37, 41, 43, 3, -40 },
  { 14578, 30, 55, 28, 1, -55 },
  { 14785, 37, 57, 46, 3, -40 },
  { 15049, 37, 55, 47, 5, -55 },
  { 15304, 12, 55, 22, 5, -55 },
  { 15387, 21, 72, 21, -4, -55 },
  { 15576, 39, 55, 45, 6, -55 },
  { 15845, 11, 55, 21, 5, -55 },
  { 15921, 60, 40, 70, 5, -40 },
  { 16221, 37, 40, 47, 5, -40 },
  { 16406, 39, 41, 45, 3, -40 },
  { 16606, 37, 57, 46, 5, -40 },
  { 16870, 37, 57, 46, 3, -40 },
  { 17134, 26, 40, 32, 5, -40 },
  { 17264, 30, 41, 36, 3, -40 },
  { 17418, 27, 49, 31, 2, -48 },
  { 17584, 36, 40, 47, 5, -39 },
  { 17764, 41, 39, 41, 0, -39 },
  { 17964, 60, 39, 62, 1, -39 },
  { 18257, 41, 39, 42, 0, -39 },
  { 18457, 41, 56, 41, 0, -39 },
  { 18744, 31, 39, 36, 2, -39 },
  { 18896, 24, 62, 28, 1, -51 },
  { 19082, 8, 71, 40, 16, -55 },
  { 19153, 24, 62, 28, 3, -51 },
  { 19339, 35, 12, 41, 3, -31 },
};

const GFXfont NotoSans_Bold72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold72pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_BOLD72PT7B_H_
