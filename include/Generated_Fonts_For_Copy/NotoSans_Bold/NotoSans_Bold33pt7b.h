#ifndef _NOTOSANS_BOLD33PT7B_H_
#define _NOTOSANS_BOLD33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF1, 0xEF,
  0x1E, 0xF0, 0xE7, 0x0E, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0x71, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7,
  0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF9, 0xF3, 0x84, 0xF9,
  0xC0, 0x3E, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xDF, 0x00, 0xE7, 0xF0, 0x73, 0xFF, 0x3B,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0xF8, 0x03, 0xC0, 0x7F,
  0xC0, 0x78, 0x07, 0xBE, 0x07, 0x80, 0xF1, 0xE0, 0xF0, 0x0F, 0x1E, 0x0F,
  0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE3, 0xC0, 0x0F,
  0x1E, 0x78, 0x00, 0xF1, 0xE7, 0x9F, 0x87, 0xBE, 0xF3, 0xFC, 0x7F, 0xCF,
  0x7F, 0xE3, 0xF9, 0xE7, 0x9E, 0x0F, 0x1E, 0x78, 0xF0, 0x03, 0xC7, 0x8F,
  0x00, 0x78, 0x70, 0xF0, 0x07, 0x87, 0x0F, 0x00, 0xF0, 0x78, 0xF0, 0x0F,
  0x07, 0x8F, 0x01, 0xE0, 0x79, 0xE0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x3F,
  0xC0, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x3E, 0x3F, 0xF0, 0x7C, 0x3F, 0xF8, 0x7C, 0x7E, 0xFC,
  0x7C, 0x7C, 0x7E, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE,
  0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x7B, 0xCE, 0x70, 0x07, 0x87,
  0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xF0,
  0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x1F, 0x07, 0x83,
  0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x1F,
  0x0F, 0x0F, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x43, 0xC2, 0xFB, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xE0,
  0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x0C, 0x30, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3D, 0xF7, 0xDE, 0x79, 0xEF, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7,
  0xE3, 0xE3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1E, 0x78, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0xC7, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF,
  0x3F, 0xF7, 0xFF, 0xFD, 0xF7, 0x9F, 0x31, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF,
  0x9F, 0xFF, 0xC7, 0xE3, 0xF1, 0xC0, 0xF8, 0x80, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0x83, 0xF1, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x3F, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xD8, 0x07, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x07,
  0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF,
  0xCF, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xE7,
  0xFF, 0xEF, 0xFF, 0xE4, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0,
  0x00, 0x7E, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0xFE, 0x3E, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xDF, 0x03, 0xEF, 0xC3, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E,
  0x3E, 0x1F, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xF1,
  0xF9, 0xFC, 0xF8, 0x3E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xE7, 0xE3, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE7, 0xE7, 0xE0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xEF, 0x87, 0xF7, 0xFF,
  0xF9, 0xFF, 0xFC, 0x7F, 0xBC, 0x1F, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7C, 0xF9, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x3E, 0x7C, 0xF1, 0xE3, 0xCF, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x7F, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xF7,
  0x87, 0xE4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xC3, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0xE0, 0x79,
  0xE1, 0xFF, 0x8E, 0x70, 0xFF, 0xE3, 0xFC, 0x7E, 0x78, 0xFF, 0x1E, 0x1E,
  0x3F, 0x8F, 0x07, 0x87, 0xE3, 0xC1, 0xE1, 0xF8, 0xF0, 0x78, 0xFE, 0x3C,
  0x1E, 0x3F, 0x8F, 0x07, 0x8F, 0xE3, 0xC3, 0xE3, 0xBC, 0x7F, 0xFF, 0xEF,
  0x1F, 0xF7, 0xF3, 0xC1, 0xF8, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0x00, 0x7F, 0xDF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F,
  0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x87,
  0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x1F, 0xBF,
  0xFF, 0x9F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xC7, 0x9F, 0xC0, 0x27, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x06, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF,
  0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0,
  0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x3F, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xFC, 0x3C, 0xFE, 0x00, 0x9F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7D,
  0xF8, 0x0F, 0xBF, 0x81, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xFE, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x87, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC3, 0xF9, 0xFB, 0xFE, 0xFF, 0x3F, 0x8F, 0x80, 0xF8,
  0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0,
  0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xC7,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x8F, 0x81,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xDE, 0x03, 0xDF,
  0xEF, 0x01, 0xEF, 0xF7, 0x80, 0xF7, 0xFB, 0xE0, 0xF3, 0xFC, 0xF0, 0x79,
  0xFE, 0x78, 0x3D, 0xFF, 0x3E, 0x3C, 0xFF, 0x8F, 0x1E, 0x7F, 0xC7, 0x8F,
  0x3F, 0xE3, 0xCF, 0x1F, 0xF0, 0xF7, 0x8F, 0xF8, 0x7B, 0xC7, 0xFC, 0x3F,
  0xC3, 0xFE, 0x0F, 0xE1, 0xFF, 0x07, 0xF0, 0xFF, 0x83, 0xF0, 0x7F, 0xC1,
  0xF8, 0x3F, 0xE0, 0x7C, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFE,
  0xF8, 0x1F, 0xF3, 0xE0, 0xFF, 0x9F, 0x87, 0xFC, 0x7C, 0x3F, 0xE3, 0xF1,
  0xFF, 0x0F, 0x8F, 0xF8, 0x7E, 0x7F, 0xC1, 0xF3, 0xFE, 0x07, 0xCF, 0xF0,
  0x3F, 0x7F, 0x80, 0xFB, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x07,
  0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xE0, 0x1F,
  0x9F, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFD, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0x8F,
  0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x3F, 0x07, 0xE0,
  0x7F, 0xF9, 0xFF, 0xFB, 0xFF, 0xEF, 0xC7, 0xDF, 0x01, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x03, 0xFF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0xE7, 0xFF, 0xFC,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF9,
  0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x03,
  0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x3E, 0x7C, 0x07,
  0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x3C, 0x0F,
  0xF0, 0x3C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x1F, 0xF0, 0x7C, 0x3E, 0x1E,
  0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x3E,
  0x78, 0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x3C,
  0x3C, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x00,
  0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x87, 0xE0,
  0x3E, 0x1F, 0x00, 0xFC, 0xFC, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x00,
  0xF8, 0x7C, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xE0,
  0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC,
  0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1C, 0xF0, 0x1E, 0x38, 0x0E, 0x1E, 0x0F,
  0x07, 0x07, 0x03, 0xC7, 0x80, 0xE3, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x0F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1E, 0x3F, 0x10, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x7F, 0x7F, 0xFF, 0x7F, 0xEF, 0x1F, 0xC7, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF3, 0xF8, 0xFB, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD,
  0xF7, 0xFC, 0xF1, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF, 0x9F, 0xFE,
  0xFC, 0x0B, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x37, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x1F, 0xDF, 0x3F, 0xEF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xCF, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x02, 0x7F, 0x1E, 0x3F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xE3, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xCF, 0x3F, 0xEF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F,
  0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xDF, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x60, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xF8, 0x1F, 0xE0,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF3, 0xF8, 0xFB, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x7B, 0xFF, 0xFE, 0x30, 0x00, 0x3E,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xF8, 0x07, 0x83, 0xF0, 0xFC, 0x3E, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0xBF, 0xEF, 0xFB, 0xFC, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3F,
  0xF0, 0x3F, 0x78, 0x3F, 0x3C, 0x3F, 0x1E, 0x3F, 0x0F, 0x3F, 0x07, 0x9F,
  0x03, 0xDF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0x7E, 0x1E,
  0x1F, 0x0F, 0x07, 0xC7, 0x83, 0xF3, 0xC0, 0xFD, 0xE0, 0x3E, 0xF0, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xFC, 0x3F, 0x8F, 0xBF, 0xE7, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F, 0xC3, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8, 0x0F, 0x81,
  0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8,
  0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8,
  0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF1, 0xFC, 0x7D, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x0F,
  0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xEF, 0xEF, 0xC1, 0xF7, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xE0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07,
  0xF8, 0x00, 0xF9, 0xFC, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFB, 0xFE, 0x7C, 0xFE, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xCF,
  0x3F, 0xEF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xDF, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0xF0, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3F, 0xF3, 0xFF, 0xFF, 0xFD, 0xF0, 0xEF,
  0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0xEF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFE, 0x00, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xF7, 0x8F, 0xE3, 0xC0, 0xF8,
  0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xE3, 0xC0, 0x3E,
  0xF8, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0x81, 0xF7, 0xC1, 0xF8,
  0x1E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xFC, 0x3E, 0x3C, 0x3F, 0xC3, 0xE3,
  0xE3, 0xDC, 0x3C, 0x3E, 0x39, 0xC7, 0xC3, 0xE3, 0x9E, 0x7C, 0x1E, 0x79,
  0xE7, 0x81, 0xF7, 0x9E, 0x78, 0x1F, 0x70, 0xEF, 0x80, 0xF7, 0x0F, 0xF8,
  0x0F, 0x70, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xEF,
  0xC1, 0xF8, 0xFC, 0x3E, 0x0F, 0x8F, 0x81, 0xFB, 0xF0, 0x1F, 0x7C, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x3E, 0x0F, 0xC7, 0xE1, 0xF0, 0x7C, 0x7E,
  0x0F, 0xDF, 0x80, 0xFC, 0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x10, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x1F, 0x8F, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x80, 0xFF, 0x03,
  0xF0, 0x7F, 0x0F, 0xF1, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x81,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 12, 9, 16, 2, -24 },
  { 30, 20, 24, 21, 1, -24 },
  { 90, 17, 27, 19, 1, -25 },
  { 148, 28, 24, 30, 1, -24 },
  { 232, 24, 24, 25, 1, -24 },
  { 304, 5, 9, 9, 2, -24 },
  { 310, 9, 29, 11, 1, -24 },
  { 343, 9, 29, 11, 1, -24 },
  { 376, 16, 15, 18, 1, -25 },
  { 406, 16, 16, 19, 1, -20 },
  { 438, 6, 8, 9, 1, -4 },
  { 444, 9, 4, 11, 1, -11 },
  { 449, 5, 5, 9, 2, -5 },
  { 453, 14, 24, 14, 0, -24 },
  { 495, 17, 24, 19, 1, -24 },
  { 546, 12, 24, 19, 2, -24 },
  { 582, 17, 24, 19, 1, -24 },
  { 633, 17, 24, 19, 1, -24 },
  { 684, 17, 24, 19, 1, -24 },
  { 735, 15, 24, 19, 2, -24 },
  { 780, 17, 24, 19, 1, -24 },
  { 831, 17, 24, 19, 1, -24 },
  { 882, 17, 24, 19, 1, -24 },
  { 933, 17, 24, 19, 1, -24 },
  { 984, 5, 18, 9, 2, -18 },
  { 996, 7, 22, 9, 1, -18 },
  { 1016, 16, 18, 19, 1, -21 },
  { 1052, 16, 10, 19, 1, -17 },
  { 1072, 16, 18, 19, 1, -21 },
  { 1108, 15, 24, 16, 0, -24 },
  { 1153, 26, 27, 30, 2, -24 },
  { 1241, 23, 24, 23, 0, -24 },
  { 1310, 17, 24, 22, 3, -24 },
  { 1361, 18, 24, 21, 2, -24 },
  { 1415, 19, 24, 24, 3, -24 },
  { 1472, 14, 24, 18, 3, -24 },
  { 1514, 13, 24, 18, 3, -24 },
  { 1553, 19, 24, 24, 2, -24 },
  { 1610, 19, 24, 25, 3, -24 },
  { 1667, 11, 24, 13, 1, -24 },
  { 1700, 10, 31, 11, -2, -24 },
  { 1739, 19, 24, 22, 3, -24 },
  { 1796, 14, 24, 18, 3, -24 },
  { 1838, 25, 24, 31, 3, -24 },
  { 1913, 21, 24, 27, 3, -24 },
  { 1976, 22, 24, 26, 2, -24 },
  { 2042, 16, 24, 21, 3, -24 },
  { 2090, 22, 30, 26, 2, -24 },
  { 2173, 19, 24, 22, 3, -24 },
  { 2230, 15, 24, 18, 2, -24 },
  { 2275, 17, 24, 19, 1, -24 },
  { 2326, 19, 24, 25, 3, -24 },
  { 2383, 21, 24, 21, 0, -24 },
  { 2446, 32, 24, 32, 0, -24 },
  { 2542, 22, 24, 22, 0, -24 },
  { 2608, 21, 24, 21, 0, -24 },
  { 2671, 17, 24, 19, 1, -24 },
  { 2722, 8, 29, 11, 2, -24 },
  { 2751, 14, 24, 14, 0, -24 },
  { 2793, 8, 29, 11, 1, -24 },
  { 2822, 17, 16, 19, 1, -24 },
  { 2856, 14, 2, 14, 0, 3 },
  { 2860, 10, 5, 12, 1, -25 },
  { 2867, 16, 18, 20, 1, -18 },
  { 2903, 17, 25, 21, 2, -25 },
  { 2957, 14, 18, 17, 2, -18 },
  { 2989, 16, 25, 21, 2, -25 },
  { 3039, 16, 18, 20, 2, -18 },
  { 3075, 13, 25, 13, 1, -25 },
  { 3116, 16, 26, 21, 2, -18 },
  { 3168, 17, 25, 21, 2, -25 },
  { 3222, 6, 25, 10, 2, -25 },
  { 3241, 10, 33, 10, -2, -25 },
  { 3283, 17, 25, 20, 3, -25 },
  { 3337, 5, 25, 10, 2, -25 },
  { 3353, 28, 18, 32, 2, -18 },
  { 3416, 17, 18, 21, 2, -18 },
  { 3455, 17, 18, 21, 2, -18 },
  { 3494, 17, 26, 21, 2, -18 },
  { 3550, 16, 26, 21, 2, -18 },
  { 3602, 12, 18, 15, 2, -18 },
  { 3629, 13, 18, 17, 2, -18 },
  { 3659, 12, 22, 14, 1, -22 },
  { 3692, 17, 18, 21, 2, -18 },
  { 3731, 19, 18, 19, 0, -18 },
  { 3774, 28, 18, 28, 0, -18 },
  { 3837, 19, 18, 19, 0, -18 },
  { 3880, 19, 26, 19, 0, -18 },
  { 3942, 14, 18, 16, 1, -18 },
  { 3974, 12, 29, 13, 0, -24 },
  { 4018, 4, 32, 18, 7, -25 },
  { 4034, 12, 29, 13, 1, -24 },
  { 4078, 16, 5, 19, 1, -14 },
};

const GFXfont NotoSans_Bold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold33pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_BOLD33PT7B_H_
