#ifndef _NOTOSANS_BOLD51PT7B_H_
#define _NOTOSANS_BOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xFB, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xCF, 0xC1, 0x80, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0x87, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x0F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xF7, 0x1F, 0x9F, 0xE3, 0x80, 0xCF, 0xF1,
  0xC0, 0x07, 0xF8, 0xE0, 0x03, 0xFC, 0x70, 0x00, 0xFF, 0xB8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0E, 0x7F, 0xC0, 0x07, 0x1F, 0xE0, 0x03, 0x87,
  0xF8, 0x01, 0xC3, 0xFF, 0x00, 0xE3, 0xFF, 0xF8, 0x73, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x3F,
  0x9F, 0xC0, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xF0, 0xFC, 0x3F, 0x1F,
  0x8F, 0xFE, 0x3F, 0x9F, 0xC7, 0xE7, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xFF,
  0xF8, 0xFF, 0xF9, 0xFC, 0xFF, 0xFE, 0x3F, 0xFC, 0x7E, 0x3F, 0x1F, 0xC7,
  0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x3F,
  0x00, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFE, 0x0F, 0xFF, 0x80,
  0x1F, 0xC1, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF,
  0xFF, 0x03, 0xF8, 0x7F, 0xCF, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xF8,
  0xFF, 0x03, 0xFE, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0xFF, 0x00, 0xFF,
  0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x7C, 0x06, 0x7E, 0x3E, 0x3F,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x0F, 0x03, 0xC0, 0x01, 0x81, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0x9F, 0xCF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF8,
  0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x7F, 0xDF, 0xFF, 0xEF, 0xF7, 0xF3, 0xFC, 0xF0, 0xFF, 0x18, 0x3F, 0xC4,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x7E, 0x03, 0xFE, 0x1E, 0x00, 0xFF, 0x04, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xFC, 0x38, 0x03, 0xFE,
  0x10, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFC, 0x7F,
  0x80, 0x3F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xF8, 0x3F, 0xC0, 0x7E,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x1F, 0xE0, 0xFC, 0x03, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1,
  0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xEC, 0x00, 0x0F, 0xF7, 0xC0, 0x1F, 0xFB, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xF8, 0x08, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x38, 0x03, 0xF8, 0xFF, 0xC1, 0xFC, 0xFF, 0xF8, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7,
  0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF,
  0x07, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFF, 0x1F, 0xF0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xBF,
  0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x9F,
  0xF9, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFD, 0xFC,
  0x3F, 0xFC, 0xFE, 0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x7E, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC3, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xCF, 0xC1, 0x80, 0x3F,
  0x1F, 0xE7, 0xF9, 0xFF, 0x7F, 0xDF, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xE1, 0xFF, 0x9E, 0x00, 0xFF, 0x10, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0xFF, 0xC7, 0xE3, 0xF0, 0x3F, 0xFF, 0xE1, 0xF9, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFC, 0xF8, 0x3F, 0xE3, 0xF8, 0x3E, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x7E,
  0x1F, 0xC0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC0, 0x3F, 0x07, 0xDF, 0x07, 0xE0,
  0x1F, 0x03, 0xFF, 0x87, 0xE0, 0x0F, 0x81, 0xFF, 0xC3, 0xF0, 0x07, 0xC0,
  0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x7F, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0xF8,
  0x3E, 0x01, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x3E, 0x0F, 0xC0,
  0xFF, 0x1F, 0x9F, 0x07, 0xF9, 0xFF, 0x9F, 0x8F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xE0, 0x7F, 0xFD, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0,
  0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x01,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xF0, 0x0F,
  0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x1C, 0x3F, 0xF0, 0x00, 0x43,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x06, 0x1F, 0xFC, 0x03, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x7F, 0x80, 0x1F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x1F, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x1C,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x0F, 0xF1, 0xFF,
  0xC0, 0x3F, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0x3E, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x0F,
  0xF1, 0xFC, 0x00, 0xFF, 0x8F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0xFF, 0x83,
  0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0x7F, 0xC0, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFE,
  0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F,
  0x00, 0x7F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF8, 0xFE, 0x00,
  0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFD, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x7F,
  0xFD, 0xF8, 0x00, 0x7E, 0xFF, 0xFB, 0xF0, 0x00, 0xFD, 0xFF, 0xF7, 0xE0,
  0x03, 0xF3, 0xFF, 0xEF, 0xE0, 0x07, 0xEF, 0xFF, 0xCF, 0xC0, 0x0F, 0xDF,
  0xFF, 0x9F, 0x80, 0x3F, 0xBF, 0xFF, 0x3F, 0x80, 0x7E, 0x7F, 0xFE, 0x3F,
  0x00, 0xFC, 0xFF, 0xFC, 0x7E, 0x03, 0xF9, 0xFF, 0xF8, 0xFE, 0x07, 0xE3,
  0xFF, 0xF0, 0xFC, 0x0F, 0xC7, 0xFF, 0xE1, 0xF8, 0x3F, 0x8F, 0xFF, 0xC3,
  0xF8, 0x7E, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x3F, 0xFF, 0x07, 0xE3, 0xF8,
  0x7F, 0xFE, 0x0F, 0xE7, 0xE0, 0xFF, 0xFC, 0x1F, 0xCF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xBF, 0x83, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0x00,
  0x7F, 0xFC, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0x80, 0x7F, 0xFC, 0x7F, 0x80,
  0x7F, 0xFC, 0x3F, 0xC0, 0x7F, 0xFC, 0x3F, 0xE0, 0x7F, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x07, 0xF8,
  0x7F, 0xFC, 0x07, 0xF8, 0x7F, 0xFC, 0x03, 0xFC, 0x7F, 0xFC, 0x03, 0xFE,
  0x7F, 0xFC, 0x01, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0x7F, 0xFC, 0x00, 0xFF,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0xFB, 0xFC, 0x03,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x03, 0xFE, 0xFF, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF, 0xBF,
  0xC0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0x80, 0x3C, 0x7F, 0x80, 0x04, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xDF,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xBF, 0x00, 0xFF,
  0x07, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0x81, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF9, 0xF8, 0x1F,
  0xE0, 0x3F, 0x81, 0xFC, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFC, 0x7E, 0x07,
  0xF0, 0x0F, 0xF0, 0x7E, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x1F, 0xC1,
  0xFC, 0x01, 0xFC, 0x3F, 0x87, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0x83, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xC1, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x7E,
  0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x3F, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x1F,
  0x9F, 0xC0, 0x03, 0xF9, 0xF8, 0x0F, 0xEF, 0xE0, 0x00, 0xFC, 0xFC, 0x03,
  0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xF8, 0x18, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xE0, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x0F,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xCF, 0xC7, 0xFF,
  0xC7, 0xE1, 0xFF, 0x83, 0xF0, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0xFE,
  0x7F, 0xF8, 0x3F, 0xBF, 0xFF, 0x0F, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07,
  0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFE, 0xFF, 0xFC, 0x3F, 0x1F, 0xFE, 0x0F,
  0xC3, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xF8, 0x0E, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x47, 0xFC, 0x03, 0x8F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F,
  0xF9, 0xFE, 0x1F, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xC0,
  0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0xFE, 0x0F,
  0xFF, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE3, 0xFC, 0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x7F,
  0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x63, 0xFF, 0x81, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0xE0, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF,
  0x7F, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF,
  0xF8, 0x1F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x03,
  0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xFC,
  0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xFC, 0x1F, 0xFE, 0x7F, 0x81, 0xFF,
  0x8F, 0xF0, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x20, 0x00, 0x7F, 0xC7, 0x80, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0xFE, 0x7F, 0xFC,
  0x3F, 0xBF, 0xFF, 0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF0, 0x3F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFC, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x00, 0x78, 0x03,
  0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xDF, 0xFF, 0xBF,
  0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0x01,
  0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7,
  0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xDF, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xF8,
  0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0x1F, 0xFF, 0x0F, 0xCF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xF3, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0x1F, 0xFE, 0x0F, 0xEF, 0xFF, 0xC3, 0xFB,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x1F, 0xFB,
  0xFE, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xF0, 0x7F,
  0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xBF,
  0xFF, 0x0F, 0xE7, 0xFF, 0x83, 0xF8, 0xFF, 0xC0, 0xFE, 0x01, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0xFF, 0xF1, 0xFC, 0x3F, 0xFF, 0x7F, 0x8F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xF8, 0x1F, 0xFB, 0xFE,
  0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFB, 0xFC, 0x1F, 0xFE, 0x7F, 0x81, 0xFF, 0x8F, 0xF0, 0x03, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xC1, 0xFB, 0xFC, 0x00, 0x9F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x1C, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xCF, 0xC7,
  0xFF, 0xC7, 0xE1, 0xFF, 0xC3, 0xF0, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0x00, 0xFE,
  0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0x9F, 0xC0, 0x7F, 0xF0, 0x1F, 0xE7, 0xF8,
  0x1F, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xDF, 0x81, 0xFC, 0x3F, 0x81, 0xF7,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFC, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x3F, 0x0F,
  0xE0, 0x7F, 0x0F, 0x8F, 0xC3, 0xF8, 0x1F, 0xC3, 0xE3, 0xF1, 0xFE, 0x07,
  0xF9, 0xF8, 0x7C, 0x7F, 0x00, 0xFE, 0x7E, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F,
  0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xC1, 0xF9, 0xF8, 0x03, 0xF9, 0xF0, 0x3E,
  0xFE, 0x00, 0x7E, 0xFC, 0x0F, 0xBF, 0x80, 0x1F, 0xFF, 0x03, 0xEF, 0xE0,
  0x07, 0xFF, 0x80, 0xFB, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0x8F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE1, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x00, 0x7F, 0xFD, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_Bold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 37, 14, 3, -36 },
  { 43, 18, 13, 24, 3, -36 },
  { 73, 31, 36, 33, 1, -36 },
  { 213, 25, 42, 29, 2, -39 },
  { 345, 42, 37, 46, 2, -37 },
  { 540, 36, 38, 38, 2, -37 },
  { 711, 7, 13, 14, 3, -36 },
  { 723, 14, 44, 17, 2, -36 },
  { 800, 13, 44, 17, 2, -36 },
  { 872, 25, 24, 28, 1, -39 },
  { 947, 25, 24, 29, 2, -30 },
  { 1022, 9, 13, 15, 2, -6 },
  { 1037, 14, 7, 16, 1, -17 },
  { 1050, 9, 9, 14, 3, -8 },
  { 1061, 21, 37, 21, 0, -37 },
  { 1159, 25, 38, 29, 2, -37 },
  { 1278, 18, 36, 29, 3, -36 },
  { 1359, 25, 37, 29, 2, -37 },
  { 1475, 25, 38, 29, 2, -37 },
  { 1594, 27, 36, 29, 1, -36 },
  { 1716, 25, 37, 29, 2, -36 },
  { 1832, 25, 38, 29, 2, -37 },
  { 1951, 26, 36, 29, 1, -36 },
  { 2068, 25, 38, 29, 2, -37 },
  { 2187, 25, 38, 29, 2, -37 },
  { 2306, 9, 29, 14, 3, -28 },
  { 2339, 10, 35, 15, 2, -28 },
  { 2383, 25, 27, 29, 2, -32 },
  { 2468, 25, 16, 29, 2, -26 },
  { 2518, 25, 27, 29, 2, -32 },
  { 2603, 23, 38, 24, 0, -37 },
  { 2713, 41, 41, 46, 2, -37 },
  { 2924, 35, 37, 35, 0, -37 },
  { 3086, 27, 36, 34, 4, -36 },
  { 3208, 28, 38, 33, 3, -37 },
  { 3341, 31, 36, 37, 4, -36 },
  { 3481, 21, 36, 29, 5, -36 },
  { 3576, 20, 36, 28, 5, -36 },
  { 3666, 30, 38, 37, 3, -37 },
  { 3809, 29, 36, 39, 5, -36 },
  { 3940, 16, 36, 20, 2, -36 },
  { 4012, 16, 47, 17, -4, -36 },
  { 4106, 29, 36, 34, 5, -36 },
  { 4237, 23, 36, 29, 4, -36 },
  { 4341, 39, 36, 48, 5, -36 },
  { 4517, 32, 36, 41, 5, -36 },
  { 4661, 34, 38, 40, 3, -37 },
  { 4823, 26, 36, 32, 4, -36 },
  { 4940, 34, 46, 40, 3, -37 },
  { 5136, 30, 36, 33, 4, -36 },
  { 5271, 24, 38, 28, 2, -37 },
  { 5385, 27, 36, 29, 1, -36 },
  { 5507, 30, 37, 39, 4, -36 },
  { 5646, 33, 36, 33, 0, -36 },
  { 5795, 49, 36, 49, 0, -36 },
  { 6016, 34, 36, 34, 0, -36 },
  { 6169, 32, 36, 32, 0, -36 },
  { 6313, 27, 36, 30, 1, -36 },
  { 6435, 12, 44, 17, 4, -36 },
  { 6501, 21, 37, 21, 0, -37 },
  { 6599, 12, 44, 17, 1, -36 },
  { 6665, 27, 24, 29, 1, -37 },
  { 6746, 21, 3, 21, 0, 5 },
  { 6754, 15, 8, 19, 2, -39 },
  { 6769, 25, 29, 31, 2, -28 },
  { 6860, 26, 40, 32, 4, -39 },
  { 6990, 23, 29, 26, 2, -28 },
  { 7074, 27, 40, 32, 2, -39 },
  { 7209, 26, 29, 30, 2, -28 },
  { 7304, 21, 39, 20, 1, -39 },
  { 7407, 27, 40, 32, 2, -28 },
  { 7542, 26, 39, 33, 4, -39 },
  { 7669, 9, 39, 15, 3, -39 },
  { 7713, 15, 51, 15, -3, -39 },
  { 7809, 28, 39, 32, 4, -39 },
  { 7946, 7, 39, 15, 4, -39 },
  { 7981, 42, 28, 50, 4, -28 },
  { 8128, 26, 28, 33, 4, -28 },
  { 8219, 27, 29, 32, 2, -28 },
  { 8317, 26, 40, 32, 4, -28 },
  { 8447, 27, 40, 32, 2, -28 },
  { 8582, 18, 28, 23, 4, -28 },
  { 8645, 21, 29, 26, 2, -28 },
  { 8722, 20, 35, 22, 1, -34 },
  { 8810, 25, 29, 33, 4, -28 },
  { 8901, 29, 28, 29, 0, -28 },
  { 9003, 42, 28, 44, 1, -28 },
  { 9150, 29, 28, 29, 0, -28 },
  { 9252, 29, 40, 29, 0, -28 },
  { 9397, 22, 28, 25, 2, -28 },
  { 9474, 17, 44, 20, 1, -36 },
  { 9568, 6, 51, 28, 11, -39 },
  { 9607, 17, 44, 20, 2, -36 },
  { 9701, 25, 8, 29, 2, -22 },
};

const GFXfont NotoSans_Bold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold51pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_BOLD51PT7B_H_
