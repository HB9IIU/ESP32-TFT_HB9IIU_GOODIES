#ifndef _NOTOSANS_BOLD38PT7B_H_
#define _NOTOSANS_BOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0x3F, 0x7F, 0xFF, 0xF9,
  0xF0, 0x80, 0xFC, 0xFF, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x78, 0x7D, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0xF0, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF8, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE0, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0xC1, 0x3E, 0x30,
  0x0F, 0x8C, 0x03, 0xFB, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0x3F, 0x00,
  0xC7, 0xE0, 0x31, 0xFF, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xC7, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0x80,
  0x7F, 0xF0, 0x0F, 0x00, 0x7D, 0xF0, 0x1F, 0x00, 0xF8, 0xF8, 0x1E, 0x00,
  0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x7C, 0x00,
  0xF8, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF0, 0xE0,
  0x78, 0xF9, 0xE3, 0xF8, 0x7D, 0xF3, 0xE7, 0xFC, 0x7F, 0xF3, 0xCF, 0xFE,
  0x3F, 0xE7, 0xCF, 0x9E, 0x1F, 0xC7, 0x8F, 0x1F, 0x02, 0x0F, 0x9F, 0x1F,
  0x00, 0x0F, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x0F, 0x00, 0x3E, 0x1F, 0x0F,
  0x00, 0x3C, 0x1F, 0x0F, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x78, 0x0F, 0x1F,
  0x00, 0xF8, 0x0F, 0xBE, 0x00, 0xF0, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xFC,
  0x03, 0xE0, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x3F, 0x0F, 0xFE, 0x07, 0xE3, 0xFF, 0xE0, 0xFC, 0x7F, 0xFE,
  0x3F, 0x1F, 0xCF, 0xE7, 0xE3, 0xF0, 0xFE, 0xF8, 0x7E, 0x0F, 0xFF, 0x0F,
  0x80, 0xFF, 0xC1, 0xF8, 0x0F, 0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xFC, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0xFE, 0x07,
  0xFE, 0x0F, 0xF0, 0xFF, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x07,
  0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xC3,
  0xC1, 0x9F, 0x39, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0x81, 0xF8,
  0xF8, 0x0E, 0x1E, 0x00, 0x41, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xFB, 0xFF, 0xFF, 0xCF, 0x84, 0x00,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7E, 0x3F, 0x9F, 0x83, 0xF3, 0xF0,
  0x3E, 0x7E, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xEF, 0x80,
  0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xCF, 0x83,
  0xF1, 0xFC, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xDF, 0x3F, 0x38, 0xFC, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFE, 0x3F, 0x8F, 0x03, 0xF8, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x40, 0x01, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x78, 0x3F, 0x84, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x03, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xDF, 0x80, 0x7D, 0xF8, 0x0F, 0x9F, 0x80, 0xF1, 0xF8, 0x1F, 0x1F, 0x83,
  0xE1, 0xF8, 0x3C, 0x1F, 0x87, 0xC1, 0xF8, 0xF8, 0x1F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0x8F, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xEF, 0x8F, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0x01,
  0xF3, 0xFC, 0x3E, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xE0, 0x3E, 0xFC, 0x0F, 0xCF, 0xE3, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE7, 0xE0, 0xFC, 0xFC, 0x0F,
  0x9F, 0x81, 0xFB, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xF3, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFD, 0xFE,
  0x7E, 0x0F, 0xCF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC7, 0xF1, 0xFC, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xF7, 0xE0, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xDF, 0x0F, 0xF3, 0xE0, 0x60, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7D, 0xFB, 0xFF, 0xFF,
  0xCF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFD, 0xFF,
  0xFF, 0xE7, 0xC2, 0x00, 0x3E, 0x7E, 0x7F, 0x7F, 0x7E, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB,
  0xE1, 0xFC, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x03, 0xFF, 0x1E, 0x7C, 0x3F, 0xFC,
  0x7D, 0xE1, 0xFF, 0xF0, 0xF7, 0x87, 0xC3, 0xC3, 0xFE, 0x3E, 0x0F, 0x0F,
  0xF0, 0xF0, 0x3C, 0x3F, 0xC7, 0xC0, 0xF0, 0xFF, 0x1F, 0x03, 0xC3, 0xFC,
  0x7C, 0x0F, 0x0F, 0xF1, 0xF0, 0x3C, 0x3F, 0xC7, 0xC1, 0xF0, 0xFF, 0x0F,
  0x07, 0xC7, 0xBC, 0x3F, 0xFF, 0xFE, 0xF8, 0x7F, 0xFF, 0xF1, 0xE0, 0xFF,
  0x3F, 0x87, 0xC0, 0xF0, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07,
  0xE0, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFC,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x3F,
  0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0,
  0x7E, 0xFC, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF1, 0xF8,
  0xFE, 0x00, 0x8F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x47, 0xFF, 0x7E, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0x80, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0x9F, 0x81,
  0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xE3, 0xE3, 0xFC, 0x00, 0x8F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7E,
  0x00, 0x7D, 0xFC, 0x01, 0xF3, 0xF8, 0x07, 0xCF, 0xFC, 0x7F, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7F, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F,
  0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFE, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xEF, 0x00, 0x7F, 0xFF, 0x7C, 0x03, 0xFF, 0xFB, 0xE0,
  0x1E, 0xFF, 0xCF, 0x01, 0xF7, 0xFE, 0x7C, 0x0F, 0xBF, 0xF3, 0xE0, 0x79,
  0xFF, 0xDF, 0x07, 0xCF, 0xFE, 0x78, 0x3E, 0x7F, 0xF3, 0xE1, 0xE3, 0xFF,
  0x9F, 0x1F, 0x1F, 0xFC, 0x78, 0xF8, 0xFF, 0xE3, 0xE7, 0x87, 0xFF, 0x1F,
  0x7C, 0x3F, 0xF8, 0x7B, 0xE1, 0xFF, 0xC3, 0xFE, 0x0F, 0xFE, 0x1F, 0xF0,
  0x7F, 0xF0, 0x7F, 0x83, 0xFF, 0x83, 0xF8, 0x1F, 0xFC, 0x1F, 0xC0, 0xFF,
  0xE0, 0xFE, 0x07, 0xFF, 0x03, 0xE0, 0x3E, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFB, 0xF0, 0x1F, 0xF9, 0xF8, 0x1F, 0xF9, 0xF8,
  0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7E, 0x1F, 0xFC, 0x7F,
  0x1F, 0xFC, 0x3F, 0x1F, 0xFC, 0x1F, 0x9F, 0xFC, 0x1F, 0x9F, 0xFC, 0x0F,
  0xDF, 0xFC, 0x0F, 0xCF, 0xFC, 0x07, 0xEF, 0xFC, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3,
  0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3,
  0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x07, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x01,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0x00, 0x40,
  0x07, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF7, 0xF8, 0xFB, 0xF0,
  0x0D, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFC,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x3F, 0x9F, 0xFB, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xFD, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0x9F, 0x00,
  0x7F, 0x00, 0xFC, 0xF8, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x3F,
  0x3F, 0x01, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0xF8, 0x0F, 0x87, 0xC0, 0x7B,
  0xC0, 0xFC, 0x3F, 0x07, 0xDE, 0x07, 0xE1, 0xF8, 0x3E, 0xF8, 0x3E, 0x07,
  0xC1, 0xF7, 0xC1, 0xF0, 0x3E, 0x0F, 0x3E, 0x1F, 0x81, 0xF8, 0xF8, 0xF0,
  0xFC, 0x0F, 0xC7, 0xC7, 0xC7, 0xC0, 0x3E, 0x3E, 0x3E, 0x3E, 0x01, 0xF1,
  0xE1, 0xF3, 0xF0, 0x0F, 0xDF, 0x07, 0x9F, 0x80, 0x3E, 0xF8, 0x3E, 0xF8,
  0x01, 0xF7, 0xC1, 0xF7, 0xC0, 0x0F, 0xBC, 0x0F, 0xBE, 0x00, 0x7D, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x7E, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xE0, 0x0F, 0x1E, 0x01, 0xF1, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0xF8, 0x3C, 0x07, 0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xC7,
  0x80, 0x3E, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1C, 0x1F, 0xC4, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x03, 0xFF, 0xC7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xDF, 0x3F, 0xC3, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0xFC, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFB, 0xFD, 0xFC, 0x1F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7D,
  0xFF, 0x8F, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF,
  0xE7, 0xFF, 0xE3, 0xF0, 0x13, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x02, 0x7F, 0x8F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE3, 0xE3, 0xFE,
  0x7C, 0xFF, 0xEF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7F, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xEF, 0x8F, 0xFD, 0xF0, 0xFE, 0x1E, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF0, 0xFC, 0xFC, 0x0F,
  0xBF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFC, 0xC3, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0xE3, 0xFE, 0x7C,
  0xFF, 0xEF, 0xBF, 0xFF, 0xF7, 0xFB, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7F, 0x0F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xEF, 0x8F, 0xFD, 0xF0, 0xFE, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x40, 0x0F, 0xEF, 0xEF, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0xFE, 0x1F, 0x3F, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7E, 0x73, 0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xDF,
  0xFB, 0xFF, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x3F, 0x03, 0xF1,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x1F, 0xBF,
  0x00, 0xFB, 0xF8, 0x07, 0xDF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0x3F, 0x03, 0xF1, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xFE,
  0x07, 0xF1, 0xF7, 0xFE, 0x3F, 0xF3, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x03, 0xF8,
  0x1F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0x80,
  0x7F, 0xF0, 0x1F, 0x00, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0xC0, 0x7C, 0x03,
  0xFF, 0x80, 0xF8, 0x07, 0xFF, 0x01, 0xF0, 0x0F, 0xFE, 0x03, 0xE0, 0x1F,
  0xFC, 0x07, 0xC0, 0x3F, 0xF8, 0x0F, 0x80, 0x7F, 0xF0, 0x1F, 0x00, 0xFF,
  0xE0, 0x3E, 0x01, 0xFF, 0xC0, 0x7C, 0x03, 0xE0, 0xF0, 0xFE, 0x1F, 0x3F,
  0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x9F, 0xC7, 0xE0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xE7,
  0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0xF8, 0xFE, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFB, 0xFD, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7D, 0xFF, 0x8F, 0x8F, 0xE1, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE3, 0xE3, 0xFE, 0x7C, 0xFF, 0xEF, 0xBF, 0xFF,
  0xF7, 0xFB, 0xFF, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xEF,
  0x8F, 0xFD, 0xF0, 0xFE, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0xF0, 0x7F, 0xC7, 0xEF, 0xBF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xC1, 0xDF, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x84, 0x7F, 0xF1, 0xFF,
  0xC3, 0xFF, 0x07, 0xFC, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xEF, 0x9F, 0xF9, 0xF1, 0xFE, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC,
  0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xF0, 0x3F,
  0x7E, 0x07, 0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x3E, 0x3E, 0x0F, 0xF0, 0x7E,
  0x3E, 0x0F, 0xF8, 0x7E, 0x3F, 0x0F, 0x78, 0x7C, 0x3F, 0x1E, 0x78, 0x7C,
  0x1F, 0x1E, 0x78, 0xFC, 0x1F, 0x1E, 0x7C, 0xF8, 0x1F, 0x9E, 0x3C, 0xF8,
  0x0F, 0xBE, 0x3C, 0xF8, 0x0F, 0xBC, 0x3D, 0xF8, 0x0F, 0xBC, 0x3D, 0xF0,
  0x0F, 0xBC, 0x1F, 0xF0, 0x07, 0xBC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F,
  0x07, 0xE1, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF3, 0xF0,
  0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0xC0, 0xFE, 0xFE,
  0x01, 0xFC, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xC1, 0xF8,
  0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xBF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0xFF, 0x8F, 0xE0, 0xF8, 0x0F,
  0xF0, 0xFF, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xF0, 0x7F,
  0x01, 0xF0, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xF0, 0x00, 0x08, 0x00, 0x5F, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xE8, 0x01, 0xE0,
};

const GFXglyph NotoSans_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 28, 11, 2, -27 },
  { 26, 14, 10, 18, 2, -27 },
  { 44, 23, 27, 25, 1, -27 },
  { 122, 18, 31, 22, 2, -29 },
  { 192, 32, 28, 34, 1, -28 },
  { 304, 27, 28, 29, 2, -28 },
  { 399, 6, 10, 10, 2, -27 },
  { 407, 10, 33, 13, 2, -27 },
  { 449, 10, 33, 13, 1, -27 },
  { 491, 19, 18, 21, 1, -29 },
  { 534, 18, 19, 22, 2, -23 },
  { 577, 8, 9, 11, 1, -4 },
  { 586, 10, 5, 12, 1, -13 },
  { 593, 7, 7, 11, 2, -6 },
  { 600, 16, 27, 16, 0, -27 },
  { 654, 19, 28, 22, 1, -28 },
  { 721, 14, 27, 22, 2, -27 },
  { 769, 19, 28, 22, 1, -28 },
  { 836, 19, 28, 22, 1, -28 },
  { 903, 20, 27, 22, 1, -27 },
  { 971, 18, 27, 22, 2, -27 },
  { 1032, 19, 27, 22, 1, -27 },
  { 1097, 19, 27, 22, 1, -27 },
  { 1162, 19, 27, 22, 1, -27 },
  { 1227, 19, 27, 22, 1, -27 },
  { 1292, 7, 22, 11, 2, -21 },
  { 1312, 8, 26, 11, 1, -21 },
  { 1338, 18, 20, 22, 2, -24 },
  { 1383, 18, 11, 22, 2, -19 },
  { 1408, 18, 20, 22, 2, -24 },
  { 1453, 17, 29, 18, 0, -28 },
  { 1515, 30, 30, 34, 2, -27 },
  { 1628, 26, 27, 26, 0, -27 },
  { 1716, 20, 27, 25, 3, -27 },
  { 1784, 21, 28, 24, 2, -28 },
  { 1858, 23, 27, 28, 3, -27 },
  { 1936, 16, 27, 21, 3, -27 },
  { 1990, 16, 27, 21, 3, -27 },
  { 2044, 22, 28, 28, 2, -28 },
  { 2121, 23, 27, 29, 3, -27 },
  { 2199, 13, 27, 15, 1, -27 },
  { 2243, 12, 35, 13, -3, -27 },
  { 2296, 22, 27, 25, 3, -27 },
  { 2371, 17, 27, 21, 3, -27 },
  { 2429, 29, 27, 36, 3, -27 },
  { 2527, 24, 27, 31, 3, -27 },
  { 2608, 26, 28, 30, 2, -28 },
  { 2699, 19, 27, 24, 3, -27 },
  { 2764, 26, 34, 30, 2, -28 },
  { 2875, 22, 27, 25, 3, -27 },
  { 2950, 17, 28, 21, 2, -28 },
  { 3010, 20, 27, 22, 1, -27 },
  { 3078, 23, 27, 29, 3, -27 },
  { 3156, 25, 27, 25, 0, -27 },
  { 3241, 37, 27, 37, 0, -27 },
  { 3366, 25, 27, 25, 0, -27 },
  { 3451, 24, 27, 24, 0, -27 },
  { 3532, 20, 27, 22, 1, -27 },
  { 3600, 9, 33, 13, 3, -27 },
  { 3638, 16, 27, 16, 0, -27 },
  { 3692, 9, 33, 13, 1, -27 },
  { 3730, 20, 17, 22, 1, -27 },
  { 3773, 16, 3, 16, 0, 3 },
  { 3779, 10, 6, 14, 2, -29 },
  { 3787, 18, 21, 23, 2, -21 },
  { 3835, 19, 29, 24, 3, -29 },
  { 3904, 17, 21, 20, 2, -21 },
  { 3949, 19, 29, 24, 2, -29 },
  { 4018, 19, 21, 23, 2, -21 },
  { 4068, 15, 29, 15, 1, -29 },
  { 4123, 19, 30, 24, 2, -21 },
  { 4195, 19, 29, 25, 3, -29 },
  { 4264, 6, 29, 11, 3, -29 },
  { 4286, 11, 38, 11, -2, -29 },
  { 4339, 21, 29, 24, 3, -29 },
  { 4416, 6, 29, 11, 3, -29 },
  { 4438, 31, 21, 37, 3, -21 },
  { 4520, 19, 21, 25, 3, -21 },
  { 4570, 20, 21, 24, 2, -21 },
  { 4623, 19, 30, 24, 3, -21 },
  { 4695, 19, 30, 24, 2, -21 },
  { 4767, 14, 21, 17, 3, -21 },
  { 4804, 15, 21, 19, 2, -21 },
  { 4844, 14, 25, 16, 1, -25 },
  { 4888, 19, 21, 25, 3, -21 },
  { 4938, 22, 21, 22, 0, -21 },
  { 4996, 32, 21, 33, 0, -21 },
  { 5080, 22, 21, 22, 0, -21 },
  { 5138, 22, 30, 22, 0, -21 },
  { 5221, 17, 21, 19, 1, -21 },
  { 5266, 12, 33, 15, 1, -27 },
  { 5316, 5, 38, 21, 8, -29 },
  { 5340, 12, 33, 15, 2, -27 },
  { 5390, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_Bold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold38pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_BOLD38PT7B_H_
