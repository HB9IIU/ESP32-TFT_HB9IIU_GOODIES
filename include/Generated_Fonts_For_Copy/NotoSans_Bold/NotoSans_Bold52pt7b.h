#ifndef _NOTOSANS_BOLD52PT7B_H_
#define _NOTOSANS_BOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0xC0, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE7, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xF9, 0xE1, 0xE3, 0xFC, 0x78, 0x08, 0xFF, 0x1E, 0x00, 0x3F, 0xC7, 0x80,
  0x0F, 0xF9, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0x9F, 0xF0, 0x01, 0xE3, 0xFC, 0x00, 0x78, 0xFF, 0x80, 0x1E,
  0x3F, 0xFC, 0x07, 0x9F, 0xEF, 0xF1, 0xEF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x7F, 0x07, 0xC0, 0xFC, 0x1F,
  0x8F, 0xC3, 0xFE, 0x1F, 0xC7, 0xE3, 0xF9, 0xFF, 0xE1, 0xFD, 0xFC, 0x7E,
  0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0x8F, 0xFF, 0xE3, 0xFF, 0xE3, 0xF1, 0xFD,
  0xFC, 0x3F, 0xF8, 0xFC, 0x7F, 0x1F, 0xC3, 0xFE, 0x1F, 0x8F, 0xC1, 0xF8,
  0x0E, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xFF,
  0xF8, 0x1F, 0xE1, 0xFF, 0xBF, 0xE0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x83, 0xFE, 0x7F, 0x87, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F,
  0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x7F,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0x80,
  0xFC, 0x02, 0xF8, 0x3E, 0x1F, 0x7F, 0xDE, 0x7F, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xF9, 0xF8,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x07,
  0xC0, 0x07, 0x03, 0x80, 0x00, 0x80, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xF9,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE7, 0xF7, 0xF1, 0xFC, 0xF8, 0x7F, 0x1C, 0x1F, 0xC6, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF0, 0xFE, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0x87, 0x00, 0x1F, 0xE0,
  0x80, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xFC, 0x18, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE8, 0x00, 0x0F, 0xFB,
  0xC0, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0xFF, 0xE0, 0xFE, 0x7F,
  0xFE, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF8, 0xFF,
  0x83, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFE, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x9F,
  0xC0, 0x1F, 0xE7, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xF1, 0xFF, 0x07, 0xFC,
  0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xF7,
  0xF1, 0xFF, 0xFB, 0xF8, 0x3F, 0xFC, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0x58, 0x00, 0x00, 0x3C, 0x3F, 0xBF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0xC0, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xF8, 0xFE, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3E, 0x01, 0xFF, 0x10, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x7E, 0x3F, 0x03,
  0xFF, 0xFE, 0x0F, 0xCF, 0xC1, 0xFF, 0xFF, 0x83, 0xF7, 0xE0, 0xFF, 0x07,
  0xE0, 0xFD, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x7E, 0x1F, 0xC0, 0x7E, 0x07,
  0xDF, 0x87, 0xE0, 0x1F, 0x81, 0xF7, 0xC1, 0xF8, 0x07, 0xE0, 0x7D, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0x07, 0xE0,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0xFF, 0xF0, 0x7E, 0x03, 0xF8,
  0x3E, 0x7C, 0x1F, 0x80, 0xFE, 0x1F, 0x9F, 0x07, 0xF0, 0x7F, 0x87, 0xE7,
  0xE0, 0xFF, 0x7F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x7E, 0x07,
  0xFF, 0xDF, 0xFE, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC7,
  0xFC, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x07, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x7C, 0x3F, 0xF8, 0x00,
  0x41, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x83, 0xFF, 0xC0, 0x7C,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xC0, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFC, 0xFF, 0x00, 0x1F,
  0xF9, 0xFE, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xF7, 0xF8,
  0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x9F, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0x3C,
  0x1F, 0xF8, 0x00, 0x10, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xDF,
  0xF0, 0x00, 0x7F, 0x7F, 0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x07, 0xF3, 0xFF,
  0x00, 0x1F, 0xC7, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xC3,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC7,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF7, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF,
  0x8F, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xFC,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x3F, 0xFF, 0xFB, 0xF0, 0x00, 0xFF, 0xFF,
  0xF7, 0xF0, 0x01, 0xFB, 0xFF, 0xE7, 0xE0, 0x03, 0xF7, 0xFF, 0xCF, 0xC0,
  0x0F, 0xEF, 0xFF, 0x9F, 0xC0, 0x1F, 0x9F, 0xFF, 0xBF, 0x80, 0x3F, 0x3F,
  0xFF, 0x3F, 0x00, 0x7E, 0x7F, 0xFE, 0x7F, 0x01, 0xF8, 0xFF, 0xFC, 0xFE,
  0x03, 0xF1, 0xFF, 0xF8, 0xFC, 0x07, 0xE3, 0xFF, 0xF1, 0xF8, 0x1F, 0x87,
  0xFF, 0xE3, 0xF8, 0x3F, 0x0F, 0xFF, 0xC3, 0xF0, 0x7E, 0x1F, 0xFF, 0x87,
  0xE1, 0xF8, 0x3F, 0xFF, 0x0F, 0xE3, 0xF0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE0,
  0xFF, 0xFC, 0x1F, 0x9F, 0x81, 0xFF, 0xF8, 0x3F, 0xBF, 0x03, 0xFF, 0xF0,
  0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0x9F, 0xE0,
  0x07, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0x00, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xC3, 0xFF, 0xF0, 0x1F, 0xE1, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0xFC,
  0x03, 0xFC, 0x7F, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0x9F, 0xFF,
  0x80, 0x1F, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xFB, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0xFC, 0x7F,
  0x80, 0x0C, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFB, 0xC0, 0x03, 0xFD, 0xFC,
  0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x3F, 0xCF, 0xFC, 0x00, 0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xF0, 0x7F, 0x00, 0xFE, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x3F, 0x00,
  0xFE, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF3, 0xF8,
  0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x1F,
  0x81, 0xFC, 0x03, 0xFC, 0x1F, 0x87, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xE1,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0x07, 0xF8, 0xFE,
  0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x03, 0xF1, 0xFE, 0x00, 0x3F, 0x8F,
  0xC0, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x03, 0xF9,
  0xFC, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x7E, 0x01, 0xF9, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x7E, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1E, 0x03, 0xFE, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xE0,
  0x3F, 0xBF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xCF, 0xFF, 0xE7, 0xE3, 0xFF, 0xE3, 0xF0,
  0xFF, 0xC0, 0xF8, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x3F, 0xF8,
  0x3F, 0xDF, 0xFF, 0x0F, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFC, 0xFF, 0xEF, 0xFC, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xBF, 0xFF, 0x8F, 0xC7, 0xFF,
  0xC3, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xFF, 0x3F, 0x1F, 0xF0, 0x04, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x4F,
  0xFC, 0x07, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x7E, 0x0F, 0xF0, 0x3F, 0xF9, 0xFE, 0x0F, 0xFF, 0xBF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x7F, 0xFD,
  0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF7, 0xF8, 0x00,
  0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x9F, 0xC1, 0xFF, 0xE3, 0xF8, 0x0F,
  0xF8, 0x3F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x60,
  0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x05, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xF1, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF1, 0xFC, 0x1F, 0xFF, 0x3F, 0x87, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFC, 0x3F, 0xFB, 0xFF, 0x01, 0xFF,
  0x7F, 0xC0, 0x3F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0x3F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xCF,
  0xF8, 0x1F, 0xF9, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0x7F, 0x83, 0xFF, 0xCF, 0xF0, 0x1F, 0xF1, 0xFE, 0x00,
  0x20, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE4, 0x00, 0x07, 0xFC, 0xF0, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x3F, 0xFC, 0x3F, 0x9F,
  0xFF, 0x8F, 0xEF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0x10, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF,
  0x8F, 0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F,
  0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0x87, 0xFF, 0x81, 0xFF, 0xC3, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0x0F, 0xFF, 0x0F, 0xC7, 0xFF, 0xE3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x03, 0xFE,
  0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0xDF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xFE, 0x0F, 0xE7,
  0xFF, 0xC3, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFF, 0x3F, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xEF, 0xFF, 0xE3, 0xF9, 0xFF, 0xF0, 0xFF,
  0x1F, 0xF0, 0x3F, 0xC0, 0x40, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF1,
  0xFC, 0x1F, 0xFF, 0x3F, 0x87, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFC, 0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F,
  0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x1F, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0x7F, 0x83, 0xFF, 0xCF, 0xF0, 0x1F, 0xF1, 0xFE, 0x00, 0x20, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0x7E, 0x3F, 0xEF, 0xEF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xE6, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0x3F, 0xC0, 0x04, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x02, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x08,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xCF, 0xFF,
  0xF7, 0xF1, 0xFF, 0xF8, 0xFC, 0x1F, 0xF8, 0x3F, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0x3F, 0x80, 0x7F, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xFE, 0x03, 0xFC,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x1F, 0xE0, 0x7E, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xDF, 0x83, 0xFC, 0x3F, 0xC1, 0xF3, 0xF0, 0x7F, 0x07, 0xF8, 0x3E,
  0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xCF, 0xC3, 0xFC, 0x0F, 0xE1, 0xF8, 0xF8,
  0x7F, 0x81, 0xFE, 0x3F, 0x1F, 0x8F, 0xE0, 0x3F, 0xCF, 0xC3, 0xF1, 0xFC,
  0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x80, 0x7F, 0x3F, 0x07, 0xCF, 0xE0, 0x0F,
  0xE7, 0xE0, 0xFD, 0xFC, 0x00, 0xFC, 0xF8, 0x1F, 0xBF, 0x80, 0x1F, 0xDF,
  0x03, 0xF7, 0xF0, 0x03, 0xFF, 0xE0, 0x3E, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC1,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x81,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xDF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFE, 0x03, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x9F, 0xFC, 0x00, 0x5F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x1F, 0xFE, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 9, 38, 15, 3, -37 },
  { 44, 19, 13, 25, 3, -37 },
  { 75, 31, 37, 34, 1, -37 },
  { 219, 26, 42, 30, 2, -39 },
  { 356, 43, 38, 47, 2, -38 },
  { 561, 37, 39, 39, 2, -38 },
  { 742, 8, 13, 14, 3, -37 },
  { 755, 14, 45, 18, 2, -37 },
  { 834, 14, 45, 18, 2, -37 },
  { 913, 25, 25, 28, 2, -40 },
  { 992, 25, 25, 30, 2, -31 },
  { 1071, 10, 13, 15, 2, -6 },
  { 1088, 14, 6, 17, 1, -17 },
  { 1099, 9, 9, 15, 3, -8 },
  { 1110, 21, 37, 22, 0, -37 },
  { 1208, 26, 39, 30, 2, -38 },
  { 1335, 18, 37, 30, 3, -37 },
  { 1419, 26, 38, 30, 2, -38 },
  { 1543, 26, 39, 30, 2, -38 },
  { 1670, 28, 37, 30, 1, -37 },
  { 1800, 24, 38, 30, 3, -37 },
  { 1914, 26, 39, 30, 2, -38 },
  { 2041, 27, 37, 30, 1, -37 },
  { 2166, 26, 39, 30, 2, -38 },
  { 2293, 26, 39, 30, 2, -38 },
  { 2420, 9, 30, 15, 3, -29 },
  { 2454, 10, 36, 15, 2, -29 },
  { 2499, 25, 28, 30, 2, -33 },
  { 2587, 25, 15, 30, 2, -26 },
  { 2634, 25, 28, 30, 2, -33 },
  { 2722, 24, 39, 25, 0, -38 },
  { 2839, 42, 41, 47, 2, -37 },
  { 3055, 36, 37, 36, 0, -37 },
  { 3222, 28, 37, 35, 4, -37 },
  { 3352, 29, 39, 33, 3, -38 },
  { 3494, 31, 37, 38, 4, -37 },
  { 3638, 21, 37, 29, 5, -37 },
  { 3736, 21, 37, 29, 5, -37 },
  { 3834, 30, 39, 38, 3, -38 },
  { 3981, 30, 37, 40, 5, -37 },
  { 4120, 17, 37, 20, 2, -37 },
  { 4199, 17, 48, 17, -4, -37 },
  { 4301, 30, 37, 35, 5, -37 },
  { 4440, 23, 37, 29, 4, -37 },
  { 4547, 39, 37, 49, 5, -37 },
  { 4728, 33, 37, 42, 5, -37 },
  { 4881, 35, 39, 41, 3, -38 },
  { 5052, 26, 37, 32, 4, -37 },
  { 5173, 35, 47, 41, 3, -38 },
  { 5379, 30, 37, 34, 4, -37 },
  { 5518, 25, 39, 29, 2, -38 },
  { 5640, 28, 37, 30, 1, -37 },
  { 5770, 31, 38, 39, 4, -37 },
  { 5918, 34, 37, 34, 0, -37 },
  { 6076, 50, 37, 50, 0, -37 },
  { 6308, 35, 37, 35, 0, -37 },
  { 6470, 33, 37, 33, 0, -37 },
  { 6623, 28, 37, 30, 1, -37 },
  { 6753, 12, 45, 17, 4, -37 },
  { 6821, 21, 37, 22, 0, -37 },
  { 6919, 13, 45, 17, 1, -37 },
  { 6993, 28, 24, 30, 1, -37 },
  { 7077, 21, 3, 21, 0, 5 },
  { 7085, 15, 8, 19, 2, -40 },
  { 7100, 25, 30, 31, 2, -29 },
  { 7194, 26, 41, 33, 4, -40 },
  { 7328, 23, 30, 27, 2, -29 },
  { 7415, 27, 41, 33, 2, -40 },
  { 7554, 27, 30, 31, 2, -29 },
  { 7656, 21, 40, 20, 1, -40 },
  { 7761, 27, 41, 33, 2, -29 },
  { 7900, 26, 40, 34, 4, -40 },
  { 8030, 8, 40, 16, 4, -40 },
  { 8070, 15, 52, 16, -3, -40 },
  { 8168, 28, 40, 32, 4, -40 },
  { 8308, 8, 40, 16, 4, -40 },
  { 8348, 43, 29, 51, 4, -29 },
  { 8504, 26, 29, 34, 4, -29 },
  { 8599, 28, 30, 33, 2, -29 },
  { 8704, 26, 41, 33, 4, -29 },
  { 8838, 27, 41, 33, 2, -29 },
  { 8977, 19, 29, 23, 4, -29 },
  { 9046, 22, 30, 26, 2, -29 },
  { 9129, 20, 35, 23, 1, -34 },
  { 9217, 26, 29, 34, 4, -28 },
  { 9312, 30, 28, 30, 0, -28 },
  { 9417, 43, 28, 45, 1, -28 },
  { 9568, 30, 28, 30, 0, -28 },
  { 9673, 30, 40, 30, 0, -28 },
  { 9823, 22, 28, 26, 2, -28 },
  { 9900, 17, 45, 20, 1, -37 },
  { 9996, 5, 51, 29, 12, -39 },
  { 10028, 18, 45, 20, 2, -37 },
  { 10130, 25, 9, 30, 2, -23 },
};

const GFXfont NotoSans_Bold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold52pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_BOLD52PT7B_H_
