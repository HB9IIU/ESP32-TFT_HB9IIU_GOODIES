#ifndef _NOTOSANS_BOLD23PT7B_H_
#define _NOTOSANS_BOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x70, 0x2F, 0xF7, 0xF7, 0xBB, 0x98,
  0xCC, 0x66, 0x33, 0x18, 0x07, 0x38, 0x1C, 0xC0, 0x63, 0x01, 0x9C, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x0C, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7,
  0x30, 0x18, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x60, 0x04, 0x03, 0xF1, 0xFF,
  0xFF, 0xFF, 0x45, 0xC8, 0x3D, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x82,
  0x78, 0x4F, 0xFF, 0xFF, 0xF3, 0xFC, 0x04, 0x00, 0x80, 0x38, 0x00, 0x0F,
  0x81, 0xC3, 0xF8, 0x70, 0x73, 0x0E, 0x0C, 0x63, 0x81, 0x8E, 0x70, 0x31,
  0x9C, 0x07, 0x33, 0x3C, 0xFE, 0xEF, 0xCF, 0x99, 0x9C, 0xE7, 0x73, 0x81,
  0xCE, 0x70, 0x39, 0xCE, 0x0E, 0x39, 0xC1, 0xC3, 0x38, 0x70, 0x7E, 0x1C,
  0x07, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x79, 0xE0, 0x78, 0xE0,
  0x39, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0x7F, 0x0E, 0xF7, 0xDE,
  0xF3, 0xFC, 0xF1, 0xFC, 0xF0, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x8F,
  0xF7, 0x66, 0x66, 0x1C, 0xE7, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x38, 0x0E, 0x01, 0x82,
  0x30, 0xFE, 0xFF, 0xFE, 0x7F, 0x07, 0xC1, 0xD8, 0x73, 0x86, 0x20, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x77, 0xFE, 0xEC, 0xFF, 0xFF, 0xC0, 0x2F, 0xF7, 0x03,
  0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x38,
  0xEF, 0x1F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F,
  0x0F, 0xE3, 0xDF, 0xF1, 0xFE, 0x1F, 0x80, 0x0F, 0x8F, 0xCF, 0xFF, 0xF7,
  0x79, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0E, 0x0F, 0xF3, 0xFF, 0x38, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1E, 0x0F, 0xF3, 0xFF, 0x30, 0xF0, 0x1E, 0x03, 0xC0, 0x71, 0xFC,
  0x3F, 0x07, 0xF8, 0x07, 0x80, 0x70, 0x0F, 0x03, 0xFF, 0xFF, 0xFE, 0xFF,
  0x80, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x06, 0xF0, 0x77,
  0x87, 0x3C, 0x31, 0xE3, 0x8F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xE7, 0xFE, 0x63, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x1F, 0xFF, 0xBF, 0xF7,
  0xF8, 0x03, 0xC3, 0xF8, 0xFF, 0x3E, 0x07, 0x01, 0xE0, 0x39, 0xC7, 0x7E,
  0xFF, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xDF, 0xF9, 0xFE, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x0E,
  0x07, 0xF1, 0xFF, 0x78, 0xFF, 0x0F, 0xE3, 0xDE, 0xF1, 0xFC, 0x1F, 0x0F,
  0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x7B, 0xFE, 0x3F, 0x80, 0x0E,
  0x07, 0xF1, 0xFF, 0x78, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xF3, 0xEF,
  0xFC, 0xFB, 0x80, 0x70, 0x1E, 0x03, 0x97, 0xF3, 0xFC, 0x7E, 0x00, 0x6F,
  0xF7, 0x00, 0x00, 0x02, 0xFF, 0x70, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x77,
  0xFE, 0xEC, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xC7, 0xC1, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xC0, 0x1E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0xF8, 0x7E, 0x7E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x0E, 0x1F,
  0xEF, 0xFD, 0x87, 0x01, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0,
  0x70, 0x00, 0x02, 0x01, 0xE0, 0x78, 0x1C, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0xE3, 0xFB, 0x98, 0xFF,
  0x37, 0x38, 0xE7, 0xE6, 0x1C, 0xFC, 0xC3, 0x9F, 0x98, 0x73, 0x73, 0x0E,
  0x6E, 0x7F, 0xFC, 0xC7, 0xDF, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x1E,
  0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E,
  0xF0, 0x0F, 0xFF, 0xCF, 0xFE, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xFF,
  0xEF, 0xF8, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xEF, 0xF8, 0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x7C, 0x67, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3E,
  0x04, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8E, 0x3F, 0x38,
  0x1E, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xEE,
  0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFB, 0xFE, 0xFF, 0xBC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x01, 0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x7C, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xDC, 0x0F, 0x78, 0x3D, 0xF0,
  0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFC,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0xBF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0xFE, 0xFC, 0xF0, 0xF0, 0x7F, 0x87,
  0xBC, 0x79, 0xE7, 0x8F, 0x78, 0x7B, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x87,
  0xBC, 0x3C, 0xF1, 0xE3, 0x8F, 0x1E, 0x78, 0x7B, 0xC3, 0xDE, 0x0F, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x37, 0xFC, 0x1F, 0xFB, 0x87, 0xFE, 0xE1, 0xBF, 0xB8,
  0xEF, 0xE7, 0x3B, 0xF9, 0xCC, 0xFE, 0x77, 0x3F, 0x8D, 0xCF, 0xE3, 0xE3,
  0xF8, 0xF8, 0xFE, 0x1E, 0x3F, 0x87, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFE, 0xE1, 0xFD, 0xE3, 0xF9, 0xC7, 0xF3, 0xC7, 0xE3, 0xCF,
  0xC7, 0x9F, 0x87, 0xBF, 0x07, 0x7E, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x1F, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E, 0x78,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70,
  0x0F, 0x78, 0x1E, 0x7C, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x9F, 0xFB, 0x8F, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0xFF, 0xFF, 0xDF,
  0xF3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x7C,
  0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0x38, 0xF9, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x87, 0x9F, 0xF8, 0xFF, 0x87, 0xFC, 0x38, 0xF1, 0xC7, 0x8E, 0x1E,
  0x70, 0x73, 0x83, 0xDC, 0x0F, 0x0F, 0x07, 0xFD, 0xFF, 0x78, 0x6F, 0x01,
  0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x03,
  0xFF, 0xF7, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0xF8, 0xF0, 0x1E, 0xE0,
  0x39, 0xC0, 0x73, 0xC1, 0xE3, 0x83, 0x87, 0x07, 0x0F, 0x1E, 0x0E, 0x38,
  0x1C, 0x70, 0x3D, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0xF7, 0x07, 0xC3, 0x9C,
  0x3F, 0x0E, 0x78, 0xFC, 0x38, 0xE3, 0xF1, 0xE3, 0x8E, 0xE7, 0x0E, 0x73,
  0x9C, 0x3D, 0xCE, 0x70, 0x77, 0x39, 0xC1, 0xDC, 0x7E, 0x07, 0x61, 0xF8,
  0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0xF8,
  0x3E, 0x70, 0x78, 0xF1, 0xE0, 0xF3, 0x80, 0xEF, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3B, 0xC0, 0xF3, 0x83, 0xC7, 0x87,
  0x87, 0x9E, 0x0F, 0x78, 0x0F, 0xF0, 0x3D, 0xE0, 0xE3, 0x87, 0x8F, 0x1C,
  0x1C, 0xF0, 0x7B, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xF0, 0xE0, 0x38,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0xE0, 0x0E, 0x01,
  0xF0, 0x1B, 0x03, 0xB8, 0x31, 0x87, 0x1C, 0x60, 0xCE, 0x0E, 0xC0, 0x70,
  0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0x87, 0x0F, 0x0F, 0xF8, 0xFF, 0x90, 0xF0,
  0x0E, 0x3F, 0xDF, 0xFF, 0xC7, 0xF0, 0xFC, 0x3F, 0xCF, 0xFF, 0xF7, 0xE6,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x71, 0xDF, 0xBF, 0xFF, 0x8F, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE3, 0xFF, 0xFF, 0xFE, 0xEF, 0x80,
  0x0F, 0x8F, 0xF7, 0xFD, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x17, 0xFC, 0xFF, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E,
  0xF3, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0x7F, 0xF7, 0xF7, 0x3E, 0x70, 0x0F, 0x03, 0xFC, 0x7F, 0xE7,
  0x0E, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x7C, 0x63,
  0xFE, 0x1F, 0xE0, 0x07, 0x07, 0xF1, 0xF8, 0xF0, 0x3C, 0x0F, 0xEF, 0xFB,
  0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x00,
  0xF6, 0x1E, 0x7F, 0xE7, 0xFC, 0x04, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x79, 0xDF, 0xBF, 0xFF, 0x8F, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xE0, 0x5F, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x08, 0x71, 0xC7, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xBF, 0xFF, 0x90, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x78, 0xEF, 0x0E, 0xE0, 0xFE,
  0x0F, 0xF0, 0xF7, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC7, 0x87, 0x1F, 0xFB, 0xFB, 0xFF, 0xFF,
  0x78, 0xF8, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F,
  0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1E,
  0xC7, 0x9F, 0xFB, 0xFF, 0xF8, 0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0F,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x0F, 0x7D, 0xE3, 0xFE,
  0x1F, 0x80, 0xE7, 0x1D, 0xFB, 0xFF, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFE, 0x3F, 0xFF, 0xFF, 0xEE, 0xF9, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x8F, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0x7F, 0xF7, 0xFF, 0x3E,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xC7, 0xEF,
  0xFF, 0xFD, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E,
  0x1F, 0xEF, 0xFB, 0x82, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0xFE,
  0x3B, 0xFE, 0xFF, 0x00, 0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x7F, 0x3F, 0x3F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xFF, 0xFF, 0xF7,
  0xEE, 0xF0, 0x7F, 0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0x8F, 0x1C, 0x70, 0xF3,
  0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xF0,
  0xF0, 0xEE, 0x1E, 0x1D, 0xC7, 0xC3, 0xB8, 0xF8, 0xF7, 0x9B, 0x9C, 0x73,
  0x73, 0x8E, 0xE6, 0xF1, 0xDC, 0xDC, 0x1F, 0x9F, 0x83, 0xE3, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0xF0, 0x7B, 0xC7, 0x8E, 0x3C, 0x7B,
  0xC1, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0xC1, 0xEF, 0x0F, 0x3C,
  0xF1, 0xEF, 0x07, 0x80, 0xF0, 0x3F, 0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0x8F,
  0x1C, 0x70, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x08, 0x00, 0xFF,
  0xBF, 0xEF, 0xF8, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0xFC, 0xF0, 0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF8, 0x78,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x0F, 0x1F, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0xF8, 0xF0, 0xC0, 0x78, 0x3F, 0xFF, 0x7F, 0xC1, 0xE0,
};

const GFXglyph NotoSans_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 14, 16, 15, 0, -16 },
  { 44, 11, 18, 13, 1, -17 },
  { 69, 19, 17, 21, 1, -17 },
  { 110, 16, 17, 17, 1, -17 },
  { 144, 4, 6, 6, 1, -16 },
  { 147, 6, 20, 8, 1, -16 },
  { 162, 6, 20, 8, 1, -16 },
  { 177, 11, 10, 12, 1, -17 },
  { 191, 11, 11, 13, 1, -14 },
  { 207, 4, 6, 7, 1, -3 },
  { 210, 6, 3, 7, 1, -8 },
  { 213, 4, 4, 6, 1, -4 },
  { 215, 9, 17, 10, 0, -17 },
  { 235, 11, 17, 13, 1, -17 },
  { 259, 9, 16, 13, 1, -16 },
  { 277, 11, 17, 13, 1, -17 },
  { 301, 11, 17, 13, 1, -17 },
  { 325, 13, 16, 13, 0, -16 },
  { 351, 11, 16, 13, 1, -16 },
  { 373, 11, 17, 13, 1, -17 },
  { 397, 11, 16, 13, 1, -16 },
  { 419, 11, 17, 13, 1, -17 },
  { 443, 11, 17, 13, 1, -17 },
  { 467, 4, 13, 6, 1, -13 },
  { 474, 4, 16, 7, 1, -13 },
  { 482, 11, 12, 13, 1, -14 },
  { 499, 11, 7, 13, 1, -12 },
  { 509, 11, 12, 13, 1, -14 },
  { 526, 10, 17, 11, 0, -17 },
  { 548, 19, 19, 21, 1, -17 },
  { 594, 16, 16, 16, 0, -16 },
  { 626, 12, 16, 15, 2, -16 },
  { 650, 13, 17, 15, 1, -17 },
  { 678, 14, 16, 17, 2, -16 },
  { 706, 10, 16, 13, 2, -16 },
  { 726, 9, 16, 13, 2, -16 },
  { 744, 14, 17, 17, 1, -17 },
  { 774, 14, 16, 18, 2, -16 },
  { 802, 7, 16, 9, 1, -16 },
  { 816, 8, 21, 8, -2, -16 },
  { 837, 13, 16, 15, 2, -16 },
  { 863, 10, 16, 13, 2, -16 },
  { 883, 18, 16, 22, 2, -16 },
  { 919, 15, 16, 19, 2, -16 },
  { 949, 16, 17, 18, 1, -17 },
  { 983, 11, 16, 14, 2, -16 },
  { 1005, 16, 21, 18, 1, -17 },
  { 1047, 13, 16, 15, 2, -16 },
  { 1073, 11, 17, 13, 1, -17 },
  { 1097, 13, 16, 13, 0, -16 },
  { 1123, 13, 16, 17, 2, -16 },
  { 1149, 15, 16, 15, 0, -16 },
  { 1179, 22, 16, 22, 0, -16 },
  { 1223, 15, 16, 15, 0, -16 },
  { 1253, 14, 16, 14, 0, -16 },
  { 1281, 12, 16, 13, 1, -16 },
  { 1305, 5, 20, 8, 2, -16 },
  { 1318, 9, 17, 10, 0, -17 },
  { 1338, 5, 20, 8, 1, -16 },
  { 1351, 12, 11, 13, 1, -17 },
  { 1368, 10, 2, 9, 0, 2 },
  { 1371, 6, 4, 8, 1, -18 },
  { 1374, 11, 13, 14, 1, -13 },
  { 1392, 11, 17, 15, 2, -17 },
  { 1416, 10, 13, 12, 1, -13 },
  { 1433, 12, 17, 15, 1, -17 },
  { 1459, 12, 13, 14, 1, -13 },
  { 1479, 10, 18, 9, 0, -18 },
  { 1502, 12, 19, 15, 1, -13 },
  { 1531, 11, 17, 15, 2, -17 },
  { 1555, 3, 18, 7, 2, -18 },
  { 1562, 6, 24, 7, -1, -18 },
  { 1580, 12, 17, 14, 2, -17 },
  { 1606, 3, 17, 7, 2, -17 },
  { 1613, 19, 13, 22, 2, -13 },
  { 1644, 11, 13, 15, 2, -13 },
  { 1662, 12, 13, 14, 1, -13 },
  { 1682, 11, 19, 15, 2, -13 },
  { 1709, 12, 19, 15, 1, -13 },
  { 1738, 8, 13, 10, 2, -13 },
  { 1751, 10, 13, 12, 1, -13 },
  { 1768, 8, 15, 10, 1, -15 },
  { 1783, 11, 13, 15, 2, -13 },
  { 1801, 13, 13, 13, 0, -13 },
  { 1823, 19, 13, 20, 0, -13 },
  { 1854, 13, 13, 13, 0, -13 },
  { 1876, 13, 19, 13, 0, -13 },
  { 1907, 10, 13, 11, 1, -13 },
  { 1924, 8, 20, 9, 0, -16 },
  { 1944, 3, 22, 13, 5, -17 },
  { 1953, 8, 20, 9, 1, -16 },
  { 1973, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_Bold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold23pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_BOLD23PT7B_H_
