#ifndef _NOTOSANS_BOLD57PT7B_H_
#define _NOTOSANS_BOLD57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Bold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Bold57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x7F, 0x87, 0x80, 0xFF, 0x87, 0xFB, 0xFC, 0x3F, 0xDF,
  0xE1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFC, 0xF0, 0x7C, 0x7F, 0x8F, 0x00, 0x8F, 0xF8, 0xF0, 0x00, 0xFF,
  0x8F, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x7F, 0xEF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF7, 0xFF,
  0x00, 0x0F, 0x1F, 0xF0, 0x00, 0xF0, 0xFF, 0x00, 0x0F, 0x0F, 0xF4, 0x00,
  0xF0, 0xFF, 0x70, 0x0F, 0x1F, 0xF7, 0xF0, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7F, 0xE0, 0x7E, 0x1F, 0xC7, 0xF1, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xE7, 0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x0F, 0xFE, 0x1F,
  0x87, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x87, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0x3F, 0xF7, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x3F, 0xF0, 0x07,
  0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xFC, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x00, 0xF8,
  0x02, 0xFC, 0x1F, 0x07, 0xDF, 0xF3, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7F, 0x87, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x01,
  0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF,
  0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF,
  0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x3F,
  0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0xFF, 0x9F, 0xF3, 0xF8, 0xFF, 0x8F, 0x87, 0xFC, 0x70,
  0x3F, 0xE1, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFC, 0x0F, 0xFC, 0x1F, 0x80, 0x3F, 0xE0, 0xF0, 0x00, 0xFF, 0x03, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0xFE, 0x1C, 0x00, 0x3F, 0xE0, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0xFF,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0xEF, 0xF8,
  0x00, 0x3F, 0x9F, 0xF0, 0x00, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0xC0,
  0x07, 0xF0, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0x00, 0x3F, 0x83, 0xFE, 0x00,
  0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x1F,
  0xC0, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xDE, 0x00, 0x1F, 0xFB, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE1, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0x07, 0xF9, 0xFF, 0xFC,
  0x3F, 0xDF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFC, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xCF,
  0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x14, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07,
  0xF8, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFD, 0xFE, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xCF,
  0xF0, 0x3F, 0xFC, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x04, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0C, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7F, 0x9F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x1E, 0x00, 0x06, 0x03, 0xF8,
  0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0xDF, 0xF9, 0xFE, 0x3F, 0xC1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x9F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x18,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x08, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xFF, 0xC1, 0xFC, 0x3F,
  0x80, 0x7F, 0xFF, 0xC3, 0xF0, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0x9F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7E, 0x7E, 0x07,
  0xF8, 0x1F, 0xC1, 0xFB, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xEF, 0xE0, 0xFE,
  0x01, 0xF8, 0x1F, 0xBF, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0,
  0x1F, 0x81, 0xFF, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xEF, 0xC1, 0xF8, 0x01,
  0xF8, 0x1F, 0xBF, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0x80, 0x3F,
  0x81, 0xFB, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xEF, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0xBF, 0x07, 0xF0, 0x1F, 0xE0, 0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0xC7,
  0xF3, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x1F, 0x81, 0xFF, 0xFD, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xE3, 0xFF, 0x81,
  0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xC0, 0x03, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF,
  0x81, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0x18, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x04, 0x1F, 0xFE, 0x00,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x34, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFE, 0x3F,
  0xE0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x3F,
  0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xF8, 0x1F, 0xFE, 0x00, 0x06, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00,
  0x7F, 0xC7, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xA0, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xE0, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC7,
  0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFE, 0x00,
  0x07, 0xEF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0xFE, 0x7F, 0x00, 0x0F,
  0xEF, 0xFF, 0xF7, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0x7F, 0x00, 0x1F, 0xCF,
  0xFF, 0xF3, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0x3F, 0x80, 0x1F, 0x8F, 0xFF,
  0xF3, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0x8F, 0xFF, 0xF1,
  0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xFF, 0xF1, 0xFC,
  0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x0F, 0xC0,
  0xFF, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC0, 0xFF,
  0xFF, 0x03, 0xF9, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFF,
  0x03, 0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0x80,
  0x0F, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xE7,
  0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xF1, 0xFF, 0x00, 0xFF,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0x0F, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F,
  0xFF, 0x00, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0x00, 0x7F,
  0xC7, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0xF0,
  0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFE,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFE, 0xFF, 0x80,
  0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFA, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0x80,
  0xFC, 0xFF, 0x80, 0x07, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x3F,
  0xF8, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x1F,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xF8, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF7, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0x8F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x00,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1,
  0xFC, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x00,
  0x1F, 0xEF, 0xE0, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xDF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0x03, 0xFF, 0x02, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x0F,
  0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x07,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF3,
  0xFF, 0xFE, 0x7F, 0x1F, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0x3F, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xC0, 0x0F, 0xF8, 0xFF,
  0xE0, 0x7F, 0xCF, 0xFF, 0x83, 0xFE, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFF, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0x3F, 0x83,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0xFC, 0x7F, 0xE0, 0x04, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x02, 0x7F, 0xE0, 0x07,
  0x3F, 0xFE, 0x3F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x78, 0x1F, 0xF0, 0x3F, 0xF8,
  0xFF, 0x83, 0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0xBF, 0xE3, 0xFF, 0xFE, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xFE, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F,
  0xF7, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE7, 0xF8, 0x3F, 0xFE, 0x1F, 0xC0, 0x7F,
  0xC0, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x63, 0xFF, 0x80,
  0x3E, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFE, 0x0C, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1,
  0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0xC3, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0x10,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF4, 0x00, 0x01, 0xFF, 0x38, 0x00, 0x1F, 0xF9, 0xFC, 0x03, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x5F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xE0, 0x0F, 0xF8, 0xFF, 0xF0,
  0x7F, 0xCF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x1F, 0xFD, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFE, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xDF, 0xF0,
  0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xE7, 0xFE,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x07,
  0xF0, 0x7F, 0xF8, 0x3F, 0x87, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0xCF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x01,
  0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0x7F, 0xF0, 0x3F, 0xC7, 0xFF, 0xC1, 0xFE, 0x7F, 0xFF, 0x0F, 0xF7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFE, 0x0F,
  0xFE, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF,
  0xE0, 0x3F, 0xF7, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xDF, 0xFF, 0xC3, 0xFE, 0x7F, 0xFC,
  0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x80, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF,
  0x7F, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0,
  0x1F, 0xFB, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0xF0, 0x3F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0x7F, 0xBF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFE, 0x17, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xF0, 0xFE, 0x7F, 0x80, 0x1C, 0xFF, 0x00, 0x09, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x01, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF9, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF1, 0xFF,
  0xFF, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0x06, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x7E, 0x03, 0xFC, 0x3F, 0xC0, 0x7E, 0xFC,
  0x07, 0xF8, 0x7F, 0xC1, 0xFD, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xF3, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xC7, 0xE1,
  0xFF, 0x03, 0xFE, 0x3F, 0x8F, 0xC3, 0xFC, 0x03, 0xFC, 0x7E, 0x1F, 0xC7,
  0xF8, 0x07, 0xF8, 0xFC, 0x1F, 0x8F, 0xF0, 0x0F, 0xF1, 0xF8, 0x3F, 0x1F,
  0xC0, 0x0F, 0xE7, 0xF0, 0x7E, 0x7F, 0x80, 0x1F, 0xEF, 0xC0, 0xFE, 0xFF,
  0x00, 0x3F, 0xDF, 0x81, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0x01, 0xFB, 0xF8,
  0x00, 0x7F, 0x7E, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x07, 0xEF, 0xE0,
  0x01, 0xFD, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x11, 0xFF, 0xC0, 0x01, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0xC0, 0x01, 0xFF, 0xC8, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_Bold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 42, 16, 3, -41 },
  { 54, 21, 15, 27, 3, -41 },
  { 94, 35, 41, 37, 1, -41 },
  { 274, 28, 46, 33, 2, -43 },
  { 435, 48, 42, 51, 2, -41 },
  { 687, 41, 42, 43, 2, -41 },
  { 903, 9, 15, 15, 3, -41 },
  { 920, 16, 50, 19, 2, -41 },
  { 1020, 15, 50, 19, 2, -41 },
  { 1114, 27, 26, 31, 2, -43 },
  { 1202, 28, 28, 33, 2, -34 },
  { 1300, 11, 14, 16, 2, -7 },
  { 1320, 15, 7, 18, 2, -19 },
  { 1334, 10, 10, 16, 3, -9 },
  { 1347, 23, 41, 24, 0, -41 },
  { 1465, 29, 42, 33, 2, -41 },
  { 1618, 21, 41, 33, 3, -41 },
  { 1726, 29, 41, 33, 2, -41 },
  { 1875, 28, 42, 33, 2, -41 },
  { 2022, 31, 41, 33, 1, -41 },
  { 2181, 27, 42, 33, 3, -41 },
  { 2323, 29, 42, 33, 2, -41 },
  { 2476, 29, 41, 33, 2, -41 },
  { 2625, 29, 42, 33, 2, -41 },
  { 2778, 29, 42, 33, 2, -41 },
  { 2931, 10, 33, 16, 3, -32 },
  { 2973, 11, 39, 16, 2, -32 },
  { 3027, 28, 30, 33, 2, -36 },
  { 3132, 28, 17, 33, 2, -29 },
  { 3192, 28, 30, 33, 2, -36 },
  { 3297, 26, 42, 27, 0, -41 },
  { 3434, 46, 46, 51, 3, -41 },
  { 3699, 39, 41, 39, 0, -41 },
  { 3899, 30, 41, 38, 5, -41 },
  { 4053, 32, 42, 37, 3, -41 },
  { 4221, 34, 41, 42, 5, -41 },
  { 4396, 24, 41, 32, 5, -41 },
  { 4519, 23, 41, 31, 5, -41 },
  { 4637, 34, 42, 41, 3, -41 },
  { 4816, 33, 41, 44, 5, -41 },
  { 4986, 18, 41, 22, 2, -41 },
  { 5079, 18, 53, 19, -4, -41 },
  { 5199, 33, 41, 38, 5, -41 },
  { 5369, 25, 41, 32, 5, -41 },
  { 5498, 44, 41, 54, 5, -41 },
  { 5724, 36, 41, 46, 5, -41 },
  { 5909, 39, 42, 45, 3, -41 },
  { 6114, 28, 41, 35, 5, -41 },
  { 6258, 39, 51, 45, 3, -41 },
  { 6507, 32, 41, 37, 5, -41 },
  { 6671, 26, 42, 31, 3, -41 },
  { 6808, 31, 41, 33, 1, -41 },
  { 6967, 33, 42, 43, 5, -41 },
  { 7141, 37, 41, 37, 0, -41 },
  { 7331, 55, 41, 55, 0, -41 },
  { 7613, 38, 41, 38, 0, -41 },
  { 7808, 36, 41, 36, 0, -41 },
  { 7993, 31, 41, 33, 1, -41 },
  { 8152, 13, 50, 19, 4, -41 },
  { 8234, 23, 41, 24, 0, -41 },
  { 8352, 14, 50, 19, 1, -41 },
  { 8440, 30, 27, 33, 1, -41 },
  { 8542, 24, 4, 23, 0, 5 },
  { 8554, 17, 9, 21, 2, -44 },
  { 8574, 28, 33, 34, 2, -32 },
  { 8690, 29, 44, 36, 4, -43 },
  { 8850, 25, 33, 29, 3, -32 },
  { 8954, 29, 44, 36, 3, -43 },
  { 9114, 28, 33, 34, 3, -32 },
  { 9230, 24, 44, 22, 1, -44 },
  { 9362, 29, 46, 36, 3, -32 },
  { 9529, 29, 43, 37, 4, -43 },
  { 9685, 9, 43, 17, 4, -43 },
  { 9734, 16, 57, 17, -3, -43 },
  { 9848, 31, 43, 35, 4, -43 },
  { 10015, 9, 43, 17, 4, -43 },
  { 10064, 48, 32, 56, 4, -32 },
  { 10256, 29, 32, 37, 4, -32 },
  { 10372, 30, 33, 36, 3, -32 },
  { 10496, 29, 46, 36, 4, -32 },
  { 10663, 29, 46, 36, 3, -32 },
  { 10830, 21, 32, 25, 4, -32 },
  { 10914, 23, 33, 29, 3, -32 },
  { 11009, 22, 39, 25, 1, -38 },
  { 11117, 29, 32, 37, 4, -31 },
  { 11233, 33, 31, 33, 0, -31 },
  { 11361, 47, 31, 49, 1, -31 },
  { 11544, 33, 31, 33, 0, -31 },
  { 11672, 33, 45, 33, 0, -31 },
  { 11858, 24, 31, 28, 2, -31 },
  { 11951, 19, 50, 22, 1, -41 },
  { 12070, 6, 56, 31, 13, -43 },
  { 12112, 20, 50, 22, 2, -41 },
  { 12237, 28, 10, 33, 2, -25 },
};

const GFXfont NotoSans_Bold57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Bold57pt7bBitmaps,
  (GFXglyph *)NotoSans_Bold57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_BOLD57PT7B_H_
