#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x30,
  0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0x41, 0x03, 0x0C, 0x0C, 0x30,
  0x30, 0xC0, 0xC2, 0x02, 0x08, 0x08, 0x20, 0x61, 0x81, 0x86, 0x04, 0x10,
  0x10, 0x40, 0x43, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x10, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x38, 0xC1, 0xC0, 0x18, 0x30, 0x20, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x04, 0x06,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x20, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x27, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x08,
  0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x10, 0x30, 0x08, 0x0C, 0x38, 0x03, 0xE3, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x30, 0x07, 0x70, 0x00, 0x80, 0x30, 0xC0, 0x06, 0x01, 0x81,
  0x80, 0x10, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x08,
  0x03, 0x00, 0x40, 0x60, 0x0C, 0x01, 0x01, 0x00, 0x20, 0x0C, 0x0C, 0x01,
  0x80, 0x30, 0x20, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x03, 0x04, 0x00, 0x60,
  0x0C, 0x30, 0x01, 0x00, 0x60, 0x80, 0x0C, 0x01, 0x86, 0x00, 0x30, 0x06,
  0x10, 0x10, 0xC0, 0x10, 0xC3, 0xF3, 0x00, 0xC2, 0x1C, 0x6C, 0x03, 0x18,
  0xE1, 0xB0, 0x18, 0x43, 0x02, 0xC0, 0x63, 0x18, 0x0F, 0x03, 0x0C, 0x60,
  0x3C, 0x0C, 0x63, 0x00, 0xD8, 0x61, 0x8C, 0x03, 0x77, 0x0C, 0x60, 0x0C,
  0xF8, 0x31, 0x80, 0x20, 0x01, 0x86, 0x01, 0x80, 0x06, 0x10, 0x06, 0x00,
  0x30, 0xC0, 0x18, 0x00, 0xC3, 0x00, 0x60, 0x06, 0x0C, 0x01, 0x80, 0x18,
  0x30, 0x06, 0x00, 0xC0, 0x80, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x18, 0x18,
  0x03, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x01, 0x80, 0xC0,
  0x30, 0x06, 0x06, 0x01, 0x80, 0x18, 0x30, 0x06, 0x00, 0x31, 0xC0, 0x30,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x60,
  0x06, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00,
  0x19, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x39, 0x80, 0x01, 0xC2, 0x00,
  0x06, 0x0C, 0x04, 0x30, 0x30, 0x21, 0x80, 0xC1, 0x86, 0x01, 0x06, 0x30,
  0x06, 0x18, 0xC0, 0x18, 0xC6, 0x00, 0x63, 0x18, 0x00, 0x8C, 0x60, 0x03,
  0x61, 0x00, 0x0D, 0x8C, 0x00, 0x34, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xA0, 0xE0, 0x06, 0xC1, 0x80,
  0x33, 0x07, 0x01, 0x8C, 0x0E, 0x1C, 0x10, 0x1F, 0xE0, 0x60, 0x1E, 0x00,
  0x00, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0x86,
  0x10, 0x43, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x0C, 0x0C, 0x03,
  0x04, 0x00, 0x62, 0x02, 0x0D, 0x1F, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0xB0,
  0x00, 0x88, 0x01, 0x86, 0x01, 0x81, 0x03, 0x80, 0xC0, 0x80, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x20, 0x40, 0xC0, 0xFF, 0xFC, 0x4F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x40,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x04, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00, 0x0E, 0x18,
  0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0xF0,
  0x3B, 0x07, 0x20, 0xE6, 0x18, 0x63, 0x06, 0x60, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0E, 0x01, 0x80, 0x04, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xEF, 0x80, 0x03, 0x80, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x08, 0x00, 0x70, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x20, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x10, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x70, 0x03, 0x80, 0x78, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xEE, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x18, 0xFF, 0x00, 0x11, 0xC3,
  0x80, 0x33, 0x00, 0xC0, 0x36, 0x00, 0x60, 0x3C, 0x00, 0x60, 0x38, 0x00,
  0x20, 0x38, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0x60, 0x40, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x40, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x60, 0x60, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x02, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3D, 0xE0, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x40, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC1,
  0x00, 0x01, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x3C, 0x18,
  0x00, 0xF0, 0x18, 0x03, 0x60, 0x18, 0x0C, 0xC0, 0x3F, 0xF1, 0x80, 0x1F,
  0x86, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x40, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x60, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41,
  0x80, 0x1F, 0x00, 0x86, 0x00, 0x7F, 0x81, 0x0C, 0x01, 0x86, 0x02, 0x10,
  0x06, 0x0C, 0x0C, 0x60, 0x18, 0x18, 0x18, 0xC0, 0x60, 0x30, 0x31, 0x00,
  0xC0, 0xC0, 0x66, 0x03, 0x01, 0x80, 0xCC, 0x06, 0x03, 0x01, 0x98, 0x18,
  0x06, 0x03, 0x60, 0x30, 0x18, 0x04, 0xC0, 0x40, 0x30, 0x19, 0x81, 0x80,
  0x60, 0x33, 0x03, 0x00, 0xC0, 0x66, 0x06, 0x03, 0x00, 0xC8, 0x08, 0x06,
  0x03, 0x30, 0x30, 0x0C, 0x06, 0x60, 0x60, 0x38, 0x0C, 0xC0, 0xC0, 0x60,
  0x31, 0x81, 0x80, 0xC0, 0x63, 0x03, 0x03, 0x80, 0x86, 0x06, 0x07, 0x03,
  0x0C, 0x0C, 0x1E, 0x04, 0x18, 0x18, 0x34, 0x18, 0x30, 0x38, 0xC8, 0x60,
  0x60, 0x3B, 0x1F, 0x80, 0xC0, 0x3C, 0x1E, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41, 0x80, 0x01,
  0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x02, 0xE0, 0x00, 0x04,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x01, 0xE0, 0x00, 0xC0,
  0x1C, 0x00, 0x20, 0x03, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x60, 0x08, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x10,
  0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x30, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x06, 0x07, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08,
  0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xE7, 0xC0, 0x03,
  0x80, 0x20, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xC0, 0xF0, 0x00, 0x18, 0x03, 0x80, 0x02, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0,
  0x08, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x10,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x0C, 0x00, 0x80, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x1E, 0x00, 0x10, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFF,
  0x06, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x00, 0x60, 0x02,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x20, 0x03, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x02, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x06, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x60, 0x02, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x04,
  0x38, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x27, 0x80, 0x00, 0x06, 0x58, 0x00, 0x00,
  0x6C, 0x80, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x08, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30, 0x01, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x02, 0x80, 0x00, 0x00, 0xF0, 0x03, 0x40,
  0x00, 0x00, 0x78, 0x01, 0xA0, 0x00, 0x00, 0x6C, 0x00, 0xD0, 0x00, 0x00,
  0x34, 0x00, 0x68, 0x00, 0x00, 0x36, 0x00, 0x26, 0x00, 0x00, 0x1B, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x80, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x0C, 0xC0,
  0x00, 0x0C, 0x40, 0x04, 0x60, 0x00, 0x06, 0x60, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x03, 0x18, 0x00, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x03, 0x08, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x00, 0x60,
  0x80, 0x0C, 0x10, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x00, 0x30, 0x60, 0x06,
  0x04, 0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x18, 0x18, 0x01, 0x81, 0x00,
  0x08, 0x08, 0x00, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x04, 0x06,
  0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x00, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0xC0, 0x10,
  0x01, 0x80, 0x60, 0x60, 0x18, 0x00, 0x80, 0x30, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x30, 0x03, 0x00, 0x30, 0x06, 0x18,
  0x01, 0x00, 0x18, 0x03, 0x18, 0x01, 0x80, 0x08, 0x00, 0x8C, 0x00, 0xC0,
  0x0C, 0x00, 0x4C, 0x00, 0x60, 0x06, 0x00, 0x26, 0x00, 0x30, 0x03, 0x00,
  0x1E, 0x00, 0x30, 0x01, 0x00, 0x0F, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x28, 0x00, 0x02, 0x00, 0x6C, 0x00, 0x06, 0x00, 0x6C, 0x00, 0x06,
  0x00, 0x6C, 0x00, 0x06, 0x00, 0x6C, 0x00, 0x06, 0x00, 0x44, 0x00, 0x04,
  0x00, 0xC6, 0x00, 0x0C, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0xC6, 0x00, 0x0C,
  0x00, 0xC6, 0x00, 0x0C, 0x01, 0x82, 0x00, 0x18, 0x01, 0x83, 0x00, 0x18,
  0x01, 0x83, 0x00, 0x18, 0x01, 0x83, 0x00, 0x18, 0x01, 0x03, 0x00, 0x10,
  0x03, 0x03, 0x00, 0x30, 0x03, 0x01, 0x00, 0x30, 0x03, 0x01, 0x80, 0x30,
  0x03, 0x01, 0x80, 0x30, 0x02, 0x01, 0x80, 0x20, 0x06, 0x01, 0x80, 0x60,
  0x06, 0x00, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x00, 0x40, 0xC0, 0x08, 0x00, 0x60, 0x80, 0x18, 0x00, 0x61, 0x80,
  0x18, 0x00, 0x61, 0x80, 0x18, 0x00, 0x61, 0x80, 0x18, 0x00, 0x21, 0x80,
  0x10, 0x00, 0x31, 0x00, 0x30, 0x00, 0x33, 0x00, 0x30, 0x00, 0x33, 0x00,
  0x30, 0x00, 0x33, 0x00, 0x30, 0x00, 0x33, 0x00, 0x20, 0x00, 0x12, 0x00,
  0x60, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x1E, 0x00,
  0x60, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x0E, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0C, 0x0F, 0x00, 0x06,
  0x01, 0xC0, 0x02, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x04, 0x00, 0x70, 0x06, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x02, 0x06, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0C, 0x0F, 0x00, 0x06,
  0x01, 0xC0, 0x02, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x02, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x04,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xC1, 0x80, 0x00, 0x40, 0x40, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x00, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x08, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x04,
  0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x20, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00,
  0xE0, 0x07, 0x80, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x10, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10,
  0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x04,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x48, 0x00, 0x01, 0x90, 0x00, 0x03, 0x20, 0x00, 0x0C,
  0x40, 0x00, 0x18, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x84,
  0x00, 0x06, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x20, 0x00, 0x60, 0x40,
  0x01, 0x80, 0x80, 0x03, 0x01, 0x00, 0x06, 0x02, 0x00, 0x18, 0x04, 0x00,
  0x30, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x00,
  0x08, 0x06, 0x00, 0x10, 0x18, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60, 0x00,
  0x81, 0x80, 0x01, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08,
  0x20, 0x00, 0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0x46, 0x00, 0x00, 0x8C,
  0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xA0, 0x00, 0x0E, 0x00, 0x01, 0x90,
  0x00, 0x07, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x80, 0x00, 0xC4, 0x00, 0x03,
  0xC0, 0x00, 0x62, 0x00, 0x01, 0x60, 0x00, 0x31, 0x00, 0x01, 0xA0, 0x00,
  0x30, 0x80, 0x00, 0xD0, 0x00, 0x18, 0x40, 0x00, 0x48, 0x00, 0x18, 0x20,
  0x00, 0x64, 0x00, 0x0C, 0x10, 0x00, 0x32, 0x00, 0x06, 0x08, 0x00, 0x11,
  0x00, 0x06, 0x04, 0x00, 0x18, 0x80, 0x03, 0x02, 0x00, 0x08, 0x40, 0x03,
  0x03, 0x00, 0x0C, 0x20, 0x01, 0x81, 0x80, 0x06, 0x10, 0x00, 0xC0, 0xC0,
  0x02, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x86,
  0x00, 0x60, 0x18, 0x01, 0x83, 0x00, 0x30, 0x0C, 0x00, 0xC1, 0x80, 0x10,
  0x06, 0x00, 0x40, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x00, 0x60, 0x18, 0x0C,
  0x02, 0x00, 0x30, 0x08, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x0C, 0x06, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x60, 0x40, 0x01, 0x81, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x03, 0x08, 0x00, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x86, 0x00, 0x03, 0x18, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x23,
  0x00, 0x00, 0xCC, 0x00, 0x11, 0x00, 0x00, 0x66, 0x00, 0x09, 0x80, 0x00,
  0x36, 0x00, 0x04, 0xC0, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0x0D, 0x00,
  0x01, 0x60, 0x00, 0x07, 0x80, 0x01, 0xA0, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x10, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x08, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x19, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x04, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x23, 0x00, 0x01,
  0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x26, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x43, 0x00, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x06,
  0x18, 0x20, 0xC1, 0x06, 0x08, 0x10, 0x40, 0x00, 0x3F, 0xC2, 0x00, 0xF3,
  0xCC, 0x03, 0x01, 0x98, 0x0C, 0x01, 0xA0, 0x30, 0x03, 0x40, 0xC0, 0x03,
  0x81, 0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x41, 0x80,
  0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x07,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x01, 0xE0,
  0x20, 0x02, 0xC0, 0x60, 0x09, 0x00, 0xE0, 0x32, 0x00, 0xE1, 0xCC, 0x00,
  0xFF, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC7, 0xF0, 0x00, 0x8E, 0x38,
  0x01, 0x98, 0x0C, 0x01, 0xB0, 0x06, 0x01, 0xE0, 0x06, 0x01, 0xC0, 0x06,
  0x01, 0xC0, 0x06, 0x03, 0x80, 0x02, 0x03, 0x80, 0x02, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x60, 0x38, 0x00, 0x60,
  0x38, 0x00, 0xC0, 0x78, 0x00, 0xC0, 0x6C, 0x01, 0x80, 0x4C, 0x03, 0x00,
  0x47, 0x0E, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x1C, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x81, 0x00, 0x7F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x3F, 0xC6, 0x00, 0x1E, 0x79, 0x80, 0x0C, 0x06, 0x60, 0x06,
  0x00, 0xD0, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x70, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x0C, 0x00, 0x78, 0x01, 0x00, 0x36, 0x00, 0x60, 0x09, 0x00,
  0x1C, 0x06, 0x40, 0x03, 0x87, 0x30, 0x00, 0x7F, 0x8C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x38, 0x07, 0x03, 0x80, 0xC0, 0x30,
  0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x40, 0x06, 0x18,
  0x01, 0x83, 0x00, 0xE0, 0x60, 0x78, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x80, 0xE0,
  0x70, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x40, 0x03, 0xCF, 0x30, 0x01, 0x80, 0xCC, 0x00, 0xC0, 0x1A, 0x00, 0x60,
  0x06, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x20,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03,
  0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x01, 0x80,
  0x0F, 0x00, 0x20, 0x06, 0x80, 0x0C, 0x01, 0x20, 0x03, 0x00, 0xD8, 0x00,
  0x70, 0xE6, 0x00, 0x0F, 0xF1, 0x80, 0x00, 0xE0, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x20, 0x06, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC7, 0xF0, 0x02, 0x78, 0xE0,
  0x0B, 0x80, 0xC0, 0x6C, 0x03, 0x01, 0xE0, 0x0C, 0x07, 0x00, 0x30, 0x1C,
  0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x20, 0x20, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x09, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0E,
  0x01, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x40, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xD8, 0x00, 0x1B, 0x30,
  0x00, 0x36, 0x60, 0x00, 0x78, 0xC0, 0x00, 0xE1, 0x80, 0x03, 0x81, 0x00,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x20, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x04, 0x01, 0x00,
  0x08, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x87, 0xF0, 0x7F, 0x80, 0x13,
  0x87, 0x1C, 0x78, 0x06, 0xC0, 0x66, 0x03, 0x00, 0xD0, 0x05, 0x80, 0x30,
  0x1C, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0x18, 0x1C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x00, 0x08, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x60,
  0x01, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x20,
  0x30, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x01, 0x81, 0x80, 0x06, 0x00,
  0x30, 0x30, 0x00, 0x80, 0x06, 0x06, 0x00, 0x30, 0x00, 0x80, 0x80, 0x06,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x10, 0x00, 0xC0, 0xC0,
  0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0xC0, 0x03, 0x00, 0x18, 0x18, 0x00, 0x40, 0x03, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x60, 0x03, 0x00, 0x18, 0x08, 0x00, 0x60, 0x03, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x60, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x01, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x87, 0xF0, 0x02,
  0x78, 0xE0, 0x1B, 0x80, 0xC0, 0x6C, 0x03, 0x01, 0xE0, 0x0C, 0x05, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xC0, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x04, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x00,
  0x3F, 0x80, 0x07, 0x8E, 0x00, 0x70, 0x18, 0x07, 0x00, 0xE0, 0x30, 0x03,
  0x03, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x02, 0x0C, 0x00, 0x10, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0x60,
  0x0C, 0x03, 0x80, 0xC0, 0x0E, 0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x10, 0xFE, 0x00, 0x02, 0x38, 0xE0, 0x00, 0x4C, 0x06, 0x00,
  0x1B, 0x00, 0x60, 0x03, 0x40, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x0A, 0x00,
  0x10, 0x03, 0xC0, 0x02, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x18,
  0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00,
  0x70, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x68, 0x01,
  0xC0, 0x0D, 0x00, 0x30, 0x01, 0xB0, 0x1C, 0x00, 0x33, 0x07, 0x00, 0x04,
  0x3F, 0xC0, 0x01, 0x81, 0x80, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x82,
  0x00, 0xF3, 0xCC, 0x03, 0x01, 0x98, 0x0C, 0x01, 0xA0, 0x30, 0x03, 0x40,
  0xC0, 0x03, 0x81, 0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x41, 0x80, 0x00, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30,
  0x01, 0xE0, 0x20, 0x06, 0xC0, 0x60, 0x0D, 0x00, 0xE0, 0x36, 0x00, 0xE1,
  0xCC, 0x00, 0xFF, 0x18, 0x00, 0x70, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x87, 0xE0, 0x11, 0xC4, 0x06, 0x60, 0x00, 0xD8,
  0x00, 0x1E, 0x00, 0x02, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x0F, 0x01, 0x80,
  0x30, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x08, 0x01, 0x80, 0xE0, 0x70, 0x0F, 0xFE, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0xFF, 0xC7, 0xFC, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60,
  0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x02, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00,
  0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x20, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x07,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x1E, 0x03,
  0x00, 0xD8, 0x06, 0x0E, 0x40, 0x0F, 0xF1, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x40,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xB0, 0x00, 0xE0, 0x06, 0xC0,
  0x07, 0x80, 0x1B, 0x00, 0x16, 0x00, 0x4C, 0x00, 0xD8, 0x03, 0x30, 0x03,
  0x60, 0x08, 0xC0, 0x19, 0x80, 0x63, 0x00, 0x66, 0x01, 0x8C, 0x01, 0x18,
  0x04, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x31, 0x00, 0xC3, 0x01, 0x84, 0x06,
  0x0C, 0x06, 0x10, 0x18, 0x30, 0x10, 0x40, 0x40, 0xC0, 0xC1, 0x03, 0x03,
  0x03, 0x04, 0x0C, 0x0C, 0x18, 0x10, 0x20, 0x30, 0x60, 0x41, 0x80, 0xC1,
  0x01, 0x04, 0x03, 0x0C, 0x04, 0x30, 0x0C, 0x20, 0x10, 0xC0, 0x31, 0x80,
  0x42, 0x00, 0xC6, 0x01, 0x18, 0x03, 0x30, 0x04, 0x40, 0x0C, 0xC0, 0x13,
  0x00, 0x32, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0x20, 0x03, 0x60, 0x05, 0x80,
  0x0D, 0x00, 0x14, 0x00, 0x3C, 0x00, 0x50, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x20, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x18,
  0x00, 0x01, 0x18, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x03, 0x20, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x60, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x10, 0x02, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0,
  0x05, 0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3C,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 49, 14, 1, -49 },
  { 81, 14, 18, 17, 6, -49 },
  { 113, 26, 49, 25, 0, -49 },
  { 273, 26, 56, 23, -1, -52 },
  { 455, 30, 50, 35, 3, -49 },
  { 643, 22, 50, 22, -1, -49 },
  { 781, 6, 18, 10, 6, -49 },
  { 795, 18, 59, 16, 2, -48 },
  { 928, 19, 59, 16, -5, -48 },
  { 1069, 17, 18, 22, 8, -51 },
  { 1108, 23, 32, 27, 2, -40 },
  { 1200, 8, 15, 11, -3, -6 },
  { 1215, 14, 1, 18, 2, -19 },
  { 1217, 3, 5, 10, 1, -5 },
  { 1219, 27, 48, 20, -3, -48 },
  { 1381, 22, 50, 23, 1, -49 },
  { 1519, 12, 49, 23, 7, -49 },
  { 1593, 25, 49, 23, -2, -49 },
  { 1747, 26, 50, 23, -2, -49 },
  { 1910, 25, 49, 23, -1, -49 },
  { 2064, 26, 50, 23, -2, -49 },
  { 2227, 24, 50, 23, 1, -49 },
  { 2377, 23, 49, 23, 3, -49 },
  { 2518, 25, 50, 23, -1, -49 },
  { 2675, 23, 50, 23, 0, -49 },
  { 2819, 10, 36, 10, 0, -36 },
  { 2864, 13, 45, 11, -3, -36 },
  { 2938, 23, 28, 27, 2, -38 },
  { 3019, 23, 16, 27, 2, -32 },
  { 3065, 23, 28, 27, 2, -38 },
  { 3146, 18, 49, 16, 1, -49 },
  { 3257, 31, 55, 35, 2, -49 },
  { 3471, 23, 49, 22, -5, -49 },
  { 3612, 26, 49, 25, 0, -49 },
  { 3772, 25, 50, 23, 3, -49 },
  { 3929, 27, 49, 28, 0, -49 },
  { 4095, 26, 49, 23, 0, -49 },
  { 4255, 26, 49, 21, 0, -49 },
  { 4415, 30, 50, 31, 2, -49 },
  { 4603, 31, 49, 30, 0, -49 },
  { 4793, 20, 49, 11, -4, -49 },
  { 4916, 22, 61, 10, -10, -49 },
  { 5084, 28, 49, 24, 0, -49 },
  { 5256, 15, 49, 21, 0, -49 },
  { 5348, 41, 49, 40, 0, -49 },
  { 5600, 32, 49, 31, 0, -49 },
  { 5796, 27, 50, 30, 2, -49 },
  { 5965, 25, 49, 24, 0, -49 },
  { 6119, 27, 61, 30, 2, -49 },
  { 6325, 25, 49, 24, 0, -49 },
  { 6479, 27, 50, 23, -2, -49 },
  { 6648, 21, 49, 20, 4, -49 },
  { 6777, 28, 50, 29, 2, -49 },
  { 6952, 23, 49, 23, 6, -49 },
  { 7093, 41, 49, 41, 5, -49 },
  { 7345, 29, 49, 21, -4, -49 },
  { 7523, 21, 49, 20, 4, -49 },
  { 7652, 28, 49, 21, -3, -49 },
  { 7824, 24, 60, 19, -1, -49 },
  { 8004, 9, 49, 22, 7, -49 },
  { 8060, 24, 60, 19, -4, -49 },
  { 8240, 24, 23, 27, 2, -48 },
  { 8309, 17, 2, 18, -5, 6 },
  { 8314, 6, 11, 14, 10, -52 },
  { 8323, 23, 37, 26, 2, -36 },
  { 8430, 24, 53, 25, 0, -52 },
  { 8589, 18, 37, 18, 2, -36 },
  { 8673, 26, 53, 26, 2, -52 },
  { 8846, 19, 37, 22, 2, -36 },
  { 8934, 30, 68, 13, -9, -52 },
  { 9189, 26, 52, 26, -1, -36 },
  { 9358, 22, 52, 24, 0, -52 },
  { 9501, 13, 48, 11, 0, -48 },
  { 9579, 22, 64, 11, -9, -48 },
  { 9755, 23, 52, 20, 0, -52 },
  { 9905, 13, 52, 10, 0, -52 },
  { 9990, 35, 36, 37, 0, -36 },
  { 10148, 22, 36, 24, 0, -36 },
  { 10247, 21, 37, 24, 2, -36 },
  { 10345, 27, 52, 25, -3, -36 },
  { 10521, 23, 52, 26, 2, -36 },
  { 10671, 19, 36, 16, 0, -36 },
  { 10757, 20, 37, 19, -1, -36 },
  { 10850, 13, 46, 12, 1, -45 },
  { 10925, 22, 37, 24, 2, -36 },
  { 11027, 18, 36, 18, 4, -36 },
  { 11108, 30, 36, 31, 4, -36 },
  { 11243, 25, 36, 19, -3, -36 },
  { 11356, 31, 53, 20, -8, -36 },
  { 11562, 20, 36, 16, -2, -36 },
  { 11652, 23, 60, 21, 2, -49 },
  { 11825, 1, 69, 23, 11, -52 },
  { 11834, 23, 60, 21, -4, -49 },
  { 12007, 23, 6, 27, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC68PT7B_H_
