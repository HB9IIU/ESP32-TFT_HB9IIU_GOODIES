#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x80, 0x00, 0x00, 0x10, 0x60, 0x22, 0x49,
  0x12, 0x24, 0x49, 0x22, 0x44, 0x88, 0x01, 0x08, 0x08, 0x80, 0x44, 0x04,
  0x20, 0x22, 0x01, 0x10, 0x10, 0x87, 0xFF, 0x04, 0x40, 0x42, 0x02, 0x20,
  0x11, 0x00, 0x88, 0x08, 0x40, 0x44, 0x1F, 0xF8, 0x21, 0x01, 0x10, 0x08,
  0x80, 0x84, 0x04, 0x40, 0x22, 0x02, 0x10, 0x11, 0x80, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x7F, 0x09, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20,
  0x12, 0x00, 0xA0, 0x06, 0x00, 0x60, 0x05, 0x00, 0x50, 0x04, 0x80, 0x48,
  0x08, 0x80, 0x88, 0x08, 0x80, 0x90, 0x93, 0x07, 0xC0, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x1C, 0x08, 0x90, 0x42, 0x21, 0x10, 0x84, 0x42, 0x22, 0x10,
  0x88, 0x44, 0x21, 0x10, 0x84, 0x82, 0x12, 0x08, 0x93, 0xA2, 0x51, 0x8A,
  0x46, 0x4A, 0x1E, 0x48, 0x41, 0x41, 0x09, 0x04, 0x24, 0x21, 0x10, 0x84,
  0x42, 0x21, 0x10, 0x84, 0x44, 0x12, 0x30, 0x78, 0x03, 0x81, 0x20, 0x88,
  0x22, 0x08, 0x82, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xC0, 0x20, 0x14,
  0x09, 0x06, 0x45, 0x09, 0x82, 0xA0, 0xA8, 0x2A, 0x04, 0x81, 0x20, 0xC8,
  0x51, 0xE2, 0x25, 0x24, 0xA4, 0x80, 0x01, 0x81, 0x01, 0x00, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x0C, 0x00, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x00, 0x08, 0x08,
  0x88, 0x69, 0x1E, 0x28, 0x48, 0x84, 0x04, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x12, 0x24, 0x48, 0x80, 0xFE, 0xC0, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x03, 0x81, 0x10, 0x84, 0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48,
  0x12, 0x08, 0x82, 0x21, 0x08, 0x41, 0xE0, 0x04, 0x31, 0x49, 0x44, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04,
  0x30, 0x03, 0xC0, 0x42, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F,
  0xF8, 0x03, 0xC0, 0xC3, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x78, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x0F,
  0xE0, 0x00, 0x10, 0x03, 0x00, 0x30, 0x05, 0x00, 0x90, 0x0A, 0x01, 0x20,
  0x12, 0x02, 0x20, 0x42, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x40, 0x84, 0x08, 0xBF, 0xE0, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x07, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x1F, 0xC0, 0x01, 0xE0, 0xC0, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x7C, 0x30, 0xCC, 0x09, 0x81, 0x20,
  0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x04, 0x20, 0x83,
  0xE0, 0x3F, 0xF0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x03, 0xC0, 0xC2, 0x08, 0x21, 0x01, 0x10, 0x11, 0x01, 0x10, 0x21,
  0x02, 0x10, 0x40, 0x84, 0x09, 0x00, 0x60, 0x0A, 0x03, 0x10, 0x40, 0x84,
  0x08, 0x80, 0x88, 0x08, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0xC1, 0x07,
  0xE0, 0x03, 0x80, 0x88, 0x20, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x24, 0x04, 0x80, 0x90, 0x32, 0x0C, 0x22, 0x83, 0x90, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x07, 0xC0, 0x18, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x80, 0x04, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x21, 0x04, 0x20,
  0x80, 0x00, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x00,
  0x0F, 0x08, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x01, 0x80, 0x00, 0xF0, 0x02, 0x18, 0x18, 0x10, 0x60, 0x10, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x90, 0x71, 0x21, 0x22, 0x84, 0x45, 0x10, 0x8A,
  0x22, 0x14, 0x44, 0x31, 0x08, 0xA2, 0x11, 0x44, 0x42, 0x88, 0x85, 0x11,
  0x12, 0x26, 0x44, 0x73, 0x88, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC2, 0x00, 0x78, 0x00, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50,
  0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x82,
  0x10, 0x43, 0xF8, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80,
  0x60, 0x0C, 0x01, 0x07, 0x80, 0x46, 0x04, 0x10, 0x81, 0x08, 0x10, 0x81,
  0x08, 0x10, 0x81, 0x10, 0x11, 0x02, 0x10, 0x41, 0xF8, 0x20, 0x82, 0x04,
  0x20, 0x42, 0x02, 0x20, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x08,
  0x81, 0x0F, 0xE0, 0x00, 0xF0, 0x10, 0x41, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x07, 0xE0, 0x07, 0x80, 0x23, 0x01, 0x04, 0x10,
  0x20, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02,
  0x20, 0x12, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x22, 0x01, 0x10,
  0x18, 0x80, 0x84, 0x08, 0x20, 0x82, 0x08, 0x1F, 0x80, 0x07, 0xF8, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0x82, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0xFC, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x00, 0xF8, 0x06, 0x0C, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x0F, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x42, 0x00, 0x84, 0x01, 0x04, 0x02, 0x08, 0x04, 0x08, 0x10, 0x0F, 0xE0,
  0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x04, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0xFF, 0xC2, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x04, 0x02, 0x08, 0x04, 0x20, 0x10, 0x40, 0x20, 0x07, 0xC0, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x03, 0xE0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x01, 0xC0, 0x00, 0x04, 0x04, 0x10,
  0x20, 0x41, 0x02, 0x0C, 0x08, 0x20, 0x21, 0x00, 0x88, 0x02, 0x20, 0x11,
  0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x2A, 0x00, 0xC8, 0x02, 0x20, 0x08,
  0x80, 0x22, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01, 0x02, 0x08,
  0x08, 0x20, 0x20, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x7F,
  0x04, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x60, 0xA0, 0x06, 0x0A, 0x00,
  0xA0, 0xA0, 0x0A, 0x0A, 0x01, 0x21, 0x20, 0x14, 0x12, 0x01, 0x41, 0x20,
  0x24, 0x12, 0x02, 0x41, 0x20, 0x44, 0x22, 0x04, 0x82, 0x20, 0x88, 0x22,
  0x08, 0x82, 0x21, 0x08, 0x22, 0x11, 0x04, 0x22, 0x10, 0x42, 0x21, 0x04,
  0x24, 0x10, 0x42, 0x41, 0x04, 0x18, 0x20, 0x81, 0x82, 0x08, 0x10, 0x20,
  0x04, 0x01, 0x04, 0x02, 0x06, 0x02, 0x0A, 0x02, 0x0A, 0x02, 0x0A, 0x02,
  0x0A, 0x04, 0x09, 0x04, 0x11, 0x04, 0x11, 0x04, 0x11, 0x04, 0x11, 0x08,
  0x21, 0x08, 0x20, 0x88, 0x20, 0x88, 0x20, 0x88, 0x20, 0x90, 0x40, 0x90,
  0x40, 0x50, 0x40, 0x50, 0x40, 0x60, 0x40, 0x60, 0x80, 0x60, 0x80, 0x20,
  0x01, 0xE0, 0x30, 0x81, 0x04, 0x10, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24,
  0x01, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x20, 0x41,
  0x04, 0x07, 0xC0, 0x07, 0x80, 0x46, 0x04, 0x20, 0x81, 0x08, 0x10, 0x81,
  0x08, 0x10, 0x81, 0x10, 0x11, 0x02, 0x10, 0x21, 0x04, 0x21, 0x83, 0xE0,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x01, 0xE0, 0x30, 0x81, 0x04, 0x10, 0x11, 0x00, 0x88,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88,
  0x04, 0x20, 0x41, 0x04, 0x07, 0xC0, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x07, 0x80, 0x46, 0x04, 0x20, 0x81, 0x08, 0x10,
  0x81, 0x08, 0x10, 0x81, 0x10, 0x11, 0x02, 0x10, 0x21, 0x04, 0x3F, 0x82,
  0x20, 0x22, 0x02, 0x20, 0x22, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x80, 0x88, 0x08, 0x01, 0xF0, 0x30, 0x43, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x06, 0x1F, 0xC0, 0x7F, 0xC1, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x08, 0x04, 0x20, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21,
  0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x40, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20,
  0x80, 0x82, 0x02, 0x04, 0x10, 0x1F, 0x80, 0x80, 0x30, 0x06, 0x01, 0x40,
  0x28, 0x09, 0x01, 0x20, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x41, 0x10, 0x22, 0x04, 0x40, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x40, 0x20, 0x14, 0x02, 0x01, 0x40, 0x60, 0x24,
  0x06, 0x02, 0x40, 0xA0, 0x44, 0x0A, 0x04, 0x40, 0xA0, 0x44, 0x12, 0x08,
  0x41, 0x20, 0x84, 0x22, 0x10, 0x42, 0x21, 0x04, 0x22, 0x10, 0x44, 0x22,
  0x08, 0x42, 0x20, 0x88, 0x24, 0x08, 0x82, 0x40, 0x88, 0x24, 0x09, 0x04,
  0x80, 0x90, 0x48, 0x0A, 0x05, 0x00, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x80, 0x82, 0x02,
  0x10, 0x08, 0x40, 0x22, 0x00, 0x48, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01,
  0x08, 0x04, 0x20, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x20, 0x40, 0x50,
  0x14, 0x09, 0x02, 0x41, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x02, 0x80,
  0xA0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xFC, 0x00, 0x84, 0x10, 0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x10,
  0x82, 0x10, 0x84, 0x21, 0x08, 0x21, 0x03, 0xF0, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0xFC, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x90, 0x11, 0x01, 0x08, 0x20,
  0x82, 0x04, 0x40, 0x44, 0x02, 0x80, 0x28, 0x01, 0xFF, 0x91, 0x22, 0x03,
  0x01, 0x94, 0x41, 0x90, 0x32, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x50,
  0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x18, 0x85, 0x0F, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x4C, 0x0A,
  0x62, 0x84, 0x60, 0x88, 0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24,
  0x05, 0x01, 0x20, 0x24, 0x04, 0x81, 0x10, 0x25, 0x08, 0x9E, 0x00, 0x07,
  0x04, 0x44, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x3E, 0x00, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x64, 0x0C, 0xA0, 0x83,
  0x08, 0x18, 0x40, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x84,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x10, 0x40, 0x82, 0x0C, 0x10, 0xA0, 0x79,
  0x00, 0x07, 0x04, 0x44, 0x24, 0x12, 0x0A, 0x05, 0x04, 0x84, 0x8C, 0x78,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x03, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x19, 0x41,
  0x06, 0x10, 0x30, 0x81, 0x08, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x01,
  0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81, 0x04, 0x18, 0x21, 0x40,
  0xF2, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x82,
  0x03, 0xE0, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x4C, 0x0E, 0x43, 0x04, 0x60, 0x88, 0x11, 0x02, 0x20, 0x88, 0x11,
  0x02, 0x20, 0x44, 0x08, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10, 0x44, 0x08,
  0x81, 0x00, 0x04, 0x10, 0x40, 0x00, 0x00, 0x02, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x03, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0x08,
  0x42, 0x08, 0x42, 0x08, 0x81, 0x20, 0x24, 0x09, 0x01, 0x60, 0x34, 0x04,
  0x80, 0x88, 0x21, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10, 0x81, 0x00, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x04, 0x20, 0x80, 0x01, 0x86, 0x07, 0x2C, 0xC6, 0x08,
  0x23, 0x04, 0x11, 0x02, 0x08, 0x82, 0x04, 0x41, 0x02, 0x40, 0x82, 0x20,
  0x41, 0x10, 0x40, 0x88, 0x20, 0x44, 0x10, 0x44, 0x08, 0x22, 0x04, 0x11,
  0x04, 0x08, 0x82, 0x04, 0x81, 0x04, 0x40, 0x82, 0x00, 0x01, 0x81, 0xC8,
  0x60, 0x8C, 0x11, 0x02, 0x20, 0x44, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x08, 0x81, 0x10, 0x20, 0x03, 0x02,
  0x21, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18, 0x0A,
  0x02, 0x80, 0xA0, 0x48, 0x12, 0x08, 0x82, 0x1F, 0x00, 0x00, 0xC0, 0x53,
  0x0A, 0x10, 0xC1, 0x08, 0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x10, 0x11, 0x01, 0x20, 0x22, 0x02, 0x20, 0x42, 0x04, 0x50, 0x84, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x06, 0x01, 0x14, 0x41, 0x90, 0x32, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40,
  0x50, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x18, 0x85, 0x0F,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x01, 0x87, 0x05, 0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x00, 0x03, 0x03, 0x11,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x3F, 0x00, 0x04, 0x10, 0x20, 0x40,
  0xA6, 0x84, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x0E, 0x00, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x24,
  0x09, 0x02, 0x40, 0x90, 0x48, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x18,
  0xFA, 0x00, 0x81, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x11, 0x10, 0x88,
  0x48, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0x80, 0x00, 0x81, 0x07,
  0x06, 0x0A, 0x0C, 0x14, 0x28, 0x48, 0x50, 0x90, 0xA2, 0x22, 0x44, 0x44,
  0x88, 0x91, 0x21, 0x22, 0x42, 0x45, 0x05, 0x0A, 0x0A, 0x14, 0x18, 0x30,
  0x30, 0x60, 0x60, 0x80, 0x81, 0x00, 0x08, 0x21, 0x08, 0x21, 0x04, 0x40,
  0x88, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x01, 0x40, 0x28, 0x09, 0x02, 0x20,
  0x44, 0x10, 0x44, 0x08, 0x81, 0x00, 0x01, 0x02, 0x02, 0x04, 0x04, 0x10,
  0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02,
  0x40, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x00, 0xFC, 0x00, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x38, 0x03,
  0x00, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x38, 0x0C, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x0E, 0x00, 0x78, 0x30, 0xC6, 0x07, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 24, 7, 0, -24 },
  { 22, 7, 9, 8, 3, -24 },
  { 30, 13, 24, 12, 0, -24 },
  { 69, 12, 27, 11, 0, -25 },
  { 110, 14, 24, 17, 2, -24 },
  { 152, 10, 24, 11, 0, -24 },
  { 182, 3, 9, 5, 3, -24 },
  { 186, 9, 28, 8, 1, -23 },
  { 218, 9, 28, 8, -2, -23 },
  { 250, 8, 9, 10, 4, -25 },
  { 259, 11, 15, 13, 1, -19 },
  { 280, 4, 7, 5, -1, -3 },
  { 284, 7, 1, 9, 1, -9 },
  { 285, 1, 2, 5, 1, -2 },
  { 286, 13, 24, 10, -1, -24 },
  { 325, 10, 24, 11, 1, -24 },
  { 355, 6, 24, 11, 3, -24 },
  { 373, 12, 24, 11, -1, -24 },
  { 409, 12, 24, 11, -1, -24 },
  { 445, 12, 24, 11, -1, -24 },
  { 481, 13, 24, 11, -1, -24 },
  { 520, 11, 24, 11, 1, -24 },
  { 553, 12, 24, 11, 1, -24 },
  { 589, 12, 24, 11, 0, -24 },
  { 625, 11, 24, 11, 0, -24 },
  { 658, 5, 17, 5, 0, -17 },
  { 669, 6, 21, 5, -1, -17 },
  { 685, 11, 13, 13, 1, -18 },
  { 703, 11, 8, 13, 1, -16 },
  { 714, 11, 13, 13, 1, -18 },
  { 732, 9, 24, 8, 0, -24 },
  { 759, 15, 27, 17, 1, -24 },
  { 810, 11, 24, 11, -2, -24 },
  { 843, 12, 24, 12, 0, -24 },
  { 879, 13, 24, 11, 1, -24 },
  { 918, 13, 24, 14, 0, -24 },
  { 957, 13, 24, 11, 0, -24 },
  { 996, 13, 24, 10, 0, -24 },
  { 1035, 15, 24, 15, 1, -24 },
  { 1080, 15, 24, 15, 0, -24 },
  { 1125, 10, 24, 5, -2, -24 },
  { 1155, 11, 30, 5, -5, -24 },
  { 1197, 14, 24, 11, 0, -24 },
  { 1239, 7, 24, 10, 0, -24 },
  { 1260, 20, 24, 19, 0, -24 },
  { 1320, 16, 24, 15, 0, -24 },
  { 1368, 13, 24, 15, 1, -24 },
  { 1407, 12, 24, 12, 0, -24 },
  { 1443, 13, 30, 15, 1, -24 },
  { 1492, 12, 24, 12, 0, -24 },
  { 1528, 13, 24, 11, -1, -24 },
  { 1567, 10, 24, 10, 2, -24 },
  { 1597, 14, 24, 14, 1, -24 },
  { 1639, 11, 24, 11, 3, -24 },
  { 1672, 20, 24, 20, 2, -24 },
  { 1732, 14, 24, 10, -2, -24 },
  { 1774, 10, 24, 10, 2, -24 },
  { 1804, 13, 24, 10, -1, -24 },
  { 1843, 12, 29, 9, -1, -24 },
  { 1887, 5, 24, 11, 3, -24 },
  { 1902, 12, 29, 9, -2, -24 },
  { 1946, 12, 12, 13, 1, -24 },
  { 1964, 8, 1, 9, -2, 3 },
  { 1965, 3, 5, 7, 5, -25 },
  { 1967, 11, 18, 13, 1, -18 },
  { 1992, 11, 25, 12, 0, -25 },
  { 2027, 9, 18, 9, 1, -18 },
  { 2048, 13, 25, 13, 1, -25 },
  { 2089, 9, 18, 11, 1, -18 },
  { 2110, 14, 33, 6, -4, -25 },
  { 2168, 13, 26, 12, -1, -18 },
  { 2211, 11, 25, 12, 0, -25 },
  { 2246, 6, 24, 5, 0, -24 },
  { 2264, 10, 32, 5, -4, -24 },
  { 2304, 11, 25, 10, 0, -25 },
  { 2339, 6, 25, 5, 0, -25 },
  { 2358, 17, 18, 18, 0, -18 },
  { 2397, 11, 18, 12, 0, -18 },
  { 2422, 10, 18, 12, 1, -18 },
  { 2445, 12, 26, 12, -1, -18 },
  { 2484, 11, 26, 13, 1, -18 },
  { 2520, 9, 18, 8, 0, -18 },
  { 2541, 10, 18, 9, -1, -18 },
  { 2564, 7, 22, 6, 0, -22 },
  { 2584, 10, 17, 12, 1, -17 },
  { 2606, 9, 17, 9, 2, -17 },
  { 2626, 15, 17, 15, 2, -17 },
  { 2658, 11, 17, 9, -1, -17 },
  { 2682, 15, 25, 10, -4, -17 },
  { 2729, 10, 17, 8, -1, -17 },
  { 2751, 11, 29, 10, 1, -24 },
  { 2791, 1, 33, 11, 5, -25 },
  { 2796, 11, 29, 10, -2, -24 },
  { 2836, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC33PT7B_H_
