#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x58, 0x80, 0xFF, 0x29, 0x4C, 0xB5, 0x32, 0xD4, 0xC0, 0x17,
  0x66, 0x26, 0x55, 0xE4, 0x4E, 0xB5, 0xCD, 0xF5, 0xB5, 0xB0, 0x25, 0x56,
  0x4B, 0xAA, 0xE0, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x40, 0x24, 0x92,
  0x49, 0x2A, 0x00, 0xAE, 0x80, 0x22, 0xF2, 0x22, 0xE0, 0xE0, 0x80, 0x08,
  0x42, 0x22, 0x11, 0x08, 0x80, 0x35, 0x59, 0x99, 0x9A, 0xE0, 0x75, 0x5A,
  0x80, 0x61, 0x11, 0x12, 0x48, 0xE0, 0x61, 0x11, 0x61, 0x12, 0xE0, 0x11,
  0x35, 0x5A, 0xF2, 0x20, 0x34, 0x44, 0x21, 0x12, 0xE0, 0x34, 0x4A, 0xD9,
  0x99, 0xE0, 0x78, 0x44, 0x22, 0x11, 0x08, 0x80, 0x35, 0x55, 0x6A, 0x99,
  0xE0, 0x25, 0x99, 0x97, 0x12, 0xC0, 0x40, 0x20, 0x20, 0x00, 0x94, 0x12,
  0xC6, 0x10, 0xF0, 0xF0, 0x86, 0x12, 0xC0, 0x64, 0x94, 0xA0, 0x80, 0x18,
  0x94, 0x5F, 0xB6, 0xDD, 0x6A, 0x81, 0x80, 0x11, 0x33, 0x33, 0x59, 0x90,
  0x32, 0x52, 0xA6, 0x4A, 0x52, 0xE0, 0x19, 0x10, 0x88, 0x42, 0x10, 0x60,
  0x32, 0x52, 0x94, 0xC6, 0x52, 0xE0, 0x3A, 0x10, 0x87, 0x42, 0x10, 0xE0,
  0x3A, 0x10, 0x86, 0x42, 0x10, 0x80, 0x1C, 0x84, 0x10, 0x92, 0x28, 0xA2,
  0x70, 0x4A, 0x52, 0x97, 0xC6, 0x52, 0x90, 0x32, 0x22, 0x24, 0x44, 0xC0,
  0x11, 0x11, 0x12, 0x22, 0x22, 0xC0, 0x4A, 0x54, 0xC4, 0x52, 0x94, 0x90,
  0x49, 0x25, 0x24, 0xE0, 0x22, 0x85, 0x0A, 0x36, 0xB5, 0xAD, 0x5A, 0xA4,
  0x25, 0x16, 0x5A, 0x6A, 0x69, 0x24, 0x90, 0x32, 0x52, 0x98, 0xC6, 0x32,
  0xF0, 0x25, 0x55, 0x5A, 0x88, 0x80, 0x32, 0x52, 0x98, 0xC6, 0x32, 0xD1,
  0x08, 0x25, 0x55, 0x5A, 0xAA, 0xA0, 0x34, 0x44, 0x42, 0x11, 0xE0, 0xE9,
  0x29, 0x24, 0x80, 0x4A, 0x52, 0x94, 0xC6, 0x52, 0xE0, 0x99, 0x9A, 0xAC,
  0x88, 0x80, 0x93, 0x26, 0x4D, 0xAD, 0x5B, 0x26, 0x48, 0x90, 0x29, 0x4A,
  0x21, 0x11, 0x4A, 0x90, 0xB6, 0xE9, 0x24, 0x80, 0x38, 0x42, 0x21, 0x11,
  0x08, 0xF0, 0x34, 0x44, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x95, 0x40, 0x31,
  0x11, 0x11, 0x12, 0x22, 0xE0, 0x21, 0x14, 0xA8, 0x80, 0xE0, 0xC0, 0x75,
  0x99, 0x9E, 0x24, 0x65, 0x59, 0x99, 0xE0, 0x74, 0x88, 0x8C, 0x08, 0x4A,
  0xA5, 0x4A, 0x52, 0xE0, 0x79, 0xE8, 0x8E, 0x0C, 0x41, 0x84, 0x10, 0x42,
  0x08, 0x20, 0x84, 0x30, 0x75, 0x99, 0x9E, 0x22, 0xC0, 0x24, 0x65, 0x59,
  0x99, 0xA0, 0x41, 0x6A, 0x80, 0x10, 0x01, 0x11, 0x22, 0x22, 0x4C, 0x24,
  0x45, 0x64, 0xAA, 0xA0, 0x55, 0x6A, 0x80, 0x7D, 0x59, 0x65, 0xA6, 0x90,
  0x75, 0x99, 0xAA, 0x75, 0x99, 0x9E, 0x75, 0x99, 0x9E, 0x88, 0x80, 0x75,
  0x99, 0x9E, 0x22, 0x20, 0x6A, 0x49, 0x00, 0xF1, 0x13, 0xC0, 0x55, 0xAA,
  0x55, 0x99, 0xAE, 0xBB, 0x49, 0x00, 0xAD, 0x7D, 0x6A, 0x50, 0x29, 0x88,
  0x45, 0x48, 0x29, 0x4C, 0x42, 0x11, 0x08, 0x80, 0x65, 0x29, 0x80, 0x12,
  0x22, 0x2C, 0x44, 0x48, 0x40, 0xFF, 0xF0, 0x21, 0x11, 0x11, 0x22, 0x22,
  0xC0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 9, 2, 0, -9 },
  { 4, 2, 4, 3, 1, -9 },
  { 5, 5, 9, 4, 0, -9 },
  { 11, 4, 10, 4, 0, -9 },
  { 16, 5, 9, 6, 1, -9 },
  { 22, 4, 9, 4, 0, -9 },
  { 27, 1, 4, 2, 1, -9 },
  { 28, 4, 11, 3, 0, -9 },
  { 34, 3, 11, 3, -1, -9 },
  { 39, 3, 3, 4, 1, -9 },
  { 41, 4, 6, 5, 0, -7 },
  { 44, 1, 3, 2, 0, -1 },
  { 45, 3, 1, 3, 0, -4 },
  { 46, 1, 1, 2, 0, -1 },
  { 47, 5, 9, 4, -1, -9 },
  { 53, 4, 9, 4, 0, -9 },
  { 58, 2, 9, 4, 1, -9 },
  { 61, 4, 9, 4, 0, -9 },
  { 66, 4, 9, 4, 0, -9 },
  { 71, 4, 9, 4, 0, -9 },
  { 76, 4, 9, 4, 0, -9 },
  { 81, 4, 9, 4, 0, -9 },
  { 86, 5, 9, 4, 0, -9 },
  { 92, 4, 9, 4, 0, -9 },
  { 97, 4, 9, 4, 0, -9 },
  { 102, 2, 6, 2, 0, -6 },
  { 104, 3, 8, 2, -1, -6 },
  { 107, 4, 5, 5, 0, -7 },
  { 110, 4, 3, 5, 0, -6 },
  { 112, 4, 5, 5, 0, -7 },
  { 115, 3, 9, 3, 0, -9 },
  { 119, 6, 10, 6, 0, -9 },
  { 127, 4, 9, 4, -1, -9 },
  { 132, 5, 9, 4, 0, -9 },
  { 138, 5, 9, 4, 0, -9 },
  { 144, 5, 9, 5, 0, -9 },
  { 150, 5, 9, 4, 0, -9 },
  { 156, 5, 9, 4, 0, -9 },
  { 162, 6, 9, 5, 0, -9 },
  { 169, 5, 9, 5, 0, -9 },
  { 175, 4, 9, 2, -1, -9 },
  { 180, 4, 11, 2, -2, -9 },
  { 186, 5, 9, 4, 0, -9 },
  { 192, 3, 9, 4, 0, -9 },
  { 196, 7, 9, 7, 0, -9 },
  { 204, 6, 9, 6, 0, -9 },
  { 211, 5, 9, 5, 0, -9 },
  { 217, 4, 9, 4, 0, -9 },
  { 222, 5, 11, 5, 0, -9 },
  { 229, 4, 9, 4, 0, -9 },
  { 234, 4, 9, 4, 0, -9 },
  { 239, 3, 9, 4, 1, -9 },
  { 243, 5, 9, 5, 0, -9 },
  { 249, 4, 9, 4, 1, -9 },
  { 254, 7, 9, 7, 1, -9 },
  { 262, 5, 9, 4, -1, -9 },
  { 268, 3, 9, 3, 1, -9 },
  { 272, 5, 9, 4, -1, -9 },
  { 278, 4, 11, 3, 0, -9 },
  { 284, 2, 9, 4, 1, -9 },
  { 287, 4, 11, 3, -1, -9 },
  { 293, 5, 5, 5, 0, -9 },
  { 297, 3, 1, 3, -1, 1 },
  { 298, 1, 2, 2, 2, -9 },
  { 299, 4, 6, 5, 0, -6 },
  { 302, 4, 9, 4, 0, -9 },
  { 307, 4, 6, 3, 0, -6 },
  { 310, 5, 9, 5, 0, -9 },
  { 316, 4, 6, 4, 0, -6 },
  { 319, 6, 12, 2, -2, -9 },
  { 328, 4, 9, 5, 0, -6 },
  { 333, 4, 9, 4, 0, -9 },
  { 338, 2, 9, 2, 0, -9 },
  { 341, 4, 12, 2, -2, -9 },
  { 347, 4, 9, 4, 0, -9 },
  { 352, 2, 9, 2, 0, -9 },
  { 355, 6, 6, 7, 0, -6 },
  { 360, 4, 6, 4, 0, -6 },
  { 363, 4, 6, 4, 0, -6 },
  { 366, 4, 9, 4, 0, -6 },
  { 371, 4, 9, 5, 0, -6 },
  { 376, 3, 6, 3, 0, -6 },
  { 379, 3, 6, 3, 0, -6 },
  { 382, 2, 8, 2, 0, -8 },
  { 384, 4, 6, 4, 0, -6 },
  { 387, 3, 6, 3, 1, -6 },
  { 390, 5, 6, 6, 1, -6 },
  { 394, 5, 6, 3, -1, -6 },
  { 398, 5, 9, 4, -1, -6 },
  { 404, 3, 6, 3, 0, -6 },
  { 407, 4, 11, 4, 0, -9 },
  { 413, 1, 12, 4, 2, -9 },
  { 415, 4, 11, 4, -1, -9 },
  { 421, 4, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC12PT7B_H_
