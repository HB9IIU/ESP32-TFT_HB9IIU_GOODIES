#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x40, 0x08, 0x59, 0xAA, 0xA0, 0x09,
  0x0A, 0x12, 0x12, 0x7D, 0x24, 0x24, 0x28, 0x48, 0xFC, 0x48, 0x50, 0x90,
  0x90, 0x04, 0x38, 0xA9, 0x44, 0x85, 0x0C, 0x08, 0x18, 0x30, 0x51, 0x22,
  0x5F, 0x08, 0x20, 0x71, 0x29, 0x24, 0x92, 0x89, 0x44, 0xDA, 0xB3, 0x69,
  0x54, 0x94, 0x4A, 0x49, 0x24, 0x96, 0x70, 0x1C, 0x92, 0x49, 0x28, 0xC2,
  0x14, 0x56, 0x58, 0xA2, 0x8B, 0xE0, 0xF8, 0x08, 0x88, 0x84, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x80, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x44, 0x21, 0x11, 0x08, 0x80, 0x17, 0x0E, 0xA9, 0x00, 0x20, 0x82, 0x08,
  0xFC, 0x82, 0x08, 0x20, 0x80, 0x29, 0x48, 0xF8, 0x80, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1E,
  0x44, 0x8A, 0x14, 0x28, 0x50, 0xC2, 0x85, 0x0A, 0x14, 0x48, 0x8E, 0x00,
  0x36, 0xA2, 0x22, 0x44, 0x44, 0x48, 0x88, 0x1F, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFC, 0x3E, 0x04, 0x08,
  0x10, 0x20, 0x8E, 0x04, 0x04, 0x08, 0x10, 0x40, 0x9E, 0x00, 0x02, 0x0C,
  0x28, 0x61, 0x44, 0x89, 0x22, 0x49, 0x13, 0xF0, 0x41, 0x02, 0x00, 0x1F,
  0x10, 0x10, 0x10, 0x20, 0x38, 0x04, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04,
  0xF8, 0x0E, 0x20, 0x81, 0x04, 0x0B, 0x19, 0x22, 0x85, 0x0A, 0x14, 0x28,
  0x8E, 0x00, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x00, 0x3E, 0x44, 0x89, 0x12, 0x24, 0x86, 0x34, 0x85, 0x0A,
  0x14, 0x28, 0x8E, 0x00, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0x51, 0x26, 0x34,
  0x08, 0x20, 0x41, 0x1C, 0x00, 0x24, 0x00, 0x00, 0x02, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x02, 0x44, 0x88, 0x04, 0x66, 0x20, 0x40, 0x81, 0x81, 0xFC,
  0x00, 0x3F, 0x81, 0x81, 0x81, 0x08, 0x46, 0x20, 0x7C, 0x10, 0x42, 0x08,
  0x42, 0x08, 0x41, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x89,
  0x45, 0x52, 0x95, 0x25, 0x49, 0x92, 0xA5, 0x29, 0x52, 0x68, 0x80, 0x10,
  0x04, 0x00, 0xE0, 0x04, 0x10, 0xC3, 0x14, 0x52, 0x49, 0x3D, 0x14, 0x61,
  0x86, 0x10, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x26, 0x38, 0x44, 0x42, 0x42,
  0x42, 0x84, 0x84, 0xF8, 0x0E, 0x20, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x1C, 0x00, 0x1E, 0x21, 0x21, 0x21, 0x21, 0x21,
  0x41, 0x41, 0x42, 0x42, 0x42, 0x84, 0x88, 0xF0, 0x1F, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x3C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xF8, 0x1F, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x7C, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x06, 0x19, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x86, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x7C, 0x10, 0x90, 0x48, 0x24, 0x12, 0x11, 0x08, 0xFC, 0x82,
  0x42, 0x21, 0x10, 0x90, 0x48, 0x24, 0x20, 0x1C, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x10, 0x43, 0x80, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0xE0, 0x11, 0x22, 0x24,
  0x24, 0x28, 0x30, 0x50, 0x70, 0x48, 0x48, 0x48, 0x88, 0x88, 0x84, 0x12,
  0x22, 0x22, 0x44, 0x44, 0x48, 0x8F, 0x10, 0x11, 0x03, 0x30, 0x23, 0x06,
  0x30, 0x63, 0x0A, 0x50, 0xA5, 0x12, 0x49, 0x44, 0xA4, 0x4A, 0x48, 0xC4,
  0x8C, 0x48, 0x88, 0x10, 0x4C, 0x23, 0x08, 0xA2, 0x28, 0x8A, 0x44, 0x91,
  0x24, 0x45, 0x11, 0x44, 0x62, 0x18, 0x82, 0x20, 0x80, 0x1E, 0x45, 0x0A,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14, 0x28, 0x9E, 0x00, 0x1E, 0x44,
  0x89, 0x12, 0x24, 0x51, 0x3C, 0x40, 0x81, 0x04, 0x08, 0x10, 0x00, 0x1E,
  0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14, 0x28, 0x9E, 0x04,
  0x08, 0x10, 0x1E, 0x44, 0x89, 0x12, 0x24, 0x51, 0x3C, 0x48, 0x91, 0x24,
  0x48, 0x91, 0x00, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x04, 0xF8, 0x7C, 0x41, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x00, 0x21, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x84,
  0x84, 0x84, 0x84, 0x88, 0x88, 0xF0, 0x86, 0x18, 0xA2, 0x8A, 0x49, 0x28,
  0xA2, 0x8C, 0x20, 0x82, 0x00, 0x82, 0x18, 0x21, 0x86, 0x28, 0x62, 0x8A,
  0x28, 0xA4, 0x92, 0x49, 0x28, 0x92, 0x8A, 0x28, 0xA3, 0x0C, 0x30, 0x42,
  0x08, 0x20, 0x11, 0x11, 0x12, 0x0A, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x28,
  0x28, 0x48, 0x84, 0x84, 0x85, 0x14, 0x92, 0x51, 0x46, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x00, 0x1F, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x40, 0xF8, 0x1E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0xE0, 0x92, 0x44, 0x92, 0x49,
  0x12, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0xE0, 0x08, 0x14, 0x24, 0x24, 0x42, 0x42, 0x81,
  0xFC, 0xA4, 0x3D, 0x14, 0x61, 0x86, 0x18, 0xA2, 0x8A, 0x4E, 0x80, 0x10,
  0x20, 0x41, 0x02, 0xC6, 0x48, 0x91, 0x42, 0x85, 0x0A, 0x28, 0x51, 0x3E,
  0x00, 0x3A, 0x11, 0x08, 0x42, 0x10, 0x84, 0x38, 0x02, 0x04, 0x08, 0x13,
  0xA8, 0x91, 0x42, 0x85, 0x0A, 0x24, 0x48, 0x92, 0x3A, 0x00, 0x32, 0x53,
  0x19, 0x72, 0x10, 0x84, 0x3C, 0x03, 0x81, 0x00, 0x80, 0x80, 0xE0, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x18, 0x00, 0x1E, 0x44, 0x8A, 0x14, 0x28, 0x61, 0x42, 0x85,
  0x11, 0xD0, 0x40, 0x81, 0x04, 0x70, 0x10, 0x20, 0x41, 0x02, 0xC6, 0x48,
  0x91, 0x44, 0x89, 0x12, 0x28, 0x51, 0x22, 0x00, 0x10, 0x02, 0x22, 0x44,
  0x44, 0x48, 0x88, 0x02, 0x00, 0x00, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x43, 0x00, 0x10, 0x20, 0x41, 0x02,
  0x24, 0x8A, 0x24, 0x50, 0xE1, 0x42, 0x89, 0x11, 0x22, 0x00, 0x11, 0x12,
  0x22, 0x24, 0x44, 0x44, 0x88, 0x80, 0x3D, 0xC8, 0x92, 0x25, 0x11, 0x44,
  0x51, 0x14, 0x45, 0x12, 0x88, 0xA2, 0x28, 0x88, 0x2C, 0x64, 0x89, 0x14,
  0x48, 0x91, 0x22, 0x85, 0x12, 0x20, 0x39, 0x14, 0x61, 0x86, 0x18, 0xA2,
  0x8A, 0x4E, 0x00, 0x16, 0x19, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x22,
  0x44, 0x7C, 0x40, 0x40, 0x80, 0x80, 0x80, 0x3D, 0x14, 0x61, 0x86, 0x18,
  0xA2, 0x8A, 0x4E, 0x84, 0x10, 0x41, 0x08, 0x2C, 0xC2, 0x08, 0x41, 0x04,
  0x10, 0x82, 0x08, 0x00, 0x3D, 0x04, 0x10, 0x40, 0x81, 0x04, 0x10, 0x4F,
  0x00, 0x22, 0x72, 0x24, 0x44, 0x48, 0x88, 0xC0, 0x45, 0x14, 0x61, 0x8A,
  0x28, 0xA2, 0x92, 0x4F, 0x00, 0x8C, 0x63, 0x29, 0x52, 0x94, 0xC4, 0x20,
  0x88, 0xC4, 0x66, 0x33, 0x29, 0x95, 0x52, 0xA9, 0x94, 0xCC, 0x46, 0x22,
  0x00, 0x22, 0x24, 0x50, 0xA1, 0x82, 0x04, 0x14, 0x48, 0x92, 0x20, 0x10,
  0x88, 0x44, 0x42, 0x21, 0x20, 0x90, 0x50, 0x28, 0x14, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x00, 0x81, 0x80, 0x1C, 0x10, 0x42, 0x10, 0x42, 0x08, 0x41,
  0x0F, 0x00, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x10, 0x81, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x60, 0xFF, 0xFF, 0xF0, 0x1C, 0x10, 0x41, 0x08, 0x20, 0x82,
  0x04, 0x21, 0x04, 0x10, 0x42, 0x08, 0xC0, 0xE6, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 5, 5, 2, -14 },
  { 11, 8, 14, 7, 0, -14 },
  { 25, 7, 16, 7, 0, -15 },
  { 39, 9, 14, 10, 1, -14 },
  { 55, 6, 14, 6, 0, -14 },
  { 66, 1, 5, 3, 2, -14 },
  { 67, 5, 17, 5, 1, -14 },
  { 78, 5, 17, 5, -1, -14 },
  { 89, 5, 5, 6, 2, -15 },
  { 93, 6, 10, 8, 1, -12 },
  { 101, 3, 5, 3, -1, -2 },
  { 103, 5, 1, 5, 0, -6 },
  { 104, 1, 1, 3, 0, -1 },
  { 105, 8, 14, 6, -1, -14 },
  { 119, 7, 14, 7, 0, -14 },
  { 132, 4, 14, 7, 2, -14 },
  { 139, 8, 14, 7, -1, -14 },
  { 153, 7, 14, 7, 0, -14 },
  { 166, 7, 14, 7, 0, -14 },
  { 179, 8, 14, 7, -1, -14 },
  { 193, 7, 14, 7, 0, -14 },
  { 206, 7, 14, 7, 1, -14 },
  { 219, 7, 14, 7, 0, -14 },
  { 232, 7, 14, 7, 0, -14 },
  { 245, 3, 11, 3, 0, -11 },
  { 250, 4, 14, 3, -1, -11 },
  { 257, 6, 8, 8, 1, -11 },
  { 263, 6, 4, 8, 1, -9 },
  { 266, 6, 8, 8, 1, -11 },
  { 272, 6, 14, 5, 0, -14 },
  { 283, 10, 16, 10, 0, -14 },
  { 303, 6, 14, 7, -1, -14 },
  { 314, 8, 14, 7, 0, -14 },
  { 328, 7, 15, 7, 1, -15 },
  { 342, 8, 14, 8, 0, -14 },
  { 356, 8, 14, 7, 0, -14 },
  { 370, 8, 14, 6, 0, -14 },
  { 384, 8, 15, 9, 1, -15 },
  { 399, 9, 14, 9, 0, -14 },
  { 415, 6, 14, 3, -1, -14 },
  { 426, 7, 17, 3, -3, -14 },
  { 441, 8, 14, 7, 0, -14 },
  { 455, 4, 14, 6, 0, -14 },
  { 462, 12, 14, 12, 0, -14 },
  { 483, 10, 14, 9, 0, -14 },
  { 501, 7, 14, 9, 1, -14 },
  { 514, 7, 14, 7, 0, -14 },
  { 527, 7, 17, 9, 1, -14 },
  { 542, 7, 14, 7, 0, -14 },
  { 555, 8, 14, 7, -1, -14 },
  { 569, 6, 14, 6, 1, -14 },
  { 580, 8, 14, 8, 1, -14 },
  { 594, 6, 14, 7, 2, -14 },
  { 605, 12, 14, 12, 1, -14 },
  { 626, 8, 14, 6, -1, -14 },
  { 640, 6, 14, 6, 1, -14 },
  { 651, 8, 14, 6, -1, -14 },
  { 665, 7, 17, 5, 0, -14 },
  { 680, 3, 14, 6, 2, -14 },
  { 686, 7, 17, 5, -1, -14 },
  { 701, 8, 7, 8, 0, -14 },
  { 708, 6, 1, 5, -2, 2 },
  { 709, 2, 3, 4, 3, -15 },
  { 710, 6, 11, 8, 1, -11 },
  { 719, 7, 15, 7, 0, -15 },
  { 733, 5, 11, 5, 1, -11 },
  { 740, 7, 15, 8, 1, -15 },
  { 754, 5, 11, 7, 1, -11 },
  { 761, 9, 20, 4, -3, -15 },
  { 784, 7, 16, 8, 0, -11 },
  { 798, 7, 15, 7, 0, -15 },
  { 812, 4, 14, 3, 0, -14 },
  { 819, 7, 19, 3, -3, -14 },
  { 836, 7, 15, 6, 0, -15 },
  { 850, 4, 15, 3, 0, -15 },
  { 858, 10, 11, 11, 0, -11 },
  { 872, 7, 11, 7, 0, -11 },
  { 882, 6, 11, 7, 1, -11 },
  { 891, 8, 16, 7, -1, -11 },
  { 907, 6, 16, 8, 1, -11 },
  { 919, 6, 11, 5, 0, -11 },
  { 928, 6, 11, 5, 0, -11 },
  { 937, 4, 13, 4, 0, -13 },
  { 944, 6, 11, 7, 1, -11 },
  { 953, 5, 11, 5, 1, -11 },
  { 960, 9, 11, 9, 1, -11 },
  { 973, 7, 11, 6, -1, -11 },
  { 983, 9, 16, 6, -2, -11 },
  { 1001, 6, 11, 5, -1, -11 },
  { 1010, 6, 17, 6, 1, -14 },
  { 1023, 1, 20, 7, 3, -15 },
  { 1026, 6, 17, 6, -1, -14 },
  { 1039, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC20PT7B_H_
