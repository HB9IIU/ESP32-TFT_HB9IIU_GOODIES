#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0xCC, 0x32, 0x08, 0x82, 0x20, 0x98, 0x66, 0x11, 0x04, 0x41, 0x10,
  0x4C, 0x32, 0x08, 0x82, 0x00, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x10,
  0x20, 0x03, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x06,
  0x08, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80, 0xFF, 0xFF, 0x00,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x02, 0x00, 0x10, 0x20, 0x03, 0x06, 0x00,
  0x20, 0x40, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0x40, 0x80,
  0x04, 0x18, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x02, 0x00, 0x10, 0x20, 0x03, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04,
  0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0xC1,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x03, 0xFC, 0x00, 0xE4, 0x70, 0x18, 0x41, 0x03, 0x0C,
  0x00, 0x20, 0xC0, 0x02, 0x08, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0x61,
  0x80, 0x06, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x31, 0x00, 0x01,
  0xB0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x80, 0x00, 0x4C, 0x00, 0x04, 0x60, 0x00, 0x42, 0x00, 0x0C, 0x20,
  0x00, 0xC3, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x08, 0x20, 0x01, 0x82,
  0x00, 0x10, 0x60, 0x01, 0x04, 0x08, 0x10, 0xC0, 0xF1, 0x70, 0x03, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x04, 0x07, 0xC0, 0x10, 0x10, 0x80, 0x60, 0x61,
  0x00, 0x81, 0x83, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x18, 0x18, 0x10,
  0x20, 0x20, 0x20, 0xC0, 0x40, 0x41, 0x01, 0x80, 0x86, 0x03, 0x03, 0x08,
  0x04, 0x06, 0x30, 0x08, 0x0C, 0x40, 0x10, 0x11, 0x80, 0x20, 0x22, 0x0C,
  0xC0, 0xCC, 0x7D, 0x81, 0x11, 0x8F, 0x06, 0x66, 0x1E, 0x08, 0x88, 0x14,
  0x33, 0x30, 0x28, 0x44, 0x40, 0x5F, 0x18, 0x81, 0x88, 0x23, 0x03, 0x00,
  0x44, 0x06, 0x01, 0x08, 0x08, 0x02, 0x10, 0x10, 0x08, 0x60, 0x20, 0x10,
  0xC0, 0xC0, 0x41, 0x01, 0x80, 0x82, 0x02, 0x03, 0x04, 0x04, 0x04, 0x08,
  0x18, 0x18, 0x10, 0x20, 0x20, 0x20, 0xC0, 0xC0, 0x41, 0x01, 0x00, 0xC6,
  0x06, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x18, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0x03, 0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x0C,
  0x40, 0x06, 0x60, 0x03, 0x60, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x68, 0x00, 0x64, 0x00, 0x62, 0x00, 0x21, 0x86, 0x30, 0x43, 0x30, 0x21,
  0x10, 0x10, 0x98, 0x0C, 0xCC, 0x02, 0x44, 0x01, 0x62, 0x00, 0xA3, 0x00,
  0x71, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x10, 0x0F, 0x0C, 0x0C, 0x86,
  0x0C, 0x41, 0xFC, 0x20, 0x10, 0x00, 0x33, 0x22, 0x26, 0x64, 0x44, 0xC8,
  0x80, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x08, 0x00, 0x41, 0x84, 0x06, 0x20, 0x0D,
  0x1C, 0x1F, 0x00, 0xC0, 0x09, 0x00, 0x88, 0x08, 0x21, 0x81, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x1F, 0xFF, 0xF0, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x04, 0x30, 0xC2, 0x18, 0x43, 0x08, 0x21,
  0x04, 0x20, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0x00, 0x30, 0xC0, 0x30, 0x20, 0x30, 0x10, 0x10, 0x0C, 0x18, 0x06, 0x08,
  0x03, 0x0C, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x31, 0x00, 0x10,
  0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x04, 0x60, 0x02, 0x30, 0x03, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0xC2,
  0x00, 0x41, 0x00, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x30, 0x10, 0x08, 0x18,
  0x06, 0x18, 0x01, 0xF8, 0x00, 0x20, 0x00, 0x01, 0xC0, 0xE0, 0x68, 0x32,
  0x31, 0x98, 0x44, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x00,
  0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0E, 0x03,
  0x00, 0x80, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x08, 0x06, 0x01, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xA0,
  0x00, 0x34, 0x00, 0x04, 0x80, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x0C, 0x80,
  0x03, 0x10, 0x00, 0x42, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC2, 0x00,
  0x30, 0x40, 0x04, 0x08, 0x01, 0x83, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x03,
  0x01, 0x00, 0x40, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x30,
  0x04, 0x04, 0x01, 0x81, 0x80, 0x30, 0x20, 0x04, 0x0F, 0xFF, 0xF8, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x5F, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x70, 0x0F, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC3, 0x00, 0x23, 0xF8, 0x0B, 0x03, 0x06, 0x80, 0x41, 0xC0,
  0x10, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x10, 0xC0, 0x04, 0x30, 0x01, 0x0C,
  0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x06, 0x04, 0x03, 0x01, 0x81,
  0x80, 0x20, 0xC0, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xF0, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x10, 0x06, 0x06, 0x00, 0x40, 0x80,
  0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x81, 0x00,
  0x30, 0x20, 0x04, 0x06, 0x01, 0x00, 0x40, 0x60, 0x0C, 0x18, 0x00, 0x86,
  0x00, 0x0B, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x31, 0x80, 0x18, 0x18,
  0x06, 0x01, 0x00, 0x80, 0x30, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x0C,
  0x20, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x02, 0x08, 0x00, 0x41, 0x80, 0x10, 0x10, 0x06, 0x03, 0x81, 0x80,
  0x1F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x18, 0x30,
  0x0C, 0x06, 0x02, 0x00, 0x81, 0x80, 0x20, 0x40, 0x08, 0x30, 0x02, 0x08,
  0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x21, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01, 0x84, 0x00, 0x61, 0x00, 0x38,
  0x60, 0x1C, 0x08, 0x05, 0x03, 0x06, 0x40, 0x7F, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x83, 0x80, 0x3F, 0x80, 0x03, 0x00, 0x00, 0x02, 0x07, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xC0,
  0xC0, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xC0, 0x81,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x04,
  0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC3, 0x00, 0x60,
  0x61, 0x01, 0xFC, 0x31, 0x81, 0x84, 0x18, 0x81, 0x82, 0x08, 0x40, 0x83,
  0x04, 0x60, 0xC1, 0x02, 0x30, 0x40, 0x81, 0x10, 0x60, 0x40, 0x88, 0x30,
  0x60, 0xCC, 0x10, 0x20, 0x66, 0x18, 0x10, 0x22, 0x0C, 0x18, 0x11, 0x04,
  0x0C, 0x18, 0x82, 0x06, 0x08, 0x41, 0x02, 0x04, 0x60, 0x83, 0x06, 0x30,
  0x41, 0x82, 0x18, 0x21, 0x43, 0x0C, 0x10, 0xA1, 0x06, 0x0C, 0x9B, 0x03,
  0x03, 0x87, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x28, 0x00, 0x34, 0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x06, 0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC1,
  0x00, 0x40, 0x80, 0x60, 0x40, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x0F,
  0xFC, 0x0C, 0x02, 0x04, 0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00, 0x21,
  0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01, 0x30, 0x00,
  0x90, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x1C, 0x00, 0x08, 0x00, 0xFF, 0x00,
  0x08, 0x1C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x01, 0x00, 0x20, 0x10, 0x03,
  0x01, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x02, 0x02, 0x00,
  0x20, 0x20, 0x06, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x04, 0x01, 0x80, 0x40,
  0x30, 0x04, 0x0E, 0x00, 0xFF, 0x80, 0x08, 0x1C, 0x00, 0x80, 0x60, 0x08,
  0x03, 0x01, 0x80, 0x10, 0x18, 0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x81,
  0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x30,
  0x20, 0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x18,
  0x04, 0x1F, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x00,
  0x70, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x10, 0x00, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x08,
  0x38, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x00, 0x20, 0x10, 0x03, 0x01,
  0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10,
  0x20, 0x01, 0x06, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00,
  0x21, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00,
  0x0C, 0x30, 0x00, 0x83, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x30, 0x20,
  0x02, 0x06, 0x00, 0x60, 0x40, 0x0C, 0x04, 0x01, 0x80, 0x40, 0x70, 0x0C,
  0x3C, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xE0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x20, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xFE, 0x18,
  0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00,
  0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x01, 0x00, 0xC0, 0x02,
  0x01, 0x80, 0x04, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x30, 0x01, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02, 0x01, 0x80,
  0x02, 0x01, 0x80, 0x06, 0x01, 0x00, 0x06, 0x01, 0x00, 0x04, 0x01, 0x00,
  0x04, 0x03, 0x00, 0x04, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x02, 0x00,
  0x08, 0x02, 0x00, 0x08, 0x06, 0x00, 0x08, 0x04, 0x00, 0x18, 0x04, 0x00,
  0x18, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x0F, 0xFF, 0xF0, 0x08, 0x00,
  0x30, 0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x40, 0x10, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x60, 0x00,
  0x80, 0x60, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x00, 0x40, 0x01,
  0x00, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x9C, 0x00, 0xF0,
  0x00, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x01, 0x00, 0x40, 0x04, 0x03, 0x00, 0x10, 0x18, 0x00, 0xC0, 0xC0, 0x03,
  0x02, 0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0x00, 0x86, 0x00, 0x06, 0x10,
  0x00, 0x10, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x35, 0x00, 0x00, 0xB4, 0x00, 0x02, 0x90, 0x00, 0x0C, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0,
  0x03, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x18, 0x00, 0x80, 0x60, 0x06,
  0x01, 0x80, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x04, 0x00,
  0xC0, 0x30, 0x01, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0F, 0xFE, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x14, 0x00, 0x01, 0x40, 0x28, 0x00, 0x06, 0x80, 0x50, 0x00,
  0x0B, 0x01, 0xA0, 0x00, 0x36, 0x03, 0x40, 0x00, 0x48, 0x04, 0xC0, 0x01,
  0x90, 0x09, 0x80, 0x02, 0x20, 0x13, 0x00, 0x0C, 0xC0, 0x66, 0x00, 0x11,
  0x80, 0x8C, 0x00, 0x22, 0x01, 0x18, 0x00, 0xC4, 0x02, 0x10, 0x01, 0x08,
  0x0C, 0x20, 0x06, 0x30, 0x18, 0x40, 0x08, 0x60, 0x20, 0x80, 0x30, 0x80,
  0x41, 0x00, 0x41, 0x00, 0x82, 0x01, 0x86, 0x03, 0x04, 0x02, 0x0C, 0x06,
  0x08, 0x0C, 0x10, 0x08, 0x10, 0x10, 0x20, 0x10, 0x20, 0x60, 0x40, 0x20,
  0x40, 0x81, 0x80, 0xC0, 0x83, 0x03, 0x01, 0x01, 0x04, 0x04, 0x02, 0x03,
  0x18, 0x08, 0x04, 0x06, 0x20, 0x10, 0x18, 0x0C, 0xC0, 0x60, 0x30, 0x19,
  0x00, 0xC0, 0x40, 0x36, 0x01, 0x00, 0x80, 0x68, 0x02, 0x01, 0x00, 0xF0,
  0x04, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x80, 0x70, 0x00, 0x40, 0x38, 0x00, 0x20, 0x16,
  0x00, 0x30, 0x0B, 0x00, 0x18, 0x04, 0x80, 0x08, 0x06, 0x40, 0x04, 0x03,
  0x20, 0x06, 0x01, 0x18, 0x03, 0x00, 0x8C, 0x01, 0x00, 0x42, 0x00, 0x80,
  0x61, 0x00, 0x40, 0x30, 0x80, 0x60, 0x10, 0x40, 0x30, 0x08, 0x30, 0x10,
  0x0C, 0x18, 0x08, 0x06, 0x04, 0x04, 0x02, 0x02, 0x06, 0x01, 0x01, 0x03,
  0x00, 0x80, 0xC1, 0x00, 0xC0, 0x60, 0x80, 0x60, 0x30, 0xC0, 0x20, 0x08,
  0x60, 0x10, 0x04, 0x20, 0x08, 0x02, 0x10, 0x0C, 0x01, 0x88, 0x06, 0x00,
  0xCC, 0x02, 0x00, 0x26, 0x01, 0x00, 0x12, 0x01, 0x80, 0x09, 0x00, 0xC0,
  0x06, 0x80, 0x40, 0x03, 0xC0, 0x20, 0x01, 0xE0, 0x10, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x03, 0xF8, 0x00,
  0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x20, 0x20, 0x03, 0x06, 0x00, 0x30,
  0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01,
  0x30, 0x00, 0x13, 0x00, 0x03, 0x20, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80,
  0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x03, 0x08,
  0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x40, 0x08, 0x06, 0x01, 0x80,
  0x30, 0x60, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x10,
  0xF0, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x06, 0x02, 0x00, 0xC0, 0x40,
  0x08, 0x18, 0x01, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x81, 0x00,
  0x30, 0x60, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x0C, 0x01,
  0x81, 0x80, 0x60, 0x20, 0x18, 0x04, 0x1C, 0x00, 0xFE, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x03, 0xF8, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00,
  0x20, 0x20, 0x03, 0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x18, 0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x03, 0x20,
  0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x04,
  0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x01,
  0x88, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00,
  0xC0, 0x40, 0x08, 0x06, 0x01, 0x80, 0x30, 0x60, 0x01, 0xFC, 0x00, 0x02,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE,
  0x00, 0x10, 0x70, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x06, 0x02, 0x00,
  0xC0, 0x40, 0x18, 0x18, 0x01, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x01,
  0x81, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x01, 0x81, 0x00, 0x20, 0x20, 0x0C,
  0x0C, 0x01, 0x01, 0x80, 0x60, 0x20, 0x30, 0x07, 0xFC, 0x00, 0x86, 0x00,
  0x30, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x30, 0x02, 0x06, 0x00,
  0xC0, 0x40, 0x18, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x03,
  0x00, 0xC0, 0x40, 0x08, 0x08, 0x01, 0x01, 0x00, 0x20, 0x60, 0x06, 0x0C,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x18, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x0C, 0x01, 0x80, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01,
  0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x20, 0x40,
  0x01, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20,
  0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00,
  0x20, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08,
  0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x04,
  0x08, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80,
  0x08, 0x04, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x04,
  0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x04, 0x30,
  0x03, 0x0C, 0x00, 0x83, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x04, 0x0C, 0x03,
  0x03, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x03, 0x03, 0x00,
  0xC0, 0x80, 0x30, 0x60, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30,
  0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0C, 0x80,
  0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0B, 0x00,
  0x0C, 0x00, 0x36, 0x00, 0x18, 0x00, 0x4C, 0x00, 0x50, 0x01, 0x98, 0x00,
  0xA0, 0x03, 0x30, 0x03, 0x40, 0x04, 0x60, 0x04, 0x80, 0x18, 0xC0, 0x09,
  0x00, 0x21, 0x80, 0x32, 0x00, 0xC3, 0x00, 0x44, 0x01, 0x86, 0x01, 0x88,
  0x02, 0x0C, 0x02, 0x10, 0x0C, 0x18, 0x04, 0x20, 0x10, 0x20, 0x18, 0x40,
  0x60, 0x40, 0x20, 0x80, 0xC0, 0x80, 0xC1, 0x01, 0x01, 0x01, 0x02, 0x06,
  0x02, 0x02, 0x0C, 0x08, 0x04, 0x0C, 0x18, 0x30, 0x08, 0x10, 0x30, 0x60,
  0x10, 0x60, 0x60, 0x80, 0x20, 0xC0, 0xC3, 0x00, 0x41, 0x01, 0x84, 0x00,
  0x86, 0x03, 0x18, 0x01, 0x08, 0x06, 0x30, 0x02, 0x30, 0x0C, 0x40, 0x04,
  0x60, 0x11, 0x80, 0x08, 0x80, 0x22, 0x00, 0x13, 0x00, 0x44, 0x00, 0x24,
  0x00, 0x98, 0x00, 0x48, 0x01, 0x20, 0x00, 0xB0, 0x02, 0xC0, 0x01, 0x40,
  0x05, 0x00, 0x03, 0x80, 0x0A, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x08, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x08,
  0x10, 0x00, 0x20, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40,
  0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68,
  0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00,
  0x0C, 0x20, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x10, 0x00, 0x80, 0x40, 0x06, 0x01, 0x00, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x40, 0x10, 0x01, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x60,
  0x03, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x18, 0x20,
  0x10, 0x20, 0x30, 0x20, 0x20, 0x30, 0x60, 0x30, 0x40, 0x30, 0xC0, 0x10,
  0x80, 0x11, 0x80, 0x11, 0x00, 0x13, 0x00, 0x12, 0x00, 0x16, 0x00, 0x14,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xC0, 0x81, 0x02, 0x04, 0x08,
  0x18, 0x30, 0x20, 0x40, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x40,
  0xC1, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0x40, 0x81, 0x02, 0x06,
  0x0C, 0x18, 0x10, 0x20, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x02, 0x10,
  0x00, 0xC3, 0x00, 0x30, 0x20, 0x06, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C,
  0x0C, 0x00, 0x81, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0x58, 0x00, 0x0C, 0xFF, 0xF8, 0x88, 0xC4, 0x62, 0x21, 0x00,
  0xF0, 0x01, 0xEE, 0x41, 0x81, 0x21, 0x80, 0xF0, 0x80, 0x30, 0xC0, 0x18,
  0x40, 0x0C, 0x60, 0x06, 0x20, 0x03, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00,
  0xC4, 0x00, 0x66, 0x00, 0x23, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40,
  0x06, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0xC2, 0x00, 0xE1,
  0x00, 0x60, 0x80, 0x50, 0x60, 0x68, 0x18, 0x64, 0x07, 0xE6, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x1E, 0x00, 0x9D, 0xC0, 0x2C, 0x18, 0x1E,
  0x02, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x04, 0x18, 0x01, 0x0C, 0x00,
  0x43, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x21,
  0x00, 0x08, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x63, 0x00, 0x10, 0xC0,
  0x0C, 0x30, 0x03, 0x08, 0x00, 0x87, 0x00, 0x61, 0xC0, 0x10, 0x50, 0x0C,
  0x14, 0x06, 0x05, 0x83, 0x03, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x00, 0xFC,
  0x0F, 0x60, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x06, 0x08, 0x0F, 0xE0, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xF0, 0x80, 0x3D, 0xC8,
  0x06, 0x05, 0x80, 0xC0, 0x78, 0x08, 0x03, 0x01, 0x80, 0x30, 0x10, 0x03,
  0x03, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00,
  0x60, 0x40, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x0C, 0x08, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x01, 0x80, 0x80, 0x18, 0x08,
  0x01, 0x80, 0x80, 0x38, 0x08, 0x03, 0x00, 0x80, 0x50, 0x0C, 0x0D, 0x00,
  0x61, 0x90, 0x03, 0xF3, 0x00, 0x08, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF8,
  0x0C, 0x18, 0x30, 0x10, 0x40, 0x21, 0x80, 0x46, 0x01, 0x88, 0x03, 0x10,
  0x04, 0x60, 0x18, 0x80, 0x61, 0x01, 0x86, 0x06, 0x0D, 0xF8, 0x1F, 0x80,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x80, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xB9, 0x00, 0xC0, 0x90, 0x18, 0x0F, 0x01, 0x00, 0x60, 0x30, 0x06,
  0x02, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00,
  0x40, 0x80, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00,
  0x08, 0x10, 0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x01, 0x00, 0x30, 0x10,
  0x03, 0x01, 0x00, 0x30, 0x10, 0x07, 0x01, 0x00, 0x60, 0x10, 0x0A, 0x01,
  0x81, 0xA0, 0x0C, 0x36, 0x00, 0x7E, 0x60, 0x01, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0xC0, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x21, 0xE0, 0x13, 0xB8, 0x0B, 0x06, 0x07, 0x01, 0x07,
  0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08,
  0x30, 0x04, 0x10, 0x02, 0x08, 0x03, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00,
  0x41, 0x00, 0x60, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x08, 0x20, 0x04, 0x10,
  0x06, 0x08, 0x03, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x61,
  0x80, 0x30, 0x00, 0xC0, 0x70, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x0C, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x04, 0x02, 0x06,
  0x01, 0x06, 0x00, 0x82, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x23, 0x00, 0x13,
  0x00, 0x09, 0xC0, 0x0D, 0x60, 0x05, 0xB0, 0x03, 0x88, 0x01, 0x84, 0x01,
  0x82, 0x00, 0xC1, 0x00, 0x40, 0xC0, 0x20, 0x60, 0x10, 0x10, 0x18, 0x08,
  0x0C, 0x04, 0x04, 0x02, 0x02, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x20, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x4E, 0xE7, 0x38, 0x0A, 0x05, 0x81, 0x03,
  0x80, 0xA0, 0x30, 0x70, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC1, 0x80, 0x60,
  0x18, 0x20, 0x08, 0x02, 0x0C, 0x01, 0x00, 0x41, 0x80, 0x20, 0x08, 0x20,
  0x0C, 0x03, 0x04, 0x01, 0x00, 0x60, 0x80, 0x20, 0x08, 0x30, 0x04, 0x01,
  0x06, 0x01, 0x80, 0x20, 0x80, 0x30, 0x0C, 0x10, 0x04, 0x01, 0x82, 0x00,
  0x80, 0x20, 0xC0, 0x10, 0x04, 0x10, 0x06, 0x01, 0x82, 0x00, 0xC0, 0x30,
  0x40, 0x10, 0x04, 0x18, 0x02, 0x00, 0x83, 0x00, 0xC0, 0x10, 0x40, 0x18,
  0x06, 0x08, 0x02, 0x00, 0xC1, 0x00, 0x40, 0x10, 0x60, 0x18, 0x02, 0x00,
  0x00, 0x1E, 0x01, 0x3B, 0x80, 0xB0, 0x60, 0xE0, 0x10, 0x70, 0x08, 0x30,
  0x04, 0x18, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x60, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x08, 0x20, 0x04, 0x10, 0x06,
  0x08, 0x03, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x10, 0x06, 0x18, 0x02, 0x00,
  0x00, 0x78, 0x01, 0xFC, 0x03, 0x06, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x01,
  0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06,
  0x40, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0x40, 0x08, 0x40, 0x18,
  0x40, 0x30, 0x60, 0x20, 0x30, 0xC0, 0x1F, 0x80, 0x04, 0x00, 0x00, 0x07,
  0x80, 0x09, 0xDC, 0x00, 0xB0, 0x60, 0x0A, 0x02, 0x01, 0xC0, 0x30, 0x1C,
  0x03, 0x01, 0x80, 0x10, 0x18, 0x01, 0x03, 0x00, 0x10, 0x30, 0x01, 0x03,
  0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20,
  0x40, 0x02, 0x04, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x0C, 0x01, 0x81, 0xC0, 0x10, 0x14, 0x03,
  0x01, 0x40, 0x60, 0x16, 0x0C, 0x03, 0x3F, 0x80, 0x30, 0xC0, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xFE, 0x41, 0x81, 0x21, 0x80, 0xF0, 0x80,
  0x30, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x20, 0x03, 0x30, 0x01, 0x18,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x66, 0x00, 0x23, 0x00, 0x11, 0x00, 0x08,
  0x80, 0x0C, 0x40, 0x06, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00,
  0xC2, 0x00, 0xE1, 0x00, 0x60, 0x80, 0x50, 0x60, 0x68, 0x18, 0x6C, 0x07,
  0xE6, 0x00, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x1C, 0x09, 0xD0, 0x2C, 0x01, 0xE0, 0x05, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x03, 0xDF, 0x06, 0x02, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0xC0, 0xC0, 0xFF, 0x80,
  0x08, 0x00, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x7F, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x7C, 0x08, 0x00, 0x04, 0x01, 0x82, 0x00, 0xC3, 0x00,
  0x41, 0x80, 0x20, 0x80, 0x10, 0x40, 0x18, 0x20, 0x0C, 0x30, 0x04, 0x18,
  0x02, 0x08, 0x01, 0x04, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x10, 0x40, 0x18, 0x60, 0x08, 0x30, 0x04, 0x10, 0x02, 0x08, 0x03,
  0x04, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x50, 0x30,
  0xD8, 0x0F, 0xC8, 0x01, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x68, 0x01, 0x20,
  0x04, 0x80, 0x32, 0x00, 0x88, 0x06, 0x20, 0x10, 0x80, 0xC2, 0x02, 0x08,
  0x18, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02,
  0x30, 0x08, 0x80, 0x26, 0x00, 0x90, 0x02, 0x40, 0x0B, 0x00, 0x28, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x0F,
  0x00, 0xA0, 0x16, 0x01, 0x40, 0x6C, 0x06, 0x80, 0x98, 0x09, 0x01, 0x20,
  0x12, 0x06, 0x40, 0x6C, 0x08, 0x80, 0x98, 0x31, 0x03, 0x30, 0x42, 0x04,
  0x60, 0x84, 0x08, 0xC3, 0x08, 0x21, 0x84, 0x10, 0x43, 0x08, 0x21, 0x86,
  0x20, 0x42, 0x0C, 0x40, 0x8C, 0x19, 0x81, 0x10, 0x32, 0x02, 0x20, 0x64,
  0x04, 0xC0, 0x90, 0x09, 0x01, 0x20, 0x16, 0x02, 0xC0, 0x28, 0x05, 0x00,
  0x50, 0x0A, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x03, 0x00,
  0x61, 0x80, 0x18, 0x40, 0x02, 0x30, 0x00, 0x88, 0x00, 0x24, 0x00, 0x0B,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x05, 0x80,
  0x03, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x30, 0x80, 0x08, 0x30, 0x06,
  0x04, 0x01, 0x01, 0x00, 0x80, 0x40, 0x60, 0x10, 0x10, 0x06, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x04, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x10, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x31,
  0x80, 0x00, 0x31, 0x00, 0x00, 0x31, 0x00, 0x00, 0x33, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x34, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0x80, 0x0F,
  0x00, 0x00, 0x08, 0x00, 0x3F, 0x80, 0x70, 0x70, 0x70, 0x0F, 0xE8, 0x01,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 37, 11, 1, -37 },
  { 48, 10, 13, 13, 5, -37 },
  { 65, 20, 37, 19, 0, -37 },
  { 158, 20, 43, 18, -1, -40 },
  { 266, 23, 39, 27, 2, -38 },
  { 379, 17, 39, 17, -1, -38 },
  { 462, 4, 13, 7, 5, -37 },
  { 469, 14, 45, 13, 1, -37 },
  { 548, 14, 45, 13, -4, -37 },
  { 627, 13, 14, 16, 6, -39 },
  { 650, 17, 24, 21, 2, -30 },
  { 701, 6, 12, 8, -2, -5 },
  { 710, 11, 2, 14, 1, -15 },
  { 713, 2, 4, 8, 1, -4 },
  { 714, 21, 37, 15, -2, -37 },
  { 812, 17, 39, 18, 1, -38 },
  { 895, 10, 37, 18, 5, -37 },
  { 942, 20, 38, 18, -2, -38 },
  { 1037, 19, 39, 18, -1, -38 },
  { 1130, 19, 38, 18, -1, -38 },
  { 1221, 19, 38, 18, -1, -37 },
  { 1312, 18, 39, 18, 1, -38 },
  { 1400, 18, 37, 18, 2, -37 },
  { 1484, 19, 39, 18, -1, -38 },
  { 1577, 18, 39, 18, 0, -38 },
  { 1665, 8, 28, 8, 0, -28 },
  { 1693, 10, 35, 8, -2, -28 },
  { 1737, 17, 21, 21, 2, -29 },
  { 1782, 17, 13, 21, 2, -25 },
  { 1810, 17, 21, 21, 2, -29 },
  { 1855, 14, 38, 13, 1, -38 },
  { 1922, 25, 42, 26, 1, -37 },
  { 2054, 17, 37, 17, -4, -37 },
  { 2133, 20, 37, 19, 0, -37 },
  { 2226, 20, 39, 18, 2, -38 },
  { 2324, 20, 37, 21, 0, -37 },
  { 2417, 20, 37, 18, 0, -37 },
  { 2510, 20, 37, 16, 0, -37 },
  { 2603, 23, 39, 24, 2, -38 },
  { 2716, 24, 37, 23, 0, -37 },
  { 2827, 15, 37, 9, -3, -37 },
  { 2897, 16, 46, 8, -7, -37 },
  { 2989, 22, 37, 18, 0, -37 },
  { 3091, 11, 37, 16, 0, -37 },
  { 3142, 31, 37, 31, 0, -37 },
  { 3286, 25, 37, 24, 0, -37 },
  { 3402, 20, 39, 23, 2, -38 },
  { 3500, 19, 37, 18, 0, -37 },
  { 3588, 20, 47, 23, 2, -38 },
  { 3706, 19, 37, 19, 0, -37 },
  { 3794, 21, 39, 18, -2, -38 },
  { 3897, 16, 37, 15, 3, -37 },
  { 3971, 21, 38, 22, 2, -37 },
  { 4071, 18, 37, 18, 4, -37 },
  { 4155, 31, 37, 31, 4, -37 },
  { 4299, 22, 37, 16, -3, -37 },
  { 4401, 16, 37, 15, 3, -37 },
  { 4475, 21, 37, 16, -2, -37 },
  { 4573, 18, 45, 14, -1, -37 },
  { 4675, 7, 37, 17, 5, -37 },
  { 4708, 18, 45, 14, -3, -37 },
  { 4810, 19, 18, 20, 1, -37 },
  { 4853, 13, 1, 14, -4, 5 },
  { 4855, 4, 8, 11, 8, -40 },
  { 4859, 17, 29, 20, 2, -28 },
  { 4921, 18, 41, 19, 0, -40 },
  { 5014, 14, 29, 14, 2, -28 },
  { 5065, 20, 41, 20, 2, -40 },
  { 5168, 15, 29, 17, 1, -28 },
  { 5223, 23, 52, 10, -7, -40 },
  { 5373, 20, 40, 20, -1, -28 },
  { 5473, 17, 40, 19, 0, -40 },
  { 5558, 10, 37, 8, 0, -37 },
  { 5605, 17, 49, 8, -7, -37 },
  { 5710, 17, 40, 15, 0, -40 },
  { 5795, 10, 40, 8, 0, -40 },
  { 5845, 27, 28, 28, 0, -28 },
  { 5940, 17, 28, 19, 0, -28 },
  { 6000, 16, 29, 19, 1, -28 },
  { 6058, 20, 40, 19, -2, -28 },
  { 6158, 17, 40, 20, 2, -28 },
  { 6243, 14, 28, 12, 0, -28 },
  { 6292, 16, 29, 14, -1, -28 },
  { 6350, 9, 35, 9, 1, -34 },
  { 6390, 17, 28, 19, 1, -27 },
  { 6450, 14, 27, 14, 3, -27 },
  { 6498, 23, 27, 24, 3, -27 },
  { 6576, 18, 27, 15, -2, -27 },
  { 6637, 24, 40, 15, -6, -27 },
  { 6757, 16, 27, 12, -2, -27 },
  { 6811, 17, 45, 16, 2, -37 },
  { 6907, 1, 53, 18, 8, -40 },
  { 6914, 17, 45, 16, -3, -37 },
  { 7010, 17, 5, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC52PT7B_H_
