#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x6D, 0xDD, 0x80, 0x2B, 0x24, 0xF4, 0x4B, 0xAB,
  0xF7, 0x70, 0x2D, 0x2F, 0xB0, 0xC0, 0x6A, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0x7C, 0x5D, 0x20, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x2E, 0xDB, 0x70,
  0xDA, 0xA0, 0x44, 0x95, 0x30, 0x64, 0xA2, 0x70, 0x24, 0xAA, 0x90, 0x73,
  0x13, 0x80, 0x2A, 0x7B, 0x78, 0x64, 0xA5, 0x00, 0x76, 0xAB, 0x78, 0x76,
  0xD6, 0x70, 0x88, 0x8C, 0x39, 0x10, 0xFC, 0xC5, 0x40, 0x44, 0xA9, 0x20,
  0x7B, 0xDF, 0xD8, 0xE0, 0x25, 0xB7, 0x40, 0x6F, 0xDB, 0xC0, 0x34, 0x88,
  0x88, 0xC0, 0x75, 0x99, 0xAC, 0x6B, 0xC9, 0x80, 0x6B, 0xC9, 0x00, 0x34,
  0x88, 0xB9, 0xE0, 0x55, 0xF9, 0xAA, 0x25, 0x25, 0x80, 0x25, 0x24, 0x94,
  0x74, 0x4C, 0xAA, 0x5A, 0xB0, 0x4A, 0x77, 0xBE, 0xE4, 0x55, 0xBA, 0xAA,
  0x25, 0x99, 0x99, 0xE0, 0x6E, 0xE9, 0x00, 0x25, 0x99, 0x99, 0xA4, 0x20,
  0x6E, 0xED, 0x40, 0x72, 0x22, 0x70, 0xEA, 0xA0, 0x55, 0x99, 0xAE, 0xBB,
  0x49, 0x00, 0xAE, 0x6D, 0x4A, 0x50, 0x32, 0x22, 0x6A, 0xEA, 0xA0, 0x65,
  0x29, 0x80, 0x6A, 0x49, 0x20, 0xFC, 0x31, 0x22, 0x22, 0xE0, 0x56, 0x80,
  0xE0, 0xC0, 0x76, 0xDC, 0x49, 0xDB, 0x78, 0x72, 0x4C, 0x11, 0x6A, 0xAA,
  0xC0, 0x77, 0x4C, 0x32, 0x24, 0x44, 0x44, 0x80, 0x76, 0xDC, 0x70, 0x49,
  0xDB, 0x68, 0x5A, 0xA0, 0x25, 0x24, 0x94, 0x49, 0xE5, 0xB0, 0x56, 0xA8,
  0x7D, 0x6B, 0x5B, 0x00, 0x76, 0xDA, 0x76, 0xDE, 0x76, 0xDF, 0x20, 0x76,
  0xDC, 0x50, 0x72, 0x48, 0x71, 0x2C, 0x5A, 0xA0, 0x76, 0xDC, 0xEA, 0x80,
  0xDE, 0xEC, 0xC0, 0xA9, 0x2C, 0x55, 0x62, 0x44, 0xC0, 0x56, 0x80, 0x69,
  0x45, 0x30, 0xFF, 0x80, 0x24, 0x92, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 3, 6, 3, 0, -6 },
  { 7, 3, 8, 3, 0, -7 },
  { 10, 4, 7, 5, 0, -7 },
  { 14, 3, 7, 3, 0, -7 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 2, 3, 3, 1, -7 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 1, 2, 1, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 1, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 7, 3, 0, -7 },
  { 36, 2, 6, 3, 1, -6 },
  { 38, 3, 7, 3, 0, -7 },
  { 41, 3, 7, 3, 0, -7 },
  { 44, 3, 7, 3, 0, -7 },
  { 47, 3, 6, 3, 0, -6 },
  { 50, 3, 7, 3, 0, -7 },
  { 53, 3, 6, 3, 0, -6 },
  { 56, 3, 7, 3, 0, -7 },
  { 59, 3, 7, 3, 0, -7 },
  { 62, 1, 5, 1, 0, -5 },
  { 63, 1, 6, 1, 0, -5 },
  { 64, 3, 4, 4, 0, -5 },
  { 66, 3, 2, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -5 },
  { 69, 3, 7, 2, 0, -7 },
  { 72, 4, 7, 5, 0, -6 },
  { 76, 3, 6, 3, -1, -6 },
  { 79, 3, 6, 3, 0, -6 },
  { 82, 4, 7, 3, 0, -7 },
  { 86, 4, 6, 4, 0, -6 },
  { 89, 3, 6, 3, 0, -6 },
  { 92, 3, 6, 3, 0, -6 },
  { 95, 4, 7, 4, 0, -7 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 3, 6, 1, -1, -6 },
  { 105, 3, 8, 1, -1, -6 },
  { 108, 4, 6, 3, 0, -6 },
  { 111, 2, 6, 3, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 4, 6, 4, 0, -6 },
  { 120, 4, 7, 4, 0, -7 },
  { 124, 3, 6, 3, 0, -6 },
  { 127, 4, 9, 4, 0, -7 },
  { 132, 3, 6, 3, 0, -6 },
  { 135, 3, 7, 3, 0, -7 },
  { 138, 2, 6, 3, 1, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 3, 6, 3, 1, -6 },
  { 146, 5, 6, 5, 1, -6 },
  { 150, 4, 6, 3, -1, -6 },
  { 153, 2, 6, 3, 1, -6 },
  { 155, 3, 6, 3, 0, -6 },
  { 158, 3, 7, 2, 0, -6 },
  { 161, 1, 6, 3, 1, -6 },
  { 162, 4, 7, 2, -1, -6 },
  { 166, 3, 3, 4, 0, -6 },
  { 168, 3, 1, 2, -1, 0 },
  { 169, 1, 2, 2, 1, -7 },
  { 170, 3, 5, 3, 0, -5 },
  { 172, 3, 7, 3, 0, -7 },
  { 175, 3, 5, 2, 0, -5 },
  { 177, 4, 7, 3, 0, -7 },
  { 181, 3, 5, 3, 0, -5 },
  { 183, 4, 9, 2, -1, -7 },
  { 188, 3, 7, 3, 0, -5 },
  { 191, 3, 7, 3, 0, -7 },
  { 194, 2, 6, 1, 0, -6 },
  { 196, 3, 8, 1, -1, -6 },
  { 199, 3, 7, 3, 0, -7 },
  { 202, 2, 7, 1, 0, -7 },
  { 204, 5, 5, 5, 0, -5 },
  { 208, 3, 5, 3, 0, -5 },
  { 210, 3, 5, 3, 0, -5 },
  { 212, 3, 7, 3, 0, -5 },
  { 215, 3, 7, 3, 0, -5 },
  { 218, 3, 5, 2, 0, -5 },
  { 220, 3, 5, 2, 0, -5 },
  { 222, 2, 6, 2, 0, -6 },
  { 224, 3, 5, 3, 0, -5 },
  { 226, 2, 5, 2, 1, -5 },
  { 228, 4, 5, 4, 1, -5 },
  { 231, 3, 5, 3, 0, -5 },
  { 233, 4, 7, 3, -1, -5 },
  { 237, 2, 5, 2, 0, -5 },
  { 239, 3, 7, 3, 0, -6 },
  { 242, 1, 9, 3, 1, -7 },
  { 244, 3, 7, 3, -1, -6 },
  { 247, 3, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC9PT7B_H_
