#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x18, 0xC0,
  0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0x80, 0x8C, 0x0C, 0x60, 0x63,
  0x03, 0x10, 0x10, 0x80, 0x84, 0x0C, 0x60, 0x63, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x10, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x20, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xF1, 0x0F, 0x00, 0x70, 0x40,
  0x80, 0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x60, 0x20, 0x00, 0x18, 0x18, 0x00, 0x04, 0x06, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x08, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x03,
  0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x08, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x10, 0x30,
  0x0C, 0x04, 0x38, 0x03, 0xF3, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xC0, 0x38, 0xC0, 0x02, 0x01, 0xC1, 0x80, 0x18,
  0x06, 0x06, 0x00, 0x40, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0x60, 0x20, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x06, 0x04, 0x01, 0x80, 0x30,
  0x30, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x03, 0x06, 0x00, 0x60, 0x0C, 0x18,
  0x01, 0x80, 0x30, 0xC0, 0x04, 0x01, 0x83, 0x00, 0x30, 0x06, 0x18, 0x00,
  0xC0, 0x18, 0x60, 0xF3, 0x00, 0x63, 0x0F, 0xEC, 0x03, 0x0C, 0x71, 0xF0,
  0x0C, 0x63, 0x83, 0xC0, 0x61, 0x8C, 0x0F, 0x01, 0x8C, 0x60, 0x3C, 0x0C,
  0x31, 0x80, 0xD8, 0x31, 0x8C, 0x03, 0x61, 0x86, 0x30, 0x0C, 0xFC, 0x30,
  0xC0, 0x31, 0xE0, 0xC6, 0x00, 0xC0, 0x06, 0x18, 0x03, 0x00, 0x18, 0x60,
  0x0C, 0x00, 0xC1, 0x00, 0x20, 0x03, 0x0C, 0x01, 0x80, 0x18, 0x30, 0x06,
  0x00, 0x60, 0xC0, 0x18, 0x03, 0x03, 0x00, 0x60, 0x0C, 0x0C, 0x01, 0x00,
  0x60, 0x20, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x06,
  0x03, 0x00, 0xC0, 0x08, 0x18, 0x06, 0x00, 0x30, 0x60, 0x18, 0x00, 0xC3,
  0x00, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0E, 0x00, 0x38, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x60, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00,
  0xC6, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x30, 0xC0, 0xC0, 0xC6, 0x01,
  0x02, 0x18, 0x06, 0x18, 0xC0, 0x18, 0x63, 0x00, 0x61, 0x18, 0x00, 0x8C,
  0x60, 0x03, 0x31, 0x80, 0x0C, 0x8C, 0x00, 0x36, 0x30, 0x00, 0x58, 0xC0,
  0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03,
  0xC3, 0x80, 0x1B, 0x06, 0x00, 0xCC, 0x1C, 0x06, 0x10, 0x38, 0x70, 0x40,
  0x7F, 0x81, 0x80, 0x78, 0x00, 0x00, 0x18, 0xCC, 0x63, 0x18, 0x8C, 0x63,
  0x10, 0x84, 0x63, 0x10, 0x84, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x04, 0x04, 0x07, 0x06, 0x00, 0xE3, 0x00, 0x19,
  0x07, 0x03, 0xBE, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xC8, 0x00, 0xC6, 0x00,
  0xC1, 0x00, 0xC0, 0x40, 0x80, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x81, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x04, 0x06,
  0x00, 0x10, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x06, 0x00, 0x04, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x60, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x10, 0x01, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x38, 0x70,
  0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0,
  0x3B, 0x06, 0x21, 0xC6, 0x38, 0x67, 0x06, 0x20, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xC0, 0x70, 0x01, 0xC0, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x02, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x60,
  0x00, 0x01, 0xA0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x30, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x70, 0x03,
  0xC0, 0x78, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x38, 0x08, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x07, 0xC0, 0x06, 0x3F,
  0xE0, 0x09, 0xC0, 0xE0, 0x33, 0x00, 0x60, 0x68, 0x00, 0xC0, 0xF0, 0x00,
  0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20,
  0x00, 0x30, 0x40, 0x00, 0x60, 0x80, 0x01, 0x81, 0x00, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x0E, 0x00, 0x38, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x03, 0x80, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x07, 0x03, 0x00, 0x01, 0x87, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x04, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0x70, 0x03, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0xE0, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C,
  0x00, 0x1C, 0x18, 0x00, 0x78, 0x18, 0x01, 0xB0, 0x30, 0x06, 0xC0, 0x38,
  0x39, 0x80, 0x3F, 0xE3, 0x00, 0x1E, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x81, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x10, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x7F, 0x03, 0x0C,
  0x01, 0xE7, 0x03, 0x0C, 0x03, 0x83, 0x03, 0x18, 0x07, 0x06, 0x03, 0x18,
  0x06, 0x06, 0x03, 0x18, 0x0C, 0x06, 0x03, 0x30, 0x0C, 0x06, 0x03, 0x30,
  0x18, 0x0C, 0x06, 0x30, 0x18, 0x0C, 0x06, 0x30, 0x30, 0x0C, 0x06, 0x60,
  0x30, 0x0C, 0x06, 0x60, 0x30, 0x18, 0x06, 0x60, 0x60, 0x18, 0x04, 0x60,
  0x60, 0x18, 0x0C, 0x60, 0x60, 0x18, 0x0C, 0xC0, 0x60, 0x30, 0x0C, 0xC0,
  0x40, 0x30, 0x18, 0xC0, 0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x70, 0x18, 0xC0,
  0xC0, 0x60, 0x30, 0xC0, 0xC0, 0x60, 0x30, 0xC0, 0xC0, 0xE0, 0x60, 0xC0,
  0xC0, 0xA0, 0x60, 0xC0, 0xC1, 0xA0, 0xC0, 0xC0, 0x63, 0x31, 0x80, 0xC0,
  0x7E, 0x3F, 0x80, 0xC0, 0x3C, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x09, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x07, 0xFF, 0xE0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x3F, 0xF8, 0x00, 0x0C, 0x1F, 0x80, 0x03, 0x00, 0x70, 0x00, 0xC0,
  0x0E, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x08, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x1C, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x06, 0x01, 0xE0, 0x01, 0x80, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x04, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x70, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xF0, 0x08, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x1F, 0x80, 0x00, 0xC0, 0x3C,
  0x00, 0x18, 0x01, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x08, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00,
  0x80, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x0E,
  0x00, 0x18, 0x0F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x01, 0xFF, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x04, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x30, 0x02, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x08, 0x00, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x08, 0x38, 0x00, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x30, 0x01,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x02, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x4D, 0x00, 0x00, 0x06, 0xCC, 0x00, 0x00, 0x34, 0x60,
  0x00, 0x01, 0xE3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE0, 0x40, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08,
  0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x02, 0xC0, 0x00, 0x00, 0xD0, 0x03,
  0x60, 0x00, 0x00, 0x78, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x26, 0x00, 0x00, 0x19,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x0C,
  0xC0, 0x00, 0x0C, 0x60, 0x06, 0x60, 0x00, 0x06, 0x30, 0x06, 0x30, 0x00,
  0x06, 0x10, 0x03, 0x18, 0x00, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x01, 0x0C,
  0x00, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x41, 0x00, 0x00, 0xC2, 0x00, 0x60,
  0x80, 0x00, 0xC3, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x18, 0x20, 0x00,
  0x60, 0xC0, 0x0C, 0x10, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x00, 0x30, 0x20,
  0x06, 0x06, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x06,
  0x02, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0xC0,
  0x18, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x00, 0x80, 0x30, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x30, 0x06, 0x00, 0x60, 0x04, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x8C, 0x00, 0xC0, 0x08, 0x00, 0xCC, 0x00,
  0x40, 0x0C, 0x00, 0x66, 0x00, 0x60, 0x06, 0x00, 0x36, 0x00, 0x30, 0x03,
  0x00, 0x1B, 0x00, 0x18, 0x01, 0x00, 0x0F, 0x00, 0x0C, 0x01, 0x80, 0x07,
  0x80, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0x80,
  0x00, 0x60, 0x02, 0xC0, 0x00, 0x30, 0x03, 0x60, 0x00, 0x18, 0x01, 0xB0,
  0x00, 0x18, 0x00, 0xC8, 0x00, 0x0C, 0x00, 0x66, 0x00, 0x06, 0x00, 0x23,
  0x00, 0x03, 0x00, 0x31, 0x80, 0x01, 0x80, 0x18, 0xC0, 0x01, 0x80, 0x0C,
  0x60, 0x00, 0xC0, 0x06, 0x10, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x30, 0x03,
  0x06, 0x00, 0x10, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00,
  0x40, 0x40, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00,
  0x18, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x80, 0x30, 0x03, 0x00, 0x60, 0x30, 0x01, 0x80, 0x30, 0x18,
  0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x02, 0x02,
  0x00, 0x30, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x60,
  0xC0, 0x0C, 0x00, 0x30, 0x60, 0x06, 0x00, 0x18, 0x20, 0x03, 0x00, 0x06,
  0x30, 0x01, 0x80, 0x03, 0x18, 0x00, 0x80, 0x01, 0x8C, 0x00, 0xC0, 0x00,
  0xC6, 0x00, 0x60, 0x00, 0x66, 0x00, 0x30, 0x00, 0x13, 0x00, 0x18, 0x00,
  0x0D, 0x80, 0x08, 0x00, 0x06, 0xC0, 0x0C, 0x00, 0x03, 0x40, 0x06, 0x00,
  0x01, 0xE0, 0x03, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x7E, 0x00, 0x0C, 0x03, 0x80, 0x06,
  0x00, 0xE0, 0x02, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x04, 0x00, 0x70, 0x06, 0x00, 0x70, 0x03, 0x01, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x7E, 0x00,
  0x0C, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x20, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x02, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x08, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x38,
  0x03, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x04, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0x81, 0x80, 0x01,
  0x03, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x08, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0x21, 0x80, 0x00, 0x46, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x10,
  0x00, 0x02, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x80, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0xE0, 0x00, 0x31, 0x00, 0x00, 0xB0, 0x00, 0x18, 0x80, 0x00,
  0xD8, 0x00, 0x18, 0x40, 0x00, 0x6C, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00,
  0x0C, 0x10, 0x00, 0x33, 0x00, 0x06, 0x08, 0x00, 0x11, 0x80, 0x02, 0x04,
  0x00, 0x18, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x60, 0x01, 0x81, 0x00, 0x0C,
  0x30, 0x01, 0x80, 0x80, 0x06, 0x18, 0x00, 0xC0, 0x40, 0x02, 0x0C, 0x00,
  0x40, 0x20, 0x03, 0x04, 0x00, 0x60, 0x10, 0x01, 0x82, 0x00, 0x30, 0x18,
  0x01, 0x81, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x80, 0x18, 0x06, 0x00, 0x40,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x10, 0x06,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x00, 0x60, 0x18, 0x04, 0x03, 0x00, 0x30,
  0x0C, 0x06, 0x01, 0x00, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x30, 0x20, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x01, 0x88, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x50, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x01, 0x80, 0x40, 0x06, 0x01, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x60, 0x00,
  0x21, 0x80, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x0D, 0x80, 0x00, 0x34,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x60, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x06,
  0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x84, 0x03, 0x81, 0x88, 0x0E, 0x01, 0xB0, 0x18, 0x01, 0x60, 0x60, 0x02,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0x60, 0x03, 0xC0, 0x60, 0x05, 0x80, 0xC0, 0x1B, 0x01, 0xC0, 0x64, 0x01,
  0xC3, 0x88, 0x01, 0xFE, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC1, 0xF0, 0x00, 0xC7, 0xF8,
  0x00, 0x8C, 0x1C, 0x01, 0x98, 0x0E, 0x01, 0xB0, 0x06, 0x01, 0xE0, 0x06,
  0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30,
  0x38, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x68, 0x00, 0xC0, 0x6C, 0x01, 0x80,
  0x4C, 0x03, 0x00, 0x47, 0x0E, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0x81, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x08, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7C,
  0x10, 0x00, 0x3F, 0xC6, 0x00, 0x1C, 0x0C, 0xC0, 0x07, 0x00, 0xD8, 0x00,
  0xC0, 0x0B, 0x00, 0x30, 0x01, 0x40, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x07,
  0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x0C,
  0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x30, 0x01, 0xE0, 0x03, 0x00, 0x2C,
  0x00, 0x60, 0x0D, 0x80, 0x0E, 0x03, 0x20, 0x00, 0xE1, 0xC4, 0x00, 0x0F,
  0xF1, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x03,
  0x83, 0x80, 0xE0, 0x30, 0x38, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x1C, 0x0C, 0x1E,
  0x01, 0xFF, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x10, 0x1C, 0x0E, 0x01, 0xFF, 0x80, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x23, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x10, 0x01, 0xC0, 0xC4, 0x00, 0xE0,
  0x1B, 0x00, 0x30, 0x02, 0xC0, 0x18, 0x00, 0xA0, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x10, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x06, 0x00,
  0x1C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0xB0, 0x03,
  0x00, 0x6C, 0x00, 0xE0, 0x32, 0x00, 0x1C, 0x39, 0x80, 0x03, 0xFC, 0x60,
  0x00, 0x3C, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x08, 0x01, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x61, 0xF8, 0x00, 0xCF, 0xF8, 0x01, 0x38, 0x38,
  0x02, 0xC0, 0x30, 0x0D, 0x00, 0x30, 0x1E, 0x00, 0x60, 0x38, 0x00, 0xC0,
  0x60, 0x01, 0x00, 0xC0, 0x02, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00, 0x06, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30,
  0x00, 0x40, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x23, 0x80, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x30, 0x1C, 0x00, 0x40, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00,
  0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x60, 0x00, 0x61, 0x80, 0x00,
  0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x3C, 0x00, 0x0C, 0xD8, 0x00, 0x1B,
  0x30, 0x00, 0x34, 0x60, 0x00, 0x78, 0xC0, 0x00, 0xE0, 0x80, 0x03, 0x81,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18,
  0x00, 0xC0, 0x10, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x06, 0x01,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x43, 0xE0, 0x1F, 0x00,
  0x08, 0xFF, 0x87, 0xFC, 0x00, 0x98, 0x18, 0xC0, 0xE0, 0x1B, 0x00, 0xD8,
  0x06, 0x01, 0xE0, 0x0F, 0x00, 0x20, 0x1C, 0x00, 0xE0, 0x03, 0x01, 0xC0,
  0x0E, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x02, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x18, 0x00, 0x40, 0x60, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x60, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x40, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x20, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x01, 0x01, 0x80, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0x03, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x02, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x08, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x06, 0x02, 0x00, 0x18, 0x00, 0x40, 0x60, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x00, 0x43, 0xE0, 0x01, 0x1F, 0xF0,
  0x02, 0x70, 0x70, 0x0D, 0x80, 0x60, 0x1E, 0x00, 0x40, 0x38, 0x00, 0xC0,
  0x70, 0x01, 0x80, 0xC0, 0x02, 0x03, 0x80, 0x04, 0x07, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x08,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x81,
  0x80, 0x02, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x10,
  0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x38,
  0x38, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x03, 0x80, 0x18, 0x18, 0x00, 0x61,
  0xC0, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x64, 0x00, 0x03,
  0x60, 0x00, 0x13, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xE0, 0x06, 0x03, 0x00, 0x60, 0x1C, 0x07,
  0x00, 0x70, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x3E,
  0x00, 0x02, 0x1F, 0xE0, 0x00, 0x46, 0x0E, 0x00, 0x09, 0x80, 0xE0, 0x03,
  0x60, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x03,
  0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x18, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x60, 0x0E,
  0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0D, 0x00, 0x18,
  0x01, 0xB0, 0x06, 0x00, 0x36, 0x01, 0x80, 0x06, 0x60, 0xE0, 0x00, 0x87,
  0xF8, 0x00, 0x30, 0x38, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x84, 0x03, 0x81, 0x88, 0x0E, 0x01, 0xB0, 0x18, 0x03, 0x60, 0x60,
  0x02, 0x81, 0x80, 0x05, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00,
  0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xE0, 0x60, 0x03, 0xC0, 0x40, 0x05, 0x80, 0xC0, 0x1B, 0x01, 0xC0, 0x64,
  0x01, 0xC3, 0x98, 0x01, 0xFE, 0x30, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x43, 0xE0, 0x11, 0xFC, 0x02, 0x70,
  0x00, 0xD8, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x50, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0x20, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x20, 0x06, 0x01, 0xC0, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00,
  0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x01, 0x83,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00,
  0x08, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x18,
  0x30, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20,
  0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03,
  0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x02, 0x80, 0xC0, 0x1E, 0x03, 0x00,
  0xD8, 0x06, 0x0E, 0x60, 0x0F, 0xF1, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x10, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xC8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x1B, 0x00, 0x0E, 0x00, 0x36, 0x00, 0x1C, 0x00, 0x4C, 0x00,
  0x78, 0x01, 0x98, 0x00, 0xB0, 0x03, 0x30, 0x03, 0x60, 0x0C, 0x60, 0x06,
  0xC0, 0x18, 0xC0, 0x09, 0x80, 0x21, 0x80, 0x33, 0x00, 0xC3, 0x00, 0x46,
  0x01, 0x86, 0x01, 0x8C, 0x06, 0x0C, 0x03, 0x18, 0x0C, 0x18, 0x0C, 0x30,
  0x10, 0x30, 0x18, 0x60, 0x60, 0x60, 0x20, 0xC0, 0xC0, 0xC0, 0xC1, 0x81,
  0x01, 0x81, 0x83, 0x06, 0x03, 0x06, 0x06, 0x08, 0x06, 0x0C, 0x0C, 0x30,
  0x0C, 0x10, 0x18, 0x60, 0x18, 0x60, 0x30, 0x80, 0x30, 0xC0, 0x63, 0x00,
  0x63, 0x00, 0xC6, 0x00, 0xC6, 0x01, 0x98, 0x01, 0x88, 0x03, 0x30, 0x03,
  0x30, 0x06, 0x40, 0x06, 0x60, 0x0D, 0x80, 0x0D, 0x80, 0x13, 0x00, 0x1B,
  0x00, 0x24, 0x00, 0x34, 0x00, 0x58, 0x00, 0x78, 0x00, 0xA0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x03, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x04,
  0x30, 0x00, 0x02, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x04, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x02, 0x00, 0x06, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x18, 0x00, 0x02, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x87, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x7B, 0xE0, 0x07, 0x80, 0xF0,
  0x1E, 0x00, 0x78, 0xE8, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 49, 14, 1, -49 },
  { 81, 13, 18, 18, 7, -49 },
  { 111, 26, 49, 25, 0, -49 },
  { 271, 26, 56, 24, -1, -52 },
  { 453, 30, 51, 36, 3, -50 },
  { 645, 22, 51, 22, -1, -50 },
  { 786, 5, 18, 10, 7, -49 },
  { 798, 18, 60, 17, 2, -49 },
  { 933, 19, 60, 17, -5, -49 },
  { 1076, 17, 18, 22, 8, -52 },
  { 1115, 23, 32, 28, 2, -40 },
  { 1207, 9, 15, 11, -3, -6 },
  { 1224, 14, 2, 18, 2, -20 },
  { 1228, 3, 5, 11, 1, -5 },
  { 1230, 28, 49, 20, -3, -49 },
  { 1402, 22, 51, 24, 1, -50 },
  { 1543, 12, 49, 24, 7, -49 },
  { 1617, 26, 50, 24, -2, -50 },
  { 1780, 26, 51, 24, -2, -50 },
  { 1946, 25, 50, 24, -1, -50 },
  { 2103, 26, 50, 24, -2, -49 },
  { 2266, 23, 51, 24, 2, -50 },
  { 2413, 23, 49, 24, 3, -49 },
  { 2554, 25, 51, 24, -1, -50 },
  { 2714, 23, 51, 24, 0, -50 },
  { 2861, 10, 37, 11, 0, -37 },
  { 2908, 14, 46, 11, -3, -37 },
  { 2989, 23, 29, 28, 2, -39 },
  { 3073, 23, 17, 28, 2, -33 },
  { 3122, 23, 29, 28, 2, -39 },
  { 3206, 18, 50, 17, 1, -50 },
  { 3319, 32, 56, 35, 2, -50 },
  { 3543, 23, 49, 23, -5, -49 },
  { 3684, 26, 49, 26, 0, -49 },
  { 3844, 26, 51, 23, 3, -50 },
  { 4010, 27, 49, 28, 0, -49 },
  { 4176, 26, 49, 23, 0, -49 },
  { 4336, 26, 49, 22, 0, -49 },
  { 4496, 31, 51, 31, 2, -50 },
  { 4694, 31, 49, 30, 0, -49 },
  { 4884, 20, 49, 11, -4, -49 },
  { 5007, 22, 61, 11, -10, -49 },
  { 5175, 29, 49, 24, 0, -49 },
  { 5353, 15, 49, 21, 0, -49 },
  { 5445, 41, 49, 41, 0, -49 },
  { 5697, 33, 49, 32, 0, -49 },
  { 5900, 27, 51, 31, 2, -50 },
  { 6073, 25, 49, 24, 0, -49 },
  { 6227, 27, 62, 31, 2, -50 },
  { 6437, 25, 49, 25, 0, -49 },
  { 6591, 27, 51, 24, -2, -50 },
  { 6764, 22, 49, 20, 4, -49 },
  { 6899, 29, 50, 29, 2, -49 },
  { 7081, 23, 49, 24, 6, -49 },
  { 7222, 41, 49, 41, 5, -49 },
  { 7474, 30, 49, 21, -4, -49 },
  { 7658, 22, 49, 20, 4, -49 },
  { 7793, 28, 49, 21, -3, -49 },
  { 7965, 24, 60, 19, -1, -49 },
  { 8145, 9, 49, 22, 7, -49 },
  { 8201, 24, 60, 19, -4, -49 },
  { 8381, 25, 23, 27, 2, -49 },
  { 8453, 17, 2, 18, -5, 6 },
  { 8458, 6, 11, 14, 10, -53 },
  { 8467, 23, 38, 26, 2, -37 },
  { 8577, 24, 53, 26, 0, -52 },
  { 8736, 19, 38, 19, 2, -37 },
  { 8827, 27, 53, 26, 2, -52 },
  { 9006, 19, 38, 23, 2, -37 },
  { 9097, 30, 70, 13, -9, -53 },
  { 9360, 26, 54, 26, -1, -37 },
  { 9536, 23, 52, 25, 0, -52 },
  { 9686, 13, 49, 11, 0, -49 },
  { 9766, 22, 66, 11, -9, -49 },
  { 9948, 23, 52, 20, 0, -52 },
  { 10098, 13, 52, 10, 0, -52 },
  { 10183, 36, 37, 38, 0, -37 },
  { 10350, 23, 37, 25, 0, -37 },
  { 10457, 21, 38, 25, 2, -37 },
  { 10557, 27, 53, 26, -3, -37 },
  { 10736, 23, 53, 26, 2, -37 },
  { 10889, 19, 37, 16, 0, -37 },
  { 10977, 21, 38, 19, -1, -37 },
  { 11077, 13, 46, 12, 1, -45 },
  { 11152, 22, 37, 25, 2, -36 },
  { 11254, 18, 36, 19, 4, -36 },
  { 11335, 31, 36, 32, 4, -36 },
  { 11475, 25, 36, 20, -3, -36 },
  { 11588, 32, 53, 20, -8, -36 },
  { 11800, 20, 36, 16, -2, -36 },
  { 11890, 24, 60, 21, 2, -49 },
  { 12070, 2, 70, 24, 11, -53 },
  { 12088, 24, 60, 21, -5, -49 },
  { 12268, 23, 5, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC69PT7B_H_
