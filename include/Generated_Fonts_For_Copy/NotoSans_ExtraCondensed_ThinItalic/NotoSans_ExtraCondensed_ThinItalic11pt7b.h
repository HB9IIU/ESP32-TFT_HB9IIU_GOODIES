#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0xFC, 0x33, 0x76, 0x6A, 0xAC, 0x36, 0x44, 0x26, 0x6C,
  0x40, 0xDD, 0xEB, 0xB5, 0xBA, 0x6D, 0xAD, 0x6F, 0xE0, 0x25, 0x49, 0x24,
  0x90, 0x24, 0x92, 0x4A, 0x50, 0xCE, 0x80, 0x22, 0xF2, 0x20, 0xC0, 0xE0,
  0x80, 0x08, 0x44, 0x22, 0x21, 0x10, 0x35, 0x59, 0x9A, 0xAE, 0x75, 0x6A,
  0x71, 0x11, 0x24, 0x8E, 0x71, 0x16, 0x22, 0x2E, 0x13, 0x26, 0xAA, 0x62,
  0x74, 0x44, 0x21, 0x2E, 0x34, 0x46, 0x99, 0xAE, 0x71, 0x12, 0x24, 0x48,
  0x75, 0x56, 0xAA, 0xAE, 0x75, 0x99, 0x62, 0x2C, 0x40, 0x20, 0x20, 0x00,
  0xB0, 0x3C, 0x43, 0xFF, 0xC3, 0x3C, 0x64, 0xA5, 0x04, 0x3A, 0x57, 0x7D,
  0xEE, 0xD0, 0xE0, 0x11, 0x33, 0x75, 0x59, 0x75, 0x57, 0x99, 0x9E, 0x3A,
  0x11, 0x08, 0x42, 0x1C, 0x75, 0x55, 0x99, 0x9E, 0x74, 0x46, 0x88, 0x8E,
  0x74, 0x44, 0xA8, 0x88, 0x3A, 0x11, 0x09, 0xC6, 0x4E, 0x4A, 0x52, 0xD9,
  0x4A, 0x52, 0x32, 0x22, 0x44, 0x4C, 0x11, 0x11, 0x22, 0x22, 0x2C, 0x4A,
  0x98, 0x8A, 0x52, 0x94, 0x55, 0xAB, 0x42, 0x89, 0x12, 0x6A, 0xD6, 0xA9,
  0x54, 0x4A, 0x52, 0xDA, 0xDA, 0x52, 0x3A, 0x53, 0x18, 0xCA, 0x5C, 0x75,
  0x55, 0x68, 0x88, 0x3A, 0x53, 0x18, 0xCA, 0x5C, 0x21, 0x00, 0x75, 0x55,
  0xAA, 0xAA, 0x74, 0x44, 0x22, 0x2E, 0xE9, 0x49, 0x24, 0x4A, 0x52, 0xA9,
  0x4A, 0x5C, 0x9A, 0xAA, 0xC8, 0x88, 0x96, 0x9A, 0x76, 0xDA, 0xAB, 0x28,
  0x29, 0x4C, 0x42, 0x29, 0x52, 0xB7, 0x49, 0x24, 0x71, 0x22, 0x48, 0x8C,
  0x74, 0x44, 0x48, 0x88, 0x8C, 0xAA, 0x95, 0x31, 0x11, 0x12, 0x22, 0x2C,
  0x26, 0x59, 0xE0, 0x80, 0x75, 0x99, 0xAE, 0x44, 0x75, 0x99, 0x9E, 0x6A,
  0x49, 0x80, 0x08, 0x5C, 0xA9, 0x4A, 0x9C, 0x6E, 0xE9, 0xC0, 0x32, 0x22,
  0x24, 0x44, 0x48, 0x80, 0x75, 0x99, 0xAE, 0x22, 0xC0, 0x44, 0x75, 0x9A,
  0xAA, 0x45, 0xAA, 0x20, 0x92, 0x92, 0x52, 0x00, 0x44, 0x56, 0xCC, 0xAA,
  0x55, 0xAA, 0x7D, 0x59, 0x69, 0xAA, 0xA0, 0x75, 0x9A, 0xAA, 0x75, 0x99,
  0xAE, 0x75, 0x99, 0x9E, 0x88, 0x80, 0x75, 0x99, 0xAE, 0x22, 0x20, 0x6A,
  0x49, 0x00, 0x71, 0x23, 0x80, 0x56, 0xA8, 0x55, 0x9A, 0xAE, 0xBB, 0x49,
  0x00, 0xAE, 0xAD, 0x4A, 0x50, 0x6D, 0x2D, 0x40, 0x29, 0x4C, 0x42, 0x11,
  0x08, 0x80, 0x65, 0x29, 0x80, 0x12, 0x24, 0xC4, 0x44, 0x84, 0xFF, 0xE0,
  0x31, 0x11, 0x32, 0x22, 0x48, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 2, 3, 3, 1, -8 },
  { 4, 4, 8, 4, 0, -8 },
  { 8, 4, 9, 4, 0, -8 },
  { 13, 4, 8, 6, 1, -8 },
  { 17, 3, 8, 4, 0, -8 },
  { 20, 1, 3, 2, 1, -8 },
  { 21, 3, 10, 3, 0, -8 },
  { 25, 3, 10, 3, -1, -8 },
  { 29, 3, 3, 3, 1, -8 },
  { 31, 4, 5, 4, 0, -6 },
  { 34, 1, 2, 2, 0, -1 },
  { 35, 3, 1, 3, 0, -3 },
  { 36, 1, 1, 2, 0, -1 },
  { 37, 5, 8, 3, -1, -8 },
  { 42, 4, 8, 4, 0, -8 },
  { 46, 2, 8, 4, 1, -8 },
  { 48, 4, 8, 4, 0, -8 },
  { 52, 4, 8, 4, 0, -8 },
  { 56, 4, 8, 4, 0, -8 },
  { 60, 4, 8, 4, 0, -8 },
  { 64, 4, 8, 4, 0, -8 },
  { 68, 4, 8, 4, 0, -8 },
  { 72, 4, 8, 4, 0, -8 },
  { 76, 4, 8, 4, 0, -8 },
  { 80, 2, 6, 2, 0, -6 },
  { 82, 3, 7, 2, -1, -6 },
  { 85, 4, 4, 4, 0, -6 },
  { 87, 4, 2, 4, 0, -5 },
  { 88, 4, 4, 4, 0, -6 },
  { 90, 3, 8, 3, 0, -8 },
  { 93, 5, 9, 6, 0, -8 },
  { 99, 4, 8, 4, -1, -8 },
  { 103, 4, 8, 4, 0, -8 },
  { 107, 5, 8, 4, 0, -8 },
  { 112, 4, 8, 5, 0, -8 },
  { 116, 4, 8, 4, 0, -8 },
  { 120, 4, 8, 3, 0, -8 },
  { 124, 5, 8, 5, 0, -8 },
  { 129, 5, 8, 5, 0, -8 },
  { 134, 4, 8, 2, -1, -8 },
  { 138, 4, 10, 2, -2, -8 },
  { 143, 5, 8, 4, 0, -8 },
  { 148, 2, 8, 3, 0, -8 },
  { 150, 7, 8, 6, 0, -8 },
  { 157, 5, 8, 5, 0, -8 },
  { 162, 5, 8, 5, 0, -8 },
  { 167, 4, 8, 4, 0, -8 },
  { 171, 5, 10, 5, 0, -8 },
  { 178, 4, 8, 4, 0, -8 },
  { 182, 4, 8, 4, 0, -8 },
  { 186, 3, 8, 3, 1, -8 },
  { 189, 5, 8, 5, 0, -8 },
  { 194, 4, 8, 4, 1, -8 },
  { 198, 6, 8, 7, 1, -8 },
  { 204, 5, 8, 3, -1, -8 },
  { 209, 3, 8, 3, 1, -8 },
  { 212, 4, 8, 3, 0, -8 },
  { 216, 4, 10, 3, 0, -8 },
  { 221, 2, 8, 4, 1, -8 },
  { 223, 4, 10, 3, -1, -8 },
  { 228, 4, 4, 4, 0, -8 },
  { 230, 3, 1, 3, -1, 1 },
  { 231, 1, 1, 2, 2, -8 },
  { 232, 4, 6, 4, 0, -6 },
  { 235, 4, 8, 4, 0, -8 },
  { 239, 3, 6, 3, 0, -6 },
  { 242, 5, 8, 4, 0, -8 },
  { 247, 3, 6, 4, 0, -6 },
  { 250, 4, 11, 2, -1, -8 },
  { 256, 4, 9, 4, 0, -6 },
  { 261, 4, 8, 4, 0, -8 },
  { 265, 2, 8, 2, 0, -8 },
  { 267, 3, 11, 2, -1, -8 },
  { 272, 4, 8, 3, 0, -8 },
  { 276, 2, 8, 2, 0, -8 },
  { 278, 6, 6, 6, 0, -6 },
  { 283, 4, 6, 4, 0, -6 },
  { 286, 4, 6, 4, 0, -6 },
  { 289, 4, 9, 4, 0, -6 },
  { 294, 4, 9, 4, 0, -6 },
  { 299, 3, 6, 3, 0, -6 },
  { 302, 3, 6, 3, 0, -6 },
  { 305, 2, 7, 2, 0, -7 },
  { 307, 4, 6, 4, 0, -6 },
  { 310, 3, 6, 3, 1, -6 },
  { 313, 5, 6, 5, 1, -6 },
  { 317, 3, 6, 3, 0, -6 },
  { 320, 5, 9, 3, -1, -6 },
  { 326, 3, 6, 3, 0, -6 },
  { 329, 4, 10, 3, 0, -8 },
  { 334, 1, 11, 4, 1, -8 },
  { 336, 4, 10, 3, -1, -8 },
  { 341, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC11PT7B_H_
