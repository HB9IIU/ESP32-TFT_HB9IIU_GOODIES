#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x30, 0x00, 0x30, 0x90, 0xC8, 0x6C, 0x24, 0x12, 0x09,
  0x0C, 0x84, 0xC2, 0x41, 0x20, 0x90, 0x88, 0x40, 0x00, 0x10, 0x60, 0x06,
  0x08, 0x00, 0x81, 0x00, 0x10, 0x60, 0x06, 0x08, 0x00, 0x81, 0x00, 0x10,
  0x60, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x60, 0x3F, 0xFF, 0x80, 0xC1,
  0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x0C,
  0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x18, 0x20,
  0x3F, 0xFF, 0x80, 0x41, 0x00, 0x18, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00,
  0x18, 0x20, 0x02, 0x04, 0x00, 0x41, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00,
  0x41, 0x80, 0x08, 0x20, 0x03, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x64, 0x70, 0x21, 0x00,
  0x10, 0x40, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08,
  0x20, 0x03, 0x08, 0x00, 0xC4, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0xD0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x09, 0x00,
  0x06, 0x60, 0x01, 0x08, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04, 0x30, 0x03,
  0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x60, 0x06, 0x30, 0x31, 0x38,
  0x07, 0xF8, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x07, 0xC0, 0x10, 0x31, 0x00, 0x80, 0x86, 0x02, 0x04, 0x18,
  0x18, 0x10, 0x60, 0x40, 0xC1, 0x83, 0x02, 0x06, 0x08, 0x08, 0x18, 0x60,
  0x60, 0x41, 0x01, 0x01, 0x0C, 0x04, 0x04, 0x20, 0x10, 0x11, 0x80, 0x40,
  0xC4, 0x03, 0x02, 0x30, 0x0C, 0x08, 0x8F, 0xB0, 0x66, 0x62, 0xC1, 0x13,
  0x0B, 0x04, 0xC8, 0x2C, 0x22, 0x60, 0xD1, 0x99, 0x02, 0x7C, 0x44, 0x08,
  0x03, 0x30, 0x20, 0x08, 0x80, 0x80, 0x62, 0x02, 0x01, 0x08, 0x18, 0x0C,
  0x60, 0x60, 0x21, 0x81, 0x01, 0x84, 0x04, 0x04, 0x10, 0x30, 0x30, 0x40,
  0xC0, 0x81, 0x02, 0x06, 0x04, 0x18, 0x10, 0x18, 0x40, 0xC0, 0x63, 0x02,
  0x00, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00, 0xC6, 0x00, 0x82, 0x01,
  0x82, 0x01, 0x02, 0x01, 0x02, 0x01, 0x06, 0x01, 0x06, 0x01, 0x04, 0x01,
  0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x10, 0x01, 0x30, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0x40, 0x18, 0x41, 0x10,
  0x43, 0x30, 0x62, 0x20, 0x22, 0x60, 0x26, 0x40, 0x24, 0x40, 0x34, 0x40,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0x40, 0x28, 0x40, 0x48, 0x60,
  0xC8, 0x3F, 0x8C, 0x32, 0x26, 0x44, 0x44, 0xC8, 0x88, 0x80, 0x00, 0x0C,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x08, 0x20, 0x62, 0x01, 0x47, 0x0F, 0x80, 0xC0,
  0x12, 0x02, 0x10, 0x41, 0x08, 0x08, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F, 0xFF, 0xF0, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0C, 0x20, 0x86,
  0x10, 0xC2, 0x08, 0x42, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0x86, 0x01, 0x02, 0x02, 0x02, 0x06, 0x03, 0x04, 0x03,
  0x0C, 0x03, 0x08, 0x03, 0x08, 0x03, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02,
  0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0x80, 0x08,
  0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x60,
  0x80, 0x40, 0xC0, 0xC0, 0x40, 0x80, 0x61, 0x00, 0x3E, 0x00, 0x01, 0x81,
  0xC3, 0x43, 0x23, 0x13, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x00, 0x00, 0x7F, 0x00, 0x38, 0x30, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x83, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0xE0, 0x60, 0x20, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x01, 0xF0, 0x00, 0xBC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x20, 0x38, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x03,
  0x20, 0x00, 0x98, 0x00, 0x64, 0x00, 0x11, 0x00, 0x08, 0x40, 0x06, 0x30,
  0x01, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x10, 0x20, 0x0C, 0x18, 0x02,
  0x04, 0x01, 0x81, 0x00, 0x40, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02,
  0x03, 0x00, 0x80, 0x80, 0x20, 0x40, 0x18, 0x30, 0x06, 0x0F, 0xFF, 0xF0,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xBC, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x20, 0x38, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x8F, 0xC0, 0x58, 0x30, 0x78,
  0x08, 0x28, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x84, 0x00, 0x46, 0x00, 0x23,
  0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x60, 0x30,
  0x60, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x30, 0x60,
  0x10, 0x0C, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x18,
  0x01, 0x06, 0x00, 0x41, 0x80, 0x30, 0x20, 0x08, 0x08, 0x06, 0x03, 0x01,
  0x00, 0x40, 0x80, 0x18, 0xC0, 0x03, 0x60, 0x00, 0x60, 0x00, 0x68, 0x00,
  0x73, 0x00, 0x30, 0x60, 0x18, 0x08, 0x0C, 0x01, 0x02, 0x00, 0x41, 0x80,
  0x18, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x02,
  0x30, 0x01, 0x84, 0x00, 0x41, 0x00, 0x30, 0x60, 0x08, 0x0C, 0x0C, 0x01,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0xC3, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x40,
  0x10, 0x60, 0x08, 0x20, 0x04, 0x10, 0x03, 0x18, 0x01, 0x08, 0x00, 0x84,
  0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x20, 0x06,
  0x10, 0x07, 0x08, 0x03, 0x06, 0x02, 0x81, 0x86, 0x40, 0x7E, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x3F, 0x80, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xC1, 0x80, 0x00, 0x80, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xE0, 0xC1, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x70, 0x70, 0x01, 0x80, 0x20, 0x06, 0x00, 0x60, 0x18, 0x00, 0x40,
  0x60, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18,
  0x00, 0x04, 0x20, 0x3F, 0x08, 0xC0, 0xC4, 0x11, 0x03, 0x08, 0x22, 0x0C,
  0x30, 0x4C, 0x10, 0x41, 0x90, 0x60, 0x83, 0x20, 0x81, 0x06, 0xC1, 0x06,
  0x09, 0x86, 0x08, 0x12, 0x08, 0x10, 0x24, 0x10, 0x20, 0xC8, 0x20, 0xC1,
  0x10, 0xC1, 0x82, 0x61, 0x82, 0x0C, 0xC3, 0x0C, 0x11, 0x86, 0x18, 0x63,
  0x0C, 0x50, 0x86, 0x08, 0xA3, 0x0C, 0x1E, 0x3C, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0B,
  0x00, 0x0B, 0x00, 0x1B, 0x00, 0x13, 0x00, 0x13, 0x00, 0x23, 0x00, 0x23,
  0x00, 0x63, 0x00, 0x43, 0x00, 0xC3, 0x00, 0x83, 0x00, 0x83, 0x01, 0x83,
  0x01, 0x03, 0x03, 0x03, 0x02, 0x03, 0x03, 0xFF, 0x06, 0x03, 0x04, 0x03,
  0x0C, 0x03, 0x08, 0x03, 0x08, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03,
  0x20, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x01, 0xFE, 0x00, 0x30, 0x70, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x06, 0x00, 0x80, 0x80, 0x18, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08,
  0x18, 0x01, 0x02, 0x00, 0x60, 0x40, 0x08, 0x08, 0x02, 0x03, 0x00, 0xC0,
  0x60, 0x60, 0x0F, 0xF0, 0x01, 0x07, 0x00, 0x20, 0x10, 0x0C, 0x01, 0x01,
  0x80, 0x20, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x03, 0x04,
  0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0xC0, 0x08, 0x10,
  0x03, 0x02, 0x00, 0x40, 0x40, 0x30, 0x08, 0x1C, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x0F, 0xF0, 0x0E, 0x04, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x02, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x30, 0xE0, 0x04, 0x06, 0x00, 0x80, 0x60, 0x10, 0x04, 0x06, 0x00, 0xC0,
  0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00, 0x82,
  0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x08,
  0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x0C, 0x20,
  0x01, 0x84, 0x00, 0x20, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x20, 0x80,
  0x0C, 0x10, 0x01, 0x02, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x06, 0x02, 0x01,
  0x80, 0x40, 0x60, 0x18, 0x78, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFE, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0x80, 0x18, 0x06, 0x03, 0x00, 0x10, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x1F, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x10,
  0x80, 0x01, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x60, 0x01, 0x83, 0x00, 0x08, 0x08, 0x00, 0x40, 0x60, 0x02, 0x01,
  0x80, 0x10, 0x06, 0x01, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x04, 0x06,
  0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x08, 0x0C, 0x00,
  0x20, 0x20, 0x00, 0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40,
  0x60, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0xC0,
  0x02, 0x03, 0x00, 0x08, 0x0F, 0xFF, 0xE0, 0x20, 0x01, 0x80, 0x80, 0x04,
  0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x03, 0x01, 0x00, 0x08, 0x04,
  0x00, 0x20, 0x30, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00,
  0x40, 0x60, 0x01, 0x01, 0x80, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0,
  0x40, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x10, 0x18, 0x02, 0x01, 0x00,
  0x60, 0x10, 0x0C, 0x01, 0x00, 0x80, 0x30, 0x10, 0x02, 0x03, 0x00, 0x20,
  0x60, 0x02, 0x04, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00, 0x43, 0x00, 0x04,
  0x20, 0x00, 0x46, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x09, 0x80, 0x00,
  0xAC, 0x00, 0x0E, 0x40, 0x01, 0xC4, 0x00, 0x18, 0x40, 0x01, 0x06, 0x00,
  0x10, 0x60, 0x01, 0x02, 0x00, 0x30, 0x20, 0x02, 0x02, 0x00, 0x20, 0x30,
  0x02, 0x01, 0x00, 0x60, 0x10, 0x06, 0x01, 0x00, 0x40, 0x18, 0x04, 0x01,
  0x80, 0x40, 0x08, 0x0C, 0x00, 0x80, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x28, 0x09, 0x00, 0x03, 0x40,
  0x48, 0x00, 0x12, 0x02, 0x40, 0x01, 0xB0, 0x12, 0x00, 0x09, 0x01, 0x90,
  0x00, 0xC8, 0x08, 0x80, 0x04, 0x40, 0x44, 0x00, 0x66, 0x02, 0x20, 0x02,
  0x30, 0x31, 0x00, 0x31, 0x01, 0x88, 0x01, 0x08, 0x08, 0x40, 0x18, 0x40,
  0x42, 0x00, 0x86, 0x02, 0x10, 0x04, 0x30, 0x30, 0x80, 0x41, 0x01, 0x06,
  0x02, 0x08, 0x08, 0x30, 0x20, 0x40, 0x41, 0x81, 0x06, 0x02, 0x0C, 0x18,
  0x20, 0x30, 0x60, 0x81, 0x01, 0x01, 0x0C, 0x08, 0x08, 0x08, 0x40, 0x40,
  0x40, 0x46, 0x06, 0x06, 0x02, 0x20, 0x20, 0x30, 0x13, 0x01, 0x01, 0x00,
  0x90, 0x08, 0x08, 0x05, 0x80, 0xC0, 0x40, 0x28, 0x06, 0x06, 0x01, 0xC0,
  0x20, 0x30, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x02, 0x03, 0x00, 0x04, 0x07,
  0x00, 0x18, 0x0A, 0x00, 0x30, 0x14, 0x00, 0x40, 0x68, 0x00, 0x80, 0x90,
  0x01, 0x01, 0x30, 0x06, 0x02, 0x60, 0x08, 0x04, 0x40, 0x10, 0x18, 0x80,
  0x20, 0x21, 0x00, 0x40, 0x42, 0x01, 0x80, 0x86, 0x02, 0x03, 0x04, 0x04,
  0x06, 0x08, 0x08, 0x08, 0x10, 0x30, 0x10, 0x20, 0x60, 0x20, 0x60, 0x80,
  0xC0, 0xC1, 0x01, 0x80, 0x82, 0x02, 0x01, 0x0C, 0x04, 0x02, 0x18, 0x08,
  0x06, 0x20, 0x30, 0x0C, 0x40, 0x40, 0x08, 0x80, 0x80, 0x13, 0x01, 0x00,
  0x24, 0x06, 0x00, 0x48, 0x0C, 0x00, 0xD0, 0x10, 0x01, 0xA0, 0x20, 0x01,
  0xC0, 0x40, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0x00, 0x18, 0x30, 0x04, 0x03, 0x01, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00,
  0xC2, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01,
  0x90, 0x00, 0x32, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x64, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x62,
  0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x18, 0x30, 0x02, 0x06,
  0x00, 0xC0, 0x40, 0x30, 0x0C, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x63, 0xC0, 0x10, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x30,
  0x30, 0x04, 0x08, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x60, 0x0C, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x0C, 0x08, 0x06,
  0x02, 0x03, 0x00, 0x87, 0x80, 0x7F, 0x80, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x30, 0x04, 0x03,
  0x01, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x03,
  0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x32, 0x00, 0x06,
  0xC0, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0B,
  0x00, 0x03, 0x60, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x64,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x62, 0x00, 0x08, 0x40, 0x03, 0x08,
  0x00, 0x41, 0x00, 0x18, 0x30, 0x02, 0x06, 0x00, 0xC0, 0x40, 0x30, 0x0C,
  0x0C, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x61, 0xC0, 0x10, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x60,
  0x0C, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x08,
  0x08, 0x06, 0x02, 0x07, 0x00, 0xFF, 0x00, 0x61, 0x00, 0x18, 0x40, 0x04,
  0x18, 0x01, 0x06, 0x00, 0x40, 0x80, 0x30, 0x20, 0x08, 0x08, 0x02, 0x02,
  0x00, 0x80, 0xC0, 0x20, 0x10, 0x18, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40,
  0x40, 0x18, 0x30, 0x06, 0x0C, 0x00, 0x80, 0x00, 0x7F, 0xC0, 0x18, 0x0C,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x10, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C,
  0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x41,
  0x80, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00, 0x83, 0x00, 0x18,
  0x30, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x03,
  0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x80,
  0x08, 0x08, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00, 0xC0, 0x20, 0x06,
  0x06, 0x00, 0x3F, 0x80, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0xD0,
  0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x11, 0x00, 0x18, 0x80, 0x08,
  0x40, 0x0C, 0x20, 0x04, 0x10, 0x06, 0x08, 0x02, 0x04, 0x01, 0x02, 0x01,
  0x81, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x60, 0x10, 0x20, 0x08,
  0x10, 0x04, 0x18, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x84, 0x00, 0x42, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x80, 0x02, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xA0, 0x01, 0x80, 0x0D, 0x00, 0x0C, 0x00, 0x48, 0x00,
  0xA0, 0x02, 0x40, 0x05, 0x00, 0x32, 0x00, 0x68, 0x01, 0x10, 0x02, 0x40,
  0x18, 0x80, 0x12, 0x00, 0x84, 0x01, 0x10, 0x04, 0x20, 0x08, 0x80, 0x61,
  0x00, 0xC4, 0x02, 0x08, 0x04, 0x20, 0x30, 0x40, 0x21, 0x01, 0x02, 0x03,
  0x08, 0x08, 0x10, 0x10, 0xC0, 0xC0, 0x81, 0x86, 0x04, 0x04, 0x08, 0x30,
  0x60, 0x20, 0x41, 0x82, 0x01, 0x06, 0x0C, 0x10, 0x08, 0x20, 0x61, 0x80,
  0x43, 0x03, 0x08, 0x02, 0x10, 0x10, 0xC0, 0x10, 0x80, 0x84, 0x00, 0x8C,
  0x04, 0x20, 0x04, 0x40, 0x23, 0x00, 0x26, 0x01, 0x10, 0x01, 0x20, 0x09,
  0x80, 0x09, 0x00, 0x48, 0x00, 0x58, 0x02, 0x40, 0x02, 0x80, 0x16, 0x00,
  0x14, 0x00, 0xA0, 0x00, 0xC0, 0x05, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x40, 0x06, 0x06, 0x00, 0x30, 0x20, 0x00, 0x83, 0x00, 0x04, 0x10,
  0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02,
  0x60, 0x00, 0x12, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x4C,
  0x00, 0x06, 0x60, 0x00, 0x21, 0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x01,
  0x02, 0x00, 0x18, 0x10, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x20,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x02, 0x00, 0x60, 0x30, 0x01, 0x00, 0x40,
  0x02, 0x80, 0x0D, 0x80, 0x13, 0x00, 0x46, 0x00, 0x84, 0x02, 0x08, 0x04,
  0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x83, 0x01, 0x04, 0x02, 0x18, 0x04,
  0x20, 0x0C, 0xC0, 0x19, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x40, 0x3F, 0xC0, 0x00, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x61,
  0x82, 0x08, 0x20, 0x82, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x41, 0x86, 0x08,
  0x20, 0x82, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x40, 0x00, 0x7F, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x3F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x04,
  0xC0, 0x01, 0x10, 0x00, 0x86, 0x00, 0x60, 0x80, 0x10, 0x20, 0x0C, 0x0C,
  0x02, 0x01, 0x01, 0x80, 0x60, 0x40, 0x08, 0x30, 0x03, 0x08, 0x00, 0x46,
  0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC2,
  0x18, 0x42, 0x08, 0x60, 0x00, 0xF8, 0x81, 0xC6, 0x41, 0x81, 0xA0, 0x80,
  0x60, 0xC0, 0x30, 0x40, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x02, 0x10,
  0x01, 0x08, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x18, 0x40, 0x0C, 0x60, 0x04, 0x30, 0x02, 0x18, 0x03, 0x0C, 0x01,
  0x82, 0x01, 0xC1, 0x00, 0xC0, 0xC0, 0xA0, 0x20, 0x90, 0x1F, 0x88, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x4F, 0xC0, 0x6C, 0x30, 0x2C, 0x08, 0x14, 0x06, 0x0C, 0x03, 0x06, 0x00,
  0x86, 0x00, 0x43, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x40, 0x0C, 0x60,
  0x06, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x42,
  0x00, 0x21, 0x00, 0x30, 0x80, 0x10, 0xC0, 0x08, 0x60, 0x08, 0x38, 0x0C,
  0x14, 0x04, 0x0B, 0x0C, 0x08, 0xFC, 0x00, 0x00, 0xFC, 0x0C, 0x10, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x7C, 0x40, 0x38, 0xC8,
  0x0C, 0x0F, 0x01, 0x00, 0xC0, 0x60, 0x18, 0x08, 0x03, 0x02, 0x00, 0x60,
  0x40, 0x0C, 0x18, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x18, 0x01, 0x82,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20, 0x06, 0x0C,
  0x00, 0x81, 0x80, 0x10, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x40, 0x38, 0x08,
  0x06, 0x01, 0x81, 0x40, 0x10, 0x48, 0x03, 0xF1, 0x00, 0x00, 0xF8, 0x0C,
  0x30, 0x60, 0x43, 0x01, 0x08, 0x04, 0x60, 0x11, 0x00, 0xCC, 0x02, 0x20,
  0x08, 0x80, 0x46, 0x03, 0x10, 0x30, 0x7F, 0x81, 0xE0, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x40, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x17, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x20, 0x1C, 0x64, 0x06, 0x06, 0x80,
  0x80, 0x60, 0x30, 0x0C, 0x04, 0x01, 0x81, 0x00, 0x30, 0x20, 0x06, 0x0C,
  0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x20,
  0x02, 0x04, 0x00, 0x40, 0x80, 0x18, 0x10, 0x03, 0x06, 0x00, 0x40, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x20, 0x1C, 0x04, 0x03, 0x00, 0x80,
  0xA0, 0x08, 0x24, 0x01, 0xF9, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x40, 0x60, 0x0F, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x7E, 0x02,
  0xC3, 0x05, 0x01, 0x07, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x03, 0x0C,
  0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x18, 0x06, 0x10, 0x06, 0x10,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x60, 0x08, 0x60, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x01, 0x06, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x04, 0x08, 0x04,
  0x10, 0x0C, 0x30, 0x08, 0x60, 0x08, 0x40, 0x08, 0x80, 0x09, 0x80, 0x1B,
  0x80, 0x12, 0x80, 0x14, 0x80, 0x18, 0x80, 0x30, 0xC0, 0x30, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x20, 0x40, 0x60, 0x40, 0x40, 0x60, 0x40, 0x60, 0x40,
  0x20, 0x40, 0x20, 0xC0, 0x20, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x02,
  0x7C, 0x3F, 0x03, 0x43, 0x30, 0xC1, 0x40, 0xA0, 0x20, 0xC0, 0x70, 0x10,
  0x60, 0x30, 0x08, 0x20, 0x18, 0x04, 0x30, 0x08, 0x02, 0x18, 0x04, 0x03,
  0x08, 0x02, 0x01, 0x84, 0x03, 0x00, 0x82, 0x01, 0x80, 0x43, 0x00, 0x80,
  0x21, 0x00, 0x40, 0x30, 0x80, 0x20, 0x10, 0x40, 0x30, 0x08, 0x60, 0x10,
  0x04, 0x30, 0x08, 0x02, 0x10, 0x04, 0x03, 0x08, 0x02, 0x01, 0x04, 0x03,
  0x00, 0x86, 0x01, 0x00, 0x43, 0x00, 0x80, 0x61, 0x00, 0x40, 0x30, 0x80,
  0x60, 0x10, 0x40, 0x30, 0x08, 0x60, 0x10, 0x0C, 0x00, 0x02, 0x7E, 0x06,
  0xC3, 0x05, 0x01, 0x07, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x03, 0x0C,
  0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x18, 0x06, 0x10, 0x04, 0x10,
  0x04, 0x10, 0x04, 0x30, 0x04, 0x30, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x60, 0x18, 0x60, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0,
  0x30, 0x01, 0xF8, 0x06, 0x18, 0x18, 0x10, 0x60, 0x30, 0x80, 0x23, 0x00,
  0x44, 0x00, 0x98, 0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x0B, 0x00, 0x16,
  0x00, 0x68, 0x00, 0xD0, 0x01, 0x20, 0x02, 0x40, 0x0D, 0x80, 0x1B, 0x00,
  0x26, 0x00, 0xCC, 0x01, 0x18, 0x06, 0x10, 0x08, 0x30, 0x30, 0x60, 0xC0,
  0x7F, 0x00, 0x00, 0x8F, 0x80, 0x36, 0x18, 0x05, 0x81, 0x00, 0xA0, 0x30,
  0x18, 0x06, 0x03, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x01, 0x03, 0x00, 0x20,
  0x40, 0x04, 0x08, 0x01, 0x83, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x81,
  0x00, 0x10, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x20, 0x06, 0x04,
  0x00, 0x81, 0x80, 0x10, 0x30, 0x04, 0x05, 0x01, 0x80, 0xA0, 0x60, 0x16,
  0x18, 0x06, 0x7E, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x81, 0x86, 0x41, 0x81,
  0xA0, 0x80, 0x60, 0x80, 0x30, 0x40, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x30,
  0x02, 0x10, 0x01, 0x08, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x60, 0x04, 0x30, 0x02, 0x18, 0x03,
  0x0C, 0x01, 0x82, 0x01, 0xC1, 0x00, 0xC0, 0x80, 0xA0, 0x20, 0x90, 0x1F,
  0x98, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x02, 0x7C, 0x1B, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x00, 0x01,
  0xFC, 0x06, 0x0C, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x80, 0xC1, 0xFE, 0x00,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFE, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF0,
  0x04, 0x01, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02,
  0x18, 0x06, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x30, 0x04, 0x30, 0x0C,
  0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x60, 0x18, 0x60, 0x18, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xA0,
  0x41, 0xA0, 0x7F, 0x20, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x06,
  0x40, 0x22, 0x01, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x20, 0x41, 0x06, 0x08,
  0x20, 0x43, 0x02, 0x10, 0x10, 0x80, 0x8C, 0x04, 0x40, 0x26, 0x01, 0x20,
  0x0B, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x80,
  0x30, 0x0E, 0x00, 0xC0, 0x28, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x50,
  0x12, 0x03, 0x40, 0xC8, 0x09, 0x02, 0x20, 0x24, 0x08, 0x81, 0x10, 0x62,
  0x04, 0x41, 0x08, 0x31, 0x0C, 0x20, 0x84, 0x20, 0x82, 0x10, 0x82, 0x10,
  0x46, 0x08, 0x41, 0x10, 0x23, 0x04, 0x40, 0x88, 0x32, 0x02, 0x60, 0xC8,
  0x09, 0x03, 0x60, 0x24, 0x0D, 0x00, 0xB0, 0x34, 0x02, 0x80, 0xE0, 0x0E,
  0x02, 0x80, 0x30, 0x0A, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0xC0, 0x80, 0x60, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x41,
  0x00, 0x10, 0xC0, 0x06, 0x20, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x02,
  0x40, 0x01, 0x98, 0x00, 0x42, 0x00, 0x20, 0x80, 0x18, 0x20, 0x04, 0x08,
  0x02, 0x03, 0x01, 0x80, 0x40, 0x40, 0x10, 0x30, 0x04, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x40, 0x02, 0x00,
  0x80, 0x04, 0x03, 0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20, 0x20,
  0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x23, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x98, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x05,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x3E,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0xB0, 0xE0, 0x60, 0x1F, 0xC0, 0x01, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 35, 10, 1, -35 },
  { 41, 9, 13, 13, 5, -35 },
  { 56, 19, 35, 18, 0, -35 },
  { 140, 18, 40, 17, 0, -37 },
  { 230, 22, 36, 25, 2, -35 },
  { 329, 16, 35, 16, -1, -35 },
  { 399, 4, 13, 7, 5, -35 },
  { 406, 14, 43, 12, 1, -35 },
  { 482, 13, 43, 12, -3, -35 },
  { 552, 12, 13, 16, 6, -37 },
  { 572, 17, 23, 20, 1, -29 },
  { 621, 6, 10, 8, -2, -4 },
  { 629, 11, 1, 13, 1, -14 },
  { 631, 2, 3, 8, 1, -3 },
  { 632, 20, 35, 14, -2, -35 },
  { 720, 16, 35, 17, 1, -35 },
  { 790, 9, 35, 17, 5, -35 },
  { 830, 19, 35, 17, -2, -35 },
  { 914, 18, 36, 17, -1, -35 },
  { 995, 18, 35, 17, -1, -35 },
  { 1074, 18, 35, 17, -1, -35 },
  { 1153, 17, 35, 17, 1, -35 },
  { 1228, 17, 35, 17, 2, -35 },
  { 1303, 18, 35, 17, -1, -35 },
  { 1382, 17, 35, 17, 0, -35 },
  { 1457, 7, 26, 8, 0, -26 },
  { 1480, 10, 32, 8, -2, -26 },
  { 1520, 17, 20, 20, 1, -27 },
  { 1563, 17, 12, 20, 1, -23 },
  { 1589, 17, 20, 20, 1, -27 },
  { 1632, 13, 35, 12, 1, -35 },
  { 1689, 23, 39, 25, 1, -35 },
  { 1802, 16, 35, 16, -3, -35 },
  { 1872, 19, 35, 18, 0, -35 },
  { 1956, 18, 36, 17, 2, -36 },
  { 2037, 19, 35, 20, 0, -35 },
  { 2121, 19, 35, 17, 0, -35 },
  { 2205, 19, 35, 15, 0, -35 },
  { 2289, 21, 36, 22, 2, -36 },
  { 2384, 22, 35, 22, 0, -35 },
  { 2481, 15, 35, 8, -3, -35 },
  { 2547, 16, 43, 8, -7, -35 },
  { 2633, 20, 35, 17, 0, -35 },
  { 2721, 11, 35, 15, 0, -35 },
  { 2770, 29, 35, 29, 0, -35 },
  { 2897, 23, 35, 23, 0, -35 },
  { 2998, 19, 35, 22, 2, -35 },
  { 3082, 18, 35, 17, 0, -35 },
  { 3161, 19, 43, 22, 2, -35 },
  { 3264, 18, 35, 18, 0, -35 },
  { 3343, 19, 35, 17, -1, -35 },
  { 3427, 15, 35, 14, 3, -35 },
  { 3493, 20, 35, 21, 2, -35 },
  { 3581, 17, 35, 17, 4, -35 },
  { 3656, 29, 35, 29, 4, -35 },
  { 3783, 21, 35, 15, -3, -35 },
  { 3875, 15, 35, 14, 3, -35 },
  { 3941, 20, 35, 15, -2, -35 },
  { 4029, 17, 43, 13, -1, -35 },
  { 4121, 6, 35, 16, 5, -35 },
  { 4148, 17, 43, 13, -3, -35 },
  { 4240, 18, 17, 19, 1, -35 },
  { 4279, 13, 2, 13, -4, 4 },
  { 4283, 5, 7, 10, 7, -37 },
  { 4288, 17, 26, 19, 1, -26 },
  { 4344, 17, 37, 18, 0, -37 },
  { 4423, 14, 26, 13, 1, -26 },
  { 4469, 19, 37, 19, 1, -37 },
  { 4557, 14, 26, 16, 1, -26 },
  { 4603, 21, 49, 9, -6, -37 },
  { 4732, 19, 38, 18, -1, -26 },
  { 4823, 16, 37, 18, 0, -37 },
  { 4897, 9, 35, 8, 0, -35 },
  { 4937, 16, 47, 8, -7, -35 },
  { 5031, 16, 37, 15, 0, -37 },
  { 5105, 9, 37, 7, 0, -37 },
  { 5147, 25, 26, 27, 0, -26 },
  { 5229, 16, 26, 18, 0, -26 },
  { 5281, 15, 26, 18, 1, -26 },
  { 5330, 19, 37, 18, -2, -26 },
  { 5418, 17, 37, 19, 1, -26 },
  { 5497, 14, 26, 11, 0, -26 },
  { 5543, 15, 26, 13, -1, -26 },
  { 5592, 9, 32, 9, 1, -32 },
  { 5628, 16, 26, 18, 1, -26 },
  { 5680, 13, 26, 13, 3, -26 },
  { 5723, 22, 26, 23, 3, -26 },
  { 5795, 18, 26, 14, -2, -26 },
  { 5854, 23, 38, 14, -6, -26 },
  { 5964, 15, 26, 11, -2, -26 },
  { 6013, 16, 43, 15, 2, -35 },
  { 6099, 1, 49, 17, 8, -37 },
  { 6106, 16, 43, 15, -3, -35 },
  { 6192, 17, 4, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC49PT7B_H_
