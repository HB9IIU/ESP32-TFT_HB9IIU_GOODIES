#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x00, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x30,
  0x61, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x20, 0x61, 0x03, 0x18, 0x18,
  0xC0, 0x86, 0x04, 0x20, 0x21, 0x03, 0x08, 0x10, 0xC0, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x04, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x60, 0x20,
  0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x08, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x18, 0x03, 0xFF, 0xFF, 0xE0, 0x0C,
  0x04, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x71, 0x8F, 0x00, 0x60, 0xC1, 0x00, 0x60, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x08, 0x08, 0x00, 0x0C, 0x04, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x60, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x08, 0x00, 0x06, 0x04, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x10, 0x30, 0x00, 0x08, 0x38, 0x08, 0x0C, 0x38, 0x07, 0x86, 0x78,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0xC3, 0x00,
  0x30, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x06, 0x06, 0x00, 0xC0,
  0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x40, 0x18, 0x18, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x20, 0xC0, 0x0C, 0x03, 0x06, 0x00,
  0x40, 0x18, 0x60, 0x06, 0x00, 0xC3, 0x00, 0x30, 0x06, 0x30, 0x01, 0x80,
  0x61, 0x83, 0x8C, 0x03, 0x18, 0x7E, 0x60, 0x18, 0xC7, 0x1B, 0x01, 0x8C,
  0x70, 0x58, 0x0C, 0x63, 0x03, 0xC0, 0xC6, 0x30, 0x1E, 0x06, 0x31, 0x80,
  0xF0, 0x61, 0x18, 0x06, 0xC6, 0x18, 0xC0, 0x37, 0xE0, 0x86, 0x01, 0x8C,
  0x0C, 0x60, 0x08, 0x00, 0x43, 0x00, 0x40, 0x06, 0x18, 0x06, 0x00, 0x20,
  0x80, 0x30, 0x03, 0x0C, 0x01, 0x80, 0x10, 0x60, 0x0C, 0x01, 0x83, 0x00,
  0x40, 0x08, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x04, 0x04, 0x01, 0x80,
  0x60, 0x20, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x60, 0x18, 0x02, 0x03, 0x00, 0x80, 0x10, 0x30, 0x0C, 0x00, 0xC1,
  0x80, 0x40, 0x06, 0x18, 0x06, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x07, 0x18, 0x00, 0x30, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30,
  0x03, 0x01, 0x80, 0x10, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x20,
  0x30, 0x01, 0x03, 0x00, 0x08, 0x18, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x0C,
  0x30, 0x00, 0xC0, 0x81, 0x86, 0x06, 0x0C, 0x60, 0x30, 0x46, 0x01, 0x86,
  0x30, 0x04, 0x31, 0x00, 0x31, 0x98, 0x01, 0x98, 0xC0, 0x0C, 0xC4, 0x00,
  0x24, 0x60, 0x01, 0xE3, 0x00, 0x0F, 0x18, 0x00, 0x70, 0xC0, 0x01, 0x86,
  0x00, 0x1C, 0x30, 0x01, 0xE1, 0x80, 0x0B, 0x06, 0x00, 0xC8, 0x30, 0x0C,
  0x40, 0xE1, 0xC3, 0x03, 0xFC, 0x18, 0x07, 0x00, 0x00, 0x18, 0xC6, 0x31,
  0x18, 0xC6, 0x21, 0x18, 0xC6, 0x21, 0x08, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x80, 0x80,
  0xE0, 0x80, 0x30, 0x80, 0x0D, 0x87, 0x07, 0x7C, 0x01, 0x80, 0x02, 0x80,
  0x0C, 0xC0, 0x18, 0x40, 0x30, 0x60, 0xE0, 0x20, 0x40, 0x30, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x20, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x06,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x01, 0x01, 0x80, 0x08,
  0x18, 0x00, 0x40, 0xC0, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x18,
  0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x18, 0x18,
  0x00, 0xE3, 0x80, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x01, 0xE0, 0x76, 0x0E, 0x61, 0x84, 0x30, 0xC6, 0x0C, 0x40, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x1E, 0x07, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0E, 0x03, 0x80,
  0x0E, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x38, 0x03, 0x80, 0x70, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x64,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x60,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x80,
  0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x6F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x08, 0x00, 0x60, 0x07, 0x01, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x38, 0x08, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC1, 0xE0, 0x01, 0x8F, 0xF0, 0x06, 0x70, 0x70, 0x0D, 0x80, 0x30,
  0x1A, 0x00, 0x60, 0x38, 0x00, 0x60, 0x70, 0x00, 0xC1, 0xC0, 0x01, 0x83,
  0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00,
  0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0x40, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x01, 0x80, 0x06, 0x0E, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x31,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x76, 0x00, 0x01, 0xC3,
  0x00, 0x03, 0x83, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0x20, 0x60, 0x00,
  0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x1E, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0x80, 0x03, 0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x20, 0x00, 0x60, 0x80,
  0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x78, 0x30, 0x03, 0x60, 0x60, 0x19,
  0x00, 0xE1, 0xCC, 0x01, 0xFE, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x08, 0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x80, 0x70, 0x1C, 0x06, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x60, 0x70, 0x10, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x10, 0x01,
  0xF0, 0x10, 0xC0, 0x1F, 0xE0, 0x43, 0x00, 0xC1, 0x81, 0x18, 0x06, 0x04,
  0x04, 0x60, 0x30, 0x30, 0x31, 0x80, 0xC0, 0xC0, 0xCC, 0x06, 0x03, 0x03,
  0x30, 0x18, 0x18, 0x0C, 0xC0, 0xC0, 0x60, 0x32, 0x03, 0x01, 0x80, 0xD8,
  0x18, 0x06, 0x02, 0x60, 0x60, 0x30, 0x19, 0x81, 0x80, 0xC0, 0x64, 0x04,
  0x03, 0x01, 0x90, 0x30, 0x08, 0x04, 0xC0, 0xC0, 0x60, 0x33, 0x03, 0x01,
  0x80, 0xCC, 0x0C, 0x06, 0x03, 0x30, 0x30, 0x38, 0x18, 0xC0, 0xC0, 0xC0,
  0x63, 0x03, 0x03, 0x01, 0x0C, 0x0C, 0x1C, 0x0C, 0x20, 0x30, 0x50, 0x60,
  0x80, 0xC3, 0x61, 0x82, 0x03, 0x99, 0x9C, 0x08, 0x07, 0xC3, 0xE0, 0x20,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00,
  0x13, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x03, 0xFF, 0xF0, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x62, 0x00,
  0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x34,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x08, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00,
  0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x07, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0C, 0x03, 0x80, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x40, 0x20, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x70, 0x06, 0x00, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x02, 0x01, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0x40, 0x3C, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x1C, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x18, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x08, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x06,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x10, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x06,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x87, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x40, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06, 0x78, 0x00, 0x00, 0x6D,
  0x80, 0x00, 0x07, 0x98, 0x00, 0x00, 0x50, 0x80, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x01, 0x00, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x40, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x58,
  0x00, 0x00, 0x34, 0x00, 0x58, 0x00, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0xC8, 0x00, 0x00, 0xCC, 0x00, 0xC8, 0x00, 0x00, 0xC8, 0x00,
  0x88, 0x00, 0x01, 0x98, 0x01, 0x88, 0x00, 0x01, 0x98, 0x01, 0x88, 0x00,
  0x03, 0x18, 0x01, 0x88, 0x00, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x06, 0x10,
  0x01, 0x0C, 0x00, 0x06, 0x30, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x18,
  0x20, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x06,
  0x0C, 0x00, 0x20, 0x60, 0x06, 0x0C, 0x00, 0x60, 0x40, 0x04, 0x0C, 0x00,
  0x40, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x04, 0x01, 0x80, 0xC0, 0x0C, 0x04, 0x01, 0x80, 0x80, 0x08, 0x04,
  0x03, 0x01, 0x80, 0x18, 0x04, 0x03, 0x01, 0x80, 0x18, 0x04, 0x06, 0x01,
  0x80, 0x18, 0x04, 0x06, 0x01, 0x80, 0x18, 0x06, 0x0C, 0x01, 0x00, 0x10,
  0x06, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x18, 0x03, 0x00, 0x30, 0x06, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x30, 0x02, 0x00, 0x20, 0x06, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x60, 0x06, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0x60, 0x06,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0xC0, 0x04, 0x00, 0x40, 0x07, 0x80, 0x0C,
  0x00, 0xC0, 0x07, 0x80, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x18, 0x03,
  0xC0, 0x00, 0x30, 0x06, 0x80, 0x00, 0x40, 0x0D, 0x00, 0x01, 0x80, 0x1B,
  0x00, 0x03, 0x00, 0x26, 0x00, 0x06, 0x00, 0xCC, 0x00, 0x0C, 0x01, 0x98,
  0x00, 0x10, 0x03, 0x10, 0x00, 0x60, 0x04, 0x20, 0x00, 0xC0, 0x18, 0x60,
  0x01, 0x80, 0x30, 0xC0, 0x02, 0x00, 0x61, 0x80, 0x0C, 0x00, 0xC3, 0x00,
  0x18, 0x01, 0x02, 0x00, 0x30, 0x06, 0x06, 0x00, 0x60, 0x0C, 0x0C, 0x00,
  0x80, 0x18, 0x18, 0x03, 0x00, 0x30, 0x30, 0x06, 0x00, 0x40, 0x20, 0x0C,
  0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x80, 0xC0,
  0x08, 0x03, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x60, 0x04, 0x04, 0x00,
  0xC0, 0x0C, 0x18, 0x01, 0x80, 0x18, 0x30, 0x02, 0x00, 0x30, 0x60, 0x0C,
  0x00, 0x60, 0xC0, 0x18, 0x00, 0x41, 0x00, 0x30, 0x00, 0xC6, 0x00, 0x60,
  0x01, 0x8C, 0x00, 0x80, 0x03, 0x18, 0x03, 0x00, 0x06, 0x30, 0x06, 0x00,
  0x0C, 0x40, 0x0C, 0x00, 0x09, 0x80, 0x18, 0x00, 0x1B, 0x00, 0x60, 0x00,
  0x36, 0x00, 0xC0, 0x00, 0x68, 0x01, 0x80, 0x00, 0xD0, 0x03, 0x00, 0x00,
  0xE0, 0x04, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x08, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x20, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x20, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x02, 0x01, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x38,
  0x06, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x06, 0x03, 0xC0, 0x07, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x08, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x20, 0x1C,
  0x00, 0x60, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x03,
  0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x02,
  0x01, 0x80, 0x06, 0x01, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x04, 0x0C, 0x00,
  0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x02, 0x00,
  0x10, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x01, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xE0,
  0x01, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x20, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30,
  0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00,
  0x02, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60, 0x10,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x0C,
  0x02, 0x00, 0x01, 0x80, 0x40, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x10, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x60, 0x00, 0x70, 0x38,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x32, 0x00, 0x00,
  0xC8, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00, 0x03, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00,
  0x30, 0x20, 0x01, 0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0xC0,
  0x20, 0x03, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x08, 0x03, 0x00, 0x20,
  0x0C, 0x00, 0x80, 0x20, 0x02, 0x01, 0x80, 0x08, 0x06, 0x00, 0x20, 0x30,
  0x00, 0x80, 0xC0, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x20, 0x40, 0x00,
  0x83, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x60, 0x00, 0x21, 0x80, 0x00, 0x8C,
  0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00, 0x26, 0x00, 0x00, 0x98, 0x00,
  0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x80,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xC0,
  0x00, 0x6C, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x0F, 0x00, 0x03, 0x30,
  0x00, 0x16, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x00, 0x98,
  0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x60, 0x01, 0x86,
  0x00, 0x08, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x00, 0x0C, 0x18, 0x00, 0x42,
  0x00, 0x18, 0x30, 0x01, 0x84, 0x00, 0x60, 0x60, 0x03, 0x08, 0x00, 0xC0,
  0xC0, 0x04, 0x10, 0x01, 0x81, 0x80, 0x18, 0x20, 0x06, 0x03, 0x00, 0x30,
  0x40, 0x0C, 0x06, 0x00, 0xC0, 0x80, 0x30, 0x0C, 0x01, 0x81, 0x00, 0x60,
  0x18, 0x02, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x04, 0x03, 0x00, 0x60, 0x18,
  0x18, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x03, 0x01, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x01, 0x81, 0x80, 0x0C, 0x0C,
  0x03, 0x03, 0x00, 0x18, 0x30, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x0C, 0x18,
  0x00, 0x60, 0x80, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x03, 0x10, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x26,
  0x00, 0x01, 0xB0, 0x00, 0x48, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x07,
  0x80, 0x01, 0x60, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x39, 0x00, 0x01, 0x88, 0x00, 0x18, 0x40, 0x00, 0xC3, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x00,
  0x40, 0x60, 0x02, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x01,
  0x20, 0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x01, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x20, 0x00, 0x06, 0x60, 0x00,
  0x18, 0x40, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x73, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x10, 0x00, 0x3F, 0x84, 0x01, 0xE7, 0x10, 0x1C, 0x06, 0xC0, 0x60,
  0x1B, 0x03, 0x00, 0x28, 0x18, 0x00, 0xA0, 0x60, 0x03, 0x83, 0x00, 0x0E,
  0x08, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x14,
  0x0C, 0x00, 0xF0, 0x18, 0x06, 0xC0, 0x60, 0x13, 0x00, 0xE1, 0x88, 0x01,
  0xFC, 0x20, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x43, 0xF8, 0x01, 0x8E, 0x78, 0x03, 0x30, 0x30, 0x06, 0xC0, 0x30,
  0x0B, 0x00, 0x60, 0x14, 0x00, 0x40, 0x70, 0x00, 0xC0, 0xE0, 0x01, 0x81,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x80, 0x00, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0xC0, 0x06, 0x03,
  0x80, 0x0C, 0x0F, 0x00, 0x30, 0x1A, 0x00, 0xC0, 0x26, 0x03, 0x80, 0x46,
  0x0E, 0x01, 0x87, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3C,
  0x20, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0E, 0x0C,
  0x01, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x10, 0x00, 0x79, 0xCC,
  0x00, 0x70, 0x1B, 0x00, 0x18, 0x06, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0x00,
  0x38, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x20, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x38,
  0x03, 0x00, 0x1C, 0x00, 0xC0, 0x05, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x01,
  0xB0, 0x01, 0x80, 0xCC, 0x00, 0x38, 0x62, 0x00, 0x07, 0xF0, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0xE0, 0x1C, 0x0C, 0x0E, 0x03,
  0x03, 0x00, 0x41, 0x80, 0x10, 0xC0, 0x04, 0x30, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x18, 0x01, 0x86, 0x00,
  0xC1, 0x80, 0xE0, 0x43, 0xF0, 0x3F, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x08, 0x0E, 0x0E, 0x01, 0xFF, 0x80, 0x0D, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x38, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x80, 0x07, 0x9C, 0x40, 0x0E, 0x03, 0x60, 0x06, 0x01,
  0xB0, 0x06, 0x00, 0x50, 0x06, 0x00, 0x28, 0x03, 0x00, 0x1C, 0x03, 0x00,
  0x0E, 0x01, 0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C,
  0x03, 0x00, 0x0E, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x05, 0x00, 0x60, 0x07,
  0x80, 0x18, 0x06, 0xC0, 0x0C, 0x06, 0x60, 0x03, 0x06, 0x20, 0x00, 0xFE,
  0x30, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x21, 0xFC,
  0x00, 0x9E, 0x78, 0x06, 0xC0, 0x60, 0x1E, 0x00, 0x80, 0x50, 0x03, 0x01,
  0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10,
  0x18, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30,
  0x01, 0x80, 0x80, 0x06, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x01, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x08, 0x0C, 0x00, 0x60, 0x20, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x10, 0x18, 0x00, 0x40, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x03, 0x01,
  0x80, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x60, 0x18, 0x01, 0x00,
  0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x02, 0x06, 0x00,
  0x08, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x11,
  0xC0, 0x00, 0xCF, 0x00, 0x03, 0x24, 0x00, 0x0D, 0x90, 0x00, 0x3C, 0x60,
  0x00, 0xE1, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x20, 0x01,
  0x00, 0x80, 0x04, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0xC0, 0x08, 0x03, 0x00, 0x60, 0x04, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x40, 0x06, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x8F, 0xE0, 0x7F, 0x00,
  0x67, 0x1C, 0x71, 0xE0, 0x1B, 0x01, 0xB0, 0x18, 0x07, 0x80, 0x78, 0x03,
  0x01, 0x40, 0x1E, 0x00, 0xC0, 0x60, 0x07, 0x00, 0x30, 0x38, 0x01, 0xC0,
  0x0C, 0x0E, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x00, 0x20, 0x30, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x10, 0x30,
  0x00, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x00, 0x30, 0x20, 0x01, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x00,
  0x10, 0x10, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x30, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x40, 0x06, 0x06, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x00, 0x18, 0x10, 0x00, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x87, 0xE0, 0x06, 0x79, 0xE0, 0x1B, 0x01, 0x80, 0x78, 0x02, 0x01,
  0x40, 0x0C, 0x07, 0x00, 0x30, 0x38, 0x00, 0x80, 0xE0, 0x02, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10,
  0x18, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x80, 0x04, 0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x40, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0x1C, 0x01, 0xC0, 0xC0, 0x30, 0x06, 0x07,
  0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x03,
  0x87, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x10, 0xFE, 0x00, 0x04,
  0x73, 0xC0, 0x03, 0x30, 0x30, 0x00, 0xD8, 0x06, 0x00, 0x2C, 0x01, 0x80,
  0x0A, 0x00, 0x30, 0x07, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06,
  0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0xF0, 0x03, 0x00,
  0x34, 0x01, 0x80, 0x0D, 0x80, 0xE0, 0x03, 0x30, 0x70, 0x00, 0x87, 0xF0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x84, 0x03, 0xCF, 0x10, 0x1C, 0x0E, 0xC0, 0xE0,
  0x1B, 0x03, 0x00, 0x28, 0x18, 0x00, 0xA0, 0x40, 0x03, 0x83, 0x00, 0x0E,
  0x08, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x14,
  0x0C, 0x00, 0xF0, 0x18, 0x06, 0xC0, 0x60, 0x33, 0x00, 0xE1, 0xC8, 0x01,
  0xFC, 0x60, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x87, 0xC0, 0x67,
  0x90, 0x1B, 0x00, 0x06, 0x80, 0x01, 0x40, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x1F, 0x01, 0x80, 0x20, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x80,
  0x18, 0x0E, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x1F, 0xF1, 0xFF,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x7C, 0x03, 0x80, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C,
  0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04,
  0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x04, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81,
  0x80, 0x04, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x40, 0x07, 0x02, 0x00, 0x78,
  0x18, 0x06, 0x80, 0xC0, 0x64, 0x03, 0x07, 0x60, 0x1F, 0xE3, 0x00, 0x1C,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x68, 0x00,
  0x64, 0x00, 0x32, 0x00, 0x11, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x0C, 0x20,
  0x06, 0x10, 0x06, 0x08, 0x03, 0x04, 0x01, 0x02, 0x01, 0x81, 0x00, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0xF0, 0x01, 0xC0, 0x05, 0x80, 0x0A, 0x00, 0x6C, 0x00, 0x50, 0x03, 0x60,
  0x07, 0x80, 0x13, 0x00, 0x2C, 0x01, 0x98, 0x03, 0x60, 0x0C, 0xC0, 0x1B,
  0x00, 0xC6, 0x00, 0x98, 0x06, 0x30, 0x0C, 0xC0, 0x21, 0x80, 0x46, 0x03,
  0x0C, 0x06, 0x30, 0x18, 0x60, 0x31, 0x81, 0x83, 0x03, 0x0C, 0x0C, 0x18,
  0x18, 0x60, 0x40, 0xC0, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0xC1, 0x01, 0x86, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x80, 0x61, 0x01, 0x8C,
  0x03, 0x18, 0x0C, 0x60, 0x18, 0x80, 0x62, 0x00, 0xCC, 0x03, 0x30, 0x06,
  0x60, 0x19, 0x00, 0x32, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0xC0, 0x0D, 0x00,
  0x34, 0x00, 0x58, 0x01, 0x60, 0x02, 0xC0, 0x0A, 0x00, 0x14, 0x00, 0x50,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x40, 0x06, 0x00, 0x40, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0x20, 0x20,
  0x00, 0x20, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x13, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x44, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x06, 0x02, 0x00, 0x06, 0x02, 0x00,
  0x0C, 0x03, 0x00, 0x08, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x04, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0xE0, 0x07, 0x8E, 0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 47, 13, 1, -47 },
  { 78, 13, 17, 17, 6, -47 },
  { 106, 25, 47, 24, 0, -47 },
  { 253, 25, 54, 23, -1, -50 },
  { 422, 29, 49, 34, 3, -48 },
  { 600, 21, 49, 21, -1, -48 },
  { 729, 5, 17, 9, 6, -47 },
  { 740, 18, 57, 16, 2, -47 },
  { 869, 18, 57, 16, -5, -47 },
  { 998, 16, 18, 21, 8, -50 },
  { 1034, 22, 30, 26, 2, -38 },
  { 1117, 8, 14, 10, -3, -6 },
  { 1131, 14, 2, 17, 2, -19 },
  { 1135, 3, 4, 10, 1, -4 },
  { 1137, 27, 47, 19, -3, -47 },
  { 1296, 21, 49, 23, 1, -48 },
  { 1425, 12, 47, 23, 7, -47 },
  { 1496, 25, 48, 23, -2, -48 },
  { 1646, 25, 49, 23, -2, -48 },
  { 1800, 24, 48, 23, -1, -48 },
  { 1944, 25, 48, 23, -2, -47 },
  { 2094, 23, 49, 23, 1, -48 },
  { 2235, 23, 47, 23, 2, -47 },
  { 2371, 24, 49, 23, -1, -48 },
  { 2518, 22, 49, 23, 0, -48 },
  { 2653, 10, 35, 10, 0, -35 },
  { 2697, 13, 43, 10, -3, -35 },
  { 2767, 22, 27, 26, 2, -37 },
  { 2842, 22, 16, 26, 2, -31 },
  { 2886, 22, 27, 26, 2, -37 },
  { 2961, 18, 48, 16, 1, -48 },
  { 3069, 30, 53, 34, 2, -47 },
  { 3268, 21, 47, 22, -4, -47 },
  { 3392, 25, 47, 25, 0, -47 },
  { 3539, 25, 49, 22, 2, -48 },
  { 3693, 26, 47, 27, 0, -47 },
  { 3846, 25, 47, 22, 0, -47 },
  { 3993, 25, 47, 21, 0, -47 },
  { 4140, 29, 49, 30, 2, -48 },
  { 4318, 30, 47, 29, 0, -47 },
  { 4495, 20, 47, 11, -4, -47 },
  { 4613, 21, 58, 10, -9, -47 },
  { 4766, 28, 47, 23, 0, -47 },
  { 4931, 15, 47, 20, 0, -47 },
  { 5020, 40, 47, 39, 0, -47 },
  { 5255, 31, 47, 30, 0, -47 },
  { 5438, 26, 49, 29, 2, -48 },
  { 5598, 24, 47, 23, 0, -47 },
  { 5739, 26, 59, 29, 2, -48 },
  { 5931, 24, 47, 24, 0, -47 },
  { 6072, 26, 49, 23, -2, -48 },
  { 6232, 20, 47, 19, 4, -47 },
  { 6350, 27, 48, 28, 2, -47 },
  { 6512, 22, 47, 23, 6, -47 },
  { 6642, 39, 47, 39, 5, -47 },
  { 6872, 29, 47, 20, -4, -47 },
  { 7043, 21, 47, 19, 4, -47 },
  { 7167, 27, 47, 20, -3, -47 },
  { 7326, 23, 57, 18, -1, -47 },
  { 7490, 8, 47, 21, 7, -47 },
  { 7537, 23, 57, 18, -4, -47 },
  { 7701, 23, 22, 26, 2, -47 },
  { 7765, 17, 2, 17, -5, 6 },
  { 7770, 6, 10, 14, 10, -50 },
  { 7778, 22, 36, 25, 2, -35 },
  { 7877, 23, 51, 25, 0, -50 },
  { 8024, 18, 36, 18, 2, -35 },
  { 8105, 26, 51, 25, 2, -50 },
  { 8271, 18, 36, 22, 2, -35 },
  { 8352, 29, 66, 12, -9, -50 },
  { 8592, 25, 51, 25, -1, -35 },
  { 8752, 22, 50, 24, 0, -50 },
  { 8890, 12, 47, 10, 0, -47 },
  { 8961, 22, 63, 11, -9, -47 },
  { 9135, 22, 50, 20, 0, -50 },
  { 9273, 13, 50, 10, 0, -50 },
  { 9355, 34, 35, 36, 0, -35 },
  { 9504, 22, 35, 24, 0, -35 },
  { 9601, 20, 36, 24, 2, -35 },
  { 9691, 26, 50, 25, -3, -35 },
  { 9854, 22, 50, 25, 2, -35 },
  { 9992, 18, 35, 15, 0, -35 },
  { 10071, 20, 36, 18, -1, -35 },
  { 10161, 12, 44, 12, 1, -43 },
  { 10227, 21, 36, 24, 2, -35 },
  { 10322, 17, 35, 18, 4, -35 },
  { 10397, 29, 35, 30, 4, -35 },
  { 10524, 24, 35, 19, -3, -35 },
  { 10629, 31, 51, 19, -8, -35 },
  { 10827, 19, 35, 15, -2, -35 },
  { 10911, 22, 57, 20, 2, -47 },
  { 11068, 2, 66, 23, 10, -50 },
  { 11085, 22, 57, 20, -4, -47 },
  { 11242, 22, 5, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC66PT7B_H_
