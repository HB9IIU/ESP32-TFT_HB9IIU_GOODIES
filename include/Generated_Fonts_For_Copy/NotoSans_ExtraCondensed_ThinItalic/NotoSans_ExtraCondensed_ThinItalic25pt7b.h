#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42, 0x20, 0x00, 0x44,
  0x00, 0x4A, 0x52, 0x95, 0x4A, 0x40, 0x04, 0x41, 0x20, 0x48, 0x22, 0x09,
  0x0F, 0xF1, 0x10, 0x48, 0x12, 0x08, 0x82, 0x43, 0xFC, 0x24, 0x11, 0x04,
  0x81, 0x20, 0x88, 0x24, 0x00, 0x02, 0x01, 0x03, 0xE2, 0x82, 0x41, 0x20,
  0x90, 0x48, 0x18, 0x04, 0x02, 0x01, 0x81, 0x20, 0x90, 0x48, 0x24, 0x14,
  0x7C, 0x08, 0x04, 0x00, 0x18, 0x44, 0x89, 0x12, 0x22, 0x44, 0x91, 0x12,
  0x22, 0x84, 0x56, 0x95, 0x32, 0xA5, 0xA8, 0x85, 0x11, 0x22, 0x24, 0x48,
  0x91, 0x22, 0x42, 0x48, 0x70, 0x0E, 0x12, 0x12, 0x12, 0x12, 0x14, 0x14,
  0x18, 0x10, 0x28, 0x48, 0x49, 0x8A, 0x86, 0x84, 0x84, 0x8C, 0xF2, 0x55,
  0x68, 0x04, 0x10, 0x84, 0x20, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x81, 0x00, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x04,
  0x10, 0x00, 0x10, 0x4D, 0x4E, 0x52, 0x20, 0x80, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25, 0x28, 0xF8, 0x60,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x00, 0x07,
  0x04, 0x84, 0x22, 0x12, 0x09, 0x05, 0x04, 0x82, 0x41, 0x20, 0x90, 0x50,
  0x28, 0x24, 0x12, 0x09, 0x08, 0x48, 0x38, 0x00, 0x13, 0xD1, 0x22, 0x22,
  0x44, 0x44, 0x48, 0x88, 0x88, 0x0F, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x3F, 0x80, 0x0F, 0x82, 0x20, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x04, 0x0E, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x3F, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x0A, 0x02, 0x81, 0x20, 0x50,
  0x24, 0x11, 0x04, 0x42, 0x10, 0x88, 0x42, 0x3F, 0xE0, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x0F, 0xC2, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xF0,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x3E,
  0x00, 0x0F, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0xB8, 0xC4, 0x82, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0xF0, 0x7F, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84,
  0x24, 0x0C, 0x1A, 0x11, 0x10, 0x48, 0x24, 0x12, 0x09, 0x04, 0x84, 0x3C,
  0x00, 0x0E, 0x11, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x23, 0x3D,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x12, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x80, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x44, 0x21, 0x10,
  0x01, 0x06, 0x18, 0x60, 0x80, 0xC0, 0x20, 0x18, 0x06, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x03, 0x04, 0x18,
  0x60, 0x80, 0x3C, 0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x40, 0x82,
  0x04, 0x08, 0x00, 0x00, 0x41, 0x00, 0x07, 0xC1, 0x04, 0x40, 0x90, 0x12,
  0x02, 0x86, 0x51, 0x4A, 0x49, 0x91, 0x32, 0x26, 0x48, 0xC9, 0x29, 0x25,
  0x2C, 0xA6, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x3C, 0x00, 0x01, 0x01,
  0x03, 0x03, 0x03, 0x05, 0x05, 0x09, 0x09, 0x09, 0x1F, 0x11, 0x21, 0x21,
  0x21, 0x41, 0x41, 0x81, 0x0F, 0x08, 0x44, 0x22, 0x11, 0x08, 0x84, 0x82,
  0x42, 0x3E, 0x11, 0x08, 0x48, 0x24, 0x12, 0x09, 0x05, 0x04, 0x86, 0x7C,
  0x00, 0x07, 0x84, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x3C, 0x00, 0x0F, 0x04,
  0x21, 0x04, 0x41, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x48, 0x24, 0x09,
  0x02, 0x40, 0x90, 0x44, 0x12, 0x08, 0x84, 0x3C, 0x00, 0x0F, 0x88, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x3E, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x7E, 0x00, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x0F, 0x84, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC1, 0x04, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x72, 0x02, 0x40, 0x48, 0x09, 0x02,
  0x20, 0x44, 0x08, 0x41, 0x07, 0xC0, 0x08, 0x22, 0x04, 0x40, 0x88, 0x11,
  0x02, 0x20, 0x88, 0x11, 0x02, 0x3F, 0xC4, 0x09, 0x02, 0x20, 0x44, 0x08,
  0x81, 0x10, 0x44, 0x08, 0x81, 0x10, 0x20, 0x1E, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x41, 0xC0, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x07, 0x80,
  0x08, 0x44, 0x11, 0x08, 0x44, 0x12, 0x04, 0x82, 0x40, 0xA0, 0x38, 0x0A,
  0x02, 0x81, 0x10, 0x44, 0x11, 0x04, 0x42, 0x08, 0x82, 0x20, 0x80, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x83,
  0xF0, 0x08, 0x02, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x61, 0x80, 0xC3, 0x02,
  0x8A, 0x05, 0x14, 0x12, 0x28, 0x28, 0x50, 0x91, 0x11, 0x22, 0x24, 0x44,
  0x48, 0x88, 0xA2, 0x11, 0x44, 0x43, 0x08, 0x86, 0x11, 0x08, 0x20, 0x08,
  0x10, 0x81, 0x18, 0x11, 0x82, 0x14, 0x21, 0x42, 0x24, 0x22, 0x44, 0x24,
  0x42, 0x24, 0x42, 0x44, 0x24, 0x42, 0x84, 0x28, 0x42, 0x88, 0x18, 0x81,
  0x08, 0x10, 0x0F, 0x04, 0x22, 0x04, 0x81, 0x40, 0x50, 0x14, 0x06, 0x01,
  0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x08, 0x84, 0x1E,
  0x00, 0x0F, 0x08, 0x44, 0x22, 0x11, 0x08, 0x84, 0x82, 0x42, 0x21, 0x17,
  0x14, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x00, 0x0F, 0x04,
  0x22, 0x04, 0x81, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A,
  0x02, 0x81, 0x20, 0x48, 0x12, 0x08, 0x84, 0x1A, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x0F, 0x08, 0x44, 0x22, 0x11, 0x08, 0x84, 0x82, 0x42, 0x21,
  0x1F, 0x12, 0x08, 0x84, 0x42, 0x21, 0x11, 0x08, 0x82, 0x41, 0x00, 0x07,
  0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x3F, 0x00, 0xFE, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x00, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x90, 0x24, 0x09, 0x02,
  0x41, 0x10, 0x48, 0x12, 0x04, 0x81, 0x20, 0x88, 0x22, 0x08, 0x84, 0x1E,
  0x00, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x08, 0x88, 0x44,
  0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0, 0x40, 0x00, 0x81, 0x03,
  0x02, 0x0A, 0x0C, 0x14, 0x18, 0x28, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44,
  0x88, 0x89, 0x11, 0x22, 0x42, 0x44, 0x85, 0x0A, 0x0A, 0x14, 0x14, 0x28,
  0x30, 0x60, 0x61, 0x40, 0x83, 0x01, 0x02, 0x00, 0x08, 0x42, 0x10, 0x88,
  0x22, 0x09, 0x02, 0x40, 0xA0, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x50, 0x14,
  0x09, 0x04, 0x41, 0x10, 0x82, 0x20, 0x80, 0x83, 0x06, 0x14, 0x28, 0x91,
  0x24, 0x28, 0x60, 0xC1, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x00, 0x0F,
  0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x3F, 0x80, 0x0F, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x92, 0x49, 0x24, 0x49,
  0x24, 0x91, 0x24, 0x07, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x87, 0xC0, 0x08, 0x0C, 0x05, 0x04, 0x82, 0x22, 0x11, 0x05,
  0x02, 0x80, 0x80, 0xFE, 0xA5, 0x1F, 0x21, 0x41, 0x41, 0x82, 0x82, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00,
  0x90, 0x74, 0x21, 0x20, 0x90, 0x48, 0x24, 0x14, 0x12, 0x09, 0x04, 0x82,
  0x42, 0x62, 0x2E, 0x00, 0x1C, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x70, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x68, 0x4C, 0x42, 0x41,
  0x20, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x09, 0x08, 0x84, 0x46, 0x3D, 0x00,
  0x1C, 0x45, 0x0A, 0x18, 0x53, 0x30, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80,
  0x00, 0xE0, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x03, 0xC0, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0xC0, 0x00, 0x0F,
  0x88, 0x48, 0x24, 0x14, 0x12, 0x09, 0x04, 0x82, 0x42, 0x21, 0x10, 0x88,
  0xC7, 0xA0, 0x10, 0x10, 0x08, 0x04, 0x04, 0x3C, 0x00, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x16, 0x19, 0x11, 0x21, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42,
  0x42, 0x42, 0x84, 0x84, 0x08, 0xC0, 0x00, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x21, 0x08, 0x84, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x11, 0x22,
  0x24, 0x24, 0x28, 0x38, 0x68, 0x48, 0x48, 0x48, 0x84, 0x84, 0x84, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x20, 0x1F,
  0x78, 0x8C, 0x48, 0x42, 0x42, 0x12, 0x10, 0x90, 0x89, 0x08, 0x48, 0x42,
  0x42, 0x12, 0x10, 0xA1, 0x09, 0x08, 0x48, 0x42, 0x00, 0x1F, 0x11, 0x21,
  0x21, 0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x1E, 0x45,
  0x0A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x47, 0x00, 0x0F, 0x82,
  0x11, 0x84, 0x41, 0x10, 0x44, 0x12, 0x08, 0x82, 0x20, 0x88, 0x22, 0x11,
  0x88, 0x5C, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0x23,
  0x41, 0x41, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x1E, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x00, 0x3E, 0x41, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x10, 0x20, 0x4F, 0x00, 0x10, 0x84, 0xD2, 0x10, 0x84, 0x42, 0x10,
  0x84, 0x42, 0x0C, 0x21, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x84,
  0x84, 0x88, 0x88, 0xF8, 0x83, 0x0A, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA1,
  0x43, 0x06, 0x08, 0x00, 0x82, 0x18, 0x62, 0x86, 0x28, 0xA4, 0x8A, 0x49,
  0x24, 0x92, 0x89, 0x28, 0xA3, 0x0A, 0x30, 0xC2, 0x0C, 0x20, 0x82, 0x00,
  0x10, 0x88, 0x84, 0x81, 0x40, 0xC0, 0x40, 0x20, 0x30, 0x14, 0x12, 0x11,
  0x08, 0x88, 0x40, 0x04, 0x30, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x48,
  0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xE0, 0x00, 0x1F, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0xF8, 0x03, 0x04, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x60, 0xC0, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0x06,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0,
  0x50, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x07, 0x00,
  0x71, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 18, 5, 0, -18 },
  { 13, 5, 7, 6, 2, -18 },
  { 18, 10, 18, 9, 0, -18 },
  { 41, 9, 20, 9, 0, -19 },
  { 64, 11, 18, 13, 1, -18 },
  { 89, 8, 18, 8, 0, -18 },
  { 107, 2, 7, 4, 2, -18 },
  { 109, 6, 22, 6, 1, -18 },
  { 126, 7, 22, 6, -2, -18 },
  { 146, 6, 7, 8, 3, -19 },
  { 152, 8, 12, 10, 1, -15 },
  { 164, 3, 5, 4, -1, -2 },
  { 166, 5, 1, 7, 1, -7 },
  { 167, 2, 2, 4, 0, -2 },
  { 168, 10, 18, 7, -1, -18 },
  { 191, 9, 18, 9, 0, -18 },
  { 212, 4, 18, 9, 3, -18 },
  { 221, 10, 18, 9, -1, -18 },
  { 244, 10, 18, 9, -1, -18 },
  { 267, 10, 18, 9, -1, -18 },
  { 290, 10, 18, 9, -1, -18 },
  { 313, 8, 18, 9, 1, -18 },
  { 331, 9, 18, 9, 1, -18 },
  { 352, 9, 18, 9, 0, -18 },
  { 373, 8, 18, 9, 0, -18 },
  { 391, 4, 13, 4, 0, -13 },
  { 398, 5, 16, 4, -1, -13 },
  { 408, 8, 10, 10, 1, -14 },
  { 418, 8, 6, 10, 1, -12 },
  { 424, 8, 10, 10, 1, -14 },
  { 434, 7, 18, 6, 0, -18 },
  { 450, 11, 20, 13, 1, -18 },
  { 478, 8, 18, 8, -2, -18 },
  { 496, 9, 18, 9, 0, -18 },
  { 517, 9, 18, 8, 1, -18 },
  { 538, 10, 18, 10, 0, -18 },
  { 561, 9, 18, 8, 0, -18 },
  { 582, 10, 18, 8, 0, -18 },
  { 605, 11, 18, 11, 1, -18 },
  { 630, 11, 18, 11, 0, -18 },
  { 655, 7, 18, 4, -1, -18 },
  { 671, 9, 22, 4, -4, -18 },
  { 696, 10, 18, 9, 0, -18 },
  { 719, 6, 18, 8, 0, -18 },
  { 733, 15, 18, 15, 0, -18 },
  { 767, 12, 18, 12, 0, -18 },
  { 794, 10, 18, 11, 1, -18 },
  { 817, 9, 18, 9, 0, -18 },
  { 838, 10, 22, 11, 1, -18 },
  { 866, 9, 18, 9, 0, -18 },
  { 887, 10, 18, 9, -1, -18 },
  { 910, 7, 18, 7, 2, -18 },
  { 926, 10, 18, 11, 1, -18 },
  { 949, 9, 18, 9, 2, -18 },
  { 970, 15, 18, 15, 2, -18 },
  { 1004, 10, 18, 8, -1, -18 },
  { 1027, 7, 18, 7, 2, -18 },
  { 1043, 10, 18, 8, -1, -18 },
  { 1066, 8, 22, 7, 0, -18 },
  { 1088, 3, 18, 8, 3, -18 },
  { 1095, 9, 22, 7, -2, -18 },
  { 1120, 9, 9, 10, 1, -18 },
  { 1131, 7, 1, 7, -2, 2 },
  { 1132, 2, 4, 5, 4, -19 },
  { 1133, 8, 13, 9, 1, -13 },
  { 1146, 9, 19, 9, 0, -19 },
  { 1168, 6, 13, 7, 1, -13 },
  { 1178, 9, 19, 9, 1, -19 },
  { 1200, 7, 13, 8, 1, -13 },
  { 1212, 11, 25, 5, -3, -19 },
  { 1247, 9, 19, 9, 0, -13 },
  { 1269, 8, 19, 9, 0, -19 },
  { 1288, 5, 18, 4, 0, -18 },
  { 1300, 8, 24, 4, -3, -18 },
  { 1324, 8, 19, 7, 0, -19 },
  { 1343, 5, 19, 4, 0, -19 },
  { 1355, 13, 13, 14, 0, -13 },
  { 1377, 8, 13, 9, 0, -13 },
  { 1390, 7, 13, 9, 1, -13 },
  { 1402, 10, 19, 9, -1, -13 },
  { 1426, 8, 19, 10, 1, -13 },
  { 1445, 7, 13, 6, 0, -13 },
  { 1457, 7, 13, 7, 0, -13 },
  { 1469, 5, 16, 5, 0, -16 },
  { 1479, 8, 13, 9, 1, -13 },
  { 1492, 7, 13, 7, 1, -13 },
  { 1504, 12, 13, 12, 1, -13 },
  { 1524, 9, 13, 7, -1, -13 },
  { 1539, 12, 19, 7, -3, -13 },
  { 1568, 8, 13, 6, -1, -13 },
  { 1581, 8, 22, 8, 1, -18 },
  { 1603, 1, 25, 9, 4, -19 },
  { 1607, 9, 22, 8, -2, -18 },
  { 1632, 8, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC25PT7B_H_
