#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x80, 0x02, 0x10, 0x4A,
  0x95, 0x29, 0x48, 0x04, 0x84, 0x82, 0x41, 0x23, 0xF8, 0x90, 0x48, 0x48,
  0x24, 0x12, 0x3F, 0x89, 0x04, 0x82, 0x42, 0x41, 0x20, 0x04, 0x0E, 0x15,
  0x24, 0x24, 0x28, 0x28, 0x18, 0x08, 0x08, 0x14, 0x12, 0x12, 0x12, 0x24,
  0xF8, 0x20, 0x20, 0x10, 0x0A, 0x24, 0x89, 0x24, 0x89, 0x22, 0x88, 0xA2,
  0x57, 0x96, 0x6A, 0x94, 0xA4, 0x51, 0x14, 0x49, 0x12, 0x49, 0x12, 0x47,
  0x00, 0x0C, 0x24, 0x48, 0x92, 0x44, 0x86, 0x0C, 0x10, 0x61, 0x2C, 0x58,
  0xD0, 0xA1, 0x46, 0xF4, 0x56, 0xA0, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10,
  0x41, 0x04, 0x00, 0x25, 0x1E, 0xC9, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE2,
  0x04, 0x08, 0x10, 0x20, 0x25, 0x28, 0xF0, 0xC0, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x00, 0x06, 0x09, 0x11, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70, 0x17, 0x91, 0x12, 0x22, 0x22,
  0x44, 0x44, 0x48, 0x0E, 0x08, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0xFC, 0x00, 0x07,
  0x0C, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x1C, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0xF8, 0x00, 0x01, 0x03, 0x03, 0x05, 0x0A,
  0x0A, 0x12, 0x12, 0x24, 0x44, 0x44, 0x84, 0xF6, 0x08, 0x08, 0x08, 0x08,
  0x0F, 0x84, 0x04, 0x02, 0x01, 0x01, 0x00, 0xF0, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x11, 0xF0, 0x07, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x5C, 0x62, 0x42, 0x42, 0x82, 0x82, 0x82, 0x84, 0x44, 0x78, 0x7F,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x0E, 0x11, 0x21, 0x21, 0x21, 0x21, 0x22, 0x14, 0x18,
  0x24, 0x44, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x0C, 0x12, 0x21, 0x21,
  0x41, 0x41, 0x41, 0x41, 0x42, 0x26, 0x1A, 0x02, 0x04, 0x04, 0x08, 0x08,
  0xF0, 0x20, 0x00, 0x00, 0x02, 0x40, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x84, 0x42, 0x00, 0x02, 0x08, 0x63, 0x08, 0x08, 0x0C, 0x04, 0x06,
  0x04, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x86, 0x10, 0xC1, 0x00, 0x18, 0x90, 0x41, 0x04, 0x10, 0x82, 0x10, 0x84,
  0x10, 0x40, 0x00, 0x20, 0x80, 0x03, 0x03, 0x21, 0x04, 0x81, 0x20, 0x51,
  0xD4, 0x96, 0x49, 0x92, 0x64, 0x9A, 0x26, 0x92, 0xA4, 0xAB, 0x49, 0x22,
  0x00, 0x80, 0x20, 0x07, 0x80, 0x01, 0x03, 0x03, 0x05, 0x05, 0x05, 0x09,
  0x09, 0x11, 0x1F, 0x11, 0x21, 0x21, 0x41, 0x41, 0x81, 0x1F, 0x08, 0x44,
  0x22, 0x12, 0x09, 0x08, 0x88, 0x78, 0x42, 0x21, 0x10, 0x48, 0x24, 0x24,
  0x12, 0x11, 0xF0, 0x07, 0x84, 0x04, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x78, 0x00, 0x1F,
  0x08, 0x44, 0x22, 0x12, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x90, 0x48,
  0x24, 0x24, 0x12, 0x11, 0xF0, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x7C, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0xF0, 0x1F,
  0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x5E, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x07, 0x82, 0x11, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x21, 0xC8, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22,
  0x08, 0x7E, 0x00, 0x10, 0x44, 0x11, 0x04, 0x41, 0x20, 0x48, 0x22, 0x08,
  0xFE, 0x40, 0x90, 0x24, 0x11, 0x04, 0x41, 0x20, 0x48, 0x22, 0x08, 0x1C,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x38, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x86, 0x00, 0x10, 0xC4, 0x41, 0x10, 0x48, 0x24, 0x0A,
  0x02, 0x80, 0xC0, 0x28, 0x12, 0x04, 0x81, 0x10, 0x44, 0x21, 0x08, 0x42,
  0x10, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x1F, 0x10,
  0x0C, 0x60, 0x21, 0x81, 0x8A, 0x06, 0x28, 0x28, 0xA0, 0xA2, 0x84, 0x8A,
  0x14, 0x48, 0x91, 0x22, 0x44, 0x91, 0x12, 0x48, 0x4A, 0x22, 0x28, 0x88,
  0xA2, 0x21, 0x08, 0x10, 0x23, 0x04, 0x61, 0x0C, 0x22, 0x84, 0x48, 0x89,
  0x11, 0x24, 0x44, 0x88, 0x91, 0x12, 0x21, 0x44, 0x31, 0x06, 0x20, 0xC4,
  0x08, 0x0E, 0x08, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0,
  0xA0, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08, 0x78, 0x00, 0x1F, 0x11, 0x11,
  0x11, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x0E, 0x08, 0x88, 0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0,
  0xA0, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08, 0x68, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x1F, 0x11, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x48, 0x48,
  0x48, 0x44, 0x84, 0x84, 0x84, 0x07, 0x04, 0x44, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xFC,
  0x00, 0x7F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x20, 0x90, 0x48, 0x28, 0x14, 0x12, 0x09,
  0x04, 0x82, 0x82, 0x41, 0x20, 0x90, 0x48, 0x24, 0x22, 0x10, 0xF0, 0x81,
  0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0xC0,
  0xC0, 0x80, 0x80, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x0C, 0x28, 0xA1, 0x45,
  0x12, 0x48, 0x92, 0x48, 0x92, 0x45, 0x12, 0x28, 0xA1, 0x45, 0x0C, 0x30,
  0x61, 0x82, 0x08, 0x10, 0x40, 0x08, 0xC2, 0x20, 0x90, 0x24, 0x0A, 0x02,
  0x80, 0x40, 0x20, 0x08, 0x05, 0x01, 0x40, 0x90, 0x44, 0x11, 0x08, 0x42,
  0x10, 0x43, 0x42, 0x44, 0x44, 0x48, 0x48, 0x50, 0x50, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x0F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0xF8, 0x1F,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x91, 0x24, 0x92, 0x44, 0x92,
  0x49, 0x0F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0xE0, 0x18, 0x28, 0x24,
  0x44, 0x42, 0x82, 0x81, 0xFC, 0x95, 0x3E, 0x85, 0x0C, 0x18, 0x30, 0xA1,
  0x42, 0x85, 0x12, 0x27, 0xC0, 0x10, 0x10, 0x10, 0x10, 0x14, 0x2A, 0x31,
  0x21, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0xC4, 0xB8, 0x3D, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x91, 0xA9, 0x08, 0x84, 0x82, 0x41, 0x21, 0x10, 0x88, 0x44, 0x22, 0x21,
  0x10, 0xF8, 0x00, 0x3D, 0x14, 0x61, 0x8B, 0xC8, 0x20, 0x82, 0x08, 0x3C,
  0x00, 0xC0, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0xF0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x03, 0x00, 0x1F, 0x21, 0x21, 0x41, 0x41, 0x42,
  0x42, 0x42, 0x82, 0x84, 0x44, 0x7C, 0x04, 0x04, 0x04, 0x08, 0x90, 0x60,
  0x10, 0x10, 0x10, 0x10, 0x14, 0x2A, 0x31, 0x21, 0x22, 0x22, 0x42, 0x42,
  0x42, 0x44, 0x84, 0x84, 0x84, 0x10, 0x00, 0x22, 0x22, 0x24, 0x44, 0x48,
  0x88, 0x02, 0x00, 0x00, 0x00, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x18, 0x00, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x23, 0x22, 0x24, 0x28, 0x30, 0x50, 0x68, 0x48, 0x48, 0x88,
  0x88, 0x88, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x88, 0x80, 0x3E,
  0xF2, 0x11, 0x21, 0x12, 0x21, 0x22, 0x14, 0x22, 0x42, 0x24, 0x42, 0x44,
  0x28, 0x44, 0x84, 0x48, 0x44, 0x2E, 0x31, 0x21, 0x22, 0x22, 0x42, 0x42,
  0x42, 0x44, 0x84, 0x84, 0x84, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x61, 0x42,
  0x85, 0x12, 0x27, 0x80, 0x17, 0x0C, 0x44, 0x22, 0x11, 0x09, 0x04, 0x82,
  0x42, 0x21, 0x10, 0x98, 0x8B, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x00,
  0x3E, 0x85, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0x12, 0x27, 0xC0, 0x81,
  0x02, 0x08, 0x10, 0x2C, 0xC2, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x3E, 0x81, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x10, 0x27, 0x80, 0x10,
  0x88, 0xF2, 0x10, 0x88, 0x42, 0x11, 0x08, 0x43, 0x80, 0x42, 0x85, 0x0A,
  0x28, 0x50, 0xA1, 0x42, 0x89, 0x12, 0x67, 0x40, 0x86, 0x18, 0xA2, 0x8A,
  0x49, 0x28, 0xA3, 0x0C, 0x20, 0x84, 0x30, 0x8A, 0x31, 0x46, 0x49, 0x49,
  0x29, 0x29, 0x45, 0x28, 0xA6, 0x18, 0xC3, 0x10, 0x42, 0x00, 0x11, 0x12,
  0x12, 0x14, 0x14, 0x08, 0x18, 0x18, 0x28, 0x44, 0x44, 0x84, 0x04, 0x20,
  0x88, 0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x40, 0x28, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0x1E,
  0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x07, 0xC0, 0x07, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x40, 0x20, 0xFF, 0xFF, 0xFF, 0x06, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0xE0, 0xF3, 0x1C,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 5, 6, 6, 2, -16 },
  { 15, 9, 16, 8, 0, -16 },
  { 33, 8, 18, 8, 0, -17 },
  { 51, 10, 17, 12, 1, -17 },
  { 73, 7, 17, 7, 0, -17 },
  { 88, 2, 6, 3, 2, -16 },
  { 90, 6, 20, 6, 1, -16 },
  { 105, 7, 20, 6, -2, -16 },
  { 123, 5, 6, 7, 3, -17 },
  { 127, 7, 10, 9, 1, -13 },
  { 136, 3, 5, 4, -1, -2 },
  { 138, 4, 1, 6, 1, -7 },
  { 139, 1, 2, 4, 0, -2 },
  { 140, 9, 16, 7, -1, -16 },
  { 158, 8, 17, 8, 0, -17 },
  { 175, 4, 16, 8, 2, -16 },
  { 183, 9, 17, 8, -1, -17 },
  { 203, 9, 17, 8, -1, -17 },
  { 223, 8, 17, 8, 0, -17 },
  { 240, 9, 16, 8, -1, -16 },
  { 258, 8, 17, 8, 0, -17 },
  { 275, 8, 16, 8, 1, -16 },
  { 291, 8, 17, 8, 0, -17 },
  { 308, 8, 17, 8, 0, -17 },
  { 325, 3, 12, 4, 0, -12 },
  { 330, 5, 15, 4, -1, -12 },
  { 340, 7, 10, 9, 1, -13 },
  { 349, 7, 6, 9, 1, -11 },
  { 355, 7, 10, 9, 1, -13 },
  { 364, 6, 17, 6, 0, -17 },
  { 377, 10, 19, 12, 1, -17 },
  { 401, 8, 16, 8, -2, -16 },
  { 417, 9, 16, 9, 0, -16 },
  { 435, 9, 17, 8, 1, -17 },
  { 455, 9, 16, 9, 0, -16 },
  { 473, 9, 16, 8, 0, -16 },
  { 491, 9, 16, 7, 0, -16 },
  { 509, 10, 17, 10, 1, -17 },
  { 531, 10, 16, 10, 0, -16 },
  { 551, 6, 16, 4, -1, -16 },
  { 563, 7, 20, 4, -3, -16 },
  { 581, 10, 16, 8, 0, -16 },
  { 601, 5, 16, 7, 0, -16 },
  { 611, 14, 16, 14, 0, -16 },
  { 639, 11, 16, 11, 0, -16 },
  { 661, 9, 17, 10, 1, -17 },
  { 681, 8, 16, 8, 0, -16 },
  { 697, 9, 21, 10, 1, -17 },
  { 721, 8, 16, 8, 0, -16 },
  { 737, 9, 17, 8, -1, -17 },
  { 757, 8, 16, 7, 1, -16 },
  { 773, 9, 16, 10, 1, -16 },
  { 791, 8, 16, 8, 2, -16 },
  { 807, 13, 16, 14, 2, -16 },
  { 833, 10, 16, 7, -1, -16 },
  { 853, 8, 16, 7, 1, -16 },
  { 869, 9, 16, 7, -1, -16 },
  { 887, 8, 20, 6, 0, -16 },
  { 907, 3, 16, 7, 2, -16 },
  { 913, 8, 20, 6, -1, -16 },
  { 933, 8, 7, 9, 1, -16 },
  { 940, 6, 1, 6, -2, 2 },
  { 941, 2, 4, 5, 3, -18 },
  { 942, 7, 12, 9, 1, -12 },
  { 953, 8, 17, 9, 0, -17 },
  { 970, 6, 12, 6, 1, -12 },
  { 979, 9, 17, 9, 1, -17 },
  { 999, 6, 12, 8, 1, -12 },
  { 1008, 10, 24, 4, -3, -18 },
  { 1038, 8, 18, 9, 0, -12 },
  { 1056, 8, 17, 8, 0, -17 },
  { 1073, 4, 16, 4, 0, -16 },
  { 1081, 7, 22, 4, -3, -16 },
  { 1101, 8, 17, 7, 0, -17 },
  { 1118, 4, 17, 3, 0, -17 },
  { 1127, 12, 12, 13, 0, -12 },
  { 1145, 8, 12, 8, 0, -12 },
  { 1157, 7, 12, 8, 1, -12 },
  { 1168, 9, 17, 9, -1, -12 },
  { 1188, 7, 17, 9, 1, -12 },
  { 1203, 6, 12, 5, 0, -12 },
  { 1212, 7, 12, 6, 0, -12 },
  { 1223, 5, 15, 4, 0, -15 },
  { 1233, 7, 12, 8, 1, -12 },
  { 1244, 6, 12, 6, 1, -12 },
  { 1253, 11, 12, 11, 1, -12 },
  { 1270, 8, 12, 7, -1, -12 },
  { 1282, 11, 18, 7, -3, -12 },
  { 1307, 7, 12, 5, -1, -12 },
  { 1318, 8, 20, 7, 1, -16 },
  { 1338, 1, 24, 8, 3, -18 },
  { 1341, 8, 20, 7, -2, -16 },
  { 1361, 7, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC23PT7B_H_
