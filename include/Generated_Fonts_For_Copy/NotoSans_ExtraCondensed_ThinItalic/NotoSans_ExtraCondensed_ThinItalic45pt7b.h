#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x80, 0x30, 0x90, 0xC8,
  0x44, 0x22, 0x13, 0x09, 0x08, 0x84, 0x42, 0x21, 0x21, 0x80, 0x00, 0x20,
  0x80, 0x30, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x04, 0x10, 0x02,
  0x08, 0x01, 0x04, 0x01, 0x84, 0x0F, 0xFF, 0xC0, 0x41, 0x00, 0x61, 0x80,
  0x20, 0x80, 0x10, 0x40, 0x18, 0x60, 0x08, 0x20, 0x04, 0x10, 0x02, 0x18,
  0x02, 0x08, 0x01, 0x04, 0x0F, 0xFF, 0xC0, 0x82, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x30, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x04, 0x10, 0x02,
  0x08, 0x01, 0x0C, 0x01, 0x04, 0x00, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x01, 0xFF, 0x02, 0x21, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x20,
  0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x04, 0x80,
  0x06, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x20,
  0x01, 0x30, 0x01, 0x10, 0x02, 0x18, 0x02, 0x18, 0x02, 0x18, 0x02, 0x18,
  0x02, 0x10, 0x04, 0x10, 0x04, 0x20, 0x84, 0x40, 0xFF, 0x80, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xF8,
  0x04, 0x08, 0x80, 0xC1, 0x0C, 0x08, 0x30, 0x41, 0x82, 0x04, 0x10, 0x20,
  0xC3, 0x06, 0x0C, 0x20, 0x40, 0x86, 0x04, 0x08, 0x40, 0x40, 0x8C, 0x0C,
  0x08, 0x80, 0xC1, 0x98, 0x08, 0x11, 0x08, 0x81, 0x33, 0xE8, 0x32, 0x62,
  0x82, 0x64, 0x38, 0x64, 0xC3, 0xC4, 0xC8, 0x37, 0x89, 0x83, 0x21, 0x90,
  0x20, 0x11, 0x02, 0x01, 0x10, 0x20, 0x23, 0x02, 0x02, 0x30, 0x60, 0x42,
  0x06, 0x04, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0xC1, 0x02, 0x08, 0x10,
  0x21, 0x82, 0x03, 0x10, 0x60, 0x1E, 0x00, 0x00, 0x80, 0x00, 0x20, 0x01,
  0xF0, 0x02, 0x30, 0x08, 0x20, 0x10, 0x40, 0x60, 0x80, 0xC3, 0x01, 0x06,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x18, 0x80, 0x32, 0x00, 0x2C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x0D, 0x00, 0x32, 0x00, 0xC4, 0x11, 0x0C,
  0x44, 0x08, 0x88, 0x11, 0x20, 0x26, 0x40, 0x68, 0x80, 0x51, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x08, 0x0A, 0x10, 0x14, 0x30, 0xC8, 0x3F, 0x18, 0x32,
  0x22, 0x26, 0x44, 0x44, 0x80, 0x00, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x08, 0x61, 0x03, 0x20, 0x1B, 0xC1,
  0x80, 0x50, 0x12, 0x0C, 0x21, 0x02, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0C, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x00, 0xFF, 0xC0, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x07, 0xE0, 0x30, 0xC0, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42,
  0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x16,
  0x00, 0xD0, 0x03, 0x40, 0x09, 0x00, 0x24, 0x00, 0xB0, 0x06, 0xC0, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x10,
  0x80, 0xC2, 0x02, 0x0C, 0x10, 0x10, 0xC0, 0x3E, 0x00, 0x03, 0x0E, 0x1A,
  0x32, 0x42, 0x86, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40,
  0x40, 0xC0, 0x80, 0x80, 0x80, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x60, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0xC0, 0xC0, 0x40,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x81, 0x01, 0x80,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xA0, 0x00, 0xD0, 0x00, 0x58, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22,
  0x00, 0x31, 0x00, 0x11, 0x80, 0x10, 0x80, 0x18, 0x40, 0x08, 0x20, 0x0C,
  0x10, 0x04, 0x10, 0x04, 0x08, 0x06, 0x04, 0x02, 0x02, 0x03, 0x03, 0x01,
  0x01, 0x01, 0x00, 0x81, 0x80, 0x40, 0x80, 0x20, 0xFF, 0xFE, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x20, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x02, 0x03, 0x01, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x20, 0x19, 0xF8, 0x2C, 0x18, 0x50, 0x10, 0xC0, 0x31, 0x00, 0x66,
  0x00, 0x4C, 0x00, 0x98, 0x03, 0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x18, 0x08, 0x10, 0x30, 0x30, 0xC0,
  0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x60, 0xC0, 0x40, 0x20, 0x20,
  0x18, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0x81,
  0x00, 0x40, 0xC0, 0x40, 0x20, 0x60, 0x18, 0x60, 0x04, 0x60, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xB0, 0x03, 0x0C, 0x03, 0x02, 0x03, 0x00, 0x81, 0x00,
  0x41, 0x00, 0x30, 0x80, 0x08, 0x40, 0x04, 0x60, 0x02, 0x30, 0x01, 0x18,
  0x01, 0x84, 0x00, 0x82, 0x00, 0x41, 0x80, 0x40, 0x60, 0x60, 0x1F, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0xF0, 0x0C, 0x10, 0x30, 0x30, 0x40, 0x21, 0x00,
  0x42, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x13,
  0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x10, 0x0C, 0x20, 0x28, 0x60,
  0xD0, 0x7E, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0xFC, 0x00, 0x04, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x60,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x01, 0xFC, 0x10,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x02, 0x00, 0x20, 0x30, 0x01, 0x83,
  0x00, 0x04, 0x10, 0x00, 0x21, 0x80, 0x01, 0x08, 0x00, 0x08, 0xC0, 0xF8,
  0x44, 0x0C, 0x42, 0x20, 0x84, 0x12, 0x0C, 0x20, 0x90, 0x41, 0x04, 0x86,
  0x18, 0x6C, 0x20, 0x83, 0x41, 0x04, 0x12, 0x18, 0x20, 0x90, 0x83, 0x04,
  0x84, 0x10, 0x6C, 0x20, 0x82, 0x61, 0x0C, 0x12, 0x08, 0x61, 0x10, 0x43,
  0x08, 0x82, 0x28, 0x84, 0x1B, 0x6C, 0x20, 0x71, 0x81, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x18, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x02, 0x40, 0x0D, 0x80, 0x13,
  0x00, 0x26, 0x00, 0x8C, 0x01, 0x18, 0x06, 0x30, 0x08, 0x60, 0x10, 0xC0,
  0x41, 0x80, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x1F, 0xF8, 0x20, 0x30, 0x40,
  0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x10, 0x06, 0x20, 0x0C, 0x80, 0x19,
  0x00, 0x36, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xC0, 0x03, 0x01, 0xFC, 0x00,
  0x83, 0x80, 0xC0, 0x40, 0x40, 0x30, 0x20, 0x08, 0x10, 0x04, 0x08, 0x02,
  0x0C, 0x01, 0x04, 0x01, 0x82, 0x00, 0x81, 0x00, 0x41, 0x80, 0x60, 0x80,
  0x60, 0x40, 0x60, 0x23, 0xE0, 0x1F, 0xC0, 0x18, 0x18, 0x08, 0x06, 0x04,
  0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08,
  0x20, 0x04, 0x10, 0x02, 0x18, 0x02, 0x08, 0x01, 0x04, 0x01, 0x02, 0x01,
  0x83, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x41, 0x80, 0x30, 0x10, 0x08,
  0x06, 0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x18, 0x03, 0x04, 0x00,
  0xC1, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x03, 0x08, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x61, 0x00, 0x10, 0x40,
  0x04, 0x10, 0x01, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x04,
  0x08, 0x03, 0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x30, 0x10, 0x18, 0x0C,
  0x38, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x1F, 0xF0, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x1F, 0xF8,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xF8, 0x07, 0x00, 0x81, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x03, 0xE2, 0x00, 0x84, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10,
  0x40, 0x02, 0x0C, 0x00, 0x40, 0x80, 0x18, 0x18, 0x03, 0x01, 0x80, 0x40,
  0x1F, 0xF8, 0x00, 0x01, 0x00, 0x10, 0x10, 0x01, 0x03, 0x00, 0x10, 0x20,
  0x03, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04,
  0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0x40,
  0x80, 0x0C, 0x08, 0x00, 0x80, 0xFF, 0xF8, 0x18, 0x00, 0x81, 0x00, 0x18,
  0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x03, 0x00, 0x10, 0x20, 0x03,
  0x02, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00,
  0x60, 0x40, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x08, 0x00, 0xC0, 0x01,
  0xFC, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x0B, 0x80, 0x38, 0x00, 0x01, 0x00, 0x60, 0x20, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0x80, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x83, 0x00, 0x20, 0x40,
  0x04, 0x10, 0x00, 0x86, 0x00, 0x10, 0x80, 0x06, 0x20, 0x00, 0x88, 0x00,
  0x13, 0x00, 0x02, 0x40, 0x00, 0x54, 0x00, 0x1C, 0x80, 0x03, 0x10, 0x00,
  0x62, 0x00, 0x08, 0x60, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01,
  0x03, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x30, 0x04, 0x04, 0x00, 0xC0, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0xFF, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x0A, 0x00, 0x03, 0x01,
  0x40, 0x00, 0xE0, 0x28, 0x00, 0x14, 0x05, 0x00, 0x06, 0x80, 0xA0, 0x00,
  0xB0, 0x24, 0x00, 0x34, 0x04, 0x80, 0x04, 0x80, 0x90, 0x00, 0x90, 0x12,
  0x00, 0x22, 0x06, 0x40, 0x04, 0xC0, 0x88, 0x01, 0x10, 0x11, 0x00, 0x22,
  0x02, 0x20, 0x08, 0x40, 0x44, 0x01, 0x08, 0x18, 0xC0, 0x43, 0x02, 0x18,
  0x08, 0x40, 0x43, 0x03, 0x08, 0x08, 0x20, 0x41, 0x01, 0x04, 0x18, 0x60,
  0x60, 0x82, 0x08, 0x08, 0x10, 0xC1, 0x01, 0x02, 0x10, 0x20, 0x20, 0x46,
  0x04, 0x0C, 0x08, 0x81, 0x81, 0x01, 0x30, 0x20, 0x20, 0x24, 0x04, 0x04,
  0x05, 0x80, 0x80, 0x80, 0xA0, 0x10, 0x30, 0x1C, 0x06, 0x04, 0x03, 0x00,
  0x80, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x40, 0xE0, 0x02, 0x05, 0x00, 0x30,
  0x28, 0x01, 0x01, 0x40, 0x08, 0x0B, 0x00, 0x40, 0xC8, 0x02, 0x04, 0x40,
  0x30, 0x22, 0x01, 0x01, 0x10, 0x08, 0x18, 0xC0, 0x40, 0x82, 0x06, 0x04,
  0x10, 0x20, 0x20, 0x81, 0x01, 0x04, 0x08, 0x18, 0x20, 0x40, 0x81, 0x86,
  0x04, 0x04, 0x20, 0x20, 0x21, 0x01, 0x01, 0x08, 0x18, 0x08, 0x40, 0x80,
  0x66, 0x04, 0x01, 0x20, 0x20, 0x09, 0x03, 0x00, 0x48, 0x18, 0x02, 0x40,
  0x80, 0x1C, 0x04, 0x00, 0xE0, 0x20, 0x03, 0x03, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x40, 0xC0, 0x40, 0x20, 0x40, 0x18,
  0x60, 0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02, 0xC0,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x01, 0x04, 0x01, 0x81, 0x01, 0x80, 0xC1, 0x80, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x01, 0x06, 0x03, 0x03, 0x02, 0x01, 0x02, 0x01, 0x02, 0x01,
  0x02, 0x01, 0x06, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x0C, 0x03,
  0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x08, 0x18, 0x30, 0x1F, 0xC0,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x40, 0xC0, 0x40,
  0x20, 0x40, 0x18, 0x60, 0x04, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x98,
  0x00, 0x48, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06,
  0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x68, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x81, 0x01, 0x80, 0xC1, 0x80,
  0x3F, 0x80, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0x06,
  0x03, 0x02, 0x02, 0x01, 0x02, 0x01, 0x02, 0x01, 0x02, 0x01, 0x06, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x0C, 0x03, 0x08, 0x02, 0x08, 0x06,
  0x08, 0x0C, 0x08, 0x18, 0x1F, 0xF0, 0x1F, 0x80, 0x10, 0xC0, 0x10, 0x40,
  0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x60, 0x20, 0x20,
  0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x30, 0x80, 0x10,
  0x00, 0x18, 0x00, 0x3F, 0xF0, 0x18, 0x08, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x02, 0x01, 0x80,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x20, 0xC0, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08,
  0x00, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x60,
  0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x41, 0x80,
  0x18, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x03, 0x06, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x08, 0x18, 0x01,
  0x03, 0x00, 0x20, 0x60, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x08, 0x18,
  0x00, 0xFE, 0x00, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x68, 0x00,
  0x90, 0x03, 0x20, 0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0x42, 0x01, 0x84,
  0x02, 0x08, 0x0C, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01, 0x06,
  0x02, 0x08, 0x04, 0x30, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00,
  0x98, 0x01, 0x20, 0x02, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x06, 0x00, 0x28, 0x00, 0xC0, 0x0D, 0x00, 0x38,
  0x01, 0x20, 0x07, 0x00, 0x64, 0x00, 0xE0, 0x08, 0x80, 0x28, 0x01, 0x10,
  0x05, 0x00, 0x42, 0x01, 0xA0, 0x08, 0x40, 0x24, 0x03, 0x08, 0x04, 0x80,
  0x41, 0x01, 0x10, 0x08, 0x20, 0x22, 0x02, 0x04, 0x0C, 0x40, 0x40, 0x81,
  0x08, 0x18, 0x10, 0x21, 0x02, 0x02, 0x0C, 0x20, 0x40, 0x41, 0x04, 0x10,
  0x08, 0x60, 0x82, 0x03, 0x08, 0x10, 0xC0, 0x61, 0x02, 0x10, 0x0C, 0x60,
  0x42, 0x01, 0x88, 0x08, 0x80, 0x31, 0x01, 0x10, 0x06, 0x40, 0x26, 0x00,
  0xC8, 0x04, 0x80, 0x1B, 0x00, 0x90, 0x03, 0x40, 0x14, 0x00, 0x68, 0x02,
  0x80, 0x0A, 0x00, 0x70, 0x01, 0x40, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x40, 0x40, 0x04,
  0x04, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x04, 0x30, 0x00,
  0x42, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x70, 0x00, 0x05, 0x00,
  0x00, 0x90, 0x00, 0x19, 0x00, 0x01, 0x10, 0x00, 0x31, 0x00, 0x02, 0x10,
  0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x81, 0x00, 0x18, 0x10, 0x01, 0x01,
  0x80, 0x30, 0x18, 0x02, 0x00, 0x80, 0x60, 0x08, 0x0C, 0x00, 0x80, 0x40,
  0x0D, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x84, 0x04, 0x18,
  0x10, 0x60, 0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88, 0x02,
  0x40, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF,
  0x00, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x10, 0x60, 0x82,
  0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20,
  0x83, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x02, 0x60, 0x02, 0x20, 0x04, 0x30, 0x04, 0x10, 0x08, 0x18, 0x08,
  0x08, 0x10, 0x0C, 0x10, 0x04, 0x20, 0x06, 0x20, 0x02, 0x40, 0x03, 0xC0,
  0x01, 0xFF, 0xE0, 0x88, 0x44, 0x22, 0x10, 0x01, 0xF1, 0x03, 0x1A, 0x04,
  0x0A, 0x0C, 0x06, 0x08, 0x06, 0x10, 0x06, 0x10, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x60, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08, 0xC0,
  0x18, 0xC0, 0x10, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0x40,
  0x60, 0x40, 0xA0, 0x61, 0xA0, 0x3F, 0x20, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x78, 0x04, 0x84, 0x05, 0x02, 0x06, 0x02, 0x0E,
  0x02, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x02, 0x18, 0x02, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x08, 0x60, 0x08, 0x60, 0x18, 0x60, 0x10, 0x70, 0x20, 0x50,
  0x40, 0x8F, 0x80, 0x01, 0xF0, 0x31, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x1F, 0x30, 0x0C, 0x68, 0x04, 0x0A, 0x03, 0x01, 0x80, 0x80,
  0x60, 0x40, 0x18, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80, 0x30,
  0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x18, 0x30,
  0x04, 0x0C, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x1C, 0x04, 0x06,
  0x01, 0x02, 0x80, 0x61, 0xA0, 0x0F, 0xC8, 0x00, 0x01, 0xF0, 0x18, 0x81,
  0x06, 0x10, 0x11, 0x80, 0x88, 0x0C, 0xC0, 0x44, 0x02, 0x20, 0x32, 0x03,
  0x10, 0x30, 0xBE, 0x07, 0x80, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x82, 0x07, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x09, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x40, 0x31, 0xA0, 0x10, 0x28, 0x0C,
  0x06, 0x02, 0x01, 0x81, 0x00, 0x60, 0x40, 0x10, 0x20, 0x04, 0x08, 0x01,
  0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x83,
  0x00, 0x60, 0xC0, 0x10, 0x30, 0x04, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x70, 0x10, 0x18, 0x04, 0x0A, 0x01, 0x86, 0x80, 0x3F, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x80, 0xC0, 0x39, 0xE0, 0x03, 0xE0, 0x00, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x11, 0xE0, 0x2C, 0x20, 0x70, 0x60,
  0xC0, 0x43, 0x00, 0x86, 0x03, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0xC0,
  0x21, 0x00, 0xC2, 0x01, 0x04, 0x02, 0x08, 0x04, 0x30, 0x08, 0x40, 0x30,
  0x80, 0x41, 0x00, 0x86, 0x01, 0x08, 0x06, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x21, 0x80, 0x40, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x01, 0x30, 0x03, 0x80, 0x00, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x18, 0x20, 0x20, 0x40, 0x80, 0x83, 0x03, 0x0C,
  0x04, 0x10, 0x08, 0x40, 0x11, 0x80, 0x26, 0x00, 0xC8, 0x01, 0x30, 0x02,
  0xA0, 0x07, 0x60, 0x1C, 0x40, 0x30, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04,
  0x06, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40, 0x41, 0x80, 0x80,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x00, 0x04, 0xF8, 0x7C, 0x0B, 0x1B, 0x0C, 0x18, 0x14, 0x08,
  0x30, 0x30, 0x10, 0xC0, 0x60, 0x21, 0x80, 0x80, 0x42, 0x01, 0x00, 0x84,
  0x02, 0x03, 0x08, 0x0C, 0x04, 0x30, 0x10, 0x08, 0x40, 0x20, 0x10, 0x80,
  0x40, 0x21, 0x00, 0x80, 0xC6, 0x03, 0x01, 0x08, 0x04, 0x02, 0x10, 0x08,
  0x04, 0x20, 0x10, 0x18, 0x40, 0x60, 0x21, 0x80, 0x80, 0x42, 0x01, 0x00,
  0x84, 0x02, 0x01, 0x08, 0x04, 0x06, 0x10, 0x18, 0x08, 0x60, 0x20, 0x10,
  0x04, 0x78, 0x0B, 0x08, 0x1C, 0x18, 0x30, 0x10, 0xC0, 0x61, 0x80, 0xC2,
  0x01, 0x04, 0x02, 0x08, 0x04, 0x30, 0x08, 0x40, 0x30, 0x80, 0x41, 0x00,
  0x86, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x80, 0x42,
  0x01, 0x84, 0x02, 0x08, 0x04, 0x10, 0x08, 0x60, 0x30, 0x01, 0xF0, 0x18,
  0x60, 0x40, 0x82, 0x03, 0x18, 0x04, 0x40, 0x13, 0x00, 0x48, 0x01, 0x20,
  0x05, 0x80, 0x34, 0x00, 0xD0, 0x02, 0x40, 0x09, 0x00, 0x2C, 0x00, 0xB0,
  0x06, 0xC0, 0x12, 0x00, 0x48, 0x03, 0x30, 0x08, 0xC0, 0x61, 0x03, 0x06,
  0x18, 0x0F, 0xC0, 0x01, 0x1E, 0x00, 0x48, 0x40, 0x14, 0x08, 0x06, 0x02,
  0x03, 0x80, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x08, 0x03, 0x02, 0x00, 0xC1,
  0x80, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x60, 0xC0,
  0x18, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x81, 0x80, 0x20, 0x60, 0x18,
  0x18, 0x04, 0x07, 0x02, 0x01, 0x41, 0x00, 0xCF, 0x80, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF1, 0x03, 0x1A,
  0x04, 0x0A, 0x08, 0x06, 0x18, 0x06, 0x10, 0x06, 0x10, 0x04, 0x20, 0x04,
  0x20, 0x04, 0x20, 0x0C, 0x60, 0x08, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x18, 0xC0, 0x10, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30,
  0x40, 0x60, 0x40, 0xA0, 0x61, 0xA0, 0x3F, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x04, 0x70, 0x58, 0x07, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x01, 0xF0, 0x18, 0x30, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x08, 0x18, 0x3F, 0xC0,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x3F, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xF0, 0x08, 0x06, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x21, 0x80, 0x42, 0x01, 0x84, 0x02, 0x08, 0x04, 0x30, 0x08, 0x40, 0x30,
  0x80, 0x41, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x43, 0x01, 0x84, 0x03, 0x08, 0x0C, 0x10, 0x18, 0x30, 0x50,
  0x3F, 0x20, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x0D, 0x01, 0x20, 0x64,
  0x08, 0x81, 0x10, 0x42, 0x08, 0x43, 0x08, 0x41, 0x18, 0x22, 0x04, 0xC0,
  0x90, 0x12, 0x02, 0x80, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x60, 0x38, 0x06, 0x02, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x80, 0xA0, 0x48,
  0x12, 0x04, 0x81, 0x20, 0x88, 0x12, 0x08, 0x82, 0x21, 0x88, 0x26, 0x10,
  0x84, 0x61, 0x08, 0x46, 0x20, 0x8C, 0x62, 0x08, 0x84, 0x60, 0x88, 0x44,
  0x09, 0x04, 0x40, 0x90, 0x48, 0x0B, 0x04, 0x80, 0xA0, 0x48, 0x0A, 0x05,
  0x00, 0xC0, 0x50, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x08, 0x06, 0x00, 0x02,
  0x01, 0x02, 0x03, 0x02, 0x02, 0x02, 0x04, 0x03, 0x0C, 0x01, 0x08, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0x40, 0x06, 0x40, 0x04, 0x40, 0x08, 0x40, 0x18,
  0x40, 0x10, 0x60, 0x30, 0x20, 0x20, 0x20, 0x40, 0x20, 0xC0, 0x20, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x04, 0x02, 0x00, 0x40, 0x60,
  0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x10,
  0x00, 0x41, 0x00, 0x04, 0x30, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0x44,
  0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x50, 0x00, 0x05,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x09, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x98, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x67, 0x01,
  0xC0, 0xC6, 0x80, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 32, 9, 1, -32 },
  { 33, 9, 11, 12, 4, -32 },
  { 46, 17, 32, 16, 0, -32 },
  { 114, 16, 37, 15, 0, -34 },
  { 188, 20, 34, 23, 2, -33 },
  { 273, 15, 33, 15, -1, -33 },
  { 335, 4, 11, 6, 4, -32 },
  { 341, 12, 39, 11, 1, -32 },
  { 400, 12, 39, 11, -3, -32 },
  { 459, 11, 12, 14, 5, -34 },
  { 476, 16, 20, 18, 1, -26 },
  { 516, 6, 10, 7, -2, -4 },
  { 524, 10, 1, 12, 1, -13 },
  { 526, 2, 3, 7, 1, -3 },
  { 527, 18, 32, 13, -2, -32 },
  { 599, 14, 33, 15, 1, -33 },
  { 657, 8, 32, 15, 5, -32 },
  { 689, 17, 33, 15, -2, -33 },
  { 760, 17, 34, 15, -1, -33 },
  { 833, 17, 33, 15, -1, -33 },
  { 904, 17, 32, 15, -1, -32 },
  { 972, 15, 33, 15, 1, -33 },
  { 1034, 15, 32, 15, 2, -32 },
  { 1094, 17, 33, 15, -1, -33 },
  { 1165, 15, 33, 15, 0, -33 },
  { 1227, 7, 24, 7, 0, -24 },
  { 1248, 9, 30, 7, -2, -24 },
  { 1282, 16, 18, 18, 1, -25 },
  { 1318, 16, 11, 18, 1, -21 },
  { 1340, 16, 18, 18, 1, -25 },
  { 1376, 12, 33, 11, 1, -33 },
  { 1426, 21, 36, 23, 1, -32 },
  { 1521, 15, 32, 15, -3, -32 },
  { 1581, 17, 32, 17, 0, -32 },
  { 1649, 17, 33, 15, 2, -33 },
  { 1720, 18, 32, 19, 0, -32 },
  { 1792, 17, 32, 15, 0, -32 },
  { 1860, 17, 32, 14, 0, -32 },
  { 1928, 19, 33, 20, 2, -33 },
  { 2007, 20, 32, 20, 0, -32 },
  { 2087, 14, 32, 7, -3, -32 },
  { 2143, 14, 40, 7, -6, -32 },
  { 2213, 19, 32, 16, 0, -32 },
  { 2289, 10, 32, 14, 0, -32 },
  { 2329, 27, 32, 26, 0, -32 },
  { 2437, 21, 32, 21, 0, -32 },
  { 2521, 17, 33, 20, 2, -33 },
  { 2592, 16, 32, 16, 0, -32 },
  { 2656, 17, 41, 20, 2, -33 },
  { 2744, 16, 32, 16, 0, -32 },
  { 2808, 18, 33, 15, -1, -33 },
  { 2883, 14, 32, 13, 3, -32 },
  { 2939, 19, 32, 19, 1, -32 },
  { 3015, 15, 32, 15, 4, -32 },
  { 3075, 27, 32, 27, 3, -32 },
  { 3183, 20, 32, 14, -3, -32 },
  { 3263, 14, 32, 13, 3, -32 },
  { 3319, 18, 32, 14, -2, -32 },
  { 3391, 16, 39, 12, -1, -32 },
  { 3469, 6, 32, 14, 5, -32 },
  { 3493, 16, 39, 12, -3, -32 },
  { 3571, 16, 15, 18, 1, -32 },
  { 3601, 11, 1, 12, -3, 4 },
  { 3603, 4, 7, 9, 7, -34 },
  { 3607, 16, 24, 17, 1, -24 },
  { 3655, 16, 34, 17, 0, -34 },
  { 3723, 12, 24, 12, 1, -24 },
  { 3759, 18, 34, 17, 1, -34 },
  { 3836, 13, 24, 15, 1, -24 },
  { 3875, 20, 45, 8, -6, -34 },
  { 3988, 18, 35, 17, -1, -24 },
  { 4067, 15, 34, 16, 0, -34 },
  { 4131, 8, 32, 7, 0, -32 },
  { 4163, 15, 43, 7, -6, -32 },
  { 4244, 15, 34, 13, 0, -34 },
  { 4308, 9, 34, 7, 0, -34 },
  { 4347, 23, 24, 25, 0, -24 },
  { 4416, 15, 24, 16, 0, -24 },
  { 4461, 14, 24, 16, 1, -24 },
  { 4503, 18, 34, 17, -2, -24 },
  { 4580, 16, 35, 17, 1, -24 },
  { 4650, 12, 24, 10, 0, -24 },
  { 4686, 14, 24, 12, -1, -24 },
  { 4728, 8, 29, 8, 1, -29 },
  { 4757, 15, 24, 16, 1, -24 },
  { 4802, 11, 24, 12, 3, -24 },
  { 4835, 20, 24, 21, 3, -24 },
  { 4895, 16, 24, 13, -2, -24 },
  { 4943, 20, 35, 13, -5, -24 },
  { 5031, 13, 24, 10, -1, -24 },
  { 5070, 16, 39, 14, 1, -32 },
  { 5148, 1, 45, 15, 7, -34 },
  { 5154, 15, 39, 14, -3, -32 },
  { 5228, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC45PT7B_H_
