#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xC0, 0x6D, 0x6D, 0x00, 0x79, 0x25, 0x80, 0x5E, 0xAF,
  0x5A, 0x56, 0xF0, 0xC0, 0x5A, 0xA8, 0x24, 0x92, 0xB0, 0xB0, 0x4B, 0xA0,
  0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x76, 0xDB, 0x80, 0xFC, 0x44, 0xA9,
  0x80, 0x64, 0xA3, 0x80, 0x25, 0x6C, 0x80, 0x73, 0x13, 0x80, 0x73, 0x5B,
  0x80, 0x65, 0x25, 0x00, 0x75, 0x6B, 0x80, 0x56, 0xE3, 0x80, 0x10, 0x18,
  0x78, 0x80, 0xFC, 0xCE, 0x00, 0xD6, 0xA0, 0x25, 0xFF, 0xE8, 0xC0, 0x25,
  0xB7, 0x40, 0x6E, 0xFB, 0x80, 0x6A, 0x49, 0x80, 0x6E, 0xDB, 0x80, 0x6B,
  0x49, 0x80, 0x6A, 0x69, 0x00, 0x34, 0x8B, 0xAE, 0x55, 0xDA, 0xAA, 0x5A,
  0xA0, 0x55, 0x5C, 0x69, 0x2D, 0x80, 0x5A, 0xB0, 0x4A, 0x55, 0xAB, 0x68,
  0x55, 0xDD, 0xAA, 0x6E, 0xDB, 0xC0, 0x6E, 0xA9, 0x00, 0x6E, 0xDB, 0x50,
  0x6E, 0xAD, 0x80, 0x72, 0x23, 0x80, 0xEA, 0xA0, 0x55, 0xAA, 0xAE, 0xFA,
  0xA0, 0xDD, 0xDE, 0xAC, 0x69, 0x2D, 0x80, 0xB7, 0x29, 0x00, 0x65, 0x29,
  0x80, 0x6A, 0x49, 0x20, 0xFC, 0x55, 0x58, 0x4A, 0x80, 0xC0, 0x80, 0xF6,
  0xE0, 0x4A, 0xDB, 0x80, 0xEB, 0x2E, 0xDB, 0x80, 0xFB, 0x25, 0x24, 0x94,
  0xF6, 0xE5, 0x80, 0x4A, 0xDB, 0x80, 0x4A, 0xA0, 0x21, 0x24, 0x94, 0x4F,
  0x4D, 0x80, 0x5A, 0xA0, 0xFB, 0xBD, 0xF6, 0xE0, 0xF6, 0xE0, 0xF6, 0xE9,
  0x00, 0xF6, 0xE4, 0x80, 0xEA, 0xE7, 0x6A, 0x80, 0xB6, 0xE0, 0xBA, 0x40,
  0xBD, 0xAA, 0xEA, 0x60, 0x56, 0x24, 0x4C, 0x5A, 0x29, 0x65, 0x30, 0xFF,
  0x24, 0x92, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 1, 2, 2, 1, -6 },
  { 4, 3, 6, 3, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 4, 6, 4, 0, -6 },
  { 13, 2, 6, 3, 0, -6 },
  { 15, 1, 2, 1, 1, -6 },
  { 16, 2, 7, 2, 0, -6 },
  { 18, 3, 7, 2, -1, -6 },
  { 21, 2, 2, 3, 1, -6 },
  { 22, 3, 4, 3, 0, -5 },
  { 24, 1, 2, 1, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 1, 0, -1 },
  { 27, 3, 6, 2, 0, -6 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 1, 6, 3, 1, -6 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 3, 6, 3, 0, -6 },
  { 40, 3, 6, 3, 0, -6 },
  { 43, 3, 6, 3, 0, -6 },
  { 46, 3, 6, 3, 0, -6 },
  { 49, 3, 6, 3, 0, -6 },
  { 52, 3, 6, 3, 0, -6 },
  { 55, 3, 6, 3, 0, -6 },
  { 58, 1, 4, 1, 0, -4 },
  { 59, 1, 5, 1, 0, -4 },
  { 60, 3, 3, 3, 0, -4 },
  { 62, 3, 2, 3, 0, -4 },
  { 63, 3, 3, 3, 0, -4 },
  { 65, 2, 6, 2, 0, -6 },
  { 67, 4, 7, 4, 0, -6 },
  { 71, 3, 6, 3, -1, -6 },
  { 74, 3, 6, 3, 0, -6 },
  { 77, 3, 6, 3, 0, -6 },
  { 80, 3, 6, 3, 0, -6 },
  { 83, 3, 6, 3, 0, -6 },
  { 86, 3, 6, 3, 0, -6 },
  { 89, 4, 6, 4, 0, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 2, 6, 1, 0, -6 },
  { 97, 2, 7, 1, -1, -6 },
  { 99, 3, 6, 3, 0, -6 },
  { 102, 2, 6, 2, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 4, 6, 4, 0, -6 },
  { 111, 3, 6, 4, 0, -6 },
  { 114, 3, 6, 3, 0, -6 },
  { 117, 3, 7, 4, 0, -6 },
  { 120, 3, 6, 3, 0, -6 },
  { 123, 3, 6, 3, 0, -6 },
  { 126, 2, 6, 2, 1, -6 },
  { 128, 4, 6, 3, 0, -6 },
  { 131, 2, 6, 3, 1, -6 },
  { 133, 4, 6, 5, 1, -6 },
  { 136, 3, 6, 2, 0, -6 },
  { 139, 3, 6, 2, 0, -6 },
  { 142, 3, 6, 2, 0, -6 },
  { 145, 3, 7, 2, 0, -6 },
  { 148, 1, 6, 3, 1, -6 },
  { 149, 2, 7, 2, 0, -6 },
  { 151, 3, 3, 3, 0, -6 },
  { 153, 2, 1, 2, -1, 0 },
  { 154, 1, 1, 2, 1, -6 },
  { 155, 3, 4, 3, 0, -4 },
  { 157, 3, 6, 3, 0, -6 },
  { 160, 2, 4, 2, 0, -4 },
  { 161, 3, 6, 3, 0, -6 },
  { 164, 2, 4, 3, 0, -4 },
  { 165, 3, 8, 1, -1, -6 },
  { 168, 3, 6, 3, 0, -4 },
  { 171, 3, 6, 3, 0, -6 },
  { 174, 2, 6, 1, 0, -6 },
  { 176, 3, 8, 1, -1, -6 },
  { 179, 3, 6, 2, 0, -6 },
  { 182, 2, 6, 1, 0, -6 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 3, 4, 3, 0, -4 },
  { 190, 3, 6, 3, 0, -4 },
  { 193, 3, 6, 3, 0, -4 },
  { 196, 2, 4, 2, 0, -4 },
  { 197, 2, 4, 2, 0, -4 },
  { 198, 2, 5, 1, 0, -5 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 3, 4, 2, 0, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 3, 4, 2, 0, -4 },
  { 208, 4, 6, 2, -1, -4 },
  { 211, 2, 4, 2, 0, -4 },
  { 212, 3, 7, 2, 0, -6 },
  { 215, 1, 8, 3, 1, -6 },
  { 216, 3, 7, 2, -1, -6 },
  { 219, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC8PT7B_H_
