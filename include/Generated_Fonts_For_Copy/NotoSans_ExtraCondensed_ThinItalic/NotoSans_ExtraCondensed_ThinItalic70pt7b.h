#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x18,
  0x18, 0xC0, 0xC6, 0x06, 0x60, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC4, 0x04,
  0x60, 0x23, 0x03, 0x18, 0x18, 0x80, 0xC4, 0x04, 0x20, 0x23, 0x03, 0x18,
  0x18, 0x80, 0x84, 0x04, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x06,
  0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C,
  0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x40, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7D, 0x9F, 0x00, 0x38, 0x60, 0xC0,
  0x18, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x08, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x10, 0x00, 0x06, 0x04, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x02, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x04, 0x06, 0x00, 0x01, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x0C, 0x03, 0x01, 0x0E, 0x00, 0xFC, 0xDF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x06, 0x38, 0x00, 0xC0,
  0x18, 0x30, 0x01, 0x80, 0x60, 0x60, 0x06, 0x01, 0xC0, 0xC0, 0x0C, 0x03,
  0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x01, 0x83, 0x00, 0x30, 0x06,
  0x06, 0x00, 0x60, 0x0C, 0x18, 0x00, 0xC0, 0x18, 0x30, 0x01, 0x80, 0x30,
  0xC0, 0x02, 0x00, 0x61, 0x80, 0x0C, 0x01, 0x86, 0x02, 0x18, 0x03, 0x0C,
  0x3F, 0x30, 0x06, 0x30, 0xE7, 0x60, 0x18, 0x63, 0x06, 0xC0, 0x31, 0x8E,
  0x05, 0x80, 0xC3, 0x18, 0x0F, 0x01, 0x8C, 0x60, 0x1A, 0x06, 0x18, 0xC0,
  0x36, 0x0C, 0x61, 0x80, 0x6E, 0x70, 0xC6, 0x00, 0xCF, 0xC3, 0x0C, 0x01,
  0x04, 0x06, 0x10, 0x06, 0x00, 0x18, 0x60, 0x0C, 0x00, 0x30, 0xC0, 0x18,
  0x00, 0xC1, 0x80, 0x30, 0x01, 0x82, 0x00, 0x60, 0x06, 0x0C, 0x00, 0xC0,
  0x0C, 0x18, 0x03, 0x00, 0x30, 0x30, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x02, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x08, 0x06, 0x00, 0xC0, 0x10, 0x0C, 0x03, 0x00,
  0x30, 0x30, 0x06, 0x00, 0x60, 0x60, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x01,
  0xC6, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x06, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x01, 0x80,
  0xC0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0xC3,
  0x01, 0x03, 0x18, 0x06, 0x0C, 0x60, 0x18, 0x23, 0x00, 0x61, 0x8C, 0x00,
  0x86, 0x60, 0x03, 0x11, 0x80, 0x0C, 0xC6, 0x00, 0x33, 0x30, 0x00, 0x58,
  0xC0, 0x01, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0xC3, 0x00, 0x0F, 0x0E, 0x00, 0x6C, 0x18, 0x03, 0x10, 0x70, 0x1C,
  0x40, 0xE0, 0xE1, 0x81, 0xFE, 0x06, 0x01, 0xE0, 0x00, 0x18, 0xC6, 0x63,
  0x18, 0xC4, 0x63, 0x18, 0x84, 0x23, 0x18, 0x84, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x40, 0x40, 0x38, 0x10,
  0x03, 0x04, 0x00, 0x33, 0x02, 0x06, 0x8F, 0xC0, 0x7E, 0x00, 0x1C, 0x00,
  0x0D, 0x00, 0x06, 0x20, 0x06, 0x08, 0x03, 0x01, 0x01, 0x80, 0x60, 0x40,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xC0, 0xE0,
  0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x60, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x04, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x30, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x07,
  0x60, 0x73, 0x07, 0x18, 0x60, 0x86, 0x0C, 0x60, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x0E, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x80, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x60, 0x01, 0xC0, 0x20, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFC, 0x00,
  0x3C, 0x08, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x1F, 0xE0, 0x0C, 0xF1, 0xE0, 0x13,
  0x80, 0xE0, 0x6C, 0x00, 0xC0, 0xD0, 0x00, 0xC1, 0xE0, 0x01, 0x83, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x08, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x60,
  0x80, 0x00, 0xC1, 0x00, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0x80, 0x03,
  0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x30, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01,
  0x80, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x01, 0x80, 0x07, 0x81, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x3C, 0x06, 0x00, 0x6C, 0x07, 0x00, 0xCC, 0x03, 0xC7, 0x98,
  0x00, 0xFE, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x81, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xE0, 0x1E, 0x0E, 0x01, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x3E,
  0x01, 0x04, 0x00, 0xFF, 0x01, 0x0C, 0x01, 0xC3, 0x03, 0x0C, 0x03, 0x03,
  0x03, 0x18, 0x06, 0x03, 0x03, 0x18, 0x06, 0x06, 0x03, 0x18, 0x0C, 0x06,
  0x03, 0x30, 0x0C, 0x06, 0x03, 0x30, 0x18, 0x06, 0x03, 0x30, 0x18, 0x0C,
  0x03, 0x30, 0x30, 0x0C, 0x02, 0x60, 0x30, 0x0C, 0x06, 0x60, 0x30, 0x0C,
  0x06, 0x60, 0x60, 0x18, 0x06, 0x60, 0x60, 0x18, 0x06, 0x60, 0x60, 0x18,
  0x0C, 0xC0, 0x60, 0x38, 0x0C, 0xC0, 0x60, 0x30, 0x0C, 0xC0, 0x40, 0x30,
  0x18, 0xC0, 0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x70, 0x18, 0xC0, 0xC0, 0x70,
  0x30, 0xC0, 0xC0, 0xF0, 0x30, 0xC0, 0xC0, 0xB0, 0x60, 0xC0, 0x61, 0xB0,
  0xE0, 0xC0, 0x63, 0x31, 0xC0, 0xC0, 0x7F, 0x1F, 0x80, 0xC0, 0x3C, 0x0E,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x00,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x13, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x08, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x00, 0x40, 0x18, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0F, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x3C, 0x00, 0x60, 0x03,
  0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x78, 0x1C, 0x00, 0x38, 0x02, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xC0, 0x3C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x1C, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x10, 0x00, 0x70, 0x06, 0x00, 0x1C,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0xF8, 0x30, 0x00, 0x3F, 0xE0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20,
  0x03, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x07, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x02, 0x6C, 0x00,
  0x00, 0x36, 0x60, 0x00, 0x01, 0xA3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x40, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x1A, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0B, 0x00, 0x00,
  0x03, 0x60, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0x00, 0x34,
  0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x04,
  0xC0, 0x00, 0x03, 0x30, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0xCC, 0x00,
  0x00, 0x62, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x00, 0x0C,
  0x60, 0x06, 0x10, 0x00, 0x03, 0x18, 0x01, 0x84, 0x00, 0x01, 0x86, 0x00,
  0x61, 0x00, 0x00, 0x61, 0x00, 0x18, 0x40, 0x00, 0x30, 0xC0, 0x04, 0x18,
  0x00, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x02, 0x06, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x03,
  0x00, 0x30, 0x18, 0x03, 0x00, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x60, 0x08,
  0x0C, 0x01, 0x80, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x81, 0x80,
  0x30, 0x01, 0x00, 0x30, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x03, 0x00,
  0x31, 0x80, 0x18, 0x00, 0x80, 0x0C, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xD8, 0x00, 0x40, 0x06, 0x00, 0x36, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x30,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x00, 0xC0, 0x0F, 0x00, 0x00, 0x60, 0x07, 0x80, 0x00, 0x30, 0x03, 0xC0,
  0x00, 0x30, 0x01, 0x60, 0x00, 0x18, 0x01, 0xB0, 0x00, 0x0C, 0x00, 0xC8,
  0x00, 0x06, 0x00, 0x66, 0x00, 0x02, 0x00, 0x33, 0x00, 0x03, 0x00, 0x11,
  0x80, 0x01, 0x80, 0x18, 0xC0, 0x00, 0xC0, 0x0C, 0x20, 0x00, 0x60, 0x06,
  0x18, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x30, 0x03, 0x06, 0x00, 0x18, 0x01,
  0x83, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00,
  0x30, 0x30, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x40, 0x06, 0x01, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x04,
  0x00, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x03, 0x03, 0x00, 0x30, 0x01, 0x81,
  0x80, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x30,
  0x60, 0x06, 0x00, 0x08, 0x30, 0x03, 0x00, 0x06, 0x18, 0x01, 0x80, 0x03,
  0x08, 0x00, 0xC0, 0x01, 0x8C, 0x00, 0x40, 0x00, 0xC6, 0x00, 0x60, 0x00,
  0x63, 0x00, 0x30, 0x00, 0x19, 0x80, 0x18, 0x00, 0x0C, 0x80, 0x0C, 0x00,
  0x06, 0xC0, 0x04, 0x00, 0x03, 0x60, 0x06, 0x00, 0x01, 0xB0, 0x03, 0x00,
  0x00, 0x58, 0x01, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x02, 0x03, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0x60,
  0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x02, 0x03, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x07, 0x80, 0x06, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x02, 0x00, 0x70, 0x03, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x04, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xC0,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x06,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x14,
  0x00, 0x03, 0x18, 0x00, 0x0D, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x40, 0x00,
  0x61, 0x80, 0x00, 0x90, 0x00, 0x18, 0x60, 0x00, 0x64, 0x00, 0x0C, 0x18,
  0x00, 0x1B, 0x00, 0x03, 0x06, 0x00, 0x0C, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x04, 0x00, 0x18, 0xC0, 0x03, 0x01, 0x00, 0x0C, 0x30, 0x00, 0xC0,
  0x40, 0x03, 0x0C, 0x00, 0x60, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x04, 0x00,
  0x60, 0xC0, 0x0C, 0x01, 0x00, 0x18, 0x30, 0x03, 0x00, 0x40, 0x04, 0x0C,
  0x00, 0xC0, 0x10, 0x03, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0xC0, 0x18,
  0x01, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x40, 0x18, 0x0C, 0x03, 0x00, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x02, 0x03,
  0x00, 0x0C, 0x04, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x20, 0x60, 0x00,
  0xC0, 0xC0, 0x08, 0x18, 0x00, 0x30, 0x60, 0x02, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x83, 0x00, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x00, 0xC3, 0x00, 0x08,
  0x60, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x01, 0x84, 0x00,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00,
  0x64, 0x00, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x01,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x40, 0x06, 0x01, 0x00,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x02,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xC0,
  0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xC1, 0x81, 0x03, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x08, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xC3, 0x00,
  0x78, 0xE3, 0x00, 0xE0, 0x32, 0x01, 0xC0, 0x12, 0x03, 0x80, 0x1E, 0x03,
  0x00, 0x1E, 0x06, 0x00, 0x1E, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0,
  0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x02, 0x80, 0x60, 0x07, 0x80, 0x60,
  0x0D, 0x80, 0x70, 0x19, 0x80, 0x38, 0x71, 0x00, 0x1F, 0xE1, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0xC3, 0xF8, 0x00, 0xCF, 0x3C, 0x00, 0x98, 0x0E, 0x01,
  0xB0, 0x06, 0x01, 0xB0, 0x03, 0x01, 0xE0, 0x03, 0x01, 0xC0, 0x03, 0x01,
  0xC0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x60, 0x38,
  0x00, 0x60, 0x68, 0x00, 0xC0, 0x6C, 0x01, 0x80, 0x4C, 0x03, 0x80, 0x47,
  0x0E, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x03,
  0xFC, 0x01, 0xE1, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x81, 0x00,
  0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x18, 0x00,
  0x1F, 0xC3, 0x00, 0x0F, 0x1C, 0x60, 0x03, 0x80, 0xC8, 0x00, 0xE0, 0x0B,
  0x00, 0x38, 0x01, 0xE0, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x07, 0x80, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x1C,
  0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x34, 0x00, 0x60,
  0x05, 0x80, 0x0C, 0x01, 0xB0, 0x01, 0xC0, 0x66, 0x00, 0x1C, 0x38, 0x80,
  0x01, 0xFE, 0x10, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x03,
  0xFC, 0x00, 0x71, 0xE0, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x03, 0x07,
  0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x82, 0x00, 0x30,
  0x60, 0x0E, 0x06, 0x03, 0xC0, 0x67, 0xF0, 0x07, 0xFC, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x40, 0x3C, 0x1C, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x38, 0x40, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x0C, 0x00, 0x3C, 0x71, 0x80,
  0x0E, 0x03, 0x20, 0x03, 0x80, 0x24, 0x00, 0xE0, 0x07, 0x80, 0x18, 0x00,
  0xF0, 0x06, 0x00, 0x1E, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x10, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0x1E, 0x00, 0xC0, 0x03,
  0x80, 0x18, 0x00, 0xD0, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x06, 0xC0, 0x07,
  0x01, 0x98, 0x00, 0x70, 0xE2, 0x00, 0x07, 0xF8, 0xC0, 0x00, 0x3C, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0xC7, 0xF8, 0x01, 0x9E, 0x38, 0x03,
  0x60, 0x30, 0x05, 0x80, 0x30, 0x1E, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x70,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x08, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x80, 0x60,
  0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x20, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x06,
  0x78, 0x00, 0x19, 0xB0, 0x00, 0x36, 0x60, 0x00, 0x68, 0x40, 0x00, 0xF0,
  0xC0, 0x01, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x40, 0x10, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x02, 0x00,
  0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x06, 0x00, 0x0C, 0x7F, 0x03, 0xFC, 0x00, 0xCE, 0x38, 0xF1, 0xE0, 0x09,
  0x80, 0xCC, 0x06, 0x01, 0xB0, 0x0D, 0x80, 0x30, 0x1E, 0x00, 0x70, 0x03,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x03, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x38, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0x04, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x60, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0x80, 0xC0, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x01, 0x81, 0x80, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x01, 0x81, 0x80, 0x06, 0x00, 0x10, 0x18, 0x00, 0x40, 0x03, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x08, 0x00, 0x60, 0x20, 0x01, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0x04, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x01, 0x8F, 0xF0, 0x02, 0x38, 0x70, 0x04, 0xC0, 0x60,
  0x1B, 0x00, 0x60, 0x3C, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x01,
  0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x08, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x1E, 0x38, 0x01, 0x80,
  0xE0, 0x18, 0x03, 0x01, 0x80, 0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x70, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x80, 0xE0, 0x38,
  0x03, 0x83, 0x80, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x03, 0x0F, 0xE0, 0x00, 0x67, 0x8E, 0x00, 0x09, 0xC0, 0xE0, 0x01,
  0x30, 0x0C, 0x00, 0x6C, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01, 0xC0, 0x03,
  0x00, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x38,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x04, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0E,
  0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x60, 0x07, 0x00, 0x0C,
  0x01, 0xA0, 0x03, 0x00, 0x36, 0x00, 0xC0, 0x06, 0xC0, 0x30, 0x00, 0xCE,
  0x1C, 0x00, 0x10, 0xFF, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0x78, 0xE3, 0x00, 0xE0, 0x32,
  0x01, 0x80, 0x32, 0x03, 0x00, 0x1E, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x1E,
  0x06, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x1C,
  0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80,
  0xC0, 0x02, 0x80, 0x60, 0x07, 0x80, 0x60, 0x0D, 0x80, 0x70, 0x19, 0x80,
  0x38, 0x71, 0x00, 0x1F, 0xE3, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x18, 0xFC, 0x02,
  0x38, 0x80, 0x4C, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x00, 0x3C, 0x3E, 0x03, 0x80, 0x20,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01, 0x00, 0x38, 0x0E,
  0x07, 0x80, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0xFF,
  0xC7, 0xFE, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x04, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x0C,
  0x00, 0x70, 0x30, 0x03, 0xC0, 0xC0, 0x0A, 0x03, 0x00, 0x68, 0x0C, 0x03,
  0x60, 0x1C, 0x39, 0x80, 0x3F, 0xC6, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x20, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x80, 0x30, 0x60, 0x0C,
  0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x16, 0x00, 0x1C,
  0x00, 0x6C, 0x00, 0x28, 0x00, 0xD8, 0x00, 0xD0, 0x03, 0x30, 0x01, 0xA0,
  0x06, 0x60, 0x06, 0x40, 0x08, 0xC0, 0x0C, 0x80, 0x31, 0x80, 0x11, 0x00,
  0x63, 0x00, 0x62, 0x00, 0x86, 0x00, 0xCC, 0x03, 0x0C, 0x03, 0x18, 0x06,
  0x18, 0x06, 0x30, 0x18, 0x30, 0x08, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x40,
  0xC0, 0x61, 0x81, 0x81, 0x81, 0x83, 0x03, 0x03, 0x03, 0x06, 0x0C, 0x06,
  0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x20, 0x18, 0x20, 0x30, 0xC0, 0x30,
  0xC0, 0x61, 0x80, 0x61, 0x80, 0xC6, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x8C,
  0x03, 0x10, 0x03, 0x10, 0x06, 0x60, 0x06, 0x60, 0x0C, 0xC0, 0x0C, 0xC0,
  0x19, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x36, 0x00, 0x68, 0x00, 0x68, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x04, 0x18, 0x00, 0x02, 0x18, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x04, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x10, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x70, 0x78, 0x03,
  0xC0, 0x1C, 0x07, 0x80, 0x07, 0xFC, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 50, 14, 1, -50 },
  { 83, 13, 18, 18, 7, -50 },
  { 113, 27, 50, 26, 0, -50 },
  { 282, 26, 57, 24, -1, -53 },
  { 468, 31, 52, 36, 3, -51 },
  { 670, 22, 52, 23, -1, -51 },
  { 813, 5, 18, 10, 7, -50 },
  { 825, 19, 61, 17, 2, -50 },
  { 970, 19, 61, 17, -5, -50 },
  { 1115, 18, 19, 22, 8, -53 },
  { 1158, 24, 32, 28, 2, -41 },
  { 1254, 9, 15, 11, -3, -6 },
  { 1271, 14, 2, 18, 2, -20 },
  { 1275, 3, 5, 11, 1, -5 },
  { 1277, 28, 50, 20, -3, -50 },
  { 1452, 23, 52, 24, 1, -51 },
  { 1602, 13, 50, 24, 7, -50 },
  { 1684, 26, 51, 24, -2, -51 },
  { 1850, 26, 52, 24, -2, -51 },
  { 2019, 25, 51, 24, -1, -51 },
  { 2179, 26, 51, 24, -2, -50 },
  { 2345, 23, 52, 24, 2, -51 },
  { 2495, 24, 50, 24, 3, -50 },
  { 2645, 26, 52, 24, -1, -51 },
  { 2814, 24, 52, 24, 0, -51 },
  { 2970, 10, 37, 11, 0, -37 },
  { 3017, 14, 46, 11, -3, -37 },
  { 3098, 24, 29, 28, 2, -39 },
  { 3185, 24, 17, 28, 2, -33 },
  { 3236, 24, 29, 28, 2, -39 },
  { 3323, 19, 51, 17, 1, -51 },
  { 3445, 32, 56, 36, 2, -50 },
  { 3669, 23, 50, 23, -5, -50 },
  { 3813, 26, 50, 26, 0, -50 },
  { 3976, 26, 52, 24, 3, -51 },
  { 4145, 27, 50, 29, 0, -50 },
  { 4314, 27, 50, 24, 0, -50 },
  { 4483, 27, 50, 22, 0, -50 },
  { 4652, 30, 52, 32, 3, -51 },
  { 4847, 32, 50, 31, 0, -50 },
  { 5047, 21, 50, 12, -4, -50 },
  { 5179, 23, 62, 11, -10, -50 },
  { 5358, 29, 50, 24, 0, -50 },
  { 5540, 15, 50, 21, 0, -50 },
  { 5634, 42, 50, 41, 0, -50 },
  { 5897, 33, 50, 32, 0, -50 },
  { 6104, 28, 52, 31, 2, -51 },
  { 6286, 26, 50, 25, 0, -50 },
  { 6449, 28, 63, 31, 2, -51 },
  { 6670, 25, 50, 25, 0, -50 },
  { 6827, 28, 52, 24, -2, -51 },
  { 7009, 21, 50, 21, 5, -50 },
  { 7141, 29, 51, 30, 2, -50 },
  { 7326, 24, 50, 24, 6, -50 },
  { 7476, 42, 50, 42, 5, -50 },
  { 7739, 30, 50, 21, -4, -50 },
  { 7927, 22, 50, 20, 4, -50 },
  { 8065, 28, 50, 21, -3, -50 },
  { 8240, 24, 61, 19, -1, -50 },
  { 8423, 9, 50, 22, 7, -50 },
  { 8480, 24, 61, 19, -4, -50 },
  { 8663, 25, 24, 27, 2, -50 },
  { 8738, 18, 2, 18, -5, 6 },
  { 8743, 7, 11, 14, 10, -53 },
  { 8753, 24, 39, 27, 2, -38 },
  { 8870, 24, 54, 26, 0, -53 },
  { 9032, 19, 39, 19, 2, -38 },
  { 9125, 27, 54, 27, 2, -53 },
  { 9308, 20, 39, 23, 2, -38 },
  { 9406, 30, 71, 13, -9, -54 },
  { 9673, 27, 55, 26, -1, -38 },
  { 9859, 23, 53, 25, 0, -53 },
  { 10012, 13, 50, 11, 0, -50 },
  { 10094, 23, 67, 11, -9, -50 },
  { 10287, 23, 53, 21, 0, -53 },
  { 10440, 14, 53, 10, 0, -53 },
  { 10533, 36, 38, 38, 0, -38 },
  { 10704, 23, 38, 25, 0, -38 },
  { 10814, 21, 39, 25, 2, -38 },
  { 10917, 27, 54, 26, -3, -38 },
  { 11100, 24, 54, 27, 2, -38 },
  { 11262, 19, 38, 16, 0, -38 },
  { 11353, 21, 39, 19, -1, -38 },
  { 11456, 13, 47, 13, 1, -46 },
  { 11533, 22, 38, 25, 2, -37 },
  { 11638, 18, 37, 19, 4, -37 },
  { 11722, 31, 37, 32, 4, -37 },
  { 11866, 25, 37, 20, -3, -37 },
  { 11982, 32, 54, 21, -8, -37 },
  { 12198, 20, 37, 16, -2, -37 },
  { 12291, 24, 61, 22, 2, -50 },
  { 12474, 2, 70, 24, 11, -53 },
  { 12492, 24, 61, 22, -5, -50 },
  { 12675, 24, 6, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC70PT7B_H_
