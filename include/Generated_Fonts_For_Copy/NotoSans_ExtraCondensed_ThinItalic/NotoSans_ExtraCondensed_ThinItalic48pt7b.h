#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x21, 0x90, 0x98, 0x48, 0x24, 0x12, 0x19, 0x09,
  0x84, 0x82, 0x41, 0x21, 0x10, 0x80, 0x00, 0x30, 0x40, 0x08, 0x30, 0x02,
  0x08, 0x01, 0x82, 0x00, 0x40, 0x80, 0x10, 0x40, 0x04, 0x10, 0x03, 0x04,
  0x00, 0x83, 0x00, 0x20, 0x80, 0xFF, 0xFC, 0x04, 0x18, 0x01, 0x04, 0x00,
  0xC1, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x06, 0x08, 0x01, 0x06, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x0C, 0x0F, 0xFF, 0xE0, 0x60, 0x80,
  0x10, 0x60, 0x04, 0x10, 0x03, 0x04, 0x00, 0x83, 0x00, 0x20, 0x80, 0x18,
  0x20, 0x04, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x1F, 0xF8, 0x18, 0x84,
  0x18, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04,
  0x00, 0x86, 0x00, 0x62, 0x00, 0x11, 0x00, 0x0C, 0x80, 0x02, 0x40, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x05, 0x80, 0x04, 0x40,
  0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x10, 0x40, 0x08, 0x60, 0x0C, 0x60, 0x84, 0x60, 0x3F, 0xC0, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x03, 0x80,
  0x10, 0x36, 0x01, 0x02, 0x10, 0x08, 0x30, 0x80, 0x81, 0x06, 0x04, 0x18,
  0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x60, 0x41, 0x02, 0x02, 0x10,
  0x10, 0x10, 0x80, 0x81, 0x88, 0x04, 0x0C, 0x40, 0x60, 0x44, 0x03, 0x02,
  0x23, 0xD8, 0x33, 0x32, 0xC1, 0x13, 0x0E, 0x09, 0x90, 0x70, 0x89, 0x82,
  0x8C, 0xC8, 0x16, 0xC4, 0xC0, 0x9C, 0x64, 0x04, 0x02, 0x20, 0x60, 0x31,
  0x03, 0x01, 0x18, 0x10, 0x18, 0xC0, 0x80, 0x84, 0x04, 0x0C, 0x20, 0x60,
  0x41, 0x02, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x02, 0x08, 0x10, 0x10,
  0xC1, 0x80, 0xC4, 0x08, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x6C, 0x00, 0xC6, 0x01, 0x86, 0x01, 0x86, 0x01, 0x06, 0x01, 0x06, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01,
  0x30, 0x01, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0C,
  0xC0, 0x08, 0x41, 0x10, 0x42, 0x30, 0x42, 0x20, 0x62, 0x60, 0x24, 0x40,
  0x24, 0x40, 0x2C, 0x40, 0x38, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0x40,
  0x38, 0x40, 0x48, 0x60, 0x88, 0x3F, 0x08, 0x25, 0xA4, 0x96, 0x92, 0x40,
  0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x00, 0x02, 0x00, 0x20, 0x02, 0x08, 0x40,
  0x64, 0x01, 0xDF, 0x06, 0x00, 0xA0, 0x32, 0x06, 0x10, 0x81, 0x00, 0x08,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F,
  0xFF, 0xF0, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x0C,
  0x20, 0x86, 0x10, 0xC2, 0x18, 0x42, 0x00, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x01, 0xF8,
  0x06, 0x18, 0x18, 0x10, 0x20, 0x20, 0x80, 0x43, 0x00, 0x84, 0x01, 0x08,
  0x02, 0x30, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00, 0x24, 0x00, 0x48, 0x01,
  0xB0, 0x03, 0x60, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x64, 0x00, 0xD8,
  0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0x44, 0x01,
  0x88, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x60, 0x60, 0x41, 0x80, 0xC6, 0x00,
  0xF8, 0x00, 0x03, 0x83, 0x83, 0x42, 0x66, 0x36, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0xE0, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7B, 0xC0, 0x30, 0x18,
  0x08, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x20, 0x38, 0x0F, 0xF8, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0A, 0x00,
  0x06, 0x80, 0x01, 0x60, 0x00, 0x90, 0x00, 0x64, 0x00, 0x11, 0x00, 0x0C,
  0x40, 0x02, 0x30, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x60,
  0x04, 0x10, 0x02, 0x04, 0x01, 0x81, 0x00, 0x40, 0x40, 0x30, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x03, 0x00, 0x80, 0x80, 0x60, 0x60, 0x18, 0x30, 0x04,
  0x4F, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x80, 0xC0, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7B, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x21, 0xE0, 0x26, 0x70, 0x68, 0x18,
  0x50, 0x08, 0x60, 0x08, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10,
  0x80, 0x10, 0xC0, 0x30, 0xC0, 0x20, 0x40, 0x40, 0x60, 0xC0, 0x3F, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x3D,
  0xC0, 0x18, 0x18, 0x0C, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x10, 0x60, 0x04,
  0x18, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x30, 0x60, 0x08, 0x08, 0x06, 0x02,
  0x01, 0x00, 0xC0, 0x80, 0x10, 0x40, 0x02, 0x60, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x33, 0x00, 0x30, 0x40, 0x18, 0x08, 0x04, 0x03, 0x02, 0x00, 0x41,
  0x80, 0x10, 0x40, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x04, 0x00, 0x41, 0x00, 0x30, 0x60, 0x18, 0x0C, 0x0C,
  0x01, 0xFE, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x03, 0x06, 0x02, 0x02, 0x04,
  0x03, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x03, 0x10, 0x03, 0x10,
  0x06, 0x10, 0x06, 0x18, 0x0A, 0x08, 0x12, 0x07, 0xE6, 0x03, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0xFE,
  0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC0, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x80, 0xF7, 0x04, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x60, 0x60, 0x01, 0x00, 0x20, 0x04, 0x00, 0x60, 0x10,
  0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x10, 0x06, 0x0C, 0x60, 0x7E, 0x18, 0x81, 0x8C, 0x31, 0x06, 0x10,
  0x46, 0x08, 0x20, 0x88, 0x30, 0x41, 0x10, 0x41, 0x82, 0x61, 0x82, 0x04,
  0xC2, 0x04, 0x19, 0x04, 0x08, 0x22, 0x08, 0x30, 0x44, 0x30, 0x40, 0x88,
  0x60, 0x83, 0x30, 0x83, 0x04, 0x61, 0x06, 0x08, 0xC3, 0x0C, 0x21, 0x86,
  0x28, 0x43, 0x0C, 0xD1, 0x06, 0x0F, 0x3C, 0x0C, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x81, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00, 0xA0, 0x03,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10,
  0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0xC1, 0x01, 0x02, 0x06, 0x04, 0x08,
  0x08, 0x1F, 0xF0, 0x60, 0x20, 0x80, 0x43, 0x00, 0x84, 0x01, 0x08, 0x02,
  0x30, 0x04, 0x40, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00, 0x58, 0x00, 0xA0,
  0x01, 0xC0, 0x03, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x40, 0xE0, 0x10, 0x08,
  0x04, 0x03, 0x03, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02,
  0x00, 0x41, 0x80, 0x30, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01, 0x03, 0x00,
  0xC0, 0xC0, 0x60, 0x3F, 0xE0, 0x0F, 0xF0, 0x02, 0x03, 0x01, 0x80, 0x60,
  0x60, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x20,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x10, 0x03,
  0x04, 0x01, 0x81, 0x00, 0xC0, 0xC0, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x70, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x20, 0x60, 0x04, 0x06,
  0x00, 0x80, 0x60, 0x30, 0x04, 0x04, 0x00, 0x80, 0x80, 0x18, 0x10, 0x03,
  0x02, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x30, 0x40, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x60, 0x03, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x61,
  0x80, 0x08, 0x20, 0x03, 0x04, 0x00, 0x40, 0x80, 0x18, 0x10, 0x02, 0x06,
  0x00, 0xC0, 0x80, 0x30, 0x10, 0x0C, 0x02, 0x03, 0x00, 0xC3, 0xC0, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xE7, 0x80, 0x30, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x07, 0xF1, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x06,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00,
  0x06, 0x08, 0x00, 0x20, 0x60, 0x01, 0x01, 0x00, 0x08, 0x0C, 0x00, 0xC0,
  0x20, 0x06, 0x01, 0xC0, 0x20, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x0C, 0x04,
  0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00,
  0x60, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0xC0,
  0x40, 0x03, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0,
  0x06, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x20, 0x01, 0x01, 0x80, 0x04,
  0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x0C,
  0x00, 0x60, 0x20, 0x01, 0x80, 0x80, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00,
  0x40, 0x60, 0x03, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80,
  0xC0, 0x02, 0x02, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x30, 0x10, 0x06, 0x01,
  0x00, 0xC0, 0x10, 0x08, 0x03, 0x01, 0x80, 0x20, 0x30, 0x02, 0x02, 0x00,
  0x20, 0x40, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x10, 0x00, 0x42, 0x00,
  0x04, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0x80, 0x00, 0x98, 0x00, 0x0A, 0x80,
  0x00, 0xEC, 0x00, 0x1C, 0x40, 0x01, 0x84, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x60, 0x03, 0x02, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x30, 0x06, 0x01, 0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x04,
  0x01, 0x80, 0xC0, 0x08, 0x08, 0x00, 0x80, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x1F, 0xFC, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xA0, 0x38, 0x00, 0x05,
  0x01, 0x60, 0x00, 0x58, 0x0B, 0x00, 0x02, 0x80, 0x58, 0x00, 0x24, 0x02,
  0xC0, 0x01, 0x20, 0x32, 0x00, 0x1B, 0x01, 0x10, 0x00, 0x98, 0x08, 0x80,
  0x0C, 0x80, 0x44, 0x00, 0x44, 0x06, 0x20, 0x06, 0x20, 0x31, 0x00, 0x23,
  0x01, 0x08, 0x03, 0x18, 0x08, 0x40, 0x10, 0x80, 0x42, 0x01, 0x84, 0x06,
  0x10, 0x08, 0x20, 0x20, 0x80, 0xC3, 0x01, 0x04, 0x04, 0x10, 0x08, 0x20,
  0x60, 0x80, 0x41, 0x02, 0x04, 0x06, 0x0C, 0x30, 0x20, 0x20, 0x61, 0x03,
  0x01, 0x03, 0x18, 0x10, 0x08, 0x18, 0x80, 0x80, 0xC0, 0xC4, 0x04, 0x06,
  0x02, 0x40, 0x60, 0x20, 0x12, 0x03, 0x01, 0x00, 0xA0, 0x10, 0x08, 0x05,
  0x00, 0x80, 0xC0, 0x38, 0x04, 0x04, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x10, 0x0E, 0x00, 0x20, 0x34, 0x00,
  0xC0, 0x48, 0x01, 0x80, 0x90, 0x02, 0x01, 0x20, 0x04, 0x02, 0x60, 0x08,
  0x0C, 0x40, 0x30, 0x10, 0x80, 0x60, 0x21, 0x00, 0x80, 0x42, 0x01, 0x01,
  0x86, 0x02, 0x03, 0x0C, 0x0C, 0x04, 0x08, 0x10, 0x08, 0x10, 0x20, 0x10,
  0x20, 0x40, 0x60, 0x41, 0x80, 0x80, 0xC3, 0x01, 0x00, 0x84, 0x02, 0x01,
  0x08, 0x04, 0x02, 0x10, 0x18, 0x04, 0x60, 0x20, 0x0C, 0xC0, 0x40, 0x19,
  0x00, 0x80, 0x12, 0x03, 0x00, 0x24, 0x06, 0x00, 0x58, 0x08, 0x00, 0xA0,
  0x10, 0x01, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x3D, 0xC0, 0x18, 0x18, 0x0C, 0x02, 0x06, 0x00, 0xC1,
  0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0x58, 0x00, 0x16, 0x00, 0x05, 0x00, 0x01,
  0x40, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x68, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0x83, 0x00, 0x40,
  0x40, 0x30, 0x18, 0x18, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x40, 0xC0,
  0x10, 0x18, 0x04, 0x02, 0x03, 0x00, 0x80, 0x80, 0x20, 0x20, 0x0C, 0x08,
  0x03, 0x02, 0x00, 0x81, 0x80, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x01,
  0x83, 0x00, 0x40, 0xC0, 0x30, 0x20, 0x18, 0x08, 0x0C, 0x02, 0x0E, 0x01,
  0xFE, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x3D, 0xC0, 0x18, 0x18, 0x0C, 0x02, 0x06, 0x00, 0xC1,
  0x00, 0x10, 0xC0, 0x04, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13, 0x00,
  0x04, 0x80, 0x01, 0x20, 0x00, 0x58, 0x00, 0x16, 0x00, 0x05, 0x00, 0x01,
  0x40, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x68, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0x83, 0x00, 0x40,
  0x40, 0x30, 0x18, 0x18, 0x03, 0xF8, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0xFC, 0x00, 0x83, 0x80, 0x40, 0x40, 0x20, 0x10, 0x30, 0x08,
  0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x30, 0x40, 0x10, 0x60, 0x08, 0x30, 0x08, 0x10, 0x0C, 0x08,
  0x0C, 0x07, 0xFC, 0x07, 0xF0, 0x02, 0x08, 0x01, 0x04, 0x00, 0x83, 0x00,
  0x41, 0x80, 0x60, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x06,
  0x06, 0x03, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0xC0, 0x10, 0x60,
  0x0C, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x06, 0x01, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x10, 0x0C, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x02, 0x00, 0x10, 0x20, 0x01, 0x02,
  0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x20,
  0x40, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x0C,
  0x18, 0x00, 0x81, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01,
  0x83, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x03, 0x02, 0x00,
  0x30, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x60, 0x40,
  0x04, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x04, 0x00, 0x80, 0x40, 0x18, 0x06,
  0x01, 0x00, 0x30, 0x20, 0x01, 0xFC, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80, 0x20, 0x80, 0x40, 0x80,
  0x40, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x80, 0x81, 0x00, 0x81, 0x00, 0x82,
  0x00, 0x82, 0x00, 0x86, 0x00, 0x84, 0x00, 0x8C, 0x00, 0x88, 0x00, 0x88,
  0x00, 0x90, 0x00, 0x90, 0x00, 0xB0, 0x00, 0xA0, 0x00, 0xA0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x02, 0x80, 0x0E,
  0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x0A, 0x00, 0x48, 0x01, 0xE0, 0x0C,
  0x80, 0x16, 0x00, 0x88, 0x03, 0x60, 0x08, 0x80, 0x26, 0x01, 0x88, 0x02,
  0x60, 0x10, 0x80, 0x64, 0x03, 0x08, 0x04, 0x40, 0x20, 0x80, 0x44, 0x02,
  0x08, 0x08, 0x40, 0x60, 0x80, 0x84, 0x04, 0x08, 0x18, 0x40, 0xC0, 0x81,
  0x04, 0x08, 0x08, 0x10, 0x40, 0x80, 0x82, 0x04, 0x18, 0x08, 0x20, 0x41,
  0x00, 0x86, 0x04, 0x30, 0x08, 0x40, 0x42, 0x00, 0x84, 0x04, 0x20, 0x08,
  0x80, 0x46, 0x00, 0x88, 0x04, 0x40, 0x09, 0x80, 0x4C, 0x00, 0x90, 0x04,
  0x80, 0x09, 0x00, 0x48, 0x00, 0xB0, 0x05, 0x80, 0x0A, 0x00, 0x50, 0x00,
  0xE0, 0x05, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x08, 0x00, 0x80,
  0x40, 0x04, 0x04, 0x00, 0x30, 0x60, 0x01, 0x82, 0x00, 0x04, 0x30, 0x00,
  0x21, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00, 0xC8, 0x00,
  0x04, 0x60, 0x00, 0x63, 0x00, 0x02, 0x08, 0x00, 0x20, 0x40, 0x03, 0x02,
  0x00, 0x10, 0x10, 0x01, 0x80, 0x80, 0x08, 0x04, 0x00, 0xC0, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x60, 0x00, 0x40, 0x06, 0x80, 0x09,
  0x00, 0x23, 0x00, 0x46, 0x01, 0x0C, 0x02, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x41, 0x80, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x60, 0x08, 0x80,
  0x1B, 0x00, 0x34, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x82, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x41, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x30, 0x41, 0x04, 0x10, 0x41, 0x86, 0x08, 0x20, 0x82,
  0x08, 0x30, 0xC1, 0x04, 0x10, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x26, 0x00, 0x31, 0x00, 0x10, 0x80,
  0x18, 0x20, 0x08, 0x10, 0x0C, 0x0C, 0x04, 0x02, 0x06, 0x01, 0x82, 0x00,
  0x43, 0x00, 0x31, 0x00, 0x09, 0x80, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x8C, 0x44, 0x22, 0x11, 0x00, 0x70, 0x00, 0xEC, 0x40, 0xC1, 0x40,
  0xC0, 0xA0, 0xC0, 0x30, 0x40, 0x18, 0x60, 0x0C, 0x20, 0x04, 0x30, 0x02,
  0x10, 0x03, 0x08, 0x01, 0x8C, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00,
  0x30, 0x80, 0x18, 0x40, 0x08, 0x60, 0x04, 0x30, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x82, 0x01, 0x81, 0x01, 0xC0, 0x80, 0xA0, 0x20, 0x90, 0x1F, 0x98,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x8E,
  0x00, 0xCF, 0xC0, 0x48, 0x30, 0x28, 0x08, 0x18, 0x04, 0x0C, 0x02, 0x0C,
  0x01, 0x86, 0x00, 0xC2, 0x00, 0x61, 0x00, 0x30, 0x80, 0x10, 0xC0, 0x08,
  0x40, 0x04, 0x20, 0x02, 0x10, 0x03, 0x18, 0x01, 0x0C, 0x00, 0x84, 0x00,
  0x42, 0x00, 0x61, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x10, 0x70, 0x18, 0x28,
  0x18, 0x16, 0x18, 0x11, 0xF8, 0x00, 0x00, 0x70, 0x0E, 0xC0, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x01, 0xC6, 0x00, 0xEC, 0xC0, 0x30, 0x50, 0x0C, 0x0A, 0x03, 0x00,
  0xC0, 0x40, 0x18, 0x18, 0x03, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x03,
  0x02, 0x00, 0x60, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x01, 0x81, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x0E, 0x02, 0x01, 0x80, 0x40, 0x70, 0x08, 0x0A, 0x00, 0x82, 0x40,
  0x1F, 0x98, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x20, 0xC1, 0x03, 0x08, 0x04,
  0x60, 0x31, 0x00, 0xCC, 0x02, 0x20, 0x18, 0x80, 0x46, 0x03, 0x10, 0x38,
  0x47, 0x81, 0xF0, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x40, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x11, 0x00, 0x07, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0E, 0xC4, 0x03, 0x05, 0x00, 0xC0, 0xA0, 0x30, 0x0C, 0x04, 0x01,
  0x81, 0x80, 0x30, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x30, 0x20, 0x06,
  0x0C, 0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0xC0, 0x80, 0x18,
  0x10, 0x02, 0x06, 0x00, 0x40, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0xE0,
  0x20, 0x18, 0x04, 0x07, 0x00, 0x80, 0xA0, 0x08, 0x2C, 0x01, 0xF9, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x40, 0x60, 0x0F,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x38, 0x02, 0xEE, 0x05, 0x82, 0x05, 0x03, 0x06, 0x03, 0x06,
  0x03, 0x0C, 0x03, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06, 0x18,
  0x06, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x30, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x08, 0x60, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x30, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x03, 0x06,
  0x06, 0x04, 0x0C, 0x04, 0x08, 0x04, 0x10, 0x0C, 0x30, 0x08, 0x60, 0x08,
  0x40, 0x08, 0x80, 0x09, 0x80, 0x1B, 0x80, 0x12, 0x80, 0x14, 0x80, 0x18,
  0x80, 0x38, 0x80, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0x40, 0x20, 0x40, 0x60,
  0x40, 0x40, 0x40, 0x40, 0x60, 0x40, 0x60, 0x40, 0x20, 0xC0, 0x20, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x03, 0x7E, 0x3B, 0x81, 0x40,
  0xB0, 0x40, 0xE0, 0x70, 0x30, 0x60, 0x30, 0x18, 0x20, 0x18, 0x0C, 0x30,
  0x08, 0x04, 0x18, 0x04, 0x02, 0x08, 0x06, 0x01, 0x04, 0x03, 0x00, 0x82,
  0x01, 0x00, 0xC3, 0x00, 0x80, 0x41, 0x00, 0x40, 0x20, 0x80, 0x60, 0x10,
  0x40, 0x20, 0x08, 0x60, 0x10, 0x0C, 0x30, 0x08, 0x04, 0x10, 0x04, 0x02,
  0x08, 0x06, 0x01, 0x04, 0x02, 0x01, 0x86, 0x01, 0x00, 0xC3, 0x00, 0x80,
  0x41, 0x00, 0xC0, 0x20, 0x80, 0x40, 0x10, 0x40, 0x20, 0x18, 0x60, 0x10,
  0x08, 0x00, 0x00, 0x38, 0x06, 0xEE, 0x05, 0x82, 0x05, 0x03, 0x06, 0x03,
  0x06, 0x03, 0x0C, 0x02, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06,
  0x18, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x30, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x20, 0x18, 0x60, 0x18, 0x60, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x30, 0xC0, 0x20, 0x00, 0xF0, 0x07, 0xF0, 0x18, 0x30,
  0x20, 0x20, 0xC0, 0x63, 0x00, 0xC4, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40,
  0x0C, 0x80, 0x1B, 0x00, 0x34, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02,
  0xC0, 0x0D, 0x80, 0x13, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x18, 0x06, 0x10,
  0x08, 0x20, 0x20, 0x60, 0xC0, 0x7E, 0x00, 0x00, 0x0E, 0x00, 0x33, 0xF0,
  0x04, 0x83, 0x00, 0xA0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0xC0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x03, 0x00, 0x20,
  0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20, 0x06, 0x0C, 0x00, 0x81,
  0x80, 0x10, 0x20, 0x06, 0x04, 0x00, 0x81, 0x80, 0x30, 0x30, 0x04, 0x06,
  0x01, 0x80, 0xA0, 0x60, 0x16, 0x18, 0x06, 0x7E, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xFC, 0x40, 0x81, 0x40, 0x80, 0xA0, 0xC0, 0x30, 0x40, 0x18,
  0x60, 0x0C, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x01, 0x8C, 0x00,
  0x86, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x40, 0x08, 0x60,
  0x04, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x82, 0x01, 0x81, 0x01, 0xC0,
  0x80, 0xA0, 0x60, 0xB0, 0x1F, 0x98, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x38, 0x37, 0x41, 0x60, 0x0A,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0xFC, 0x18, 0x10, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x80, 0xC1,
  0xFE, 0x00, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x64, 0xFC, 0x10, 0x08,
  0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03,
  0xC0, 0x0C, 0x03, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06, 0x18,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x30, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x18, 0x60, 0x18, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x30, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xA0, 0x41,
  0xA0, 0x7E, 0x40, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80, 0x48, 0x04,
  0x80, 0x88, 0x08, 0x81, 0x88, 0x10, 0x83, 0x08, 0x20, 0x86, 0x08, 0x40,
  0x84, 0x08, 0x80, 0x88, 0x09, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0A, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xE0, 0x1C,
  0x05, 0x00, 0xE0, 0x28, 0x0F, 0x02, 0x40, 0x58, 0x12, 0x02, 0x81, 0x90,
  0x24, 0x08, 0x81, 0x20, 0x44, 0x19, 0x04, 0x20, 0x88, 0x21, 0x0C, 0x43,
  0x08, 0x42, 0x10, 0x42, 0x10, 0x82, 0x20, 0x88, 0x11, 0x04, 0x40, 0x98,
  0x26, 0x04, 0x81, 0x20, 0x24, 0x09, 0x01, 0x40, 0x50, 0x0A, 0x02, 0x80,
  0x70, 0x14, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x00, 0x02,
  0x01, 0x81, 0x00, 0x80, 0xC0, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x08, 0x60,
  0x04, 0x20, 0x03, 0x20, 0x00, 0x90, 0x00, 0x50, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x06, 0x40, 0x02,
  0x30, 0x02, 0x08, 0x03, 0x04, 0x01, 0x02, 0x01, 0x01, 0x01, 0x80, 0xC0,
  0x80, 0x20, 0xC0, 0x10, 0x00, 0x00, 0x20, 0x06, 0x00, 0x40, 0x18, 0x00,
  0x80, 0x20, 0x01, 0x00, 0x40, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08,
  0x0C, 0x00, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0x40, 0x80, 0x00, 0x83,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40,
  0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x90, 0x00,
  0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x1E,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0xF8, 0x00, 0x80, 0x00, 0x1E, 0x00, 0xB1, 0xC0, 0x70, 0x38, 0xD0, 0x07,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 9, 12, 12, 5, -34 },
  { 54, 18, 34, 18, 0, -34 },
  { 131, 17, 39, 16, 0, -36 },
  { 214, 21, 36, 25, 2, -35 },
  { 309, 16, 35, 16, -1, -35 },
  { 379, 3, 12, 7, 5, -34 },
  { 384, 13, 42, 12, 1, -34 },
  { 453, 13, 42, 12, -3, -34 },
  { 522, 12, 12, 15, 6, -36 },
  { 540, 17, 22, 19, 1, -28 },
  { 587, 6, 10, 7, -2, -4 },
  { 595, 10, 2, 13, 1, -14 },
  { 598, 2, 3, 7, 1, -3 },
  { 599, 19, 34, 14, -2, -34 },
  { 680, 15, 35, 16, 1, -35 },
  { 746, 9, 34, 16, 5, -34 },
  { 785, 19, 35, 16, -2, -35 },
  { 869, 18, 36, 16, -1, -35 },
  { 950, 18, 35, 16, -1, -35 },
  { 1029, 18, 34, 16, -1, -34 },
  { 1106, 16, 35, 16, 1, -35 },
  { 1176, 16, 34, 16, 2, -34 },
  { 1244, 18, 35, 16, -1, -35 },
  { 1323, 16, 35, 16, 0, -35 },
  { 1393, 7, 25, 7, 0, -25 },
  { 1415, 9, 31, 7, -2, -25 },
  { 1450, 17, 20, 19, 1, -27 },
  { 1493, 17, 12, 19, 1, -23 },
  { 1519, 17, 20, 19, 1, -27 },
  { 1562, 13, 35, 12, 1, -35 },
  { 1619, 23, 38, 24, 1, -34 },
  { 1729, 15, 34, 16, -3, -34 },
  { 1793, 18, 34, 18, 0, -34 },
  { 1870, 18, 35, 16, 2, -35 },
  { 1949, 19, 34, 20, 0, -34 },
  { 2030, 18, 34, 16, 0, -34 },
  { 2107, 18, 34, 15, 0, -34 },
  { 2184, 21, 35, 22, 2, -35 },
  { 2276, 22, 34, 21, 0, -34 },
  { 2370, 14, 34, 8, -3, -34 },
  { 2430, 16, 42, 7, -7, -34 },
  { 2514, 20, 34, 17, 0, -34 },
  { 2599, 11, 34, 15, 0, -34 },
  { 2646, 29, 34, 28, 0, -34 },
  { 2770, 23, 34, 22, 0, -34 },
  { 2868, 18, 35, 21, 2, -35 },
  { 2947, 18, 34, 17, 0, -34 },
  { 3024, 18, 43, 21, 2, -35 },
  { 3121, 17, 34, 17, 0, -34 },
  { 3194, 19, 35, 16, -1, -35 },
  { 3278, 15, 34, 14, 3, -34 },
  { 3342, 20, 34, 20, 1, -34 },
  { 3427, 16, 34, 17, 4, -34 },
  { 3495, 28, 34, 29, 4, -34 },
  { 3614, 21, 34, 15, -3, -34 },
  { 3704, 15, 34, 14, 3, -34 },
  { 3768, 19, 34, 15, -2, -34 },
  { 3849, 17, 42, 13, -1, -34 },
  { 3939, 6, 34, 15, 5, -34 },
  { 3965, 17, 42, 13, -3, -34 },
  { 4055, 17, 16, 19, 1, -34 },
  { 4089, 13, 2, 13, -4, 4 },
  { 4093, 4, 8, 10, 7, -37 },
  { 4097, 17, 26, 18, 1, -26 },
  { 4153, 17, 36, 18, 0, -36 },
  { 4230, 13, 26, 13, 1, -26 },
  { 4273, 19, 36, 18, 1, -36 },
  { 4359, 14, 26, 16, 1, -26 },
  { 4405, 21, 49, 9, -6, -37 },
  { 4534, 19, 38, 18, -1, -26 },
  { 4625, 16, 36, 17, 0, -36 },
  { 4697, 9, 34, 7, 0, -34 },
  { 4736, 15, 46, 8, -6, -34 },
  { 4823, 16, 36, 14, 0, -36 },
  { 4895, 9, 36, 7, 0, -36 },
  { 4936, 25, 26, 26, 0, -26 },
  { 5018, 16, 26, 17, 0, -26 },
  { 5070, 15, 26, 17, 1, -26 },
  { 5119, 19, 37, 18, -2, -26 },
  { 5207, 17, 37, 18, 1, -26 },
  { 5286, 13, 26, 11, 0, -26 },
  { 5329, 15, 26, 13, -1, -26 },
  { 5378, 9, 31, 9, 1, -31 },
  { 5413, 16, 25, 17, 1, -25 },
  { 5463, 12, 25, 13, 3, -25 },
  { 5501, 21, 25, 22, 3, -25 },
  { 5567, 17, 25, 14, -2, -25 },
  { 5621, 23, 37, 14, -6, -25 },
  { 5728, 15, 25, 11, -2, -25 },
  { 5775, 16, 42, 15, 2, -34 },
  { 5859, 2, 49, 16, 7, -37 },
  { 5872, 16, 42, 15, -3, -34 },
  { 5956, 17, 4, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC48PT7B_H_
