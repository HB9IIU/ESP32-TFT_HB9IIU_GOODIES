#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0xC0, 0x40, 0x00, 0x10, 0xC4, 0x23, 0x08, 0x82, 0x21, 0x88, 0x42,
  0x11, 0x84, 0x41, 0x10, 0x84, 0x21, 0x08, 0x82, 0x00, 0x00, 0x30, 0x40,
  0x08, 0x30, 0x02, 0x08, 0x01, 0x82, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04,
  0x10, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x81, 0xFF, 0xFC, 0x04, 0x10,
  0x01, 0x04, 0x00, 0xC1, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x06, 0x08, 0x01,
  0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x08, 0x30, 0x02, 0x08, 0x0F, 0xFF,
  0xE0, 0x60, 0x80, 0x10, 0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0x83, 0x00,
  0x20, 0x80, 0x18, 0x20, 0x04, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x07,
  0xC0, 0x0E, 0x9C, 0x08, 0x42, 0x08, 0x60, 0x0C, 0x20, 0x04, 0x10, 0x02,
  0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x42, 0x00, 0x31, 0x00, 0x08, 0x80,
  0x06, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0D,
  0x00, 0x04, 0x40, 0x02, 0x30, 0x01, 0x08, 0x00, 0x84, 0x00, 0xC2, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x08, 0x60, 0x84, 0x60,
  0x3F, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x03, 0x80, 0x20, 0x66, 0x01, 0x02, 0x10, 0x10, 0x20, 0x80, 0x81,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x0C, 0x08, 0x20, 0x60, 0x42,
  0x02, 0x06, 0x10, 0x10, 0x31, 0x00, 0x81, 0x08, 0x0C, 0x08, 0x80, 0x60,
  0x44, 0x03, 0x06, 0x47, 0xD0, 0x22, 0x62, 0x81, 0x22, 0x16, 0x11, 0x20,
  0xF1, 0x91, 0x06, 0x98, 0x98, 0x33, 0x88, 0x81, 0x00, 0x44, 0x08, 0x04,
  0x60, 0x40, 0x22, 0x02, 0x02, 0x10, 0x30, 0x10, 0x81, 0x81, 0x04, 0x08,
  0x08, 0x20, 0x40, 0xC1, 0x06, 0x04, 0x18, 0x20, 0x60, 0x41, 0x02, 0x02,
  0x10, 0x30, 0x11, 0x83, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x38, 0x01,
  0x98, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x01, 0x82,
  0x03, 0x0C, 0x06, 0x10, 0x0C, 0x20, 0x08, 0x80, 0x13, 0x00, 0x24, 0x00,
  0x50, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x12, 0x00, 0x46, 0x01, 0x84,
  0x26, 0x08, 0x48, 0x11, 0xB0, 0x32, 0x40, 0x24, 0x80, 0x51, 0x00, 0xA6,
  0x01, 0xCC, 0x01, 0x18, 0x06, 0x10, 0x1C, 0x20, 0x2C, 0x60, 0x88, 0x7E,
  0x10, 0x11, 0x32, 0x22, 0x26, 0x44, 0x44, 0x80, 0x00, 0x18, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x02, 0x00, 0x40, 0x10, 0x42, 0x0C, 0x40, 0x68, 0x43, 0xF0, 0x60,
  0x12, 0x04, 0x43, 0x04, 0x40, 0x80, 0x08, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x0C, 0x20, 0x86, 0x10, 0xC2, 0x18, 0x42, 0x00, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x03, 0x18, 0x04,
  0x10, 0x10, 0x30, 0x60, 0x20, 0x80, 0x42, 0x00, 0x84, 0x01, 0x18, 0x02,
  0x20, 0x04, 0x40, 0x09, 0x80, 0x32, 0x00, 0x64, 0x00, 0x88, 0x01, 0x30,
  0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x32, 0x00, 0x4C, 0x00, 0x98, 0x01,
  0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x62, 0x00, 0x84, 0x01, 0x08,
  0x06, 0x10, 0x08, 0x20, 0x20, 0x20, 0xC0, 0x43, 0x00, 0x7C, 0x00, 0x01,
  0x03, 0x0D, 0x1B, 0x32, 0xC2, 0x42, 0x02, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x00, 0x7E, 0x00,
  0x70, 0xC0, 0x08, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0xC1, 0x80, 0xC0, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x80, 0xC0,
  0x7F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xA0,
  0x00, 0xF0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x64, 0x00, 0x22, 0x00, 0x33,
  0x00, 0x11, 0x00, 0x10, 0x80, 0x18, 0x40, 0x08, 0x60, 0x0C, 0x20, 0x04,
  0x10, 0x04, 0x08, 0x06, 0x04, 0x02, 0x06, 0x03, 0x02, 0x01, 0x01, 0x01,
  0x00, 0x81, 0x80, 0x40, 0x80, 0x60, 0xC0, 0x20, 0x40, 0x10, 0x7F, 0xFF,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x2F, 0x00, 0x18, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x80, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0xE1, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x27,
  0xE0, 0x6C, 0x10, 0x50, 0x18, 0x60, 0x08, 0x60, 0x08, 0x40, 0x08, 0xC0,
  0x08, 0xC0, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80,
  0x18, 0x80, 0x10, 0x80, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0x40, 0x40, 0x60,
  0x80, 0x3F, 0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x30, 0xC0, 0x10, 0x18, 0x0C, 0x02, 0x02, 0x00, 0x81, 0x80,
  0x30, 0x40, 0x0C, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0x60, 0x18,
  0x08, 0x04, 0x02, 0x02, 0x00, 0x41, 0x80, 0x18, 0xC0, 0x02, 0xC0, 0x00,
  0xC0, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x20, 0x60, 0x10, 0x08, 0x08, 0x03,
  0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x0C, 0x00, 0x43,
  0x00, 0x10, 0xC0, 0x04, 0x10, 0x01, 0x04, 0x00, 0x81, 0x80, 0x60, 0x30,
  0x30, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0x8C, 0x03, 0x06, 0x06, 0x02,
  0x04, 0x03, 0x0C, 0x03, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01,
  0x10, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x02, 0x10, 0x06,
  0x10, 0x06, 0x10, 0x0A, 0x18, 0x16, 0x0E, 0x74, 0x03, 0xC4, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0xFC, 0x00,
  0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC0, 0x00, 0x80,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x80, 0x00, 0x07,
  0xC1, 0x86, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFB, 0x80, 0x06, 0x03, 0x00, 0x30,
  0x06, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x30, 0x20, 0x00, 0x41, 0x00, 0x01,
  0x0C, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0xF8, 0x44, 0x0C, 0x41, 0x10,
  0x21, 0x04, 0xC1, 0x04, 0x12, 0x0C, 0x30, 0x48, 0x20, 0x83, 0x21, 0x82,
  0x0D, 0x84, 0x08, 0x24, 0x10, 0x60, 0x90, 0x41, 0x02, 0x43, 0x04, 0x19,
  0x08, 0x10, 0x4C, 0x20, 0xC1, 0x30, 0x83, 0x0C, 0xC2, 0x18, 0x23, 0x08,
  0x61, 0x88, 0x33, 0x44, 0x20, 0x79, 0xE0, 0x80, 0x83, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x04, 0x20,
  0x10, 0x40, 0x20, 0x80, 0xC1, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x1F,
  0xF0, 0x7F, 0xE0, 0x80, 0x43, 0x00, 0x84, 0x01, 0x08, 0x02, 0x30, 0x04,
  0x40, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0,
  0x03, 0x00, 0x04, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x10, 0x18, 0x04, 0x02,
  0x03, 0x00, 0xC0, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x00, 0xC1,
  0x80, 0x20, 0x40, 0x08, 0x10, 0x06, 0x04, 0x01, 0x03, 0x00, 0xC0, 0xC0,
  0x60, 0x20, 0xE0, 0x0F, 0xE0, 0x02, 0x06, 0x01, 0x80, 0xC0, 0x40, 0x18,
  0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x60, 0x04, 0x10, 0x02, 0x04, 0x01,
  0x81, 0x00, 0xC0, 0xC0, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x18,
  0x30, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x10, 0x30, 0x04, 0x06, 0x03, 0x00,
  0xC0, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10,
  0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x31, 0x80, 0x08, 0x40, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x04, 0x20, 0x03, 0x08, 0x00, 0x82,
  0x00, 0x60, 0x80, 0x10, 0x60, 0x0C, 0x10, 0x06, 0x04, 0x03, 0x01, 0x01,
  0x80, 0xC3, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x07, 0x01, 0x80, 0x10,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x01,
  0xF8, 0x80, 0x1F, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08,
  0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0x40, 0x04, 0x02, 0x00, 0x40,
  0x38, 0x04, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40,
  0x02, 0x02, 0x00, 0x30, 0x30, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40,
  0x40, 0x02, 0x02, 0x00, 0x30, 0x30, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00,
  0x40, 0x40, 0x02, 0x06, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x08, 0x0F,
  0xFF, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x40, 0x06, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00,
  0x08, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01,
  0x00, 0x08, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x20, 0x00, 0x01,
  0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x03, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x8C, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x30, 0x10, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x03, 0x01, 0x80, 0x20, 0x30, 0x02, 0x02, 0x00,
  0x20, 0x40, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x10, 0x00, 0x42, 0x00,
  0x04, 0x60, 0x00, 0xC4, 0x00, 0x08, 0x80, 0x00, 0x98, 0x00, 0x0B, 0x80,
  0x00, 0xA8, 0x00, 0x1C, 0x80, 0x01, 0x8C, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x03, 0x06, 0x00, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20,
  0x20, 0x06, 0x03, 0x00, 0x60, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x80, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x3F, 0xF0, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x28, 0x00, 0x0A, 0x02,
  0x80, 0x01, 0xA0, 0x28, 0x00, 0x16, 0x02, 0x80, 0x03, 0x60, 0x6C, 0x00,
  0x24, 0x04, 0xC0, 0x06, 0x40, 0x4C, 0x00, 0x44, 0x04, 0xC0, 0x0C, 0xC0,
  0xC4, 0x00, 0x88, 0x08, 0x40, 0x08, 0x80, 0x84, 0x01, 0x08, 0x08, 0x40,
  0x10, 0x80, 0x84, 0x02, 0x18, 0x18, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10,
  0x10, 0x40, 0x41, 0x01, 0x04, 0x0C, 0x10, 0x10, 0x40, 0x83, 0x03, 0x04,
  0x18, 0x20, 0x20, 0x41, 0x02, 0x02, 0x04, 0x30, 0x20, 0x20, 0x42, 0x06,
  0x06, 0x04, 0x60, 0x60, 0x60, 0x64, 0x04, 0x04, 0x06, 0xC0, 0x40, 0x40,
  0x68, 0x04, 0x04, 0x07, 0x80, 0xC0, 0xC0, 0x30, 0x08, 0x08, 0x03, 0x00,
  0x80, 0x01, 0x80, 0x04, 0x06, 0x00, 0x10, 0x18, 0x00, 0x40, 0x60, 0x03,
  0x03, 0xC0, 0x08, 0x09, 0x00, 0x20, 0x24, 0x00, 0x80, 0x90, 0x02, 0x02,
  0x40, 0x18, 0x19, 0x00, 0x40, 0x46, 0x01, 0x01, 0x08, 0x04, 0x04, 0x20,
  0x30, 0x30, 0x80, 0xC0, 0xC2, 0x02, 0x02, 0x0C, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x41, 0x81, 0x81, 0x04, 0x04, 0x04, 0x10, 0x10, 0x10, 0x40, 0x40,
  0x61, 0x01, 0x00, 0x8C, 0x0C, 0x02, 0x20, 0x20, 0x08, 0x80, 0x80, 0x22,
  0x02, 0x00, 0xC8, 0x18, 0x03, 0x60, 0x60, 0x05, 0x01, 0x00, 0x14, 0x04,
  0x00, 0x50, 0x10, 0x01, 0xC0, 0xC0, 0x07, 0x02, 0x00, 0x08, 0x00, 0x00,
  0x7E, 0x00, 0x30, 0xC0, 0x10, 0x18, 0x08, 0x02, 0x06, 0x00, 0xC3, 0x00,
  0x30, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x08, 0x20, 0x06, 0x0C, 0x01, 0x01, 0x00, 0x80, 0x60,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x40, 0xC0, 0x20,
  0x20, 0x30, 0x18, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x83,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x40, 0x10, 0x60, 0x08, 0x30, 0x0C,
  0x10, 0x0C, 0x08, 0x0C, 0x04, 0x0C, 0x07, 0xFC, 0x03, 0xE0, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x30, 0xC0, 0x10, 0x18,
  0x08, 0x02, 0x06, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x04, 0x60, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0xD8, 0x00,
  0x34, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0A,
  0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80,
  0x02, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x08, 0x20, 0x06,
  0x0C, 0x01, 0x01, 0x00, 0x80, 0x60, 0xC0, 0x0F, 0xE0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x40, 0xC0, 0x20,
  0x20, 0x30, 0x18, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x83,
  0x00, 0x41, 0x00, 0x60, 0x80, 0x30, 0x40, 0x10, 0x60, 0x18, 0x30, 0x08,
  0x10, 0x0C, 0x08, 0x0C, 0x04, 0x1C, 0x07, 0xF8, 0x02, 0x08, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x60, 0xC0, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x81, 0x00, 0x40, 0x80, 0x20,
  0xC0, 0x10, 0x40, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x38, 0x70, 0x10, 0x04,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x60, 0x3F, 0xF0, 0x00, 0x7F, 0xFD,
  0xFF, 0xF0, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x10, 0x20, 0x03, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x06, 0x04, 0x00, 0x60, 0x40, 0x04, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x08,
  0x00, 0xC0, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01, 0x81,
  0x00, 0x18, 0x10, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x30,
  0x20, 0x02, 0x02, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06,
  0x04, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x04, 0x00,
  0x80, 0x40, 0x18, 0x06, 0x03, 0x00, 0x20, 0x60, 0x01, 0xFC, 0x00, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80,
  0x60, 0x80, 0x40, 0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x81, 0x80, 0x81,
  0x00, 0x83, 0x00, 0x82, 0x00, 0x82, 0x00, 0x84, 0x00, 0x84, 0x00, 0x8C,
  0x00, 0x88, 0x00, 0x98, 0x00, 0x90, 0x00, 0x90, 0x00, 0xB0, 0x00, 0xA0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x02, 0x00, 0x14, 0x00,
  0x20, 0x01, 0x40, 0x06, 0x00, 0x34, 0x00, 0x60, 0x02, 0x40, 0x06, 0x00,
  0x64, 0x00, 0xA0, 0x04, 0x40, 0x0A, 0x00, 0x44, 0x01, 0xA0, 0x0C, 0x40,
  0x12, 0x00, 0x84, 0x01, 0x20, 0x18, 0x40, 0x22, 0x01, 0x04, 0x02, 0x20,
  0x10, 0x40, 0x62, 0x03, 0x04, 0x04, 0x20, 0x20, 0x40, 0x42, 0x06, 0x04,
  0x0C, 0x20, 0x40, 0x40, 0x82, 0x04, 0x04, 0x18, 0x20, 0xC0, 0x41, 0x02,
  0x08, 0x04, 0x10, 0x20, 0x80, 0x43, 0x02, 0x10, 0x04, 0x20, 0x21, 0x00,
  0x46, 0x02, 0x30, 0x04, 0x40, 0x22, 0x00, 0x44, 0x06, 0x20, 0x04, 0xC0,
  0x64, 0x00, 0x48, 0x06, 0x40, 0x05, 0x80, 0x6C, 0x00, 0x50, 0x04, 0x80,
  0x05, 0x00, 0x48, 0x00, 0x70, 0x05, 0x00, 0x0E, 0x00, 0x50, 0x00, 0xE0,
  0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x10, 0x08, 0x00, 0x80, 0x40, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x02,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80, 0x00,
  0x4C, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x09,
  0x00, 0x00, 0xC8, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x18, 0x00,
  0x20, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80, 0x08, 0x04,
  0x00, 0xC0, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x06, 0x00, 0x40, 0x00,
  0x40, 0x06, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01, 0x0C, 0x02, 0x18,
  0x08, 0x30, 0x10, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x0C, 0x02, 0x10,
  0x04, 0x60, 0x08, 0x80, 0x13, 0x00, 0x24, 0x00, 0x78, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x08, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x41,
  0x06, 0x18, 0x20, 0x82, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x41, 0x04, 0x18,
  0x60, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x24, 0x00, 0x32, 0x00, 0x10, 0x80,
  0x18, 0x40, 0x08, 0x30, 0x0C, 0x08, 0x04, 0x06, 0x06, 0x01, 0x02, 0x00,
  0xC3, 0x00, 0x21, 0x00, 0x19, 0x80, 0x04, 0x80, 0x03, 0xC0, 0x00, 0x80,
  0xFF, 0xF8, 0x8C, 0x44, 0x22, 0x11, 0x01, 0xF9, 0x03, 0x09, 0x06, 0x05,
  0x0C, 0x05, 0x08, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x06, 0x20, 0x06,
  0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x08,
  0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30,
  0x40, 0x50, 0x40, 0x50, 0x60, 0xA0, 0x3F, 0x20, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x7C, 0x04, 0xC6, 0x05, 0x03,
  0x07, 0x01, 0x06, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02,
  0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x60, 0x08, 0x60, 0x08,
  0x60, 0x10, 0x50, 0x30, 0x58, 0x60, 0x8F, 0xC0, 0x01, 0xF8, 0x18, 0x41,
  0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0xFC, 0x80, 0x30, 0x90, 0x0C, 0x0A, 0x03, 0x01,
  0xC0, 0x40, 0x30, 0x18, 0x06, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x10, 0x03,
  0x02, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0x40, 0x0C,
  0x08, 0x01, 0x03, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x50, 0x08, 0x1A, 0x01, 0x86, 0x80,
  0x1F, 0x90, 0x00, 0x01, 0xF0, 0x0C, 0x60, 0x60, 0x83, 0x02, 0x08, 0x0C,
  0x40, 0x21, 0x00, 0x88, 0x06, 0x20, 0x11, 0x80, 0xC4, 0x06, 0x10, 0xE0,
  0x7E, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x10, 0x3F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x19, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x40,
  0x30, 0x90, 0x18, 0x14, 0x0C, 0x05, 0x02, 0x01, 0x81, 0x80, 0x60, 0x40,
  0x18, 0x30, 0x06, 0x08, 0x01, 0x82, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04,
  0x10, 0x03, 0x04, 0x00, 0xC1, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x0C, 0x04, 0x05, 0x01, 0x03,
  0xC0, 0x61, 0xA0, 0x0F, 0xC8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x10, 0x0C, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x13, 0xE0, 0x48, 0x60, 0xA0, 0x41, 0x80, 0x83, 0x01,
  0x0C, 0x02, 0x18, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x43, 0x00, 0x84,
  0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x00,
  0x84, 0x03, 0x18, 0x04, 0x30, 0x08, 0x40, 0x10, 0x80, 0x61, 0x00, 0xC6,
  0x01, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x07, 0x80, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x03, 0x04, 0x06, 0x04, 0x04, 0x04, 0x08, 0x04, 0x10, 0x0C,
  0x30, 0x08, 0x60, 0x08, 0x40, 0x08, 0x80, 0x09, 0x80, 0x1B, 0x80, 0x13,
  0x80, 0x14, 0x80, 0x18, 0x80, 0x38, 0x80, 0x30, 0x80, 0x20, 0x80, 0x20,
  0xC0, 0x20, 0x40, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x60, 0xC0, 0x20, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x00, 0x06, 0x7C, 0x7E, 0x05,
  0x84, 0xC3, 0x05, 0x03, 0x81, 0x06, 0x03, 0x01, 0x04, 0x02, 0x01, 0x0C,
  0x02, 0x01, 0x0C, 0x06, 0x01, 0x08, 0x06, 0x03, 0x08, 0x04, 0x02, 0x08,
  0x04, 0x02, 0x18, 0x04, 0x02, 0x10, 0x0C, 0x02, 0x10, 0x08, 0x06, 0x10,
  0x08, 0x04, 0x30, 0x08, 0x04, 0x30, 0x08, 0x04, 0x20, 0x18, 0x0C, 0x20,
  0x10, 0x0C, 0x20, 0x10, 0x08, 0x60, 0x10, 0x08, 0x40, 0x30, 0x08, 0x40,
  0x30, 0x18, 0x40, 0x20, 0x10, 0x40, 0x20, 0x10, 0xC0, 0x60, 0x10, 0x04,
  0x7C, 0x09, 0x0C, 0x14, 0x08, 0x30, 0x10, 0x60, 0x21, 0x80, 0x43, 0x00,
  0x84, 0x01, 0x08, 0x06, 0x10, 0x08, 0x60, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x01, 0x8C, 0x02, 0x18, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x63, 0x00,
  0x84, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x10, 0xC0, 0x20, 0x01, 0xF0,
  0x06, 0x10, 0x18, 0x30, 0x60, 0x20, 0x80, 0x43, 0x00, 0xC4, 0x01, 0x98,
  0x03, 0x20, 0x06, 0x40, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00,
  0x90, 0x03, 0x60, 0x04, 0xC0, 0x09, 0x80, 0x33, 0x00, 0x46, 0x00, 0x8C,
  0x03, 0x08, 0x04, 0x10, 0x10, 0x30, 0x40, 0x3F, 0x00, 0x01, 0x9F, 0x00,
  0x4C, 0x60, 0x14, 0x0C, 0x07, 0x01, 0x01, 0x80, 0x40, 0xC0, 0x10, 0x30,
  0x04, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x10, 0x01,
  0x04, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x08, 0x30, 0x02, 0x0C, 0x01, 0x82,
  0x00, 0x40, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x02, 0x06, 0x01, 0x01, 0x40,
  0xC0, 0x50, 0x60, 0x33, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF1, 0x03, 0x09, 0x06, 0x05,
  0x0C, 0x05, 0x08, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x06, 0x20, 0x06,
  0x20, 0x04, 0x60, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08,
  0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30,
  0x40, 0x50, 0x40, 0x70, 0x61, 0xA0, 0x3F, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x04, 0x78, 0x24, 0x01, 0x40, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x01,
  0xF8, 0x18, 0x30, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x20, 0x20, 0xFF, 0x00, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x3F, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xF0, 0x0C, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x43,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x60, 0x10, 0xC0, 0x21, 0x00,
  0x42, 0x01, 0x84, 0x03, 0x18, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x61,
  0x00, 0x86, 0x01, 0x08, 0x06, 0x10, 0x0C, 0x30, 0x28, 0x20, 0xA0, 0x7E,
  0x40, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80, 0x48, 0x0C, 0x80, 0x88,
  0x08, 0x81, 0x08, 0x10, 0x83, 0x08, 0x20, 0x86, 0x08, 0x40, 0x8C, 0x08,
  0x80, 0x88, 0x09, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x00, 0x80, 0x20, 0x1C, 0x01, 0x00, 0xA0, 0x18, 0x05, 0x00,
  0xC0, 0x48, 0x0A, 0x02, 0x40, 0x50, 0x32, 0x06, 0x81, 0x10, 0x24, 0x08,
  0x81, 0x20, 0xC4, 0x11, 0x04, 0x20, 0x88, 0x21, 0x0C, 0x42, 0x08, 0x42,
  0x10, 0x42, 0x11, 0x82, 0x20, 0x88, 0x11, 0x04, 0x40, 0x98, 0x24, 0x04,
  0x81, 0x20, 0x24, 0x0B, 0x01, 0x40, 0x50, 0x0A, 0x02, 0x80, 0x70, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x20, 0x00, 0x02, 0x01, 0x81,
  0x00, 0x80, 0x80, 0xC0, 0x60, 0x40, 0x10, 0x40, 0x08, 0x60, 0x04, 0x20,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x50, 0x00, 0x38, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0A, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x06, 0x40, 0x02, 0x20, 0x02,
  0x18, 0x03, 0x04, 0x01, 0x02, 0x01, 0x81, 0x00, 0x80, 0x80, 0x80, 0x60,
  0xC0, 0x10, 0x00, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x60, 0x04, 0x02, 0x00, 0x20, 0x10, 0x01, 0x01, 0x00, 0x08, 0x08,
  0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x04,
  0x30, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x00, 0x00, 0x28,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x7C, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8,
  0x00, 0x08, 0x00, 0x3F, 0x01, 0xC0, 0xC3, 0x80, 0x7E,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 10, 13, 12, 4, -34 },
  { 57, 18, 34, 17, 0, -34 },
  { 134, 17, 39, 16, 0, -36 },
  { 217, 21, 35, 24, 2, -34 },
  { 309, 15, 34, 15, -1, -34 },
  { 373, 4, 13, 7, 4, -34 },
  { 380, 13, 40, 11, 1, -33 },
  { 445, 12, 40, 11, -3, -33 },
  { 505, 11, 13, 15, 6, -36 },
  { 523, 16, 21, 19, 1, -27 },
  { 565, 6, 10, 7, -2, -4 },
  { 573, 10, 1, 12, 1, -13 },
  { 575, 2, 3, 7, 1, -3 },
  { 576, 19, 33, 14, -2, -33 },
  { 655, 15, 34, 16, 1, -34 },
  { 719, 8, 34, 16, 5, -34 },
  { 753, 18, 34, 16, -2, -34 },
  { 830, 17, 35, 16, -1, -34 },
  { 905, 17, 34, 16, -1, -34 },
  { 978, 17, 34, 16, -1, -34 },
  { 1051, 16, 34, 16, 1, -34 },
  { 1119, 16, 34, 16, 2, -34 },
  { 1187, 18, 34, 16, -1, -34 },
  { 1264, 16, 34, 16, 0, -34 },
  { 1332, 7, 25, 7, 0, -25 },
  { 1354, 9, 31, 7, -2, -25 },
  { 1389, 16, 19, 19, 1, -26 },
  { 1427, 16, 11, 19, 1, -22 },
  { 1449, 16, 19, 19, 1, -26 },
  { 1487, 12, 34, 11, 1, -34 },
  { 1538, 22, 38, 24, 1, -34 },
  { 1643, 15, 34, 15, -3, -34 },
  { 1707, 18, 34, 18, 0, -34 },
  { 1784, 18, 34, 16, 2, -34 },
  { 1861, 18, 34, 19, 0, -34 },
  { 1938, 18, 34, 16, 0, -34 },
  { 2015, 18, 34, 15, 0, -34 },
  { 2092, 20, 34, 21, 2, -34 },
  { 2177, 21, 34, 21, 0, -34 },
  { 2267, 14, 34, 8, -3, -34 },
  { 2327, 15, 42, 7, -7, -34 },
  { 2406, 20, 34, 16, 0, -34 },
  { 2491, 10, 34, 14, 0, -34 },
  { 2534, 28, 34, 28, 0, -34 },
  { 2653, 22, 34, 22, 0, -34 },
  { 2747, 18, 34, 21, 2, -34 },
  { 2824, 17, 34, 17, 0, -34 },
  { 2897, 18, 42, 21, 2, -34 },
  { 2992, 17, 34, 17, 0, -34 },
  { 3065, 18, 34, 16, -1, -34 },
  { 3142, 14, 34, 14, 3, -34 },
  { 3202, 20, 34, 20, 1, -34 },
  { 3287, 16, 34, 16, 4, -34 },
  { 3355, 28, 34, 28, 3, -34 },
  { 3474, 21, 34, 14, -3, -34 },
  { 3564, 15, 34, 14, 3, -34 },
  { 3628, 19, 34, 14, -2, -34 },
  { 3709, 17, 41, 13, -1, -34 },
  { 3797, 6, 34, 15, 5, -34 },
  { 3823, 17, 41, 13, -3, -34 },
  { 3911, 17, 17, 18, 1, -34 },
  { 3948, 13, 1, 12, -4, 4 },
  { 3950, 4, 8, 10, 7, -36 },
  { 3954, 16, 25, 18, 1, -25 },
  { 4004, 16, 36, 17, 0, -36 },
  { 4076, 13, 25, 13, 1, -25 },
  { 4117, 19, 36, 18, 1, -36 },
  { 4203, 14, 25, 15, 1, -25 },
  { 4247, 20, 47, 9, -6, -36 },
  { 4365, 18, 36, 18, -1, -25 },
  { 4446, 15, 36, 17, 0, -36 },
  { 4514, 9, 33, 7, 0, -33 },
  { 4552, 15, 44, 8, -6, -33 },
  { 4635, 16, 36, 14, 0, -36 },
  { 4707, 9, 36, 7, 0, -36 },
  { 4748, 24, 25, 26, 0, -25 },
  { 4823, 15, 25, 17, 0, -25 },
  { 4870, 15, 25, 17, 1, -25 },
  { 4917, 18, 36, 18, -2, -25 },
  { 4998, 16, 36, 18, 1, -25 },
  { 5070, 13, 25, 11, 0, -25 },
  { 5111, 14, 25, 13, -1, -25 },
  { 5155, 8, 31, 9, 1, -31 },
  { 5186, 15, 25, 17, 1, -25 },
  { 5233, 12, 25, 13, 3, -25 },
  { 5271, 21, 25, 22, 3, -25 },
  { 5337, 17, 25, 13, -2, -25 },
  { 5391, 21, 36, 14, -5, -25 },
  { 5486, 14, 25, 11, -2, -25 },
  { 5530, 15, 41, 15, 2, -34 },
  { 5607, 2, 47, 16, 7, -36 },
  { 5619, 16, 41, 14, -3, -34 },
  { 5701, 16, 4, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC47PT7B_H_
