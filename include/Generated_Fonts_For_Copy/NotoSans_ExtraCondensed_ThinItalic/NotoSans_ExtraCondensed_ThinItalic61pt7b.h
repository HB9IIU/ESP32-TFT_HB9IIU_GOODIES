#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x31, 0x02, 0x30, 0x63,
  0x06, 0x30, 0x62, 0x04, 0x20, 0x46, 0x0C, 0x60, 0xC4, 0x08, 0x40, 0x84,
  0x08, 0x40, 0x8C, 0x18, 0x81, 0x08, 0x10, 0x00, 0x02, 0x02, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x02, 0x00, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x80, 0x20, 0x30, 0x00, 0x40, 0x40, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x04, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x40,
  0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x04, 0x00, 0x18, 0x08,
  0x00, 0x30, 0x30, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0x80, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x30,
  0x10, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x67, 0x80, 0x70,
  0x81, 0x00, 0xC1, 0x00, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x10,
  0x00, 0x30, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x58, 0x00, 0x00, 0x98, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x30, 0x00, 0x10, 0x60, 0x00, 0x20,
  0xC0, 0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x02, 0x06, 0x00, 0x04, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x83, 0x01,
  0xC1, 0x1C, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0x80, 0xCC, 0x00, 0x40, 0x61, 0x80, 0x30,
  0x30, 0x60, 0x08, 0x18, 0x18, 0x06, 0x06, 0x06, 0x01, 0x01, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x08, 0x06, 0x04, 0x06, 0x01,
  0x83, 0x01, 0x80, 0x40, 0x80, 0x40, 0x10, 0x60, 0x10, 0x0C, 0x10, 0x0C,
  0x03, 0x0C, 0x03, 0x00, 0xC2, 0x00, 0xC0, 0x21, 0x80, 0x30, 0x18, 0x40,
  0x8C, 0x06, 0x30, 0xFA, 0x01, 0x08, 0xE3, 0x80, 0xC6, 0x30, 0xE0, 0x31,
  0x18, 0x1C, 0x18, 0xC4, 0x07, 0x06, 0x23, 0x01, 0xC3, 0x18, 0x80, 0x5B,
  0x84, 0x60, 0x13, 0xC3, 0x18, 0x0C, 0x00, 0x84, 0x03, 0x00, 0x63, 0x00,
  0xC0, 0x10, 0xC0, 0x30, 0x0C, 0x30, 0x0C, 0x02, 0x0C, 0x02, 0x01, 0x82,
  0x01, 0x80, 0x40, 0x80, 0x60, 0x30, 0x60, 0x18, 0x08, 0x18, 0x04, 0x06,
  0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x20, 0x18, 0x18,
  0x18, 0x06, 0x04, 0x04, 0x01, 0x83, 0x03, 0x00, 0x31, 0x80, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xB8, 0x00, 0xC3,
  0x00, 0x30, 0x20, 0x06, 0x04, 0x00, 0x80, 0xC0, 0x30, 0x10, 0x06, 0x02,
  0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x09, 0x80,
  0x01, 0x60, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x68, 0x00,
  0x19, 0x80, 0x06, 0x30, 0x01, 0x82, 0x00, 0x30, 0x40, 0x8C, 0x0C, 0x33,
  0x01, 0x86, 0x60, 0x10, 0x88, 0x02, 0x13, 0x00, 0x66, 0x60, 0x0C, 0x88,
  0x00, 0xB3, 0x00, 0x16, 0x60, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x78, 0x60, 0x1B, 0x0C, 0x06, 0x20, 0xC1, 0x84, 0x0F,
  0xE0, 0xC0, 0x20, 0x00, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x62, 0x10, 0x84,
  0x62, 0x10, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x08, 0x06, 0x30, 0x06, 0x41, 0x83,
  0xBE, 0x01, 0x80, 0x05, 0x00, 0x32, 0x00, 0xC2, 0x03, 0x04, 0x08, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x00, 0xFF, 0xF8,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xDC, 0x00, 0x60,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0x20, 0x18, 0x02, 0x01, 0x00, 0x30, 0x30,
  0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x61,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x62, 0x00, 0x04,
  0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0x84, 0x00, 0x18, 0x40, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x04, 0x01, 0x80, 0x60, 0x30, 0x06,
  0x06, 0x00, 0x30, 0xC0, 0x01, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x1C, 0x07, 0x81, 0xB0, 0xE4, 0x38, 0x8C, 0x33, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x79, 0xE0, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xE7, 0xC0,
  0x1C, 0x03, 0x80, 0x20, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x02, 0x00,
  0x70, 0x0C, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x68,
  0x00, 0x03, 0x20, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x03, 0x10, 0x00,
  0x0C, 0x40, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0x80, 0x01, 0x82, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x00,
  0x0C, 0x04, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x04, 0x03, 0x00, 0x30,
  0x08, 0x01, 0x80, 0x20, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x18,
  0x06, 0x00, 0x40, 0x30, 0x01, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x09, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x20, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x1C, 0x03,
  0x80, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x78, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x81, 0x80, 0x0C, 0x7F, 0x80, 0x66,
  0x0E, 0x03, 0x60, 0x30, 0x16, 0x00, 0xC0, 0xE0, 0x06, 0x0E, 0x00, 0x10,
  0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x00,
  0x0C, 0x20, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x01, 0x00, 0x18, 0x0C, 0x00, 0x80, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x0E,
  0x1C, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x79, 0xE0, 0x01, 0x80,
  0x60, 0x06, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x40, 0x01,
  0x00, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x10,
  0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0x80, 0x20, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x18, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3B, 0x00, 0x01, 0xC3,
  0x00, 0x07, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x04,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10, 0x20, 0x00, 0x20,
  0xC0, 0x00, 0x41, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x06, 0x00, 0x02, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x10, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xCE, 0x00, 0x38, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x01, 0x80, 0x18, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x06,
  0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0x80, 0x01,
  0x04, 0x00, 0x08, 0x60, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x30, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x04, 0x00, 0x70,
  0x30, 0x02, 0x81, 0x80, 0x3C, 0x06, 0x07, 0x60, 0x1F, 0xE3, 0x00, 0x7C,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x20, 0x70, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x81,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0x9E, 0x04, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x3F, 0x83, 0x18, 0x07,
  0x18, 0x31, 0x80, 0xC1, 0x83, 0x10, 0x18, 0x10, 0x33, 0x01, 0x83, 0x03,
  0x30, 0x30, 0x30, 0x32, 0x02, 0x03, 0x03, 0x60, 0x60, 0x20, 0x26, 0x06,
  0x06, 0x02, 0x60, 0x40, 0x60, 0x64, 0x0C, 0x06, 0x06, 0x40, 0xC0, 0x40,
  0x6C, 0x08, 0x0C, 0x04, 0xC1, 0x80, 0xC0, 0xCC, 0x18, 0x0C, 0x0C, 0xC1,
  0x81, 0x80, 0x8C, 0x18, 0x18, 0x18, 0x81, 0x81, 0x81, 0x88, 0x18, 0x38,
  0x10, 0x81, 0x83, 0x83, 0x08, 0x18, 0x68, 0x60, 0x81, 0x84, 0x84, 0x08,
  0x0F, 0xCF, 0xC0, 0x80, 0x78, 0x70, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0B, 0x00, 0x01, 0xB0, 0x00, 0x13, 0x00, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x30, 0x00, 0x83, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x10, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30,
  0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x00, 0x03,
  0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0x80, 0xE0,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80,
  0x04, 0x03, 0x00, 0x18, 0x04, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x0E,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0xE0, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x40, 0x01, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00,
  0x04, 0x04, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x07,
  0x00, 0x80, 0x1C, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0x1C, 0x00, 0x70, 0x08, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x10, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x40, 0x18, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02,
  0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06, 0x00, 0x02, 0x06,
  0x00, 0x06, 0x04, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x04, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x10, 0x00, 0x10, 0x10, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x40,
  0x38, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x08, 0x01, 0x80, 0x01,
  0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x3C, 0x03, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x08, 0x00, 0x04, 0x00, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x10, 0x03, 0x00, 0x01, 0x00, 0x20, 0x00, 0x30, 0x02, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x04,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x40, 0x08, 0x00, 0x04, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x10, 0x03, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x43, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0xC0,
  0x00, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x5B, 0x00,
  0x00, 0x34, 0x40, 0x00, 0x0E, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x08, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x02, 0x00, 0x18, 0x00,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x10,
  0x00, 0x40, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x58, 0x03, 0x40, 0x00, 0x06, 0x80, 0x12, 0x00, 0x00, 0x24, 0x00, 0x90,
  0x00, 0x03, 0x60, 0x0C, 0x80, 0x00, 0x13, 0x00, 0x64, 0x00, 0x01, 0x98,
  0x03, 0x20, 0x00, 0x0C, 0x80, 0x11, 0x00, 0x00, 0xCC, 0x00, 0x88, 0x00,
  0x06, 0x60, 0x0C, 0x40, 0x00, 0x63, 0x00, 0x63, 0x00, 0x03, 0x10, 0x03,
  0x18, 0x00, 0x30, 0x80, 0x10, 0xC0, 0x01, 0x8C, 0x00, 0x86, 0x00, 0x18,
  0x60, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x0C, 0x10, 0x03, 0x0C,
  0x00, 0x60, 0x80, 0x10, 0x60, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x0C, 0x18, 0x01, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x02, 0x02, 0x00,
  0x80, 0x80, 0x10, 0x10, 0x0C, 0x0C, 0x01, 0x80, 0x80, 0x40, 0x60, 0x0C,
  0x04, 0x06, 0x02, 0x00, 0x60, 0x20, 0x20, 0x10, 0x02, 0x01, 0x03, 0x01,
  0x80, 0x10, 0x08, 0x10, 0x0C, 0x01, 0x80, 0x61, 0x80, 0x60, 0x0C, 0x03,
  0x0C, 0x02, 0x00, 0x60, 0x18, 0xC0, 0x10, 0x02, 0x00, 0xC6, 0x01, 0x80,
  0x30, 0x06, 0x60, 0x0C, 0x01, 0x80, 0x33, 0x00, 0x60, 0x0C, 0x01, 0xB0,
  0x02, 0x00, 0x40, 0x0D, 0x80, 0x10, 0x02, 0x00, 0x78, 0x01, 0x80, 0x30,
  0x03, 0xC0, 0x0C, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x20,
  0x05, 0x00, 0x03, 0x00, 0x68, 0x00, 0x18, 0x03, 0x60, 0x00, 0xC0, 0x1B,
  0x00, 0x04, 0x00, 0x98, 0x00, 0x20, 0x0C, 0x40, 0x03, 0x00, 0x62, 0x00,
  0x18, 0x03, 0x10, 0x00, 0xC0, 0x10, 0xC0, 0x04, 0x00, 0x86, 0x00, 0x20,
  0x0C, 0x30, 0x03, 0x00, 0x60, 0x80, 0x18, 0x03, 0x04, 0x00, 0xC0, 0x10,
  0x30, 0x04, 0x00, 0x81, 0x80, 0x60, 0x0C, 0x0C, 0x03, 0x00, 0x60, 0x60,
  0x18, 0x03, 0x01, 0x00, 0xC0, 0x10, 0x08, 0x04, 0x01, 0x80, 0x60, 0x60,
  0x0C, 0x03, 0x03, 0x00, 0x60, 0x18, 0x18, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x02, 0x04, 0x01, 0x80, 0x18, 0x60, 0x0C, 0x00, 0xC3, 0x00, 0x60, 0x06,
  0x18, 0x02, 0x00, 0x30, 0x80, 0x10, 0x00, 0x84, 0x01, 0x80, 0x06, 0x60,
  0x0C, 0x00, 0x33, 0x00, 0x60, 0x01, 0x98, 0x02, 0x00, 0x0C, 0x80, 0x30,
  0x00, 0x2C, 0x01, 0x80, 0x01, 0x60, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0x00,
  0x70, 0x02, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00,
  0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x10, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x60, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x06, 0x07,
  0x00, 0x10, 0x0E, 0x00, 0x40, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x80, 0x04, 0x06, 0x00, 0x10, 0x18, 0x00, 0x40, 0x60,
  0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x02,
  0x03, 0x00, 0x18, 0x08, 0x00, 0x60, 0x20, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x38, 0x01, 0x07, 0xC0, 0x0F, 0xFC,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x02, 0x01,
  0x00, 0x02, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x10, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x40,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x0E, 0x00, 0x18,
  0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0x00, 0x06, 0x07, 0x00, 0x10, 0x0E, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x80, 0x04,
  0x06, 0x00, 0x10, 0x18, 0x00, 0x40, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x04,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x20, 0x03, 0x01, 0x80, 0x08, 0x06, 0x00, 0x60, 0x18, 0x07, 0x00,
  0x40, 0x78, 0x01, 0xFF, 0x80, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81,
  0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x04, 0x03, 0x00, 0x10, 0x04, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18, 0x06, 0x00, 0x20, 0x18, 0x00,
  0x80, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x1E, 0x1F, 0x00, 0x30, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x80, 0x07, 0x00, 0xE0, 0x1E, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x20, 0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x04, 0x00,
  0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x00, 0xC0, 0x40, 0x00, 0x40, 0x60, 0x00, 0x20, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x40,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x08, 0x00, 0x08,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x20, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0x40, 0x06, 0x00, 0x30, 0x06, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x03, 0x00, 0x18,
  0x18, 0x00, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x00,
  0xC0, 0x60, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x02, 0xC0, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x0E, 0x00, 0x06, 0xC0,
  0x00, 0xE0, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x01, 0x60, 0x00,
  0x8C, 0x00, 0x16, 0x00, 0x18, 0xC0, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x26,
  0x00, 0x30, 0xC0, 0x06, 0x60, 0x03, 0x0C, 0x00, 0x66, 0x00, 0x20, 0xC0,
  0x04, 0x60, 0x06, 0x0C, 0x00, 0xC4, 0x00, 0x60, 0x80, 0x08, 0x40, 0x0C,
  0x08, 0x01, 0x84, 0x00, 0xC0, 0x80, 0x18, 0x40, 0x08, 0x08, 0x01, 0x04,
  0x01, 0x80, 0x80, 0x30, 0x40, 0x18, 0x08, 0x02, 0x04, 0x03, 0x00, 0x80,
  0x60, 0x40, 0x30, 0x08, 0x06, 0x04, 0x02, 0x00, 0x80, 0x40, 0x40, 0x60,
  0x08, 0x0C, 0x04, 0x06, 0x00, 0x80, 0x80, 0x40, 0xC0, 0x08, 0x18, 0x04,
  0x0C, 0x00, 0x81, 0x80, 0x40, 0x80, 0x08, 0x10, 0x04, 0x18, 0x00, 0x83,
  0x00, 0xC1, 0x80, 0x08, 0x30, 0x0C, 0x30, 0x00, 0x86, 0x00, 0xC3, 0x00,
  0x08, 0x60, 0x0C, 0x20, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x0C,
  0x60, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x09, 0x80, 0x0C, 0xC0, 0x00, 0x98,
  0x00, 0xC8, 0x00, 0x09, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0xD8, 0x00,
  0x0B, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x0A,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x80, 0x18, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x30, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x40, 0x18, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0x60, 0x00, 0xC0,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x01, 0x80, 0x02, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x08, 0x00, 0xC1, 0x00, 0x30, 0x20,
  0x06, 0x04, 0x01, 0x80, 0x80, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x40, 0x02, 0x18, 0x00, 0x42,
  0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x26, 0x00, 0x04, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x04,
  0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x01, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x10,
  0x00, 0x20, 0xC0, 0x03, 0x02, 0x00, 0x10, 0x18, 0x01, 0x80, 0x40, 0x08,
  0x03, 0x00, 0xC0, 0x18, 0x04, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x0C,
  0x30, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0x83, 0x04, 0x18, 0x20, 0x81, 0x04, 0x08, 0x30,
  0x00, 0x1C, 0x08, 0x03, 0xF8, 0x80, 0x70, 0x64, 0x06, 0x01, 0x20, 0x60,
  0x0F, 0x03, 0x00, 0x38, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x60, 0x01, 0x82, 0x00, 0x0C,
  0x10, 0x00, 0x60, 0x80, 0x07, 0x04, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80,
  0x1C, 0x0C, 0x01, 0xE0, 0x60, 0x0A, 0x01, 0x80, 0x90, 0x0E, 0x1C, 0x80,
  0x3F, 0x8C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x06, 0x7F, 0x80, 0x26, 0x0E,
  0x01, 0x60, 0x30, 0x1A, 0x00, 0x80, 0xF0, 0x06, 0x07, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x00,
  0x08, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x04,
  0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x18, 0x16, 0x01, 0x80, 0x90,
  0x0C, 0x04, 0xC1, 0xC0, 0x63, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0x01, 0xC1, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x20, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x18,
  0x00, 0x7F, 0x10, 0x01, 0xC1, 0x90, 0x03, 0x00, 0xB0, 0x06, 0x00, 0xF0,
  0x06, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x08, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x10, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x40, 0x00, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x00,
  0xC0, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x07, 0x00,
  0x80, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1E, 0x00,
  0xC0, 0x34, 0x00, 0x60, 0x24, 0x00, 0x70, 0xE4, 0x00, 0x3F, 0x8C, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x60, 0xC0, 0x60, 0x30,
  0x60, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x18, 0x01,
  0x8C, 0x00, 0xC4, 0x00, 0xC6, 0x00, 0x63, 0x00, 0xE1, 0x00, 0xE0, 0x81,
  0xC0, 0xFF, 0x80, 0x7C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x40, 0x60, 0x60, 0x1F,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x81, 0x00, 0x0F, 0xE2, 0x00, 0x38, 0x32, 0x00,
  0x60, 0x12, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x0C, 0x01,
  0x00, 0x0C, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x06,
  0x00, 0x18, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x10, 0x08, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x20, 0x18, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10,
  0x00, 0x60, 0x10, 0x00, 0xE0, 0x10, 0x00, 0xC0, 0x10, 0x01, 0xC0, 0x18,
  0x01, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x06, 0x80, 0x0C, 0x04, 0x80, 0x0E,
  0x1C, 0x80, 0x07, 0xF1, 0x80, 0x01, 0xC1, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x70, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x78, 0x01, 0x9F, 0xE0, 0x13, 0x06, 0x01, 0x60, 0x30, 0x3C, 0x03, 0x03,
  0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x20,
  0x60, 0x02, 0x06, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x04,
  0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00,
  0x81, 0x80, 0x08, 0x10, 0x01, 0x81, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00,
  0x10, 0x30, 0x01, 0x02, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x20, 0x60,
  0x02, 0x06, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x30,
  0x10, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x30,
  0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x30,
  0x00, 0x43, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0D, 0xA0, 0x00, 0x92,
  0x00, 0x0B, 0x30, 0x01, 0xE3, 0x00, 0x1C, 0x30, 0x01, 0x83, 0x00, 0x10,
  0x10, 0x01, 0x01, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x20, 0x18, 0x02,
  0x01, 0x80, 0x60, 0x08, 0x06, 0x00, 0x80, 0x60, 0x0C, 0x04, 0x00, 0xC0,
  0x40, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x02, 0x3F, 0x87, 0xF8, 0x04, 0xC1,
  0x98, 0x38, 0x0A, 0x01, 0x60, 0x30, 0x38, 0x02, 0x80, 0x20, 0x70, 0x06,
  0x00, 0x40, 0xC0, 0x0C, 0x00, 0x81, 0x80, 0x18, 0x01, 0x03, 0x00, 0x20,
  0x06, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x18, 0x30, 0x03, 0x00,
  0x20, 0x40, 0x04, 0x00, 0x41, 0x80, 0x08, 0x01, 0x83, 0x00, 0x30, 0x03,
  0x06, 0x00, 0x60, 0x06, 0x08, 0x00, 0xC0, 0x08, 0x10, 0x01, 0x00, 0x10,
  0x60, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x01, 0x82,
  0x00, 0x20, 0x02, 0x04, 0x00, 0x40, 0x0C, 0x18, 0x01, 0x80, 0x18, 0x30,
  0x03, 0x00, 0x30, 0x60, 0x06, 0x00, 0x40, 0x80, 0x08, 0x00, 0x81, 0x00,
  0x10, 0x03, 0x06, 0x00, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x0C, 0x18, 0x01,
  0x00, 0x10, 0x20, 0x02, 0x00, 0x20, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x11, 0xFE, 0x01, 0x30, 0x60, 0x16, 0x03, 0x03, 0xC0, 0x30, 0x38,
  0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x02, 0x06,
  0x00, 0x20, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x40,
  0xC0, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08,
  0x18, 0x00, 0x81, 0x00, 0x18, 0x10, 0x01, 0x83, 0x00, 0x10, 0x30, 0x01,
  0x03, 0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00,
  0x20, 0x40, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xC0, 0x18, 0x38, 0x0C, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0,
  0x0C, 0x60, 0x03, 0x18, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0,
  0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x48, 0x00,
  0x32, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x63, 0x00, 0x30,
  0xC0, 0x08, 0x30, 0x06, 0x06, 0x03, 0x01, 0xC3, 0x80, 0x3F, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x23, 0xFC, 0x00, 0x27, 0x0E, 0x00,
  0x2C, 0x06, 0x00, 0x68, 0x03, 0x00, 0x78, 0x03, 0x00, 0x70, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x0E, 0x00, 0x60, 0x0F, 0x00, 0xC0, 0x0D, 0x01, 0xC0, 0x09,
  0x83, 0x80, 0x08, 0xFE, 0x00, 0x18, 0x30, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x08, 0x07, 0xF8, 0x80, 0x70, 0x64, 0x06, 0x01, 0x20, 0x60, 0x0F,
  0x03, 0x00, 0x78, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x04, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x60, 0x01, 0x82, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x80, 0x07, 0x04, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x1C,
  0x0C, 0x01, 0xE0, 0x60, 0x0B, 0x01, 0x80, 0x90, 0x0E, 0x1D, 0x80, 0x3F,
  0x8C, 0x00, 0x30, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x8F, 0xC0, 0x4C, 0x00, 0x2C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x18, 0x0C, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x08, 0x03, 0x03,
  0x01, 0x80, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x1F, 0xE0, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0xE0, 0x18, 0x00, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x01, 0x86,
  0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x18,
  0x00, 0x83, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x02, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x41, 0x80,
  0x08, 0x30, 0x03, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x06, 0x00,
  0x60, 0x80, 0x0C, 0x10, 0x03, 0x82, 0x00, 0x70, 0x40, 0x1C, 0x08, 0x02,
  0x81, 0x80, 0xD0, 0x38, 0x76, 0x03, 0xF8, 0xC0, 0x1C, 0x00, 0x00, 0xC0,
  0x01, 0xE0, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x61,
  0x00, 0x30, 0x80, 0x10, 0x40, 0x18, 0x20, 0x08, 0x10, 0x0C, 0x08, 0x04,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x03, 0x00, 0x81, 0x80, 0x40, 0x80, 0x20,
  0xC0, 0x10, 0x40, 0x08, 0x60, 0x04, 0x20, 0x02, 0x30, 0x01, 0x18, 0x00,
  0x98, 0x00, 0x4C, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x70, 0x01,
  0xC0, 0x0A, 0x00, 0x38, 0x03, 0x40, 0x0E, 0x00, 0x48, 0x01, 0xC0, 0x19,
  0x00, 0x28, 0x03, 0x20, 0x0D, 0x00, 0x44, 0x01, 0x20, 0x18, 0x80, 0x64,
  0x02, 0x10, 0x0C, 0x80, 0xC2, 0x01, 0x10, 0x18, 0x40, 0x62, 0x02, 0x08,
  0x08, 0x40, 0xC1, 0x03, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20,
  0xC0, 0x83, 0x04, 0x10, 0x10, 0x40, 0x86, 0x02, 0x18, 0x10, 0xC0, 0x42,
  0x02, 0x10, 0x08, 0xC0, 0x46, 0x01, 0x18, 0x08, 0x80, 0x22, 0x01, 0x30,
  0x04, 0xC0, 0x26, 0x00, 0x90, 0x04, 0x80, 0x16, 0x00, 0xB0, 0x02, 0xC0,
  0x14, 0x00, 0x50, 0x02, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x40, 0x30, 0x01, 0x01, 0x80,
  0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0x84, 0x00, 0x02,
  0x30, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x81,
  0x00, 0x06, 0x04, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x04, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x40,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0x00, 0x0B, 0xDE, 0x00, 0x70, 0x1C, 0x0D, 0x00, 0x3F, 0xC8, 0x00,
  0x78, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 12, 44, 12, 1, -44 },
  { 67, 12, 16, 16, 6, -44 },
  { 91, 23, 44, 22, 0, -44 },
  { 218, 23, 50, 21, -1, -46 },
  { 362, 26, 45, 32, 3, -44 },
  { 509, 19, 45, 20, -1, -44 },
  { 616, 5, 16, 9, 6, -44 },
  { 626, 16, 53, 15, 2, -43 },
  { 732, 16, 53, 15, -4, -43 },
  { 838, 15, 16, 19, 7, -46 },
  { 868, 21, 29, 24, 2, -36 },
  { 945, 7, 14, 10, -2, -6 },
  { 958, 13, 1, 16, 1, -17 },
  { 960, 3, 4, 9, 1, -4 },
  { 962, 25, 43, 18, -3, -43 },
  { 1097, 20, 45, 21, 1, -44 },
  { 1210, 11, 44, 21, 6, -44 },
  { 1271, 23, 44, 21, -2, -44 },
  { 1398, 22, 45, 21, -1, -44 },
  { 1522, 22, 44, 21, -1, -44 },
  { 1643, 23, 45, 21, -2, -44 },
  { 1773, 21, 45, 21, 1, -44 },
  { 1892, 21, 44, 21, 2, -44 },
  { 2008, 23, 45, 21, -1, -44 },
  { 2138, 21, 45, 21, 0, -44 },
  { 2257, 9, 32, 9, 0, -32 },
  { 2293, 12, 40, 10, -3, -32 },
  { 2353, 21, 25, 24, 2, -34 },
  { 2419, 21, 15, 24, 2, -29 },
  { 2459, 21, 25, 24, 2, -34 },
  { 2525, 16, 44, 15, 1, -44 },
  { 2613, 28, 49, 31, 2, -44 },
  { 2785, 20, 44, 20, -4, -44 },
  { 2895, 23, 44, 23, 0, -44 },
  { 3022, 23, 45, 21, 2, -44 },
  { 3152, 24, 44, 25, 0, -44 },
  { 3284, 23, 44, 21, 0, -44 },
  { 3411, 23, 44, 19, 0, -44 },
  { 3538, 27, 45, 28, 2, -44 },
  { 3690, 28, 44, 27, 0, -44 },
  { 3844, 18, 44, 10, -4, -44 },
  { 3943, 20, 54, 9, -9, -44 },
  { 4078, 26, 44, 21, 0, -44 },
  { 4221, 13, 44, 18, 0, -44 },
  { 4293, 37, 44, 36, 0, -44 },
  { 4497, 29, 44, 28, 0, -44 },
  { 4657, 24, 45, 27, 2, -44 },
  { 4792, 22, 44, 21, 0, -44 },
  { 4913, 24, 54, 27, 2, -44 },
  { 5075, 22, 44, 22, 0, -44 },
  { 5196, 24, 45, 21, -2, -44 },
  { 5331, 19, 44, 18, 4, -44 },
  { 5436, 25, 45, 26, 2, -44 },
  { 5577, 21, 44, 21, 5, -44 },
  { 5693, 36, 44, 36, 5, -44 },
  { 5891, 27, 44, 18, -4, -44 },
  { 6040, 19, 44, 18, 4, -44 },
  { 6145, 25, 44, 19, -3, -44 },
  { 6283, 21, 54, 17, -1, -44 },
  { 6425, 8, 44, 19, 6, -44 },
  { 6469, 22, 54, 17, -4, -44 },
  { 6618, 21, 21, 24, 2, -44 },
  { 6674, 16, 1, 16, -5, 6 },
  { 6676, 6, 10, 13, 9, -47 },
  { 6684, 21, 34, 23, 2, -33 },
  { 6774, 21, 47, 23, 0, -46 },
  { 6898, 16, 34, 16, 2, -33 },
  { 6966, 24, 47, 23, 2, -46 },
  { 7107, 17, 34, 20, 2, -33 },
  { 7180, 26, 62, 11, -8, -47 },
  { 7382, 24, 48, 23, -1, -33 },
  { 7526, 20, 46, 22, 0, -46 },
  { 7641, 11, 43, 9, 0, -43 },
  { 7701, 20, 58, 10, -8, -43 },
  { 7846, 20, 46, 18, 0, -46 },
  { 7961, 12, 46, 9, 0, -46 },
  { 8030, 31, 33, 33, 0, -33 },
  { 8158, 20, 33, 22, 0, -33 },
  { 8241, 18, 34, 22, 2, -33 },
  { 8318, 24, 47, 23, -3, -33 },
  { 8459, 21, 47, 23, 2, -33 },
  { 8583, 17, 33, 14, 0, -33 },
  { 8654, 18, 34, 17, -1, -33 },
  { 8731, 11, 41, 11, 1, -40 },
  { 8788, 19, 33, 22, 2, -32 },
  { 8867, 17, 32, 17, 3, -32 },
  { 8935, 27, 32, 28, 4, -32 },
  { 9043, 22, 32, 17, -3, -32 },
  { 9131, 28, 47, 18, -7, -32 },
  { 9296, 18, 32, 14, -2, -32 },
  { 9368, 21, 54, 19, 2, -44 },
  { 9510, 1, 61, 21, 10, -46 },
  { 9518, 21, 54, 19, -4, -44 },
  { 9660, 21, 5, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC61PT7B_H_
