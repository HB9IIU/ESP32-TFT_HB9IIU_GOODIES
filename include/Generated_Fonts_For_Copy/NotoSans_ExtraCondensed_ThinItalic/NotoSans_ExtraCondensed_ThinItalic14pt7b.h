#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x10, 0x76, 0xD0, 0x19, 0x4A, 0xF5, 0x2B, 0xD4,
  0xA5, 0x00, 0x11, 0xD4, 0xA6, 0x10, 0x86, 0x52, 0xB8, 0x80, 0xEA, 0xAB,
  0x2C, 0xEF, 0xD5, 0x59, 0xAA, 0xE0, 0x35, 0x55, 0x26, 0xB9, 0x9F, 0xF0,
  0x12, 0x24, 0x48, 0x88, 0x88, 0x84, 0x21, 0x11, 0x11, 0x11, 0x22, 0x48,
  0x59, 0xE0, 0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80, 0x04, 0x10, 0x84,
  0x10, 0x82, 0x10, 0x42, 0x00, 0x3A, 0x52, 0x98, 0xC6, 0x52, 0x97, 0x00,
  0x3C, 0x94, 0x92, 0x90, 0x78, 0x42, 0x11, 0x08, 0x88, 0x87, 0x00, 0x78,
  0x42, 0x13, 0x08, 0x42, 0x17, 0x00, 0x08, 0xCA, 0x65, 0x2A, 0x5E, 0x21,
  0x00, 0x3A, 0x10, 0x86, 0x08, 0x42, 0x17, 0x00, 0x39, 0x10, 0x87, 0x46,
  0x32, 0x97, 0x00, 0xF1, 0x12, 0x24, 0x48, 0x88, 0x3A, 0x52, 0x93, 0x2A,
  0x52, 0x97, 0x80, 0x3A, 0x53, 0x18, 0xB8, 0x42, 0x17, 0x00, 0x40, 0x08,
  0x20, 0x00, 0x12, 0x80, 0x09, 0xB0, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0xC1,
  0x06, 0x32, 0x60, 0x71, 0x12, 0x24, 0x48, 0x08, 0x1C, 0x45, 0x0A, 0xD6,
  0xB5, 0x6A, 0xDA, 0x89, 0x01, 0xC0, 0x08, 0x46, 0x52, 0x9D, 0x29, 0x8C,
  0x40, 0x39, 0x52, 0x97, 0x26, 0x31, 0x97, 0x00, 0x3A, 0x21, 0x08, 0x42,
  0x10, 0x87, 0x00, 0x39, 0x52, 0x94, 0xA6, 0x31, 0x97, 0x00, 0x39, 0x10,
  0x87, 0x22, 0x10, 0x87, 0x00, 0x39, 0x10, 0x84, 0x3A, 0x10, 0x84, 0x00,
  0x1E, 0x41, 0x02, 0x08, 0x11, 0xA1, 0x44, 0x88, 0xF0, 0x24, 0x94, 0x51,
  0x75, 0x28, 0xA2, 0x8A, 0x20, 0x32, 0x22, 0x22, 0x44, 0x4C, 0x08, 0x44,
  0x21, 0x08, 0x84, 0x21, 0x09, 0x80, 0x24, 0xA5, 0x14, 0x61, 0x8A, 0x24,
  0x92, 0x40, 0x25, 0x24, 0xA4, 0x9C, 0x21, 0x21, 0x23, 0x63, 0x65, 0x65,
  0xAA, 0xAA, 0xB2, 0x92, 0x22, 0x45, 0x92, 0xA5, 0x4A, 0xA5, 0x4C, 0x89,
  0x10, 0x3C, 0x94, 0x51, 0x46, 0x18, 0x62, 0x89, 0xC0, 0x39, 0x52, 0x94,
  0xBA, 0x10, 0x84, 0x00, 0x3C, 0x94, 0x51, 0x46, 0x18, 0x62, 0x89, 0x42,
  0x04, 0x39, 0x52, 0x94, 0xBA, 0x92, 0x94, 0x80, 0x3A, 0x10, 0x82, 0x10,
  0x42, 0x17, 0x00, 0xF4, 0x44, 0x44, 0x88, 0x88, 0x25, 0x14, 0x51, 0x45,
  0x28, 0xA2, 0x89, 0xC0, 0x8C, 0x65, 0x2A, 0x53, 0x18, 0x84, 0x00, 0x89,
  0x91, 0x91, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8, 0x88, 0x88, 0x24, 0x91, 0x84,
  0x10, 0x43, 0x14, 0x52, 0x40, 0x99, 0xAA, 0xC8, 0x88, 0x88, 0x1C, 0x10,
  0x82, 0x10, 0x82, 0x10, 0x43, 0xC0, 0x39, 0x10, 0x84, 0x21, 0x10, 0x84,
  0x21, 0x80, 0xA9, 0x55, 0x50, 0x18, 0x42, 0x11, 0x08, 0x42, 0x11, 0x09,
  0xC0, 0x21, 0x92, 0x98, 0x80, 0xF0, 0xE0, 0x32, 0x53, 0x18, 0xCA, 0x5E,
  0x21, 0x08, 0xA6, 0xA5, 0x31, 0x8C, 0xBC, 0x34, 0x48, 0x88, 0x8E, 0x04,
  0x10, 0x4E, 0x49, 0x28, 0xA2, 0x92, 0x4F, 0x00, 0x35, 0x59, 0xE8, 0x8F,
  0x04, 0x20, 0x86, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x23, 0x00, 0x32,
  0x53, 0x18, 0xCA, 0x5E, 0x10, 0xB8, 0x21, 0x08, 0xA6, 0xA5, 0x2A, 0x94,
  0xA4, 0x20, 0x24, 0x94, 0x90, 0x08, 0x00, 0x21, 0x08, 0x44, 0x21, 0x08,
  0x4C, 0x00, 0x21, 0x08, 0x95, 0x29, 0x8C, 0xA5, 0x28, 0x24, 0xA4, 0x94,
  0x92, 0x00, 0x34, 0x95, 0x2A, 0x99, 0x32, 0x64, 0xCA, 0x32, 0x52, 0x99,
  0x4A, 0x52, 0x32, 0x53, 0x18, 0xCA, 0x5C, 0x08, 0xD2, 0x49, 0x25, 0x14,
  0x9E, 0x42, 0x08, 0x00, 0x32, 0x53, 0x18, 0xCA, 0x5E, 0x10, 0x88, 0x16,
  0x44, 0x88, 0x88, 0x34, 0x84, 0x22, 0x2E, 0x4D, 0x25, 0x24, 0xC0, 0x4A,
  0x53, 0x29, 0x4B, 0x80, 0xB6, 0xE9, 0x20, 0xA6, 0x9D, 0xB6, 0x92, 0x49,
  0x00, 0x29, 0x44, 0x42, 0x2A, 0x40, 0x12, 0x28, 0x50, 0xC1, 0x82, 0x04,
  0x08, 0x21, 0xC0, 0x72, 0x24, 0x88, 0xC0, 0x18, 0x88, 0x42, 0x13, 0x08,
  0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x10, 0x44, 0x21, 0x08, 0x64, 0x21, 0x09,
  0x80, 0x64, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 4, 1, -10 },
  { 7, 5, 10, 5, 0, -10 },
  { 14, 5, 12, 5, 0, -11 },
  { 22, 6, 10, 7, 1, -10 },
  { 30, 4, 10, 5, 0, -10 },
  { 35, 1, 4, 2, 1, -10 },
  { 36, 4, 12, 3, 0, -10 },
  { 42, 4, 12, 3, -1, -10 },
  { 48, 3, 4, 4, 2, -11 },
  { 50, 5, 6, 6, 0, -8 },
  { 54, 2, 3, 2, -1, -1 },
  { 55, 3, 1, 4, 0, -4 },
  { 56, 1, 1, 2, 0, -1 },
  { 57, 6, 10, 4, -1, -10 },
  { 65, 5, 10, 5, 0, -10 },
  { 72, 3, 10, 5, 1, -10 },
  { 76, 5, 10, 5, 0, -10 },
  { 83, 5, 10, 5, 0, -10 },
  { 90, 5, 10, 5, 0, -10 },
  { 97, 5, 10, 5, 0, -10 },
  { 104, 5, 10, 5, 0, -10 },
  { 111, 4, 10, 5, 1, -10 },
  { 116, 5, 10, 5, 0, -10 },
  { 123, 5, 10, 5, 0, -10 },
  { 130, 2, 7, 2, 0, -7 },
  { 132, 3, 9, 2, -1, -7 },
  { 136, 5, 6, 6, 0, -8 },
  { 140, 5, 4, 6, 0, -7 },
  { 143, 5, 6, 6, 0, -8 },
  { 147, 4, 10, 3, 0, -10 },
  { 152, 7, 11, 7, 0, -10 },
  { 162, 5, 10, 5, -1, -10 },
  { 169, 5, 10, 5, 0, -10 },
  { 176, 5, 10, 5, 1, -10 },
  { 183, 5, 10, 6, 0, -10 },
  { 190, 5, 10, 5, 0, -10 },
  { 197, 5, 10, 4, 0, -10 },
  { 204, 7, 10, 6, 0, -10 },
  { 213, 6, 10, 6, 0, -10 },
  { 221, 4, 10, 2, -1, -10 },
  { 226, 5, 12, 2, -2, -10 },
  { 234, 6, 10, 5, 0, -10 },
  { 242, 3, 10, 4, 0, -10 },
  { 246, 8, 10, 8, 0, -10 },
  { 256, 7, 10, 6, 0, -10 },
  { 265, 6, 10, 6, 0, -10 },
  { 273, 5, 10, 5, 0, -10 },
  { 280, 6, 12, 6, 0, -10 },
  { 289, 5, 10, 5, 0, -10 },
  { 296, 5, 10, 5, 0, -10 },
  { 303, 4, 10, 4, 1, -10 },
  { 308, 6, 10, 6, 0, -10 },
  { 316, 5, 10, 5, 1, -10 },
  { 323, 8, 10, 8, 1, -10 },
  { 333, 6, 10, 4, -1, -10 },
  { 341, 4, 10, 4, 1, -10 },
  { 346, 6, 10, 4, -1, -10 },
  { 354, 5, 12, 4, 0, -10 },
  { 362, 2, 10, 4, 1, -10 },
  { 365, 5, 12, 4, -1, -10 },
  { 373, 5, 5, 5, 0, -10 },
  { 377, 4, 1, 4, -1, 1 },
  { 378, 1, 3, 3, 2, -11 },
  { 379, 5, 8, 5, 0, -8 },
  { 384, 5, 11, 5, 0, -11 },
  { 391, 4, 8, 4, 0, -8 },
  { 395, 6, 11, 5, 0, -11 },
  { 404, 4, 8, 5, 0, -8 },
  { 408, 6, 14, 3, -2, -11 },
  { 419, 5, 11, 5, 0, -8 },
  { 426, 5, 11, 5, 0, -11 },
  { 433, 3, 10, 2, 0, -10 },
  { 437, 5, 13, 2, -2, -10 },
  { 446, 5, 11, 4, 0, -11 },
  { 453, 3, 11, 2, 0, -11 },
  { 458, 7, 8, 8, 0, -8 },
  { 465, 5, 8, 5, 0, -8 },
  { 470, 5, 8, 5, 0, -8 },
  { 475, 6, 11, 5, -1, -8 },
  { 484, 5, 11, 5, 0, -8 },
  { 491, 4, 8, 3, 0, -8 },
  { 495, 4, 8, 4, 0, -8 },
  { 499, 3, 9, 3, 0, -9 },
  { 503, 5, 7, 5, 0, -7 },
  { 508, 3, 7, 4, 1, -7 },
  { 511, 6, 7, 6, 1, -7 },
  { 517, 5, 7, 4, -1, -7 },
  { 522, 7, 10, 4, -2, -7 },
  { 531, 4, 7, 3, 0, -7 },
  { 535, 5, 12, 4, 0, -10 },
  { 543, 1, 14, 5, 2, -11 },
  { 545, 5, 12, 4, -1, -10 },
  { 553, 5, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC14PT7B_H_
