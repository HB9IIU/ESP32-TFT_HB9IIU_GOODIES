#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x00, 0x08, 0x80,
  0x4A, 0x52, 0xA9, 0x48, 0x04, 0x82, 0x42, 0x41, 0x20, 0x91, 0xBC, 0x48,
  0x24, 0x22, 0x12, 0x09, 0x1F, 0xC4, 0x82, 0x41, 0x21, 0x20, 0x90, 0x00,
  0x02, 0x01, 0x07, 0x64, 0x82, 0x41, 0x20, 0xA0, 0x50, 0x18, 0x04, 0x03,
  0x02, 0x81, 0x20, 0x90, 0x48, 0x28, 0xF8, 0x10, 0x08, 0x00, 0x38, 0x49,
  0x11, 0x22, 0x24, 0x88, 0x91, 0x14, 0x22, 0xA4, 0xAA, 0x95, 0x35, 0x45,
  0x28, 0x89, 0x21, 0x44, 0x48, 0x89, 0x12, 0x24, 0x43, 0x00, 0x0E, 0x24,
  0x48, 0x91, 0x42, 0x86, 0x08, 0x30, 0x91, 0x2C, 0x58, 0xB0, 0xA1, 0x46,
  0xF4, 0x55, 0xA0, 0x04, 0x21, 0x04, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x08, 0x00, 0x12, 0x86, 0xCC, 0x52, 0x60, 0x10, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25, 0x28, 0xF8, 0x60, 0x00, 0xC0,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x11, 0x11, 0x21,
  0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82, 0x84, 0x84, 0x48,
  0x70, 0x35, 0xA2, 0x22, 0x24, 0x44, 0x48, 0x88, 0x88, 0x80, 0x0F, 0x00,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x00, 0x80, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x04, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0xFC, 0x00, 0x01, 0x03, 0x05, 0x05, 0x09, 0x0A, 0x12, 0x22, 0x22, 0x44,
  0x44, 0x84, 0xFE, 0x04, 0x08, 0x08, 0x08, 0x0F, 0x84, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x3C, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0xFC, 0x00, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x40, 0x90, 0xEC, 0x84,
  0x84, 0x84, 0x84, 0x84, 0x84, 0x84, 0x88, 0xF0, 0x7F, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80,
  0x80, 0x1F, 0x21, 0x21, 0x21, 0x21, 0x21, 0x12, 0x14, 0x18, 0x64, 0x82,
  0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x1E, 0x11, 0x21, 0x21, 0x41, 0x41,
  0x41, 0x41, 0x43, 0x3E, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x12,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x44, 0x21, 0x10, 0x03, 0x0C, 0x30, 0x40, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x04,
  0x18, 0x20, 0xC0, 0x3C, 0x04, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41,
  0x02, 0x04, 0x00, 0x00, 0x20, 0x80, 0x07, 0x83, 0x08, 0x40, 0x90, 0x14,
  0x22, 0x8A, 0x52, 0x4C, 0x89, 0x92, 0x32, 0x4A, 0x89, 0x51, 0x2A, 0x49,
  0x36, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0xE0, 0x00, 0x01, 0x01, 0x03,
  0x03, 0x05, 0x05, 0x09, 0x09, 0x09, 0x1F, 0x11, 0x21, 0x21, 0x21, 0x41,
  0x41, 0x81, 0x1F, 0x08, 0x44, 0x22, 0x11, 0x09, 0x04, 0x84, 0x64, 0x2E,
  0x20, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x09, 0x08, 0xF8, 0x00, 0x0F, 0x88,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x78, 0x00, 0x1F, 0x08, 0x44, 0x22, 0x11, 0x09,
  0x04, 0x82, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x24, 0x12, 0x12, 0x09, 0x08,
  0xF8, 0x00, 0x1F, 0x88, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x7C, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0xFC, 0x00, 0x1F, 0x88,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x3E, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x00, 0x0F, 0xC4, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x83, 0x20, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48,
  0x11, 0x08, 0x3E, 0x00, 0x10, 0x22, 0x04, 0x40, 0x88, 0x21, 0x04, 0x40,
  0x88, 0x11, 0xFC, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x20,
  0x44, 0x08, 0x81, 0x00, 0x1E, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0xE0, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x0C, 0x00, 0x10, 0x44, 0x21, 0x10, 0x48, 0x12, 0x09, 0x02, 0x80, 0xA0,
  0x38, 0x0A, 0x04, 0x81, 0x10, 0x44, 0x11, 0x08, 0x42, 0x10, 0x82, 0x00,
  0x10, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x84, 0x22, 0x10, 0xF8, 0x08,
  0x04, 0x60, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x14, 0xA0, 0x62, 0x82, 0x8A,
  0x0A, 0x28, 0x49, 0x21, 0x24, 0x89, 0x12, 0x24, 0x49, 0x11, 0x14, 0x48,
  0x62, 0x21, 0x88, 0x84, 0x20, 0x08, 0x23, 0x04, 0x60, 0x8C, 0x11, 0x42,
  0x48, 0x89, 0x11, 0x22, 0x24, 0x48, 0x89, 0x0A, 0x21, 0x44, 0x28, 0x85,
  0x20, 0xC4, 0x08, 0x81, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0x0A, 0x05,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08, 0x78,
  0x00, 0x1F, 0x08, 0x84, 0x22, 0x11, 0x09, 0x04, 0x84, 0x42, 0x26, 0x18,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x08, 0x48,
  0x24, 0x14, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14,
  0x12, 0x09, 0x08, 0x68, 0x08, 0x02, 0x01, 0x00, 0x80, 0x1F, 0x08, 0x44,
  0x22, 0x11, 0x09, 0x04, 0x84, 0x42, 0x26, 0x2C, 0x12, 0x08, 0x84, 0x42,
  0x22, 0x11, 0x08, 0x84, 0x00, 0x0F, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0xFC, 0x00, 0xFE, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x80, 0x20, 0x48, 0x22, 0x08, 0x82, 0x40,
  0x90, 0x24, 0x11, 0x04, 0x41, 0x20, 0x48, 0x22, 0x08, 0x82, 0x20, 0x88,
  0x42, 0x10, 0x78, 0x00, 0x81, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88,
  0x88, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x82, 0x06, 0x08,
  0x18, 0x20, 0xA1, 0x42, 0x86, 0x12, 0x28, 0x48, 0xA1, 0x22, 0x88, 0x92,
  0x22, 0x49, 0x0A, 0x24, 0x28, 0x90, 0xA2, 0x83, 0x0A, 0x0C, 0x30, 0x20,
  0xC0, 0x82, 0x00, 0x08, 0x42, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xA0,
  0x10, 0x0C, 0x03, 0x01, 0x40, 0x50, 0x24, 0x11, 0x04, 0x42, 0x10, 0x84,
  0x00, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50, 0x60, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x0F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00,
  0xFC, 0x00, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0xF0, 0x84,
  0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x21, 0x10, 0x0F, 0x01, 0x01, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0xF0, 0x18, 0x18, 0x24, 0x24, 0x42, 0x42, 0x81,
  0x81, 0xFC, 0xC8, 0x80, 0x1D, 0x23, 0x42, 0x42, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x84, 0x8C, 0xF4, 0x08, 0x10, 0x10, 0x10, 0x10, 0x1E, 0x31,
  0x31, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0xC4, 0xB8, 0x1C,
  0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0xE8, 0x8C, 0x84, 0x42, 0x41, 0x20, 0x90, 0x48, 0x24,
  0x22, 0x11, 0x08, 0x8C, 0x7A, 0x00, 0x1C, 0x94, 0x51, 0x86, 0x2F, 0x20,
  0x82, 0x08, 0x20, 0xF8, 0x01, 0xC0, 0x40, 0x20, 0x08, 0x02, 0x03, 0xC0,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x03, 0x00, 0x0E, 0x88,
  0xC8, 0x44, 0x24, 0x12, 0x09, 0x04, 0x82, 0x42, 0x21, 0x10, 0x88, 0xC7,
  0xC0, 0x20, 0x10, 0x08, 0x08, 0x44, 0x3C, 0x00, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x1E, 0x11, 0x21, 0x21, 0x21, 0x22, 0x42, 0x42, 0x42, 0x42, 0x44,
  0x84, 0x84, 0x11, 0x00, 0x12, 0x22, 0x22, 0x44, 0x44, 0x88, 0x80, 0x01,
  0x02, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x11, 0x22, 0x22, 0x24, 0x28, 0x30, 0x68, 0x48, 0x48,
  0x48, 0x88, 0x88, 0x84, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84,
  0x21, 0x10, 0x84, 0x00, 0x1E, 0x61, 0x19, 0x21, 0x12, 0x11, 0x21, 0x12,
  0x21, 0x42, 0x14, 0x21, 0x42, 0x24, 0x42, 0x84, 0x28, 0x42, 0x84, 0x40,
  0x1E, 0x11, 0x21, 0x21, 0x21, 0x22, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84,
  0x84, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x14, 0x4F,
  0x00, 0x0F, 0x0C, 0x46, 0x22, 0x11, 0x08, 0x84, 0x82, 0x41, 0x20, 0x90,
  0x88, 0x4C, 0x45, 0xC2, 0x01, 0x01, 0x00, 0x80, 0x40, 0x00, 0x1D, 0x23,
  0x42, 0x42, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF8, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x1E, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x00, 0x1E, 0x41, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x4F, 0x00, 0x10, 0x84, 0xF2, 0x10, 0x84, 0x42, 0x10,
  0x84, 0x42, 0x0C, 0x22, 0x85, 0x0A, 0x14, 0x28, 0xA1, 0x42, 0x85, 0x0A,
  0x24, 0x4F, 0x80, 0x83, 0x0A, 0x14, 0x48, 0x91, 0x24, 0x48, 0xA1, 0x43,
  0x06, 0x08, 0x00, 0x84, 0x30, 0x86, 0x11, 0x46, 0x28, 0xC5, 0x29, 0x25,
  0x24, 0xA4, 0xA5, 0x14, 0xA3, 0x18, 0x61, 0x08, 0x40, 0x10, 0x88, 0x84,
  0x82, 0x41, 0x40, 0x40, 0x20, 0x30, 0x18, 0x12, 0x11, 0x08, 0x88, 0x40,
  0x04, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x09, 0x01, 0x20, 0x28, 0x05,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x03, 0x80, 0x00, 0x1E, 0x04, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41,
  0x02, 0x0F, 0x80, 0x07, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0xC0, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x30,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xE0, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x0E, 0x00, 0xFF,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 17, 5, 0, -17 },
  { 12, 5, 6, 6, 2, -17 },
  { 16, 9, 17, 9, 0, -17 },
  { 36, 9, 19, 8, 0, -18 },
  { 58, 11, 17, 12, 1, -17 },
  { 82, 7, 17, 8, 0, -17 },
  { 97, 2, 6, 3, 2, -17 },
  { 99, 6, 21, 6, 1, -17 },
  { 115, 7, 21, 6, -2, -17 },
  { 134, 6, 6, 8, 3, -18 },
  { 139, 8, 11, 10, 1, -14 },
  { 150, 3, 5, 4, -1, -2 },
  { 152, 5, 1, 6, 1, -7 },
  { 153, 2, 2, 4, 0, -2 },
  { 154, 10, 17, 7, -1, -17 },
  { 176, 8, 17, 8, 0, -17 },
  { 193, 4, 17, 8, 3, -17 },
  { 202, 9, 17, 8, -1, -17 },
  { 222, 9, 17, 8, -1, -17 },
  { 242, 8, 17, 8, 0, -17 },
  { 259, 9, 17, 8, -1, -17 },
  { 279, 8, 17, 8, 1, -17 },
  { 296, 8, 17, 8, 1, -17 },
  { 313, 8, 17, 8, 0, -17 },
  { 330, 8, 17, 8, 0, -17 },
  { 347, 4, 13, 4, 0, -13 },
  { 354, 5, 16, 4, -1, -13 },
  { 364, 8, 9, 10, 1, -13 },
  { 373, 8, 5, 10, 1, -11 },
  { 378, 8, 9, 10, 1, -13 },
  { 387, 7, 17, 6, 0, -17 },
  { 402, 11, 19, 12, 1, -17 },
  { 429, 8, 17, 8, -2, -17 },
  { 446, 9, 17, 9, 0, -17 },
  { 466, 9, 17, 8, 1, -17 },
  { 486, 9, 17, 10, 0, -17 },
  { 506, 9, 17, 8, 0, -17 },
  { 526, 9, 17, 7, 0, -17 },
  { 546, 10, 17, 11, 1, -17 },
  { 568, 11, 17, 11, 0, -17 },
  { 592, 7, 17, 4, -1, -17 },
  { 607, 7, 21, 4, -3, -17 },
  { 626, 10, 17, 8, 0, -17 },
  { 648, 5, 17, 7, 0, -17 },
  { 659, 14, 17, 14, 0, -17 },
  { 689, 11, 17, 11, 0, -17 },
  { 713, 9, 17, 11, 1, -17 },
  { 733, 9, 17, 8, 0, -17 },
  { 753, 9, 21, 11, 1, -17 },
  { 777, 9, 17, 9, 0, -17 },
  { 797, 10, 17, 8, -1, -17 },
  { 819, 7, 17, 7, 2, -17 },
  { 834, 10, 17, 10, 1, -17 },
  { 856, 8, 17, 8, 2, -17 },
  { 873, 14, 17, 14, 2, -17 },
  { 903, 10, 17, 7, -1, -17 },
  { 925, 7, 17, 7, 2, -17 },
  { 940, 10, 17, 7, -1, -17 },
  { 962, 8, 21, 7, 0, -17 },
  { 983, 4, 17, 8, 2, -17 },
  { 992, 8, 21, 7, -1, -17 },
  { 1013, 8, 8, 9, 1, -17 },
  { 1021, 6, 1, 6, -2, 2 },
  { 1022, 3, 3, 5, 3, -18 },
  { 1024, 8, 13, 9, 1, -13 },
  { 1037, 8, 18, 9, 0, -18 },
  { 1055, 6, 13, 6, 1, -13 },
  { 1065, 9, 18, 9, 1, -18 },
  { 1086, 6, 13, 8, 1, -13 },
  { 1096, 10, 24, 4, -3, -18 },
  { 1126, 9, 19, 9, 0, -13 },
  { 1148, 8, 18, 9, 0, -18 },
  { 1166, 4, 17, 4, 0, -17 },
  { 1175, 8, 23, 4, -3, -17 },
  { 1198, 8, 18, 7, 0, -18 },
  { 1216, 5, 18, 4, 0, -18 },
  { 1228, 12, 13, 13, 0, -13 },
  { 1248, 8, 13, 9, 0, -13 },
  { 1261, 7, 13, 9, 1, -13 },
  { 1273, 9, 18, 9, -1, -13 },
  { 1294, 8, 19, 9, 1, -13 },
  { 1313, 7, 13, 6, 0, -13 },
  { 1325, 7, 13, 7, 0, -13 },
  { 1337, 5, 16, 4, 0, -16 },
  { 1347, 7, 13, 9, 1, -13 },
  { 1359, 7, 13, 7, 1, -13 },
  { 1371, 11, 13, 11, 1, -13 },
  { 1389, 9, 13, 7, -1, -13 },
  { 1404, 11, 19, 7, -3, -13 },
  { 1431, 7, 13, 6, -1, -13 },
  { 1443, 8, 21, 7, 1, -17 },
  { 1464, 1, 24, 8, 4, -18 },
  { 1467, 9, 21, 7, -2, -17 },
  { 1491, 8, 1, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC24PT7B_H_
