#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81, 0x00,
  0x46, 0x89, 0x12, 0x28, 0x51, 0x22, 0x44, 0x88, 0x00, 0x84, 0x02, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x08, 0x08, 0x40, 0x21, 0x07, 0xFF, 0x04, 0x20,
  0x10, 0x80, 0x42, 0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x88, 0x04, 0x20,
  0xFF, 0xF0, 0x42, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x08, 0x04, 0x20,
  0x10, 0x80, 0x44, 0x02, 0x10, 0x00, 0x00, 0x40, 0x02, 0x00, 0x10, 0x07,
  0xE0, 0x48, 0x84, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x12, 0x00, 0x90, 0x03, 0x00, 0x08, 0x00, 0x60, 0x02, 0x80, 0x14, 0x01,
  0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x86, 0x58,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x02, 0x12, 0x04, 0x21,
  0x04, 0x21, 0x08, 0x41, 0x08, 0x41, 0x10, 0x42, 0x10, 0x82, 0x20, 0x82,
  0x20, 0x82, 0x40, 0x82, 0x40, 0x84, 0x8E, 0x84, 0x93, 0x85, 0x21, 0x89,
  0x21, 0x92, 0x41, 0x62, 0x41, 0x04, 0x43, 0x04, 0x82, 0x08, 0x82, 0x08,
  0x82, 0x10, 0x82, 0x10, 0x84, 0x30, 0x84, 0x20, 0x84, 0x60, 0x88, 0x40,
  0xF0, 0x01, 0x80, 0x48, 0x11, 0x82, 0x10, 0xC6, 0x10, 0x82, 0x10, 0x42,
  0x08, 0x81, 0x10, 0x14, 0x03, 0x00, 0x60, 0x18, 0x04, 0x81, 0x90, 0x22,
  0x28, 0x47, 0x04, 0xC0, 0xA8, 0x15, 0x03, 0x20, 0x24, 0x0C, 0x81, 0x90,
  0x51, 0xF3, 0x00, 0x55, 0xAA, 0x80, 0x00, 0xC0, 0x40, 0x10, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x01, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x02,
  0x03, 0x00, 0x04, 0x01, 0x08, 0x41, 0x90, 0x1B, 0xC3, 0x01, 0x40, 0x88,
  0x42, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x07, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x12, 0x22, 0x44, 0x88, 0xFF,
  0xE0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x26, 0x04, 0x20, 0x82, 0x10, 0x11, 0x01, 0x10,
  0x12, 0x03, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x08, 0x81,
  0x08, 0x10, 0x82, 0x0C, 0x40, 0x78, 0x00, 0x0C, 0x52, 0x71, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x00, 0x00, 0xE0, 0x18, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x18, 0x60, 0x40, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x1E, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC2, 0x06,
  0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x28,
  0x01, 0x20, 0x04, 0x80, 0x24, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x84,
  0x04, 0x20, 0x20, 0x80, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x04,
  0x10, 0x10, 0xFF, 0xF0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x60, 0x06, 0x70,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x81, 0x83, 0xF8,
  0x00, 0x00, 0xF0, 0x31, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0xF0, 0x50, 0x86, 0x04, 0xC0, 0x4C,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x80, 0x88,
  0x08, 0x81, 0x04, 0x20, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x31, 0x83, 0x06, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x10, 0x40, 0x82, 0x08, 0x08, 0x80, 0x78, 0x03, 0x80,
  0x64, 0x06, 0x10, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x48, 0x02, 0x40,
  0x12, 0x01, 0x10, 0x08, 0x80, 0xC2, 0x04, 0x0F, 0xC0, 0x01, 0xC0, 0x62,
  0x0C, 0x10, 0x81, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01,
  0x20, 0x12, 0x01, 0x20, 0x32, 0x03, 0x10, 0x51, 0x9A, 0x06, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0xF8, 0x00, 0x08, 0x42, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x31, 0x80, 0x02, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x00, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x10, 0x00, 0x07,
  0x06, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x10, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x73, 0x00, 0x40, 0x40, 0x40, 0x20, 0x40, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x20, 0x01, 0x10, 0x78, 0x90, 0x44, 0x48, 0x44, 0x28, 0x42, 0x14, 0x21,
  0x0A, 0x10, 0x85, 0x10, 0x85, 0x88, 0x42, 0x84, 0x21, 0x42, 0x10, 0xA3,
  0x18, 0x91, 0x08, 0x48, 0x4C, 0x44, 0x25, 0x62, 0x0C, 0xC1, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x24, 0x01,
  0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81, 0x04,
  0x08, 0x20, 0x81, 0x07, 0xF8, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88,
  0x04, 0x80, 0x24, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x02, 0x07, 0xF0, 0x10,
  0x20, 0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0x10, 0x80, 0x42, 0x03, 0x08,
  0x08, 0x20, 0x61, 0x03, 0x04, 0x38, 0x1F, 0xC0, 0x41, 0x81, 0x02, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x84,
  0x06, 0x10, 0x10, 0x81, 0x83, 0xF8, 0x00, 0x00, 0x78, 0x06, 0x10, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x41, 0x00, 0x82, 0x01, 0x04, 0x03, 0x08, 0x04,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x10,
  0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04,
  0x10, 0x10, 0x20, 0x40, 0x83, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x1F, 0xE0, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0x82, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xE1, 0xC0, 0xC0, 0x40, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x01, 0xF1,
  0x80, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x86, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x60, 0x10, 0x18, 0x08, 0x07,
  0xF8, 0x00, 0x06, 0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x40, 0x08, 0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x04,
  0x01, 0x02, 0x00, 0x81, 0xFF, 0xC0, 0x80, 0x20, 0x80, 0x10, 0x40, 0x10,
  0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x01, 0x02, 0x00,
  0x81, 0x00, 0x40, 0x80, 0x20, 0x80, 0x10, 0x40, 0x10, 0x00, 0x07, 0xE0,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x1F, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x0F, 0x00, 0x06, 0x02,
  0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x41, 0x01, 0x04, 0x02, 0x10, 0x04,
  0x60, 0x08, 0x80, 0x12, 0x00, 0x48, 0x00, 0x90, 0x01, 0x60, 0x03, 0x40,
  0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x82, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x80, 0x41, 0x00, 0x80, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0xFF, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0x41, 0x80, 0x06,
  0x06, 0x00, 0x28, 0x28, 0x00, 0xA0, 0x90, 0x04, 0x82, 0x40, 0x12, 0x09,
  0x00, 0x90, 0x24, 0x02, 0x41, 0x10, 0x19, 0x04, 0x40, 0x44, 0x11, 0x03,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x08, 0x41, 0x08, 0x21, 0x04, 0x20,
  0x84, 0x21, 0x02, 0x10, 0x84, 0x10, 0x44, 0x10, 0x41, 0x10, 0x41, 0x04,
  0x81, 0x04, 0x12, 0x08, 0x10, 0x50, 0x20, 0x81, 0x40, 0x82, 0x02, 0x02,
  0x00, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x08, 0x14, 0x02, 0x05, 0x00,
  0x82, 0x40, 0x40, 0x90, 0x10, 0x24, 0x04, 0x08, 0x81, 0x02, 0x20, 0x81,
  0x08, 0x20, 0x42, 0x08, 0x10, 0x82, 0x04, 0x20, 0x81, 0x04, 0x40, 0x81,
  0x10, 0x20, 0x44, 0x08, 0x11, 0x02, 0x04, 0x41, 0x00, 0xA0, 0x40, 0x28,
  0x10, 0x0A, 0x04, 0x02, 0x81, 0x00, 0xC0, 0x80, 0x30, 0x20, 0x04, 0x00,
  0x00, 0xF0, 0x02, 0x10, 0x08, 0x10, 0x20, 0x20, 0x80, 0x61, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x12, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0xC0, 0x09, 0x00, 0x12, 0x00, 0x24,
  0x00, 0xC8, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x40, 0x40, 0xC1,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x10, 0x60, 0x40, 0x81, 0x02, 0x04, 0x0C,
  0x20, 0x30, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x21, 0x01, 0x04, 0x04,
  0x10, 0x60, 0x47, 0x01, 0xE0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x00, 0x00, 0xF0, 0x02, 0x10, 0x08, 0x10, 0x20, 0x20, 0x80, 0x61, 0x00,
  0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x12, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0xC0, 0x09, 0x00, 0x12, 0x00,
  0x24, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x20, 0x08, 0x20, 0x10, 0x40, 0x40,
  0xC1, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x07, 0xF0, 0x20, 0xC1, 0x02, 0x08, 0x10, 0x40, 0x84,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x04, 0x20, 0x61, 0x06,
  0x0F, 0xC0, 0x44, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x81, 0x04,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x80, 0x44, 0x02, 0x00, 0x00, 0x70,
  0x06, 0x1C, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x41, 0x01, 0x03, 0xFC,
  0x00, 0x7F, 0xF0, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x0C, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x11,
  0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x40, 0x10, 0x80,
  0x21, 0x00, 0x42, 0x00, 0x84, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10,
  0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40,
  0x60, 0x40, 0x80, 0x7E, 0x00, 0x80, 0x1C, 0x00, 0xA0, 0x09, 0x00, 0x48,
  0x06, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x20, 0x41, 0x02, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x22, 0x01,
  0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x80, 0x30, 0x0E, 0x00, 0x80, 0x28, 0x06, 0x00, 0xA0, 0x18, 0x04, 0x80,
  0x60, 0x12, 0x02, 0x80, 0x88, 0x0A, 0x02, 0x20, 0x48, 0x08, 0x81, 0x20,
  0x42, 0x04, 0x81, 0x08, 0x22, 0x08, 0x20, 0x88, 0x20, 0x84, 0x20, 0x82,
  0x10, 0x84, 0x08, 0x42, 0x10, 0x22, 0x08, 0x80, 0x88, 0x22, 0x02, 0x40,
  0x88, 0x09, 0x02, 0x40, 0x24, 0x09, 0x00, 0xA0, 0x28, 0x02, 0x80, 0xA0,
  0x0E, 0x02, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x80, 0x00,
  0x02, 0x03, 0x01, 0x02, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x08, 0x40, 0x10, 0x40, 0x20, 0x40, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x40, 0x40, 0x34, 0x02, 0x40, 0x44, 0x04, 0x40, 0x82,
  0x08, 0x21, 0x02, 0x10, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x28, 0x02,
  0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x1F, 0xC0,
  0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x21, 0x04,
  0x21, 0x08, 0x42, 0x10, 0x40, 0x03, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x1F, 0x80, 0x03, 0x00, 0x28,
  0x01, 0x20, 0x11, 0x00, 0x84, 0x08, 0x20, 0x41, 0x84, 0x04, 0x20, 0x22,
  0x00, 0x90, 0x05, 0x00, 0x10, 0xFF, 0xC0, 0xC4, 0x42, 0x11, 0x03, 0x80,
  0x22, 0x42, 0x0C, 0x20, 0x63, 0x03, 0x10, 0x18, 0x80, 0x88, 0x04, 0x40,
  0x22, 0x01, 0x30, 0x09, 0x00, 0x88, 0x04, 0x40, 0x22, 0x03, 0x10, 0x18,
  0x80, 0x84, 0x0C, 0x10, 0xA0, 0xF9, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0xE0, 0x59, 0x83,
  0x04, 0x18, 0x11, 0x80, 0x8C, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00,
  0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x11, 0x80, 0x8C, 0x04, 0x60, 0x43,
  0x06, 0x28, 0x21, 0x3E, 0x00, 0x03, 0xC3, 0x10, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0x88, 0x11, 0x40,
  0x83, 0x04, 0x0C, 0x30, 0x30, 0x80, 0xC2, 0x02, 0x10, 0x08, 0x40, 0x21,
  0x00, 0x8C, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x0C, 0x20, 0x30,
  0x81, 0x82, 0x06, 0x04, 0x28, 0x1F, 0x20, 0x03, 0x83, 0x10, 0x84, 0x41,
  0x20, 0x48, 0x14, 0x05, 0x02, 0x41, 0x13, 0x8F, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x10, 0xF8, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x01, 0xD8, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x02, 0x24, 0x08, 0x30, 0x20, 0x60, 0xC0, 0xC1, 0x01, 0x82, 0x02, 0x08,
  0x04, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x82, 0x01, 0x04, 0x02,
  0x08, 0x0C, 0x10, 0x10, 0x20, 0x60, 0x40, 0xC0, 0x42, 0x80, 0xF9, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x06, 0x18, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0xE0, 0xA3, 0x0C, 0x10, 0x81, 0x08,
  0x11, 0x81, 0x10, 0x11, 0x02, 0x10, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20,
  0x42, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x08, 0x40, 0x88, 0x08, 0x06,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x00, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0xE0, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x83, 0x08, 0x20, 0x84, 0x10, 0x81, 0x18,
  0x11, 0x01, 0x20, 0x16, 0x02, 0xA0, 0x2A, 0x03, 0x20, 0x22, 0x02, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x81, 0x08, 0x18, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x00, 0x01, 0xC3,
  0x81, 0x44, 0x8C, 0x30, 0x60, 0x84, 0x08, 0x11, 0x81, 0x02, 0x20, 0x20,
  0x44, 0x08, 0x08, 0x81, 0x02, 0x10, 0x20, 0x44, 0x04, 0x08, 0x80, 0x81,
  0x10, 0x20, 0x22, 0x04, 0x08, 0x40, 0x81, 0x10, 0x10, 0x22, 0x04, 0x04,
  0x40, 0x81, 0x08, 0x10, 0x21, 0x02, 0x04, 0x40, 0xC0, 0x80, 0x00, 0xE0,
  0xA3, 0x0C, 0x10, 0x81, 0x18, 0x11, 0x01, 0x10, 0x11, 0x02, 0x10, 0x22,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x42, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44,
  0x08, 0x40, 0x88, 0x08, 0x03, 0x81, 0x88, 0x60, 0x88, 0x12, 0x02, 0x40,
  0x58, 0x0A, 0x01, 0x40, 0x28, 0x07, 0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0,
  0x14, 0x04, 0x80, 0x90, 0x21, 0x08, 0x3E, 0x00, 0x00, 0x38, 0x05, 0x98,
  0x0C, 0x10, 0x18, 0x10, 0x20, 0x20, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x04,
  0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x01, 0x86, 0x02,
  0x0C, 0x04, 0x18, 0x10, 0x30, 0x60, 0x61, 0x81, 0x3E, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x22, 0x42, 0x0C, 0x20, 0x62, 0x03, 0x10, 0x18, 0x80,
  0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x09, 0x00, 0x88, 0x04, 0x40, 0x22,
  0x03, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x10, 0xA0, 0xF9, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x00, 0xC2, 0x80, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x03, 0xC1, 0x84, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x22, 0x04, 0x7F, 0x00, 0x08, 0x21, 0x04, 0x11, 0xF1, 0x08,
  0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x38,
  0x10, 0x11, 0x02, 0x10, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x42, 0x04,
  0x40, 0x44, 0x04, 0x40, 0x44, 0x08, 0x40, 0x88, 0x08, 0x81, 0x88, 0x10,
  0x83, 0x08, 0x30, 0x7D, 0x00, 0x80, 0xE0, 0x28, 0x0A, 0x04, 0x81, 0x20,
  0x88, 0x22, 0x10, 0x84, 0x22, 0x08, 0x82, 0x20, 0x90, 0x24, 0x0A, 0x02,
  0x80, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0x81, 0xC0, 0xC0, 0xA0, 0x60, 0x50,
  0x30, 0x48, 0x28, 0x24, 0x14, 0x22, 0x12, 0x11, 0x09, 0x08, 0x84, 0x88,
  0x44, 0x44, 0x22, 0x24, 0x12, 0x12, 0x09, 0x09, 0x04, 0x85, 0x02, 0x82,
  0x81, 0x41, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x20, 0x00, 0x04, 0x0C,
  0x10, 0x60, 0x41, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x28, 0x00, 0xA0,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x40, 0x0C, 0x80, 0x22, 0x01, 0x08,
  0x04, 0x20, 0x20, 0x81, 0x01, 0x0C, 0x04, 0x00, 0x01, 0x01, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20, 0x04, 0x10, 0x02,
  0x10, 0x01, 0x08, 0x00, 0x88, 0x00, 0x44, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x60, 0x1C,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0x00, 0xC0, 0x10, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x10, 0x03, 0x70, 0x60,
  0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 26, 7, 1, -26 },
  { 24, 7, 9, 10, 4, -26 },
  { 32, 14, 26, 14, 0, -26 },
  { 78, 13, 30, 13, 0, -28 },
  { 127, 16, 27, 19, 2, -27 },
  { 181, 11, 27, 12, 0, -27 },
  { 219, 2, 9, 5, 4, -26 },
  { 222, 10, 32, 9, 1, -26 },
  { 262, 10, 32, 9, -3, -26 },
  { 302, 10, 10, 12, 4, -28 },
  { 315, 13, 17, 15, 1, -22 },
  { 343, 4, 8, 6, -1, -3 },
  { 347, 8, 1, 10, 1, -11 },
  { 348, 1, 3, 6, 1, -3 },
  { 349, 15, 26, 11, -2, -26 },
  { 398, 12, 27, 13, 1, -27 },
  { 439, 6, 26, 13, 4, -26 },
  { 459, 14, 27, 13, -1, -27 },
  { 507, 14, 27, 13, -1, -27 },
  { 555, 14, 27, 13, -1, -27 },
  { 603, 14, 26, 13, -1, -26 },
  { 649, 12, 27, 13, 1, -27 },
  { 690, 13, 26, 13, 1, -26 },
  { 733, 13, 27, 13, 0, -27 },
  { 777, 12, 27, 13, 0, -27 },
  { 818, 5, 20, 6, 0, -20 },
  { 831, 8, 25, 6, -2, -20 },
  { 856, 13, 16, 15, 1, -21 },
  { 882, 13, 9, 15, 1, -18 },
  { 897, 13, 16, 15, 1, -21 },
  { 923, 10, 27, 9, 0, -27 },
  { 957, 17, 30, 19, 1, -27 },
  { 1021, 13, 27, 12, -3, -27 },
  { 1065, 14, 26, 14, 0, -26 },
  { 1111, 14, 27, 12, 1, -27 },
  { 1159, 15, 26, 15, 0, -26 },
  { 1208, 14, 26, 13, 0, -26 },
  { 1254, 14, 26, 12, 0, -26 },
  { 1300, 17, 27, 17, 1, -27 },
  { 1358, 17, 26, 16, 0, -26 },
  { 1414, 11, 26, 6, -2, -26 },
  { 1450, 12, 32, 6, -5, -26 },
  { 1498, 15, 26, 13, 0, -26 },
  { 1547, 8, 26, 11, 0, -26 },
  { 1573, 22, 26, 22, 0, -26 },
  { 1645, 18, 26, 17, 0, -26 },
  { 1704, 15, 27, 16, 1, -27 },
  { 1755, 14, 26, 13, 0, -26 },
  { 1801, 15, 33, 16, 1, -27 },
  { 1863, 13, 26, 13, 0, -26 },
  { 1906, 15, 27, 13, -1, -27 },
  { 1957, 12, 26, 11, 2, -26 },
  { 1996, 15, 26, 16, 1, -26 },
  { 2045, 13, 26, 13, 3, -26 },
  { 2088, 22, 26, 22, 3, -26 },
  { 2160, 16, 26, 11, -2, -26 },
  { 2212, 12, 26, 11, 2, -26 },
  { 2251, 15, 26, 11, -2, -26 },
  { 2300, 13, 32, 10, -1, -26 },
  { 2352, 5, 26, 12, 4, -26 },
  { 2369, 13, 32, 10, -2, -26 },
  { 2421, 13, 12, 14, 1, -26 },
  { 2441, 10, 1, 10, -3, 3 },
  { 2443, 4, 6, 8, 5, -28 },
  { 2446, 13, 20, 14, 1, -20 },
  { 2479, 13, 28, 14, 0, -28 },
  { 2525, 10, 20, 10, 1, -20 },
  { 2550, 14, 28, 14, 1, -28 },
  { 2599, 10, 20, 12, 1, -20 },
  { 2624, 16, 37, 7, -5, -28 },
  { 2698, 15, 29, 14, -1, -20 },
  { 2753, 12, 28, 13, 0, -28 },
  { 2795, 7, 26, 6, 0, -26 },
  { 2818, 12, 35, 6, -5, -26 },
  { 2871, 12, 28, 11, 0, -28 },
  { 2913, 7, 28, 5, 0, -28 },
  { 2938, 19, 20, 20, 0, -20 },
  { 2986, 12, 20, 13, 0, -20 },
  { 3016, 11, 20, 13, 1, -20 },
  { 3044, 15, 28, 14, -2, -20 },
  { 3097, 13, 29, 14, 1, -20 },
  { 3145, 10, 20, 9, 0, -20 },
  { 3170, 11, 20, 10, -1, -20 },
  { 3198, 6, 24, 7, 1, -24 },
  { 3216, 12, 19, 13, 1, -19 },
  { 3245, 10, 19, 10, 2, -19 },
  { 3269, 17, 19, 17, 2, -19 },
  { 3310, 14, 19, 11, -2, -19 },
  { 3344, 17, 28, 11, -4, -19 },
  { 3404, 11, 19, 9, -1, -19 },
  { 3431, 13, 32, 11, 1, -26 },
  { 3483, 1, 37, 13, 6, -28 },
  { 3488, 12, 32, 11, -2, -26 },
  { 3536, 13, 3, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC37PT7B_H_
