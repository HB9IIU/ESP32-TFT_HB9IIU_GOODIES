#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x06, 0x08, 0x00, 0x23, 0x22, 0x42, 0x42, 0x42, 0x42, 0x44, 0x84, 0x84,
  0x84, 0x00, 0x43, 0x00, 0x42, 0x00, 0x82, 0x00, 0x84, 0x00, 0x84, 0x01,
  0x04, 0x01, 0x0C, 0x01, 0x08, 0x1F, 0xFF, 0x02, 0x18, 0x02, 0x10, 0x06,
  0x10, 0x04, 0x10, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x40, 0x08,
  0x40, 0xFF, 0xF8, 0x10, 0x80, 0x10, 0x80, 0x20, 0x80, 0x21, 0x80, 0x21,
  0x00, 0x61, 0x00, 0x41, 0x00, 0x42, 0x00, 0x42, 0x00, 0x86, 0x00, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x07, 0x80, 0x34, 0xE0, 0x88, 0x02, 0x10,
  0x04, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00, 0x88, 0x01,
  0xA0, 0x01, 0x40, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x09, 0x00, 0x13,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x8C, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x11, 0x84, 0x26, 0x0F, 0xF8, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x82, 0x40, 0x41, 0x18, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x18, 0x21, 0x04, 0x18, 0x41, 0x04, 0x20, 0x41, 0x08, 0x30, 0x44, 0x08,
  0x11, 0x02, 0x04, 0x80, 0x82, 0x23, 0x20, 0x93, 0x28, 0x24, 0x8E, 0x12,
  0x41, 0x8C, 0x90, 0x76, 0x4C, 0x13, 0x12, 0x0C, 0x08, 0x82, 0x02, 0x20,
  0x81, 0x10, 0x20, 0x44, 0x08, 0x21, 0x06, 0x08, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x30, 0x81, 0x08, 0x20, 0x44, 0x10, 0x0F, 0x00, 0x00, 0xC0, 0x12,
  0x02, 0x30, 0x61, 0x04, 0x10, 0x43, 0x04, 0x20, 0x42, 0x04, 0x20, 0x44,
  0x04, 0x40, 0x48, 0x05, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1A, 0x03, 0x30,
  0x21, 0x14, 0x11, 0x41, 0x18, 0x1A, 0x80, 0xA8, 0x0E, 0x80, 0xC8, 0x0C,
  0x80, 0xC8, 0x14, 0xC2, 0x47, 0xC6, 0x25, 0x24, 0x94, 0x90, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x03, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x43, 0x10, 0x38, 0xC3, 0xC1, 0x40, 0x90, 0x42, 0x20,
  0x80, 0x10, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x08, 0x46, 0x21, 0x10, 0x88, 0xC0, 0xFF, 0x80, 0xB8, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xE0, 0x1D, 0x80, 0x84, 0x08, 0x10, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01,
  0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x34, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x02, 0xC0, 0x14, 0x01, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x41, 0x02, 0x04, 0x20, 0x3E, 0x00,
  0x07, 0x0E, 0x1A, 0x22, 0x46, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x00, 0xF0, 0x07, 0x30, 0x08, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xF0, 0x07, 0x38, 0x18, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0xF0, 0x02, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x08, 0x08, 0x1F, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x01, 0x40, 0x06, 0x80, 0x09,
  0x00, 0x22, 0x00, 0x4C, 0x01, 0x10, 0x06, 0x20, 0x08, 0x40, 0x20, 0x80,
  0x42, 0x01, 0x04, 0x06, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x01,
  0x06, 0x02, 0x08, 0x04, 0x3F, 0xFE, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x01, 0xFE, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x04, 0x04,
  0x0F, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x10, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x67, 0x81, 0x23, 0x05, 0x02, 0x18, 0x08, 0x40, 0x23, 0x00, 0xCC, 0x03,
  0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01,
  0x08, 0x0C, 0x30, 0x20, 0x41, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00,
  0x70, 0x03, 0x38, 0x08, 0x18, 0x30, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x30, 0x40, 0x21, 0x00,
  0x2C, 0x00, 0x70, 0x01, 0xE0, 0x0C, 0x60, 0x30, 0x40, 0xC0, 0x41, 0x00,
  0x84, 0x01, 0x88, 0x01, 0x10, 0x02, 0x60, 0x04, 0xC0, 0x18, 0x80, 0x21,
  0x00, 0x42, 0x01, 0x82, 0x06, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x0E, 0xC0,
  0x60, 0x83, 0x02, 0x08, 0x0C, 0x20, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04,
  0xC0, 0x12, 0x00, 0x48, 0x03, 0x20, 0x08, 0x80, 0x22, 0x01, 0x84, 0x06,
  0x10, 0x28, 0x37, 0x40, 0x21, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x06, 0x03, 0xF0,
  0x00, 0x04, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0xC3, 0x00, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x80, 0x00, 0x04, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x04, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x07, 0x03, 0x30, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x10,
  0x04, 0x01, 0x01, 0x00, 0x30, 0x40, 0x02, 0x18, 0x00, 0x42, 0x00, 0x08,
  0xC0, 0x01, 0x10, 0x3E, 0x22, 0x08, 0x84, 0x82, 0x10, 0x90, 0xC2, 0x12,
  0x10, 0x82, 0x86, 0x10, 0x50, 0x82, 0x12, 0x10, 0x42, 0x42, 0x10, 0x58,
  0x82, 0x0A, 0x10, 0x42, 0x42, 0x18, 0x48, 0x43, 0x09, 0x08, 0xA2, 0x21,
  0x14, 0xC4, 0x1C, 0xF0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xCE, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00,
  0x90, 0x04, 0x40, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01,
  0x0C, 0x04, 0x30, 0x20, 0xC0, 0x83, 0x07, 0xFC, 0x10, 0x30, 0x40, 0xC2,
  0x03, 0x08, 0x0C, 0x40, 0x31, 0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x34,
  0x00, 0xD0, 0x03, 0xC0, 0x0C, 0x03, 0xF8, 0x02, 0x04, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x02, 0x04, 0x03, 0x04, 0x02, 0x04, 0x02, 0x0C, 0x02, 0x08,
  0x06, 0x08, 0x04, 0x08, 0x08, 0x08, 0x30, 0x1F, 0xC0, 0x10, 0x60, 0x10,
  0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40, 0x60, 0xC1,
  0xC0, 0xFF, 0x00, 0x00, 0x38, 0x03, 0x8C, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x02, 0x0C, 0x02, 0x02, 0x02, 0x02, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x40, 0x10,
  0x40, 0x30, 0x40, 0x60, 0x40, 0xC0, 0xC3, 0x80, 0xFE, 0x00, 0x03, 0xFF,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x1F, 0xF0, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0xF0, 0x18,
  0x04, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x3F, 0x10, 0x00, 0x84, 0x00,
  0x23, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x01, 0x0C, 0x00, 0x41, 0x00, 0x10,
  0x40, 0x04, 0x10, 0x03, 0x06, 0x00, 0x80, 0x80, 0x20, 0x10, 0x08, 0x03,
  0xFE, 0x00, 0x02, 0x00, 0x60, 0x40, 0x08, 0x08, 0x01, 0x03, 0x00, 0x20,
  0x40, 0x04, 0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x81,
  0x00, 0x30, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x3F, 0xFE, 0x04,
  0x00, 0x80, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x18, 0x01, 0x02, 0x00, 0x60, 0x40,
  0x08, 0x08, 0x01, 0x01, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x00, 0x03,
  0xF0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x02, 0x00, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x01, 0xE0, 0x00, 0x02, 0x01, 0x81, 0x00, 0x80, 0x80,
  0x80, 0xC0, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x08, 0x40, 0x0C,
  0x60, 0x04, 0x20, 0x02, 0x20, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x98, 0x00,
  0x54, 0x00, 0x32, 0x00, 0x11, 0x80, 0x08, 0x40, 0x08, 0x20, 0x04, 0x10,
  0x02, 0x08, 0x01, 0x02, 0x01, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x10, 0x04, 0x08, 0x02, 0x00, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x0F, 0xF8, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xA0, 0x50, 0x00, 0x50, 0x28, 0x00, 0x50,
  0x14, 0x00, 0x28, 0x0A, 0x00, 0x24, 0x0D, 0x00, 0x12, 0x04, 0x80, 0x13,
  0x02, 0x40, 0x09, 0x01, 0x30, 0x08, 0x80, 0x88, 0x04, 0x40, 0x84, 0x04,
  0x20, 0x42, 0x02, 0x30, 0x21, 0x03, 0x10, 0x10, 0x81, 0x08, 0x08, 0x41,
  0x84, 0x08, 0x20, 0x82, 0x04, 0x10, 0xC2, 0x02, 0x08, 0x41, 0x01, 0x04,
  0x60, 0x81, 0x82, 0x20, 0x40, 0x81, 0x10, 0x60, 0x40, 0x90, 0x20, 0x20,
  0x48, 0x10, 0x10, 0x28, 0x08, 0x10, 0x14, 0x04, 0x08, 0x0C, 0x06, 0x00,
  0x03, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x00, 0x83, 0x80, 0x10, 0x58, 0x04,
  0x09, 0x00, 0x81, 0x20, 0x10, 0x24, 0x02, 0x0C, 0x80, 0xC1, 0x10, 0x10,
  0x21, 0x02, 0x04, 0x20, 0x40, 0x84, 0x08, 0x20, 0x83, 0x04, 0x10, 0x40,
  0x83, 0x08, 0x10, 0x21, 0x02, 0x04, 0x20, 0x80, 0x88, 0x10, 0x11, 0x02,
  0x03, 0x20, 0x40, 0x24, 0x18, 0x04, 0x82, 0x00, 0xA0, 0x40, 0x14, 0x08,
  0x02, 0x81, 0x00, 0x70, 0x60, 0x06, 0x08, 0x00, 0x80, 0x00, 0x30, 0x00,
  0xCE, 0x01, 0x02, 0x02, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60,
  0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x40,
  0x10, 0x40, 0x30, 0x40, 0x20, 0x20, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x04,
  0x18, 0x08, 0x10, 0x10, 0x30, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01,
  0x0C, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x20, 0x80, 0x82, 0x03, 0x04,
  0x0C, 0x0F, 0xE0, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0xCE, 0x01, 0x02, 0x02, 0x01,
  0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x03,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x04, 0xC0, 0x04,
  0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20,
  0x20, 0xC0, 0x1F, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xF0, 0x04, 0x18, 0x08, 0x10,
  0x10, 0x30, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x0C, 0x06, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x60, 0x80, 0x83, 0x02, 0x04, 0x18, 0x0F, 0xC0,
  0x10, 0x80, 0x21, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x18, 0x18,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01, 0x06, 0x03, 0x08, 0x02,
  0x00, 0x00, 0x38, 0x01, 0xCF, 0x02, 0x01, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x80, 0xC0, 0xFF,
  0x80, 0xFF, 0xF0, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x04, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x61, 0x00, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04,
  0x30, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC2, 0x00,
  0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x10,
  0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x20, 0x60, 0x10, 0x10, 0x18, 0x0C, 0x18, 0x03, 0xF8, 0x00, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xB0, 0x02, 0xC0, 0x13, 0x00, 0x4C, 0x02, 0x30,
  0x08, 0xC0, 0x62, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82, 0x04, 0x08,
  0x10, 0x20, 0xC0, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00, 0x8C, 0x02,
  0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x38, 0x02, 0x80, 0x28, 0x06, 0x80, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x48, 0x08, 0x80, 0x48, 0x08, 0x80, 0x88, 0x18, 0x80, 0x88, 0x10, 0x81,
  0x08, 0x10, 0x81, 0x08, 0x20, 0x81, 0x08, 0x20, 0x82, 0x08, 0x60, 0x82,
  0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x10, 0x80, 0x84, 0x10, 0x80, 0x88,
  0x11, 0x80, 0x88, 0x11, 0x00, 0x98, 0x11, 0x00, 0x90, 0x12, 0x00, 0x90,
  0x12, 0x00, 0xA0, 0x14, 0x00, 0xA0, 0x14, 0x00, 0xE0, 0x14, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x40, 0x10, 0x20, 0x0C, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x98,
  0x00, 0x48, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00,
  0xC4, 0x00, 0x42, 0x00, 0x41, 0x80, 0x20, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x10, 0x08, 0x18, 0x04, 0x08, 0x02, 0x00, 0x80, 0x14, 0x02, 0x40, 0x24,
  0x04, 0x40, 0x44, 0x08, 0x40, 0x84, 0x10, 0x41, 0x04, 0x20, 0x42, 0x04,
  0x40, 0x24, 0x02, 0x80, 0x28, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x83,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x00, 0xFE, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x03, 0xFC, 0x00, 0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x22, 0x00, 0x44,
  0x01, 0x04, 0x02, 0x08, 0x08, 0x08, 0x10, 0x10, 0x40, 0x10, 0x80, 0x22,
  0x00, 0x64, 0x00, 0x50, 0x00, 0xC0, 0xFF, 0xC0, 0x84, 0x42, 0x21, 0x01,
  0xE4, 0x18, 0xD0, 0xC1, 0x42, 0x05, 0x10, 0x08, 0xC0, 0x22, 0x00, 0x88,
  0x06, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x32, 0x00, 0x88,
  0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x88, 0x0C, 0x10, 0x30, 0x41, 0x40,
  0xF9, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x13, 0xC0, 0x50, 0x82, 0x83, 0x0C,
  0x04, 0x30, 0x10, 0x80, 0x42, 0x01, 0x18, 0x04, 0x40, 0x11, 0x00, 0x44,
  0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x11, 0x80, 0x46,
  0x03, 0x18, 0x08, 0x60, 0x41, 0x43, 0x09, 0xF8, 0x00, 0x01, 0xE0, 0xC4,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x01, 0xE4,
  0x06, 0x34, 0x0C, 0x14, 0x08, 0x18, 0x10, 0x08, 0x30, 0x08, 0x20, 0x18,
  0x20, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x30,
  0x80, 0x20, 0x80, 0x20, 0x80, 0x20, 0x80, 0x60, 0x80, 0x60, 0x80, 0xC0,
  0x40, 0xC0, 0x41, 0x40, 0x3E, 0x40, 0x01, 0xC0, 0x62, 0x08, 0x31, 0x81,
  0x10, 0x32, 0x02, 0x20, 0x26, 0x06, 0x40, 0x44, 0x18, 0x4E, 0x0F, 0x80,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x83, 0xF0, 0x00, 0x07, 0x80, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x3E,
  0x00, 0x68, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x79, 0x01, 0x8D, 0x03,
  0x05, 0x02, 0x05, 0x04, 0x02, 0x0C, 0x02, 0x08, 0x06, 0x08, 0x06, 0x18,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x18, 0x20, 0x18, 0x20, 0x30, 0x10, 0x70, 0x10,
  0x50, 0x0F, 0x90, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0xC3, 0x00, 0x3C, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x27, 0x81, 0x46, 0x14, 0x10, 0xC0, 0x86, 0x04, 0x20, 0x21,
  0x01, 0x18, 0x08, 0x80, 0x44, 0x04, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80,
  0xC4, 0x04, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x22,
  0x01, 0x00, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x03, 0x80, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x30, 0x40, 0x82, 0x04, 0x08, 0x20, 0x21, 0x80,
  0x84, 0x06, 0x20, 0x11, 0x00, 0x4C, 0x01, 0x20, 0x05, 0x40, 0x39, 0x00,
  0xC4, 0x03, 0x10, 0x08, 0x40, 0x21, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x08, 0x00, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x04, 0xF1, 0xF0, 0x38, 0xD8, 0xC2, 0x83, 0x02, 0x18, 0x18, 0x10,
  0x80, 0x80, 0x84, 0x04, 0x04, 0x20, 0x20, 0x22, 0x03, 0x02, 0x10, 0x10,
  0x10, 0x80, 0x80, 0x84, 0x04, 0x04, 0x60, 0x20, 0x22, 0x02, 0x02, 0x10,
  0x10, 0x10, 0x80, 0x80, 0x84, 0x04, 0x04, 0x60, 0x60, 0x62, 0x02, 0x02,
  0x10, 0x10, 0x10, 0x80, 0x80, 0x84, 0x04, 0x04, 0x40, 0x40, 0x60, 0x04,
  0xF0, 0x28, 0xC2, 0x82, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20, 0x22, 0x01,
  0x10, 0x08, 0x80, 0x84, 0x04, 0x60, 0x22, 0x01, 0x10, 0x18, 0x80, 0x84,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x40, 0x20, 0x03,
  0xC0, 0x31, 0x82, 0x04, 0x30, 0x21, 0x01, 0x18, 0x0C, 0x80, 0x64, 0x03,
  0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x2C, 0x01, 0x40, 0x1A, 0x00, 0x90,
  0x04, 0x80, 0x64, 0x02, 0x20, 0x30, 0x81, 0x04, 0x10, 0x1F, 0x00, 0x01,
  0x3C, 0x01, 0x42, 0x02, 0x83, 0x03, 0x01, 0x03, 0x01, 0x02, 0x01, 0x02,
  0x01, 0x06, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06, 0x18, 0x04, 0x18, 0x0C, 0x18,
  0x08, 0x18, 0x10, 0x14, 0x30, 0x27, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x01, 0xC4, 0x18, 0xD0, 0xC1, 0x42, 0x05, 0x10, 0x08, 0xC0, 0x22,
  0x00, 0x88, 0x06, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x12,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x88, 0x0C, 0x10, 0x30,
  0x41, 0x40, 0xF9, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x04, 0xE0, 0xA0,
  0x28, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x00, 0x03, 0xE0, 0x30, 0xC2, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x08, 0x10, 0x7F, 0x00, 0x04, 0x10, 0x20, 0x40, 0x87, 0xD4, 0x08, 0x10,
  0x20, 0xC1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x03, 0xC0, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x31, 0x01,
  0x08, 0x08, 0xC0, 0x44, 0x02, 0x20, 0x31, 0x01, 0x08, 0x08, 0x80, 0x44,
  0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x80, 0xC4, 0x06, 0x20, 0x21, 0x03,
  0x0C, 0x28, 0x3E, 0x40, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x01,
  0x20, 0x44, 0x08, 0x83, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x10, 0x22,
  0x04, 0xC0, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x00, 0x40,
  0x40, 0x28, 0x08, 0x09, 0x03, 0x01, 0x20, 0x60, 0x64, 0x0C, 0x08, 0x82,
  0x81, 0x10, 0x50, 0x42, 0x1A, 0x08, 0x42, 0x41, 0x18, 0x48, 0x42, 0x11,
  0x08, 0x42, 0x22, 0x08, 0x84, 0x41, 0x10, 0x88, 0x22, 0x12, 0x04, 0x82,
  0x40, 0x90, 0x50, 0x14, 0x0A, 0x02, 0x81, 0x40, 0x50, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x80, 0x00, 0x04, 0x02, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x40,
  0x21, 0x80, 0x42, 0x00, 0x88, 0x00, 0x90, 0x01, 0x40, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x01, 0x20, 0x04, 0x40, 0x08, 0x40,
  0x20, 0x80, 0xC1, 0x01, 0x02, 0x04, 0x04, 0x18, 0x0C, 0x00, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x08, 0x01, 0x01,
  0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x08,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x32, 0x00, 0x06, 0x80,
  0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0F, 0xE0, 0x00,
  0x3C, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x03, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x0C,
  0x18, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 29, 8, 1, -29 },
  { 27, 8, 10, 11, 4, -29 },
  { 37, 16, 29, 15, 0, -29 },
  { 95, 15, 33, 14, 0, -31 },
  { 157, 18, 30, 21, 2, -30 },
  { 225, 12, 30, 13, 0, -30 },
  { 270, 3, 10, 6, 4, -29 },
  { 274, 11, 35, 10, 1, -29 },
  { 323, 11, 35, 10, -3, -29 },
  { 372, 10, 11, 13, 5, -31 },
  { 386, 14, 19, 16, 1, -24 },
  { 420, 5, 9, 6, -2, -4 },
  { 426, 9, 1, 11, 1, -12 },
  { 428, 2, 3, 6, 1, -3 },
  { 429, 17, 29, 12, -2, -29 },
  { 491, 13, 30, 14, 1, -30 },
  { 540, 8, 29, 14, 4, -29 },
  { 569, 15, 30, 14, -1, -30 },
  { 626, 15, 30, 14, -1, -30 },
  { 683, 15, 30, 14, -1, -30 },
  { 740, 15, 29, 14, -1, -29 },
  { 795, 14, 30, 14, 1, -30 },
  { 848, 14, 29, 14, 2, -29 },
  { 899, 15, 30, 14, -1, -30 },
  { 956, 14, 30, 14, 0, -30 },
  { 1009, 6, 22, 6, 0, -22 },
  { 1026, 8, 27, 6, -2, -22 },
  { 1053, 14, 17, 16, 1, -23 },
  { 1083, 14, 9, 16, 1, -19 },
  { 1099, 14, 17, 16, 1, -23 },
  { 1129, 11, 30, 10, 1, -30 },
  { 1171, 19, 33, 21, 1, -29 },
  { 1250, 14, 29, 13, -3, -29 },
  { 1301, 16, 29, 15, 0, -29 },
  { 1359, 15, 30, 14, 2, -30 },
  { 1416, 16, 29, 17, 0, -29 },
  { 1474, 16, 29, 14, 0, -29 },
  { 1532, 16, 29, 13, 0, -29 },
  { 1590, 18, 30, 19, 1, -30 },
  { 1658, 19, 29, 18, 0, -29 },
  { 1727, 12, 29, 7, -2, -29 },
  { 1771, 13, 36, 6, -6, -29 },
  { 1830, 17, 29, 14, 0, -29 },
  { 1892, 9, 29, 12, 0, -29 },
  { 1925, 25, 29, 24, 0, -29 },
  { 2016, 19, 29, 19, 0, -29 },
  { 2085, 16, 30, 18, 1, -30 },
  { 2145, 15, 29, 14, 0, -29 },
  { 2200, 16, 37, 18, 1, -30 },
  { 2274, 15, 29, 15, 0, -29 },
  { 2329, 16, 30, 14, -1, -30 },
  { 2389, 12, 29, 12, 3, -29 },
  { 2433, 17, 29, 17, 1, -29 },
  { 2495, 14, 29, 14, 3, -29 },
  { 2546, 24, 29, 25, 3, -29 },
  { 2633, 17, 29, 12, -2, -29 },
  { 2695, 12, 29, 12, 3, -29 },
  { 2739, 17, 29, 13, -2, -29 },
  { 2801, 15, 35, 11, -1, -29 },
  { 2867, 6, 29, 13, 4, -29 },
  { 2889, 15, 35, 11, -3, -29 },
  { 2955, 15, 14, 16, 1, -29 },
  { 2982, 10, 1, 11, -3, 4 },
  { 2984, 4, 6, 8, 6, -31 },
  { 2987, 14, 22, 16, 1, -22 },
  { 3026, 14, 31, 15, 0, -31 },
  { 3081, 11, 22, 11, 1, -22 },
  { 3112, 16, 31, 16, 1, -31 },
  { 3174, 12, 22, 13, 1, -22 },
  { 3207, 17, 41, 8, -5, -31 },
  { 3295, 16, 32, 15, -1, -22 },
  { 3359, 13, 31, 15, 0, -31 },
  { 3410, 8, 29, 6, 0, -29 },
  { 3439, 13, 39, 7, -5, -29 },
  { 3503, 14, 31, 12, 0, -31 },
  { 3558, 8, 31, 6, 0, -31 },
  { 3589, 21, 22, 22, 0, -22 },
  { 3647, 13, 22, 15, 0, -22 },
  { 3683, 13, 22, 15, 1, -22 },
  { 3719, 16, 31, 15, -2, -22 },
  { 3781, 14, 32, 16, 1, -22 },
  { 3837, 11, 22, 10, 0, -22 },
  { 3868, 13, 22, 11, -1, -22 },
  { 3904, 7, 27, 7, 1, -27 },
  { 3928, 13, 22, 15, 1, -22 },
  { 3964, 11, 22, 11, 2, -22 },
  { 3995, 19, 22, 19, 2, -22 },
  { 4048, 15, 22, 12, -2, -22 },
  { 4090, 19, 32, 12, -5, -22 },
  { 4166, 12, 22, 9, -1, -22 },
  { 4199, 14, 35, 13, 1, -29 },
  { 4261, 1, 41, 14, 6, -31 },
  { 4267, 14, 35, 13, -3, -29 },
  { 4329, 14, 3, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC41PT7B_H_
