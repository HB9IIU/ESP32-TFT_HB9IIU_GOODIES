#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x00, 0x10, 0x26, 0x0C, 0xC1, 0x98, 0x32, 0x04, 0x40, 0x98, 0x33, 0x06,
  0x40, 0x88, 0x11, 0x02, 0x60, 0xCC, 0x11, 0x02, 0x20, 0x44, 0x08, 0x00,
  0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x80, 0x01, 0x01, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x10,
  0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x06,
  0x01, 0xFF, 0xFF, 0xC0, 0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x02, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x01, 0x81,
  0x80, 0x03, 0x02, 0x00, 0x04, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x40, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x04, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x00,
  0x38, 0x87, 0x00, 0xC3, 0x02, 0x03, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x18,
  0x10, 0x00, 0x30, 0x20, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x02,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x08, 0x80, 0x00, 0x19, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x58, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x08, 0x20, 0x00, 0x10, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x03, 0x00, 0x02, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x60, 0x00, 0x40, 0x80, 0x00, 0x83,
  0x01, 0x81, 0x1C, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x03, 0x01, 0x8C, 0x00, 0xC0, 0xC1, 0x00, 0x60, 0x20, 0x60,
  0x18, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x60, 0x20, 0x10, 0x30, 0x18, 0x04, 0x0C, 0x06, 0x01, 0x06, 0x01,
  0x00, 0xC1, 0x80, 0x40, 0x30, 0x40, 0x30, 0x0C, 0x30, 0x0C, 0x03, 0x08,
  0x03, 0x00, 0x86, 0x00, 0xC0, 0x61, 0x00, 0x20, 0x18, 0xC3, 0xC8, 0x04,
  0x21, 0x9A, 0x03, 0x18, 0xC2, 0x80, 0xC4, 0x60, 0xE0, 0x63, 0x30, 0x3C,
  0x18, 0x8C, 0x0F, 0x0C, 0x62, 0x03, 0xE6, 0x11, 0x80, 0xDF, 0x0C, 0x60,
  0x30, 0x02, 0x10, 0x0C, 0x01, 0x8C, 0x02, 0x00, 0x43, 0x00, 0x80, 0x30,
  0x80, 0x60, 0x08, 0x20, 0x18, 0x06, 0x18, 0x06, 0x01, 0x06, 0x01, 0x00,
  0xC1, 0x80, 0x40, 0x20, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x02,
  0x03, 0x01, 0x81, 0x80, 0x80, 0x60, 0x40, 0x60, 0x18, 0x30, 0x10, 0x06,
  0x08, 0x0C, 0x00, 0x86, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x04, 0x01,
  0x80, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03,
  0x02, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06,
  0x30, 0x00, 0xCC, 0x00, 0x09, 0x00, 0x01, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x40, 0x00, 0xC8, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x82,
  0x04, 0x60, 0x41, 0x88, 0x0C, 0x33, 0x01, 0x84, 0x40, 0x11, 0x98, 0x02,
  0x33, 0x00, 0x64, 0x40, 0x0D, 0x98, 0x00, 0xA3, 0x00, 0x1C, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x82, 0x00, 0xD8, 0x60, 0x33,
  0x06, 0x0C, 0x20, 0x7F, 0x04, 0x01, 0x00, 0x00, 0x13, 0x33, 0x22, 0x66,
  0x44, 0x4C, 0xC8, 0x88, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x04, 0x0C, 0x0E, 0x10, 0x06, 0x20, 0x03, 0x43, 0x81, 0xF8, 0x03,
  0x00, 0x09, 0x00, 0x22, 0x01, 0x82, 0x06, 0x04, 0x18, 0x04, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x06, 0x08, 0x30, 0x61, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00,
  0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x06, 0x18, 0x01, 0x81, 0x00, 0x60, 0x30, 0x18,
  0x06, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x01, 0x06, 0x00, 0x20, 0xC0,
  0x04, 0x10, 0x00, 0x86, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0x10, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x22, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0x8C, 0x00, 0x31, 0x00, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x10,
  0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x10, 0x04, 0x02, 0x01, 0x80,
  0x60, 0x60, 0x06, 0x18, 0x00, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x1C, 0x0F, 0x03, 0x20, 0xCC, 0x31, 0x9C, 0x32, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xE0, 0x60, 0x01, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xC1, 0xC0, 0x1C, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x80, 0x1C, 0x03, 0x01, 0xC0, 0x0F, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x19, 0x00, 0x00,
  0x44, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x40, 0x01, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x80, 0x0C, 0x02, 0x00, 0x20, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x10, 0x04, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x20, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x0C, 0x01,
  0xC0, 0x70, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xE0, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x87, 0xE0, 0x0C, 0xF7, 0x80, 0x6C,
  0x06, 0x02, 0xC0, 0x10, 0x14, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00, 0x10,
  0x60, 0x00, 0x83, 0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x08, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06,
  0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x20, 0x03,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x20, 0x18, 0x01, 0xC3, 0x80, 0x07,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xE1, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x02, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x04, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x07, 0x00,
  0x06, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x03, 0xB0, 0x00, 0x1C,
  0xC0, 0x01, 0xC1, 0x80, 0x0E, 0x03, 0x00, 0x60, 0x04, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x20, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x30,
  0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC1, 0x00, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x70, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00, 0x10, 0xC0, 0x01,
  0x0C, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0xE0, 0x80, 0x0E, 0x0C, 0x01, 0xE0, 0xE0, 0x36, 0x07,
  0x0E, 0x40, 0x1F, 0x8C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x08, 0x1C, 0x00, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03, 0x81,
  0x80, 0x00, 0x10, 0x03, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF8, 0x0E, 0x0E, 0x08, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x0F,
  0x01, 0x82, 0x01, 0xFE, 0x0C, 0x30, 0x1C, 0x20, 0x41, 0x00, 0x83, 0x02,
  0x18, 0x0C, 0x18, 0x10, 0xC0, 0xC0, 0xC0, 0x84, 0x04, 0x04, 0x0C, 0x20,
  0x60, 0x60, 0x63, 0x03, 0x03, 0x03, 0x18, 0x30, 0x18, 0x18, 0x81, 0x80,
  0x80, 0x84, 0x0C, 0x0C, 0x04, 0x60, 0x40, 0x60, 0x63, 0x06, 0x02, 0x03,
  0x18, 0x30, 0x30, 0x10, 0xC1, 0x81, 0x81, 0x84, 0x0C, 0x0C, 0x0C, 0x20,
  0x60, 0xE0, 0x41, 0x03, 0x07, 0x06, 0x08, 0x18, 0x38, 0x20, 0x40, 0xC3,
  0xC3, 0x06, 0x06, 0x36, 0x30, 0x30, 0x1B, 0x1B, 0x01, 0x80, 0xF0, 0xF0,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xB0, 0x00, 0x1B, 0x00,
  0x01, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x06, 0x30,
  0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08, 0x30, 0x01, 0x83,
  0x00, 0x10, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x02, 0x03, 0x00, 0x60,
  0x30, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x0C, 0x02, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0x00, 0x20, 0x30, 0x02, 0x03, 0x00, 0x20, 0x60, 0x02, 0x06,
  0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x18, 0x00, 0x21,
  0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x02,
  0x60, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x20, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xE0, 0x01, 0x00, 0xE0, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0x80, 0x30, 0x01, 0x80, 0x40, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0xC0, 0x02, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x7C, 0x00, 0x7F, 0xC0, 0x00, 0x81, 0xE0, 0x01,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x20,
  0x01, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x04, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01,
  0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x18, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x20, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x30, 0x00, 0x40, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x06, 0x01, 0x80,
  0x02, 0x01, 0x80, 0x02, 0x01, 0x80, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x02, 0x02, 0x00,
  0x02, 0x02, 0x00, 0x02, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x0C, 0x00,
  0x0C, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x10, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x01,
  0x80, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x38,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x40, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x08, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x10, 0x00, 0xE0, 0x1C, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x20, 0x0C, 0x00,
  0x0C, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x80, 0x30, 0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x10,
  0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x18,
  0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x08, 0x03, 0x00,
  0x01, 0x00, 0x7F, 0xFF, 0xE0, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x30, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x30, 0x04,
  0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x06, 0x00, 0x02,
  0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x40, 0x18, 0x00, 0x08, 0x02, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x4E,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x04,
  0x70, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x02, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x20, 0x00, 0x20, 0x30, 0x00, 0x10, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x02, 0x18, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x2D,
  0x80, 0x00, 0x34, 0xC0, 0x00, 0x1C, 0x20, 0x00, 0x0E, 0x10, 0x00, 0x06,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x40, 0x30, 0x00, 0x20, 0x18, 0x00, 0x30, 0x04, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x40, 0x03,
  0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x01, 0xA0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xB0, 0x00,
  0x03, 0x60, 0x0B, 0x00, 0x00, 0x36, 0x01, 0xB0, 0x00, 0x02, 0x40, 0x19,
  0x00, 0x00, 0x6C, 0x01, 0x90, 0x00, 0x04, 0xC0, 0x11, 0x00, 0x00, 0xCC,
  0x01, 0x10, 0x00, 0x08, 0x80, 0x31, 0x00, 0x01, 0x88, 0x03, 0x10, 0x00,
  0x11, 0x80, 0x31, 0x00, 0x03, 0x18, 0x02, 0x10, 0x00, 0x21, 0x80, 0x21,
  0x00, 0x06, 0x10, 0x06, 0x18, 0x00, 0x41, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x04, 0x18, 0x00, 0x83, 0x00, 0x41, 0x80, 0x18, 0x30, 0x0C, 0x18, 0x01,
  0x82, 0x00, 0xC1, 0x80, 0x30, 0x20, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x81,
  0x80, 0x60, 0x60, 0x08, 0x18, 0x06, 0x04, 0x01, 0x81, 0x80, 0xC0, 0x40,
  0x18, 0x18, 0x0C, 0x0C, 0x01, 0x80, 0x81, 0x80, 0xC0, 0x10, 0x08, 0x18,
  0x0C, 0x01, 0x00, 0x81, 0x00, 0x80, 0x30, 0x08, 0x30, 0x08, 0x03, 0x00,
  0x82, 0x01, 0x80, 0x30, 0x08, 0x60, 0x18, 0x02, 0x00, 0x84, 0x01, 0x80,
  0x60, 0x08, 0xC0, 0x10, 0x06, 0x00, 0xC8, 0x01, 0x00, 0x60, 0x0D, 0x80,
  0x30, 0x04, 0x00, 0xD0, 0x03, 0x00, 0x40, 0x0F, 0x00, 0x20, 0x0C, 0x00,
  0xE0, 0x02, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x0F,
  0x00, 0x03, 0x00, 0x68, 0x00, 0x10, 0x03, 0x40, 0x00, 0x80, 0x13, 0x00,
  0x0C, 0x01, 0x98, 0x00, 0x60, 0x0C, 0xC0, 0x03, 0x00, 0x62, 0x00, 0x10,
  0x02, 0x10, 0x01, 0x80, 0x10, 0x80, 0x0C, 0x01, 0x86, 0x00, 0x60, 0x0C,
  0x30, 0x02, 0x00, 0x61, 0x80, 0x10, 0x02, 0x04, 0x01, 0x80, 0x10, 0x20,
  0x0C, 0x01, 0x81, 0x80, 0x60, 0x0C, 0x0C, 0x02, 0x00, 0x60, 0x60, 0x10,
  0x02, 0x01, 0x01, 0x80, 0x30, 0x08, 0x0C, 0x01, 0x80, 0x60, 0x60, 0x0C,
  0x03, 0x02, 0x00, 0x40, 0x18, 0x30, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x02,
  0x0C, 0x01, 0x80, 0x10, 0x40, 0x0C, 0x00, 0xC2, 0x00, 0x40, 0x06, 0x30,
  0x02, 0x00, 0x31, 0x80, 0x30, 0x00, 0x8C, 0x01, 0x80, 0x04, 0x40, 0x0C,
  0x00, 0x32, 0x00, 0x40, 0x01, 0xB0, 0x06, 0x00, 0x0D, 0x80, 0x30, 0x00,
  0x6C, 0x01, 0x80, 0x01, 0x40, 0x08, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x06, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x60, 0x00, 0x11, 0x80, 0x00, 0x23, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98,
  0x00, 0x03, 0x20, 0x00, 0x06, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x26, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x02, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x3F, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x04, 0x07, 0x00,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x20,
  0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x03,
  0x01, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x02,
  0x00, 0x18, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x40, 0x70, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0x06, 0x00, 0x02, 0x08, 0x00, 0x04, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x11, 0x80, 0x00, 0x23, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x20, 0x00, 0x06, 0x40,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x26, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x80, 0x04, 0x07, 0x00, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x20, 0x03, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x0C,
  0x00, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x10, 0x08, 0x00,
  0xC0, 0x60, 0x02, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x0E, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x00, 0x81,
  0x80, 0x06, 0x02, 0x00, 0x18, 0x08, 0x00, 0x60, 0x30, 0x01, 0x00, 0xC0,
  0x04, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x20, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x10, 0x00,
  0x80, 0x40, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x1C, 0x0F, 0x00, 0x70, 0x02, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x10, 0x00,
  0x10, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00,
  0x02, 0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x40, 0x20, 0x00, 0x20, 0x10, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60,
  0x10, 0x00, 0x30, 0x08, 0x00, 0x10, 0x06, 0x00, 0x18, 0x03, 0x00, 0x08,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x08, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x0C,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0xC0, 0x60, 0x0C, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0x80, 0x00, 0x98,
  0x00, 0x09, 0x80, 0x00, 0xB0, 0x00, 0x0B, 0x00, 0x00, 0xA0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x36, 0x00, 0x06,
  0x00, 0x03, 0x60, 0x00, 0x60, 0x00, 0x26, 0x00, 0x06, 0x00, 0x06, 0x60,
  0x00, 0xE0, 0x00, 0x46, 0x00, 0x0A, 0x00, 0x0C, 0x60, 0x01, 0xA0, 0x00,
  0xC6, 0x00, 0x1A, 0x00, 0x08, 0x40, 0x01, 0x20, 0x01, 0x84, 0x00, 0x32,
  0x00, 0x10, 0x40, 0x02, 0x20, 0x03, 0x04, 0x00, 0x62, 0x00, 0x30, 0x40,
  0x06, 0x20, 0x02, 0x04, 0x00, 0x42, 0x00, 0x60, 0x40, 0x0C, 0x20, 0x04,
  0x04, 0x00, 0x82, 0x00, 0xC0, 0x40, 0x18, 0x20, 0x0C, 0x04, 0x01, 0x86,
  0x00, 0x80, 0x40, 0x10, 0x60, 0x18, 0x04, 0x03, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x60, 0x30, 0x04, 0x02, 0x06, 0x03, 0x00, 0x40, 0x60, 0x60, 0x20,
  0x04, 0x04, 0x06, 0x06, 0x00, 0x40, 0xC0, 0x60, 0x40, 0x04, 0x0C, 0x06,
  0x0C, 0x00, 0x40, 0x80, 0x60, 0xC0, 0x04, 0x18, 0x06, 0x08, 0x00, 0x41,
  0x00, 0x61, 0x80, 0x04, 0x30, 0x06, 0x10, 0x00, 0x43, 0x00, 0x63, 0x00,
  0x04, 0x20, 0x04, 0x30, 0x00, 0x46, 0x00, 0x42, 0x00, 0x04, 0x40, 0x04,
  0x60, 0x00, 0x4C, 0x00, 0x44, 0x00, 0x04, 0xC0, 0x04, 0xC0, 0x00, 0x48,
  0x00, 0x4C, 0x00, 0x0D, 0x80, 0x04, 0x80, 0x00, 0xD0, 0x00, 0x58, 0x00,
  0x0D, 0x00, 0x05, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x00, 0x60, 0x00,
  0x80, 0x30, 0x00, 0x40, 0x30, 0x00, 0x20, 0x10, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x23, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x05, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x08,
  0x60, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00, 0x06, 0x04, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x01,
  0x80, 0x30, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x01, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x40, 0x00, 0x60, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x60, 0x80, 0x18, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x01, 0x80, 0x80,
  0x60, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x30, 0xC0,
  0x04, 0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0x80, 0x01,
  0x60, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0xC0, 0x40, 0x40, 0x40,
  0x40, 0x60, 0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10,
  0x10, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x0C,
  0x0C, 0x04, 0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03,
  0x03, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x44, 0x00, 0x03, 0x18, 0x00,
  0x08, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x20,
  0x18, 0x01, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x80, 0x06,
  0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x98,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0x86, 0x10, 0xC2,
  0x10, 0x42, 0x08, 0x40, 0x00, 0x7E, 0x10, 0x0E, 0x71, 0x01, 0x81, 0xB0,
  0x30, 0x0B, 0x06, 0x00, 0xA0, 0xC0, 0x0E, 0x0C, 0x00, 0xE1, 0x80, 0x0E,
  0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x08, 0x60, 0x00, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x30, 0x80,
  0x03, 0x08, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0xE0, 0xC0, 0x0E, 0x0C,
  0x01, 0xC0, 0xC0, 0x34, 0x06, 0x02, 0x40, 0x70, 0xCC, 0x03, 0xF8, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x3F, 0x00, 0x23, 0xBC, 0x01, 0x30, 0x70,
  0x1A, 0x01, 0x80, 0xF0, 0x04, 0x05, 0x00, 0x20, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x20, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x18, 0x20,
  0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x03, 0x80, 0x18, 0x16, 0x01, 0x80, 0x90, 0x18, 0x04, 0xC1,
  0x80, 0x63, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xE3, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x40, 0x3F, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x1F, 0x84, 0x00, 0x73, 0x98, 0x01,
  0x81, 0xB0, 0x06, 0x01, 0x60, 0x18, 0x02, 0x80, 0x60, 0x07, 0x00, 0xC0,
  0x0E, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08,
  0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00, 0x70, 0x10,
  0x00, 0xC0, 0x20, 0x01, 0x80, 0x40, 0x07, 0x00, 0xC0, 0x0E, 0x01, 0x80,
  0x28, 0x03, 0x00, 0xD0, 0x03, 0x03, 0x20, 0x07, 0x0C, 0xC0, 0x07, 0xF1,
  0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF3, 0x80, 0xE0, 0xC0,
  0xC0, 0x20, 0x60, 0x18, 0x60, 0x0C, 0x60, 0x04, 0x30, 0x02, 0x30, 0x03,
  0x18, 0x01, 0x88, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC2, 0x01, 0xC1, 0x03,
  0xC1, 0xFF, 0x80, 0xFE, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x3F,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC2, 0x00, 0x39,
  0xC4, 0x00, 0xC0, 0xD8, 0x03, 0x00, 0xB0, 0x0C, 0x01, 0x40, 0x30, 0x03,
  0x80, 0x60, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x03,
  0x00, 0x04, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x04, 0x00,
  0x30, 0x08, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x20, 0x03, 0x80, 0x60, 0x07,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x68, 0x01, 0x81, 0xB0, 0x03, 0x86, 0x60,
  0x03, 0xF8, 0xC0, 0x01, 0x81, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x04, 0x01,
  0x80, 0x0E, 0x0E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x8F, 0xC0, 0x13, 0xCE,
  0x01, 0x60, 0x60, 0x3C, 0x03, 0x03, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40,
  0x06, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x08,
  0x00, 0xC1, 0x80, 0x08, 0x18, 0x00, 0x81, 0x80, 0x18, 0x10, 0x01, 0x81,
  0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x10, 0x30, 0x03, 0x02, 0x00, 0x30,
  0x20, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x06,
  0x0C, 0x00, 0x40, 0x00, 0x20, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x30, 0x10, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x30, 0x30, 0x02, 0x02, 0x00, 0x20, 0x60, 0x06, 0x0C, 0x00,
  0x61, 0x80, 0x04, 0x10, 0x00, 0x43, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00,
  0x0D, 0xE0, 0x00, 0x92, 0x00, 0x0B, 0x20, 0x01, 0xE3, 0x00, 0x1C, 0x30,
  0x01, 0x83, 0x00, 0x10, 0x30, 0x01, 0x01, 0x00, 0x30, 0x10, 0x03, 0x01,
  0x00, 0x20, 0x18, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x60,
  0x08, 0x04, 0x00, 0x80, 0x40, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x1F, 0x81, 0xF0, 0x02, 0x73,
  0x8E, 0x78, 0x05, 0x81, 0xB0, 0x30, 0x1E, 0x03, 0xC0, 0x30, 0x38, 0x03,
  0x00, 0x60, 0x60, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x01, 0x81, 0x80, 0x30,
  0x03, 0x06, 0x00, 0x60, 0x04, 0x0C, 0x00, 0xC0, 0x08, 0x18, 0x01, 0x00,
  0x30, 0x20, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x01,
  0x03, 0x00, 0x30, 0x02, 0x04, 0x00, 0x40, 0x0C, 0x08, 0x01, 0x80, 0x18,
  0x30, 0x03, 0x00, 0x30, 0x60, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x00, 0x81,
  0x00, 0x10, 0x03, 0x02, 0x00, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x08, 0x18,
  0x01, 0x80, 0x10, 0x30, 0x02, 0x00, 0x60, 0x40, 0x04, 0x00, 0xC0, 0x80,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x02, 0x06, 0x00, 0x40, 0x04, 0x08, 0x00,
  0x80, 0x18, 0x10, 0x03, 0x00, 0x30, 0x60, 0x06, 0x00, 0x60, 0x01, 0x0F,
  0x80, 0x13, 0xCE, 0x01, 0x60, 0x60, 0x3C, 0x03, 0x03, 0x80, 0x30, 0x38,
  0x03, 0x03, 0x00, 0x20, 0x30, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x04, 0x0C, 0x00, 0xC0,
  0x80, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x00, 0x81, 0x80, 0x18,
  0x10, 0x01, 0x81, 0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x30, 0x30, 0x03,
  0x02, 0x00, 0x30, 0x20, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x04, 0x00,
  0x60, 0x40, 0x06, 0x0C, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x79, 0xC0, 0x30,
  0x18, 0x18, 0x06, 0x06, 0x00, 0x83, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x18,
  0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x0C, 0x07, 0x0E, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x43, 0xF0,
  0x00, 0x8E, 0xF0, 0x01, 0x30, 0x70, 0x06, 0xC0, 0x60, 0x0F, 0x00, 0x40,
  0x14, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60,
  0x00, 0x80, 0xC0, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0x80, 0x03,
  0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0xE0, 0x06, 0x01, 0xE0, 0x18, 0x03, 0x40, 0x60, 0x04,
  0xC1, 0x80, 0x08, 0xFE, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x10, 0x0E, 0x71, 0x03, 0x81, 0xB0, 0x30, 0x0B, 0x06, 0x00, 0xA0, 0xC0,
  0x0E, 0x08, 0x00, 0xE1, 0x80, 0x0E, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x00, 0x84,
  0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x10,
  0xC0, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x06,
  0x08, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x34, 0x06, 0x02,
  0xC0, 0x70, 0xCC, 0x03, 0xF8, 0xC0, 0x04, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0x0F, 0x80, 0x9E, 0x40, 0x58, 0x00,
  0x68, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x78, 0xF0, 0x30, 0x08, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x20, 0x0C, 0x0C, 0x06, 0x03, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x7F, 0x3F, 0xE0, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x1F, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x80, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x0C, 0x10,
  0x01, 0x82, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x00, 0x83, 0x00, 0x30, 0x40,
  0x06, 0x08, 0x00, 0x83, 0x00, 0x10, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00,
  0x18, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x80, 0x18, 0x20, 0x03, 0x04, 0x00,
  0x61, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x03,
  0x82, 0x00, 0x60, 0x40, 0x1C, 0x08, 0x02, 0x81, 0x80, 0xB0, 0x30, 0x74,
  0x03, 0xF8, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x40, 0x40, 0xC0,
  0x40, 0xC0, 0x41, 0x80, 0x41, 0x80, 0x41, 0x00, 0x43, 0x00, 0x42, 0x00,
  0x46, 0x00, 0x46, 0x00, 0x4C, 0x00, 0x4C, 0x00, 0x48, 0x00, 0x58, 0x00,
  0x50, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0A, 0x00, 0x70, 0x02, 0x80,
  0x14, 0x01, 0xA0, 0x05, 0x00, 0x48, 0x03, 0x40, 0x32, 0x00, 0x90, 0x0C,
  0x80, 0x64, 0x02, 0x20, 0x11, 0x01, 0x88, 0x04, 0x40, 0x42, 0x03, 0x10,
  0x30, 0x80, 0x84, 0x0C, 0x20, 0x61, 0x02, 0x08, 0x10, 0x41, 0x82, 0x0C,
  0x10, 0x40, 0x83, 0x04, 0x10, 0x20, 0x81, 0x0C, 0x08, 0x60, 0x42, 0x02,
  0x10, 0x11, 0x80, 0x8C, 0x04, 0x40, 0x23, 0x03, 0x10, 0x08, 0x80, 0xCC,
  0x02, 0x60, 0x32, 0x00, 0x90, 0x0D, 0x80, 0x2C, 0x03, 0x40, 0x0B, 0x00,
  0xD0, 0x02, 0x80, 0x3C, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C,
  0x00, 0xC0, 0x02, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x40, 0x30, 0x01, 0x01, 0x80, 0x04,
  0x04, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x00, 0x84, 0x00, 0x02, 0x30,
  0x00, 0x08, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00,
  0x06, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x04,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x80, 0x18, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x08, 0x02,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x01,
  0xE0, 0xE0, 0x38, 0x03, 0xCE, 0x80, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 43, 12, 1, -43 },
  { 61, 11, 16, 15, 6, -43 },
  { 83, 23, 43, 22, 0, -43 },
  { 207, 23, 49, 20, -1, -46 },
  { 348, 26, 44, 31, 3, -43 },
  { 491, 19, 44, 19, -1, -43 },
  { 596, 4, 16, 9, 6, -43 },
  { 604, 16, 52, 14, 2, -43 },
  { 708, 16, 52, 15, -4, -43 },
  { 812, 15, 16, 19, 7, -45 },
  { 842, 20, 28, 24, 2, -35 },
  { 912, 7, 13, 9, -2, -5 },
  { 924, 13, 1, 16, 1, -17 },
  { 926, 3, 4, 9, 1, -4 },
  { 928, 24, 43, 18, -3, -43 },
  { 1057, 19, 44, 21, 1, -43 },
  { 1162, 11, 43, 21, 6, -43 },
  { 1222, 23, 43, 21, -2, -43 },
  { 1346, 22, 44, 21, -1, -43 },
  { 1467, 22, 43, 21, -1, -43 },
  { 1586, 23, 44, 21, -2, -43 },
  { 1713, 21, 44, 21, 1, -43 },
  { 1829, 21, 43, 21, 2, -43 },
  { 1942, 22, 44, 21, -1, -43 },
  { 2063, 20, 44, 21, 0, -43 },
  { 2173, 9, 32, 9, 0, -32 },
  { 2209, 12, 40, 9, -3, -32 },
  { 2269, 20, 24, 24, 2, -33 },
  { 2329, 20, 14, 24, 2, -28 },
  { 2364, 20, 24, 24, 2, -33 },
  { 2424, 16, 43, 14, 1, -43 },
  { 2510, 29, 48, 31, 1, -43 },
  { 2684, 20, 43, 20, -4, -43 },
  { 2792, 23, 43, 22, 0, -43 },
  { 2916, 23, 45, 20, 2, -44 },
  { 3046, 24, 43, 25, 0, -43 },
  { 3175, 23, 43, 20, 0, -43 },
  { 3299, 23, 43, 19, 0, -43 },
  { 3423, 26, 45, 27, 2, -44 },
  { 3570, 27, 43, 26, 0, -43 },
  { 3716, 17, 43, 10, -3, -43 },
  { 3808, 20, 53, 9, -9, -43 },
  { 3941, 25, 43, 21, 0, -43 },
  { 4076, 13, 43, 18, 0, -43 },
  { 4146, 36, 43, 35, 0, -43 },
  { 4340, 29, 43, 28, 0, -43 },
  { 4496, 23, 44, 27, 2, -43 },
  { 4623, 22, 43, 21, 0, -43 },
  { 4742, 23, 53, 27, 2, -43 },
  { 4895, 22, 43, 21, 0, -43 },
  { 5014, 24, 44, 20, -2, -43 },
  { 5146, 18, 43, 18, 4, -43 },
  { 5243, 25, 44, 25, 2, -43 },
  { 5381, 20, 43, 21, 5, -43 },
  { 5489, 36, 43, 36, 4, -43 },
  { 5683, 25, 43, 18, -3, -43 },
  { 5818, 18, 43, 17, 4, -43 },
  { 5915, 25, 43, 18, -3, -43 },
  { 6050, 21, 52, 16, -1, -43 },
  { 6187, 8, 43, 19, 6, -43 },
  { 6230, 21, 52, 16, -4, -43 },
  { 6367, 22, 21, 23, 1, -43 },
  { 6425, 16, 2, 16, -5, 5 },
  { 6429, 5, 10, 12, 9, -46 },
  { 6436, 20, 33, 23, 2, -32 },
  { 6519, 21, 47, 22, 0, -46 },
  { 6643, 16, 33, 16, 2, -32 },
  { 6709, 23, 47, 23, 2, -46 },
  { 6845, 17, 33, 20, 2, -32 },
  { 6916, 26, 60, 11, -8, -46 },
  { 7111, 23, 46, 23, -1, -32 },
  { 7244, 20, 46, 21, 0, -46 },
  { 7359, 11, 43, 9, 0, -43 },
  { 7419, 20, 57, 10, -8, -43 },
  { 7562, 20, 46, 18, 0, -46 },
  { 7677, 12, 46, 9, 0, -46 },
  { 7746, 31, 32, 33, 0, -32 },
  { 7870, 20, 32, 21, 0, -32 },
  { 7950, 18, 33, 22, 2, -32 },
  { 8025, 23, 46, 22, -2, -32 },
  { 8158, 20, 46, 23, 2, -32 },
  { 8273, 17, 32, 14, 0, -32 },
  { 8341, 18, 33, 16, -1, -32 },
  { 8416, 11, 40, 11, 1, -39 },
  { 8471, 19, 33, 21, 2, -32 },
  { 8550, 16, 32, 16, 3, -32 },
  { 8614, 26, 32, 28, 4, -32 },
  { 8718, 22, 32, 17, -3, -32 },
  { 8806, 28, 47, 18, -7, -32 },
  { 8971, 18, 32, 14, -2, -32 },
  { 9043, 20, 52, 19, 2, -43 },
  { 9173, 2, 61, 21, 9, -46 },
  { 9189, 20, 52, 18, -4, -43 },
  { 9319, 20, 5, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC60PT7B_H_
