#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x80, 0x21, 0x21, 0x23, 0x62, 0x42,
  0x42, 0x42, 0x44, 0x84, 0x84, 0x84, 0x00, 0x41, 0x00, 0x43, 0x00, 0x42,
  0x00, 0x82, 0x00, 0x86, 0x00, 0x84, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08,
  0x1F, 0xFF, 0x02, 0x08, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x04, 0x30,
  0x04, 0x20, 0x08, 0x20, 0x08, 0x60, 0x08, 0x40, 0xFF, 0xF8, 0x10, 0x40,
  0x10, 0x80, 0x20, 0x80, 0x20, 0x80, 0x21, 0x00, 0x61, 0x00, 0x41, 0x00,
  0x43, 0x00, 0x42, 0x00, 0x82, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x3F, 0xE0, 0xCC, 0x43, 0x10, 0x04, 0x20, 0x08, 0x40, 0x30,
  0x80, 0x62, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x01, 0x20, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x22, 0x00, 0x44, 0x00,
  0x84, 0x01, 0x08, 0x06, 0x10, 0x08, 0x60, 0x10, 0x80, 0x23, 0x08, 0x4C,
  0x1F, 0xF0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x86, 0x20, 0x41, 0x08, 0x10, 0x82, 0x08, 0x20, 0x82, 0x18, 0x21, 0x04,
  0x08, 0x41, 0x06, 0x20, 0x41, 0x08, 0x30, 0x44, 0x08, 0x11, 0x02, 0x04,
  0x80, 0x83, 0x27, 0xA0, 0x93, 0x18, 0x24, 0x86, 0x12, 0x61, 0x8C, 0x90,
  0x5E, 0x44, 0x10, 0x12, 0x04, 0x08, 0x81, 0x02, 0x20, 0x41, 0x08, 0x20,
  0x46, 0x08, 0x21, 0x02, 0x08, 0x40, 0x86, 0x10, 0x41, 0x04, 0x10, 0xC1,
  0x08, 0x20, 0x62, 0x18, 0x0F, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x06, 0x20,
  0x10, 0x80, 0xC2, 0x02, 0x08, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02, 0x10,
  0x08, 0x80, 0x22, 0x00, 0x90, 0x03, 0x80, 0x06, 0x00, 0x30, 0x01, 0x40,
  0x09, 0x80, 0x62, 0x13, 0x08, 0x88, 0x22, 0x60, 0xC9, 0x01, 0x64, 0x05,
  0x10, 0x14, 0x40, 0x63, 0x01, 0x84, 0x06, 0x10, 0x28, 0x61, 0xA0, 0xFC,
  0x40, 0x24, 0xB4, 0x92, 0x92, 0x00, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00,
  0x04, 0x01, 0x00, 0x43, 0x10, 0x24, 0x46, 0xE0, 0xC0, 0x50, 0x22, 0x30,
  0x80, 0x10, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88, 0xC0, 0xFF, 0x80, 0xB8, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xF0, 0x10, 0xC1, 0x82, 0x08, 0x10, 0x80, 0x84,
  0x04, 0x40, 0x22, 0x01, 0x30, 0x09, 0x00, 0x48, 0x02, 0x40, 0x14, 0x00,
  0xA0, 0x0D, 0x00, 0x48, 0x02, 0xC0, 0x14, 0x00, 0xA0, 0x0D, 0x00, 0x48,
  0x02, 0x40, 0x32, 0x01, 0x10, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x61, 0x02,
  0x04, 0x20, 0x3E, 0x00, 0x03, 0x07, 0x0A, 0x32, 0x62, 0x42, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x01, 0xF8,
  0x04, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x06, 0x06, 0x02,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x80, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0A, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x34, 0x00, 0x24, 0x00, 0x44, 0x00,
  0x44, 0x00, 0x8C, 0x01, 0x88, 0x01, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04,
  0x10, 0x0C, 0x10, 0x08, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x20, 0x40, 0x20, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0xFF, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x08, 0xE0, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x80, 0x80, 0xFF, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x67, 0xC1, 0x61, 0x87, 0x02, 0x18, 0x0C, 0x40,
  0x13, 0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x62, 0x01, 0x08, 0x04, 0x10, 0x20, 0x41, 0x00, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x06, 0x02, 0x02, 0x04,
  0x03, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x03, 0x04, 0x02, 0x04,
  0x02, 0x06, 0x04, 0x02, 0x08, 0x03, 0x10, 0x01, 0xE0, 0x01, 0x80, 0x06,
  0x40, 0x0C, 0x20, 0x10, 0x30, 0x20, 0x10, 0x60, 0x18, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0x40, 0x18, 0x40, 0x10, 0x60,
  0x30, 0x30, 0x60, 0x1F, 0xC0, 0x01, 0xF0, 0x08, 0x20, 0x40, 0xC2, 0x01,
  0x08, 0x04, 0x60, 0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x0C, 0x80, 0x33, 0x01, 0x84, 0x06, 0x18, 0x68, 0x3F,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x03, 0xF0, 0x00, 0x0C, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0xC3, 0x00, 0x01, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x40, 0x80, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x1F, 0x82, 0x08, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x40, 0x30, 0x02, 0x02, 0x00, 0x20,
  0x40, 0x02, 0x08, 0x00, 0x30, 0x80, 0x03, 0x10, 0x08, 0x11, 0x03, 0xE3,
  0x30, 0x44, 0x32, 0x08, 0x43, 0x21, 0x84, 0x26, 0x10, 0x42, 0x43, 0x08,
  0x24, 0x20, 0x82, 0x42, 0x08, 0x24, 0x20, 0x84, 0xC6, 0x10, 0x4C, 0x41,
  0x04, 0x84, 0x10, 0x88, 0x43, 0x08, 0x84, 0x31, 0x08, 0x65, 0x30, 0x83,
  0x8E, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04,
  0x10, 0x30, 0x40, 0x81, 0x02, 0x04, 0x1F, 0xF0, 0x40, 0x43, 0x01, 0x08,
  0x04, 0x20, 0x11, 0x00, 0x44, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x50,
  0x01, 0x40, 0x07, 0x00, 0x10, 0x03, 0xF8, 0x02, 0x06, 0x02, 0x02, 0x02,
  0x03, 0x02, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x02, 0x0C,
  0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x08, 0x08, 0x70, 0x1F, 0xC0, 0x10,
  0x30, 0x10, 0x18, 0x10, 0x08, 0x10, 0x08, 0x30, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x08, 0x20, 0x08, 0x40, 0x18, 0x40, 0x10, 0x40, 0x30, 0x40,
  0x60, 0xC0, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0x04, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x02, 0x0C, 0x02, 0x02, 0x02, 0x03, 0x02, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01,
  0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x03,
  0x10, 0x02, 0x10, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C,
  0x60, 0x08, 0x40, 0x10, 0x40, 0x30, 0x40, 0x60, 0x40, 0xC0, 0xC3, 0x80,
  0xFE, 0x00, 0x03, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x30, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0xF8, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x10, 0x80,
  0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02,
  0x0C, 0x00, 0x81, 0x00, 0x40, 0x30, 0x10, 0x07, 0xFC, 0x00, 0x03, 0x00,
  0x20, 0x40, 0x04, 0x08, 0x01, 0x81, 0x00, 0x20, 0x20, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x10, 0x20, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x20, 0x02,
  0x04, 0x00, 0x40, 0x80, 0x10, 0x10, 0x02, 0x07, 0xFF, 0xC0, 0x80, 0x08,
  0x10, 0x03, 0x02, 0x00, 0x40, 0x40, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20,
  0x40, 0x0C, 0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81,
  0x00, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x10, 0x00, 0x03, 0xF0,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0xF8, 0x00,
  0x03, 0x00, 0xC0, 0x80, 0x40, 0x20, 0x30, 0x08, 0x08, 0x02, 0x04, 0x01,
  0x03, 0x00, 0x41, 0x80, 0x10, 0x40, 0x04, 0x20, 0x03, 0x18, 0x00, 0x8C,
  0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x01, 0x30, 0x00, 0x54, 0x00,
  0x19, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08,
  0x10, 0x02, 0x04, 0x01, 0x81, 0x00, 0x40, 0x40, 0x10, 0x18, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x20, 0x20, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x07, 0xFC, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xA0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x70, 0x28, 0x00,
  0x28, 0x14, 0x00, 0x34, 0x0A, 0x00, 0x12, 0x05, 0x80, 0x1A, 0x06, 0x40,
  0x09, 0x02, 0x20, 0x0C, 0x81, 0x10, 0x04, 0x40, 0x88, 0x06, 0x60, 0x44,
  0x02, 0x20, 0x42, 0x01, 0x10, 0x21, 0x01, 0x08, 0x10, 0x80, 0x84, 0x08,
  0x40, 0x86, 0x04, 0x20, 0x42, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81,
  0x04, 0x20, 0x40, 0x82, 0x10, 0x40, 0xC1, 0x10, 0x20, 0x40, 0x88, 0x10,
  0x20, 0x48, 0x08, 0x10, 0x34, 0x0C, 0x08, 0x1E, 0x04, 0x0C, 0x0E, 0x02,
  0x04, 0x03, 0x01, 0x00, 0x03, 0x00, 0x10, 0x30, 0x03, 0x03, 0x00, 0x20,
  0x38, 0x02, 0x02, 0x80, 0x20, 0x48, 0x02, 0x04, 0x80, 0x60, 0x48, 0x04,
  0x04, 0x80, 0x40, 0xC4, 0x04, 0x08, 0x40, 0x40, 0x84, 0x0C, 0x08, 0x40,
  0x80, 0x84, 0x08, 0x18, 0x60, 0x81, 0x02, 0x08, 0x10, 0x21, 0x01, 0x02,
  0x10, 0x10, 0x21, 0x02, 0x02, 0x10, 0x20, 0x33, 0x02, 0x01, 0x20, 0x20,
  0x12, 0x06, 0x01, 0x20, 0x40, 0x12, 0x04, 0x01, 0xE0, 0x40, 0x0C, 0x04,
  0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xC1, 0x80,
  0xC0, 0x40, 0xC0, 0x20, 0x40, 0x18, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01,
  0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x64, 0x00, 0x32, 0x00, 0x13, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x90, 0x00, 0x88,
  0x00, 0x4C, 0x00, 0x66, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18, 0x40, 0x08,
  0x20, 0x0C, 0x10, 0x04, 0x0C, 0x04, 0x02, 0x04, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x04, 0x18, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x18, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41,
  0x01, 0x06, 0x06, 0x08, 0x30, 0x1F, 0xC0, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xC1,
  0x80, 0xC0, 0x40, 0xC0, 0x20, 0x40, 0x18, 0x40, 0x04, 0x20, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x64, 0x00, 0x32, 0x00, 0x13,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x90, 0x00,
  0x88, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18, 0x40,
  0x08, 0x20, 0x0C, 0x10, 0x04, 0x0C, 0x04, 0x02, 0x04, 0x00, 0xFC, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0xF0, 0x04, 0x18, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x18, 0x04, 0x20, 0x18,
  0x40, 0x20, 0x80, 0xC1, 0x01, 0x06, 0x04, 0x0F, 0xF0, 0x1F, 0x80, 0x21,
  0x00, 0x42, 0x01, 0x04, 0x02, 0x08, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20,
  0x40, 0x40, 0x80, 0x81, 0x01, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x00,
  0x00, 0xFF, 0x03, 0x01, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x80, 0xC0, 0xFF, 0x80,
  0x7F, 0xF8, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x08, 0x00,
  0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x18, 0x01, 0x04, 0x00, 0xC1,
  0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x40, 0x80,
  0x10, 0x20, 0x04, 0x08, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08,
  0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x0C,
  0x02, 0x01, 0x01, 0x80, 0x60, 0xC0, 0x0F, 0xE0, 0x00, 0x80, 0x0E, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x18, 0x80,
  0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x81, 0x02, 0x04, 0x08, 0x30, 0x20,
  0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88, 0x02, 0x60, 0x09,
  0x00, 0x24, 0x00, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x00, 0x40, 0x08, 0x00, 0xE0, 0x04, 0x00, 0xF0, 0x06, 0x00, 0x58,
  0x03, 0x00, 0x2C, 0x01, 0x80, 0x26, 0x01, 0x40, 0x13, 0x00, 0xA0, 0x19,
  0x80, 0xD0, 0x08, 0x80, 0x48, 0x04, 0x40, 0x24, 0x04, 0x20, 0x22, 0x02,
  0x10, 0x11, 0x03, 0x08, 0x18, 0x81, 0x04, 0x08, 0x40, 0x82, 0x04, 0x20,
  0x81, 0x04, 0x10, 0x40, 0x82, 0x08, 0x40, 0x43, 0x04, 0x20, 0x21, 0x02,
  0x10, 0x10, 0x81, 0x10, 0x08, 0x80, 0x88, 0x04, 0x40, 0x48, 0x02, 0x60,
  0x24, 0x01, 0x20, 0x12, 0x00, 0x90, 0x0A, 0x00, 0x50, 0x05, 0x00, 0x28,
  0x03, 0x00, 0x14, 0x01, 0x80, 0x0C, 0x01, 0x40, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x10, 0x04, 0x04, 0x01, 0x82, 0x00,
  0x20, 0x80, 0x08, 0x40, 0x02, 0x30, 0x00, 0x88, 0x00, 0x26, 0x00, 0x09,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x40, 0x00, 0x50, 0x00, 0x24, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03,
  0x18, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x08, 0x02, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x20, 0x20, 0x08, 0x00, 0xC0, 0x1A, 0x00, 0x90,
  0x08, 0x80, 0x44, 0x04, 0x20, 0x21, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08,
  0x10, 0x80, 0xC4, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFE, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xE0, 0x00, 0x81,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0x82, 0x08, 0x20, 0x83, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x10, 0x00, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x0B, 0x00, 0x12, 0x00, 0x46, 0x00, 0x84, 0x02, 0x08, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x24, 0x00, 0x58, 0x00, 0xC0, 0xFF,
  0xE0, 0x84, 0x42, 0x21, 0x10, 0x00, 0x42, 0x07, 0xE8, 0x10, 0x50, 0x40,
  0x61, 0x80, 0xC2, 0x01, 0x8C, 0x02, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11,
  0x00, 0x42, 0x00, 0x84, 0x01, 0x18, 0x02, 0x30, 0x0C, 0x40, 0x10, 0x80,
  0x21, 0x00, 0xC2, 0x01, 0x86, 0x05, 0x04, 0x0C, 0x08, 0x28, 0x0F, 0x90,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x40, 0x13, 0xE0, 0x28, 0x60,
  0xA0, 0x41, 0x80, 0x83, 0x01, 0x04, 0x03, 0x08, 0x06, 0x30, 0x08, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x04, 0x20, 0x08,
  0x40, 0x11, 0x80, 0x43, 0x00, 0x86, 0x02, 0x0C, 0x0C, 0x14, 0x30, 0x4F,
  0xC0, 0x00, 0x50, 0x3E, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x23, 0x00, 0xFD, 0x00,
  0x82, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x40, 0x30, 0x60, 0x10, 0x20, 0x08,
  0x10, 0x04, 0x18, 0x02, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x83, 0x00,
  0x41, 0x80, 0x60, 0x80, 0x20, 0x40, 0x10, 0x20, 0x18, 0x10, 0x0C, 0x0C,
  0x0A, 0x02, 0x06, 0x01, 0x05, 0x00, 0x7C, 0x80, 0x00, 0x80, 0x3E, 0x04,
  0x30, 0x81, 0x10, 0x11, 0x01, 0x20, 0x32, 0x02, 0x60, 0x64, 0x0C, 0x41,
  0x87, 0xE0, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x08, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x03, 0xF8, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x10, 0x80, 0x7E, 0x80, 0x41, 0x40, 0x40, 0x60, 0x60, 0x30, 0x20, 0x18,
  0x30, 0x08, 0x10, 0x04, 0x08, 0x02, 0x0C, 0x03, 0x04, 0x01, 0x02, 0x00,
  0x81, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x30, 0x40, 0x10, 0x20, 0x08, 0x10,
  0x0C, 0x08, 0x06, 0x06, 0x05, 0x01, 0x03, 0x00, 0x82, 0x80, 0x3E, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x01, 0x82, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x80, 0x5F, 0x81, 0xC3, 0x0A, 0x04, 0x30, 0x10, 0xC0,
  0x42, 0x02, 0x08, 0x08, 0x60, 0x21, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40,
  0x42, 0x01, 0x08, 0x04, 0x20, 0x30, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40,
  0x21, 0x01, 0x84, 0x04, 0x30, 0x10, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x3C, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0xC1, 0x06, 0x08, 0x10, 0x20, 0x80, 0x84,
  0x02, 0x30, 0x18, 0x80, 0x44, 0x01, 0x30, 0x05, 0xC0, 0x15, 0x00, 0xE4,
  0x03, 0x10, 0x08, 0x40, 0x21, 0x00, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x10, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x00, 0x40, 0x40, 0x17, 0xE7, 0xE0, 0x60, 0xA0, 0x83, 0x03,
  0x03, 0x0C, 0x0C, 0x0C, 0x20, 0x30, 0x20, 0x80, 0x80, 0x82, 0x02, 0x02,
  0x10, 0x08, 0x08, 0x40, 0x60, 0x21, 0x01, 0x01, 0x04, 0x04, 0x04, 0x30,
  0x10, 0x10, 0x80, 0x40, 0x42, 0x02, 0x01, 0x08, 0x08, 0x08, 0x20, 0x20,
  0x21, 0x80, 0x80, 0x84, 0x06, 0x02, 0x10, 0x10, 0x18, 0x40, 0x40, 0x41,
  0x01, 0x01, 0x08, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x17, 0xE0, 0x70, 0xC2,
  0x81, 0x0C, 0x04, 0x30, 0x10, 0x80, 0x82, 0x02, 0x18, 0x08, 0x40, 0x21,
  0x00, 0x84, 0x04, 0x30, 0x10, 0x80, 0x42, 0x01, 0x08, 0x0C, 0x20, 0x21,
  0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x61, 0x01, 0x08, 0x04, 0x00, 0x00,
  0x80, 0x1F, 0x01, 0x04, 0x10, 0x31, 0x00, 0x88, 0x04, 0xC0, 0x24, 0x01,
  0x60, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x24, 0x01, 0x60, 0x0A, 0x00, 0x50,
  0x06, 0x80, 0x24, 0x01, 0x20, 0x11, 0x80, 0x84, 0x08, 0x20, 0x80, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x9F, 0x00, 0x50, 0xC0, 0x50, 0x20, 0x30, 0x10,
  0x18, 0x0C, 0x08, 0x06, 0x04, 0x03, 0x06, 0x01, 0x82, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x08, 0x10, 0x04, 0x08,
  0x02, 0x0C, 0x02, 0x06, 0x01, 0x03, 0x01, 0x01, 0x81, 0x80, 0xA1, 0x80,
  0xDF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x82, 0x07, 0xE8, 0x10, 0x50, 0x40, 0x61, 0x80, 0xC2, 0x01, 0x8C,
  0x02, 0x10, 0x04, 0x20, 0x08, 0xC0, 0x11, 0x00, 0x42, 0x00, 0x84, 0x01,
  0x08, 0x02, 0x30, 0x0C, 0x40, 0x10, 0x80, 0x21, 0x00, 0xC2, 0x01, 0x86,
  0x05, 0x04, 0x0C, 0x08, 0x28, 0x0F, 0x90, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x30, 0x5E, 0x07, 0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x3F, 0xC3, 0x02, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x40,
  0xC3, 0xFC, 0x00, 0x04, 0x08, 0x20, 0x40, 0x81, 0x1F, 0x88, 0x10, 0x20,
  0x41, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x07, 0x80, 0x08, 0x0C, 0x20, 0x21, 0x00, 0x84, 0x02, 0x10,
  0x18, 0x40, 0x43, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0xC2, 0x02, 0x18,
  0x08, 0x40, 0x21, 0x00, 0x84, 0x06, 0x10, 0x10, 0x80, 0x42, 0x03, 0x08,
  0x0C, 0x20, 0x60, 0xC2, 0x81, 0xF2, 0x00, 0x80, 0x30, 0x06, 0x01, 0x40,
  0x28, 0x09, 0x01, 0x20, 0x64, 0x08, 0x81, 0x10, 0x42, 0x08, 0x62, 0x0C,
  0x41, 0x10, 0x22, 0x06, 0xC0, 0xD0, 0x1A, 0x03, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x00, 0x40, 0x60, 0x28, 0x0C, 0x0D, 0x01, 0x81, 0x20, 0x50, 0x24,
  0x0A, 0x08, 0x82, 0x41, 0x10, 0x48, 0x22, 0x09, 0x08, 0x42, 0x21, 0x08,
  0x44, 0x41, 0x10, 0x88, 0x22, 0x11, 0x04, 0xC2, 0x40, 0x90, 0x48, 0x12,
  0x0A, 0x02, 0x81, 0x40, 0x50, 0x28, 0x1E, 0x0A, 0x02, 0x81, 0x40, 0x50,
  0x28, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x20, 0x04,
  0x20, 0x08, 0x40, 0x20, 0x80, 0xC1, 0x01, 0x02, 0x04, 0x06, 0x18, 0x04,
  0x00, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x00, 0x60, 0x20, 0x0C,
  0x08, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0x41, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x02, 0xC0, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x0F, 0xF0, 0x00, 0x1E, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0xC0, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x1E, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0xFC, 0x06, 0x06, 0x34, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 30, 8, 1, -30 },
  { 31, 8, 11, 11, 4, -30 },
  { 42, 16, 30, 15, 0, -30 },
  { 102, 15, 34, 14, 0, -32 },
  { 166, 18, 31, 22, 2, -30 },
  { 236, 14, 30, 14, -1, -30 },
  { 289, 3, 11, 6, 4, -30 },
  { 294, 11, 37, 10, 1, -30 },
  { 345, 11, 37, 10, -3, -30 },
  { 396, 10, 11, 13, 5, -32 },
  { 410, 15, 19, 17, 1, -24 },
  { 446, 5, 9, 7, -2, -4 },
  { 452, 9, 1, 11, 1, -12 },
  { 454, 2, 3, 6, 1, -3 },
  { 455, 17, 30, 12, -2, -30 },
  { 519, 13, 30, 14, 1, -30 },
  { 568, 8, 30, 14, 4, -30 },
  { 598, 15, 30, 14, -1, -30 },
  { 655, 16, 30, 14, -1, -30 },
  { 715, 16, 30, 14, -1, -30 },
  { 775, 16, 30, 14, -1, -30 },
  { 835, 14, 30, 14, 1, -30 },
  { 888, 14, 30, 14, 2, -30 },
  { 941, 16, 30, 14, -1, -30 },
  { 1001, 14, 30, 14, 0, -30 },
  { 1054, 6, 22, 6, 0, -22 },
  { 1071, 8, 27, 7, -2, -22 },
  { 1098, 15, 17, 17, 1, -23 },
  { 1130, 15, 10, 17, 1, -20 },
  { 1149, 15, 17, 17, 1, -23 },
  { 1181, 11, 30, 10, 1, -30 },
  { 1223, 20, 34, 21, 1, -30 },
  { 1308, 14, 30, 14, -3, -30 },
  { 1361, 16, 30, 16, 0, -30 },
  { 1421, 15, 30, 14, 2, -30 },
  { 1478, 16, 30, 17, 0, -30 },
  { 1538, 16, 30, 14, 0, -30 },
  { 1598, 16, 30, 13, 0, -30 },
  { 1658, 18, 30, 19, 2, -30 },
  { 1726, 19, 30, 18, 0, -30 },
  { 1798, 12, 30, 7, -2, -30 },
  { 1843, 14, 37, 6, -6, -30 },
  { 1908, 18, 30, 15, 0, -30 },
  { 1976, 9, 30, 13, 0, -30 },
  { 2010, 25, 30, 25, 0, -30 },
  { 2104, 20, 30, 19, 0, -30 },
  { 2179, 17, 30, 19, 1, -30 },
  { 2243, 15, 30, 15, 0, -30 },
  { 2300, 17, 37, 19, 1, -30 },
  { 2379, 15, 30, 15, 0, -30 },
  { 2436, 16, 30, 14, -1, -30 },
  { 2496, 13, 30, 12, 3, -30 },
  { 2545, 18, 30, 18, 1, -30 },
  { 2613, 14, 30, 14, 4, -30 },
  { 2666, 25, 30, 25, 3, -30 },
  { 2760, 18, 30, 13, -2, -30 },
  { 2828, 13, 30, 12, 3, -30 },
  { 2877, 17, 30, 13, -2, -30 },
  { 2941, 15, 37, 12, -1, -30 },
  { 3011, 6, 30, 13, 4, -30 },
  { 3034, 15, 37, 12, -3, -30 },
  { 3104, 15, 14, 16, 1, -30 },
  { 3131, 11, 1, 11, -3, 4 },
  { 3133, 4, 7, 9, 6, -32 },
  { 3137, 15, 23, 16, 1, -23 },
  { 3181, 15, 32, 16, 0, -32 },
  { 3241, 12, 23, 11, 1, -23 },
  { 3276, 17, 32, 16, 1, -32 },
  { 3344, 12, 23, 14, 1, -23 },
  { 3379, 19, 42, 8, -6, -32 },
  { 3479, 17, 33, 16, -1, -23 },
  { 3550, 14, 32, 15, 0, -32 },
  { 3606, 8, 30, 7, 0, -30 },
  { 3636, 14, 40, 7, -6, -30 },
  { 3706, 14, 32, 12, 0, -32 },
  { 3762, 8, 32, 6, 0, -32 },
  { 3794, 22, 23, 23, 0, -23 },
  { 3858, 14, 23, 15, 0, -23 },
  { 3899, 13, 23, 15, 1, -23 },
  { 3937, 17, 33, 16, -2, -23 },
  { 4008, 15, 33, 16, 1, -23 },
  { 4070, 12, 23, 10, 0, -23 },
  { 4105, 13, 23, 12, -1, -23 },
  { 4143, 7, 28, 8, 1, -28 },
  { 4168, 14, 22, 15, 1, -22 },
  { 4207, 11, 22, 11, 2, -22 },
  { 4238, 19, 22, 19, 2, -22 },
  { 4291, 15, 22, 12, -2, -22 },
  { 4333, 19, 32, 12, -5, -22 },
  { 4409, 12, 22, 10, -1, -22 },
  { 4442, 15, 37, 13, 1, -30 },
  { 4512, 1, 42, 14, 7, -32 },
  { 4518, 14, 37, 13, -3, -30 },
  { 4583, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC42PT7B_H_
