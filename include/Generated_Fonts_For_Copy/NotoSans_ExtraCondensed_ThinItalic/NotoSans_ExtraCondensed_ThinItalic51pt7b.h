#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x30, 0xC8,
  0x22, 0x08, 0x86, 0x61, 0x90, 0x44, 0x11, 0x04, 0x41, 0x30, 0x88, 0x22,
  0x08, 0x82, 0x00, 0x00, 0x18, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x00, 0x10,
  0x20, 0x02, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00, 0x41,
  0x80, 0x18, 0x20, 0x3F, 0xFF, 0x80, 0x41, 0x80, 0x18, 0x20, 0x02, 0x04,
  0x00, 0x41, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x18, 0x30,
  0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x04, 0x07, 0xFF, 0xF8,
  0x08, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x04, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x03, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01,
  0x06, 0x00, 0x60, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x01, 0xC4, 0x30, 0x10,
  0xC0, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x60, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x21, 0x00, 0x03, 0x30, 0x00,
  0x13, 0x00, 0x01, 0xA0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x58, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x04, 0x60, 0x00, 0xC2,
  0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x18,
  0x20, 0x01, 0x06, 0x00, 0x10, 0x40, 0x81, 0x08, 0x0F, 0x37, 0x00, 0x3F,
  0xC0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xC0, 0x00, 0x19, 0x80, 0x60, 0xC2, 0x01, 0x02, 0x08,
  0x0C, 0x18, 0x20, 0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x08, 0x30,
  0x20, 0x20, 0x81, 0x80, 0x86, 0x06, 0x06, 0x10, 0x10, 0x18, 0xC0, 0x40,
  0x42, 0x01, 0x01, 0x18, 0x04, 0x0C, 0x40, 0x30, 0x33, 0x1E, 0xC0, 0x88,
  0xCF, 0x06, 0x66, 0x1C, 0x11, 0x10, 0x70, 0xCC, 0xC1, 0x42, 0x22, 0x05,
  0xB9, 0x98, 0x13, 0x84, 0x40, 0x40, 0x31, 0x01, 0x00, 0x8C, 0x04, 0x06,
  0x30, 0x30, 0x10, 0x80, 0xC0, 0xC2, 0x02, 0x02, 0x08, 0x08, 0x18, 0x20,
  0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x08, 0x10, 0x60, 0x20, 0x81,
  0x00, 0x86, 0x04, 0x02, 0x10, 0x20, 0x0F, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x3C, 0x00, 0x76, 0x00, 0xC2, 0x00, 0x83, 0x00, 0x83, 0x01, 0x83, 0x01,
  0x03, 0x01, 0x02, 0x01, 0x02, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01,
  0x08, 0x01, 0x18, 0x01, 0x90, 0x01, 0xA0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x02, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x18, 0x61, 0x10, 0x21, 0x20,
  0x23, 0x20, 0x22, 0x60, 0x32, 0x40, 0x16, 0x40, 0x14, 0xC0, 0x1C, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0x40, 0x28, 0x40, 0x6C, 0x60, 0xC4, 0x3F,
  0x84, 0x04, 0x00, 0x32, 0x22, 0x64, 0x44, 0x4C, 0x88, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x0C, 0x20, 0x19, 0x00, 0x2B, 0xE0, 0xE0, 0x0E, 0x00, 0xC8,
  0x08, 0x41, 0x81, 0x04, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x04, 0x30, 0xC2, 0x18, 0x43, 0x08, 0x21, 0x0C, 0x00, 0xFF, 0xE0,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xEE, 0x01,
  0x82, 0x01, 0x03, 0x02, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x30,
  0x03, 0x20, 0x03, 0x20, 0x03, 0x60, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40,
  0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0x80,
  0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0xC0,
  0x60, 0xC0, 0x40, 0x40, 0x80, 0x61, 0x80, 0x3F, 0x00, 0x08, 0x00, 0x01,
  0x81, 0x43, 0x63, 0x33, 0x13, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0x38, 0x00, 0x80, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x1C, 0xF0, 0x0E, 0x03, 0x00, 0x80, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x40, 0x30, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x0D, 0x80, 0x01,
  0x20, 0x00, 0x64, 0x00, 0x08, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x10,
  0x80, 0x06, 0x10, 0x00, 0x82, 0x00, 0x20, 0xC0, 0x0C, 0x10, 0x01, 0x02,
  0x00, 0x60, 0x40, 0x08, 0x08, 0x02, 0x03, 0x00, 0xC0, 0x40, 0x10, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x60, 0x20, 0x0C, 0x0C, 0x01, 0x01, 0x00, 0x20,
  0x7F, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xE0, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x20, 0x00,
  0x7F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x02, 0x03, 0x80, 0x7F,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x0E, 0x20, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x8F, 0xC0, 0x26, 0x18, 0x1A, 0x03, 0x07, 0x00, 0x41, 0xC0,
  0x10, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04,
  0x30, 0x01, 0x0C, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x02, 0x0C,
  0x00, 0x83, 0x00, 0x60, 0xC0, 0x10, 0x10, 0x0C, 0x06, 0x06, 0x00, 0x83,
  0x00, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0E, 0x70, 0x02, 0x03, 0x00, 0x80, 0x20, 0x30, 0x06, 0x04,
  0x00, 0x40, 0x80, 0x08, 0x30, 0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x08,
  0x01, 0x01, 0x00, 0x20, 0x20, 0x08, 0x06, 0x03, 0x00, 0x40, 0xC0, 0x0C,
  0x30, 0x00, 0xCC, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0x88, 0x00, 0x61,
  0x80, 0x10, 0x18, 0x04, 0x01, 0x01, 0x80, 0x30, 0x60, 0x02, 0x0C, 0x00,
  0x41, 0x00, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00,
  0x86, 0x00, 0x10, 0x40, 0x06, 0x0C, 0x00, 0x80, 0x80, 0x30, 0x1C, 0x1C,
  0x00, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x73, 0x00, 0x60,
  0xC0, 0x60, 0x20, 0x60, 0x18, 0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x8C, 0x00, 0x46, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C,
  0x40, 0x06, 0x20, 0x03, 0x10, 0x01, 0x88, 0x01, 0x84, 0x01, 0xC3, 0x00,
  0xA0, 0xC1, 0xB0, 0x3F, 0x98, 0x0F, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x70, 0x0F, 0xE0,
  0x01, 0x80, 0x00, 0x02, 0x07, 0x06, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x1C, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0xF3,
  0x82, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x02, 0x01, 0x00, 0x03, 0x02, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x07, 0xC1, 0x18, 0x08,
  0x41, 0x18, 0x10, 0xC1, 0x10, 0x20, 0xC1, 0x30, 0x60, 0x83, 0x30, 0x40,
  0x83, 0x20, 0xC1, 0x83, 0x20, 0x81, 0x02, 0x60, 0x81, 0x02, 0x61, 0x81,
  0x02, 0x41, 0x83, 0x06, 0x41, 0x02, 0x04, 0x41, 0x02, 0x04, 0x41, 0x06,
  0x0C, 0xC1, 0x06, 0x08, 0xC1, 0x06, 0x08, 0xC1, 0x0A, 0x10, 0xC1, 0x0A,
  0x30, 0xC1, 0x92, 0x60, 0xC0, 0xE3, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x10, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x05, 0x00, 0x0D, 0x00, 0x09, 0x00, 0x09, 0x00, 0x19, 0x00, 0x11,
  0x00, 0x31, 0x00, 0x21, 0x00, 0x21, 0x00, 0x61, 0x00, 0x41, 0x00, 0xC1,
  0x00, 0x81, 0x00, 0x81, 0x01, 0x81, 0x01, 0x01, 0x03, 0x01, 0x03, 0xFF,
  0x07, 0xFF, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x00, 0xFF, 0x80, 0x30, 0x38, 0x06,
  0x01, 0x00, 0x80, 0x30, 0x10, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x18,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x20, 0x60,
  0x0C, 0x08, 0x01, 0x01, 0x00, 0x40, 0x20, 0x30, 0x0F, 0xF8, 0x01, 0x0F,
  0x00, 0x20, 0x18, 0x04, 0x01, 0x01, 0x80, 0x30, 0x30, 0x02, 0x04, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x00,
  0x82, 0x00, 0x30, 0x40, 0x04, 0x18, 0x01, 0x82, 0x00, 0x20, 0x40, 0x0C,
  0x08, 0x03, 0x01, 0x07, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0x9C, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x08, 0x01, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x10,
  0x06, 0x01, 0x00, 0x20, 0x10, 0x02, 0x03, 0x00, 0x30, 0x30, 0x03, 0x02,
  0x00, 0x30, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x30,
  0x40, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x04, 0x10, 0x00,
  0x41, 0x00, 0x0C, 0x10, 0x00, 0x83, 0x00, 0x08, 0x30, 0x01, 0x82, 0x00,
  0x10, 0x20, 0x03, 0x02, 0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0xC0, 0x40,
  0x18, 0x04, 0x07, 0x00, 0xC3, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFE, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF8, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0xE0, 0x06, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xF8, 0xC0, 0x00, 0x42, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC2, 0x00, 0x02,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x01, 0x83, 0x00, 0x06, 0x0C,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x02, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10, 0x00,
  0x40, 0x20, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x00,
  0x80, 0x02, 0x01, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0F, 0xFF, 0xF0, 0x10,
  0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x60, 0x01,
  0x80, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x18, 0x0C,
  0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x00, 0x80, 0xC0,
  0x0C, 0x04, 0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x60, 0x00, 0x82,
  0x00, 0x0C, 0x30, 0x00, 0x43, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x01,
  0x98, 0x00, 0x0D, 0xC0, 0x00, 0x4A, 0x00, 0x02, 0x90, 0x00, 0x18, 0x80,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10,
  0x30, 0x01, 0x81, 0x80, 0x08, 0x04, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x08, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x18, 0x05, 0x00, 0x00, 0x70, 0x0A, 0x00, 0x00,
  0xA0, 0x14, 0x00, 0x03, 0xC0, 0x28, 0x00, 0x05, 0x00, 0xD0, 0x00, 0x1A,
  0x01, 0xA0, 0x00, 0x24, 0x02, 0x40, 0x00, 0xD8, 0x04, 0x80, 0x01, 0x30,
  0x09, 0x00, 0x06, 0x40, 0x32, 0x00, 0x08, 0x80, 0x44, 0x00, 0x31, 0x00,
  0x8C, 0x00, 0x46, 0x01, 0x18, 0x01, 0x88, 0x06, 0x30, 0x02, 0x10, 0x0C,
  0x60, 0x0C, 0x20, 0x10, 0xC0, 0x10, 0xC0, 0x20, 0x80, 0x61, 0x80, 0x41,
  0x00, 0x82, 0x01, 0x82, 0x03, 0x04, 0x03, 0x04, 0x04, 0x08, 0x04, 0x08,
  0x08, 0x30, 0x08, 0x10, 0x30, 0x60, 0x10, 0x20, 0x40, 0x80, 0x60, 0x41,
  0x81, 0x00, 0x80, 0x82, 0x02, 0x01, 0x01, 0x0C, 0x0C, 0x02, 0x02, 0x10,
  0x18, 0x0C, 0x04, 0x60, 0x20, 0x18, 0x08, 0x80, 0x40, 0x20, 0x1B, 0x00,
  0x80, 0x40, 0x34, 0x03, 0x00, 0x80, 0x78, 0x04, 0x03, 0x00, 0xE0, 0x08,
  0x06, 0x01, 0xC0, 0x10, 0x00, 0x00, 0xC0, 0x01, 0x01, 0xC0, 0x03, 0x01,
  0xC0, 0x03, 0x01, 0x40, 0x02, 0x01, 0x40, 0x02, 0x01, 0x60, 0x02, 0x03,
  0x60, 0x06, 0x03, 0x20, 0x06, 0x02, 0x20, 0x04, 0x02, 0x20, 0x04, 0x02,
  0x30, 0x04, 0x06, 0x30, 0x0C, 0x04, 0x10, 0x08, 0x04, 0x10, 0x08, 0x04,
  0x10, 0x08, 0x0C, 0x10, 0x18, 0x0C, 0x18, 0x18, 0x08, 0x18, 0x10, 0x08,
  0x08, 0x10, 0x08, 0x08, 0x10, 0x18, 0x08, 0x30, 0x18, 0x0C, 0x30, 0x10,
  0x0C, 0x20, 0x10, 0x04, 0x20, 0x10, 0x04, 0x20, 0x30, 0x04, 0x60, 0x30,
  0x06, 0x40, 0x20, 0x06, 0x40, 0x20, 0x06, 0x40, 0x60, 0x02, 0x40, 0x60,
  0x02, 0xC0, 0x40, 0x02, 0x80, 0x40, 0x03, 0x80, 0x40, 0x03, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x07, 0x38, 0x00, 0xC0,
  0xC0, 0x10, 0x06, 0x03, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x20, 0xC0,
  0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x24,
  0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x04,
  0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01,
  0x88, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x0C, 0x00,
  0x40, 0xC0, 0x0C, 0x04, 0x01, 0x80, 0x60, 0x10, 0x03, 0x06, 0x00, 0x1F,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x70, 0x06, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x02,
  0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x0C, 0x08,
  0x01, 0x81, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x00, 0xC0, 0x20,
  0x70, 0x07, 0xF8, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0x38, 0x00,
  0xC0, 0xC0, 0x10, 0x06, 0x03, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00, 0x20,
  0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x03,
  0x30, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00,
  0x24, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00,
  0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80,
  0x01, 0x88, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80, 0x06, 0x0C,
  0x00, 0x40, 0xC0, 0x0C, 0x04, 0x01, 0x80, 0x60, 0x10, 0x03, 0x06, 0x00,
  0x1F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0xFE, 0x00, 0x30, 0x70, 0x06, 0x02, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x02, 0x00, 0x80, 0xC0, 0x18, 0x18, 0x03, 0x02, 0x00, 0x60, 0x40,
  0x08, 0x08, 0x01, 0x03, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x01, 0x01, 0x00,
  0x60, 0x60, 0x08, 0x0C, 0x03, 0x01, 0x01, 0xC0, 0x3F, 0xE0, 0x07, 0xF0,
  0x01, 0x86, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x18, 0x06, 0x02, 0x00, 0xC0, 0x40, 0x08, 0x08, 0x01, 0x03, 0x00, 0x20,
  0x60, 0x06, 0x00, 0x00, 0x1F, 0x80, 0x07, 0x1F, 0x01, 0x80, 0x20, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x08, 0x07, 0x00, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00,
  0x60, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08,
  0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00, 0x0C,
  0x08, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0x81, 0x00,
  0x0C, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x06, 0x00, 0x10, 0x20, 0x01, 0x81,
  0x00, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x20, 0x01,
  0x81, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x20, 0x10,
  0x01, 0x00, 0x80, 0x18, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00, 0x7F, 0x80,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x13, 0x00,
  0x0C, 0xC0, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x10, 0xC0, 0x0C,
  0x30, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x0C, 0x0C,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x10, 0x0C, 0x0C, 0x03, 0x02,
  0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC2, 0x00,
  0x31, 0x80, 0x0C, 0x40, 0x03, 0x30, 0x00, 0xC8, 0x00, 0x36, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x30, 0x00,
  0xB0, 0x01, 0x40, 0x06, 0xC0, 0x05, 0x00, 0x13, 0x00, 0x34, 0x00, 0xCC,
  0x00, 0x90, 0x02, 0x30, 0x02, 0xC0, 0x08, 0x80, 0x13, 0x00, 0x62, 0x00,
  0x4C, 0x01, 0x08, 0x03, 0x30, 0x0C, 0x20, 0x08, 0xC0, 0x20, 0x80, 0x23,
  0x00, 0x82, 0x01, 0x8C, 0x06, 0x08, 0x04, 0x30, 0x10, 0x20, 0x30, 0x80,
  0xC0, 0x80, 0x82, 0x02, 0x02, 0x02, 0x08, 0x08, 0x08, 0x18, 0x20, 0x60,
  0x20, 0x40, 0x81, 0x00, 0x83, 0x02, 0x0C, 0x02, 0x08, 0x08, 0x20, 0x08,
  0x20, 0x20, 0x80, 0x21, 0x80, 0x86, 0x00, 0x84, 0x02, 0x10, 0x02, 0x30,
  0x08, 0xC0, 0x08, 0x80, 0x22, 0x00, 0x22, 0x00, 0x88, 0x00, 0x98, 0x02,
  0x60, 0x02, 0x40, 0x09, 0x00, 0x0B, 0x00, 0x2C, 0x00, 0x28, 0x00, 0xA0,
  0x00, 0xA0, 0x02, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x20, 0x06, 0x01,
  0x00, 0x18, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x81, 0x80, 0x02, 0x04, 0x00,
  0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x86, 0x00, 0x03, 0x10, 0x00, 0x0C,
  0xC0, 0x00, 0x32, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x20, 0x30, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x10, 0x04, 0x00, 0x40, 0x30, 0x01, 0x00, 0x60, 0x03, 0x60, 0x02, 0x60,
  0x06, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x20, 0x10, 0x20, 0x30, 0x20,
  0x20, 0x20, 0x60, 0x20, 0x40, 0x30, 0xC0, 0x30, 0x80, 0x31, 0x80, 0x11,
  0x00, 0x13, 0x00, 0x12, 0x00, 0x16, 0x00, 0x14, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81,
  0x02, 0x04, 0x0C, 0x18, 0x30, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x02, 0xC0, 0x00, 0xC8, 0x00, 0x11, 0x80, 0x06, 0x10, 0x00, 0x83,
  0x00, 0x30, 0x20, 0x04, 0x06, 0x01, 0x80, 0x40, 0x20, 0x0C, 0x0C, 0x01,
  0x81, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x23, 0x00, 0x06, 0xC0, 0x00,
  0x60, 0xFF, 0xF8, 0xC2, 0x18, 0x43, 0x08, 0x41, 0x00, 0xFC, 0x40, 0x61,
  0xB0, 0x30, 0x28, 0x18, 0x0A, 0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x18,
  0x40, 0x04, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x08, 0x60,
  0x02, 0x18, 0x00, 0x84, 0x00, 0x61, 0x00, 0x18, 0x40, 0x04, 0x10, 0x01,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x06, 0x04, 0x01, 0x81,
  0x00, 0xA0, 0x60, 0x68, 0x0C, 0x34, 0x01, 0xF9, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x3E, 0x00, 0x90, 0xC0, 0x68, 0x18, 0x1C, 0x02, 0x07,
  0x00, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00,
  0x30, 0x80, 0x08, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18,
  0x40, 0x06, 0x10, 0x01, 0x0C, 0x00, 0x43, 0x00, 0x30, 0x80, 0x08, 0x20,
  0x06, 0x18, 0x01, 0x07, 0x00, 0xC1, 0x40, 0x20, 0x50, 0x18, 0x16, 0x0C,
  0x0C, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0xF8, 0x18, 0x41, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x04, 0x0F,
  0xC0, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFC, 0xC0,
  0x18, 0x6C, 0x03, 0x02, 0x80, 0x60, 0x28, 0x0C, 0x01, 0x80, 0x80, 0x18,
  0x18, 0x01, 0x01, 0x00, 0x10, 0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x03,
  0x02, 0x00, 0x20, 0x60, 0x02, 0x06, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00,
  0x60, 0x40, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x02, 0x80, 0x60, 0x58, 0x03,
  0x0D, 0x00, 0x1F, 0x90, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x03, 0x18, 0x08,
  0x18, 0x20, 0x30, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x08, 0x02, 0x30, 0x0C,
  0x40, 0x30, 0x80, 0x43, 0x03, 0x06, 0x1C, 0x0F, 0xE0, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x40, 0x7F, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0x90, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x10,
  0x06, 0x1B, 0x00, 0xC0, 0xA0, 0x18, 0x0A, 0x03, 0x00, 0x60, 0x20, 0x06,
  0x06, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00,
  0xC0, 0x80, 0x08, 0x18, 0x00, 0x81, 0x80, 0x08, 0x10, 0x01, 0x81, 0x00,
  0x18, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x07, 0x01, 0x00, 0x60, 0x10, 0x0E, 0x01, 0x00, 0xA0, 0x18, 0x1E, 0x00,
  0xC3, 0x40, 0x07, 0xE4, 0x00, 0x10, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x27, 0xE0, 0x16, 0x18, 0x0E, 0x06, 0x0E, 0x03, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x0C,
  0x10, 0x04, 0x18, 0x02, 0x0C, 0x01, 0x04, 0x01, 0x82, 0x00, 0xC1, 0x00,
  0x41, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x18, 0x20, 0x0C, 0x10, 0x04, 0x18,
  0x02, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0x83, 0x00, 0x40, 0x01, 0xC0,
  0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x01, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x18, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x08, 0x04,
  0x0C, 0x02, 0x0C, 0x01, 0x04, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x46, 0x00,
  0x22, 0x00, 0x13, 0x00, 0x1A, 0x80, 0x0B, 0x60, 0x05, 0x30, 0x03, 0x08,
  0x03, 0x04, 0x01, 0x82, 0x00, 0x81, 0x00, 0x40, 0xC0, 0x20, 0x60, 0x30,
  0x10, 0x18, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x83, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x00, 0x02, 0x7E, 0x1F, 0x80, 0xB0, 0xD8, 0x30, 0x70, 0x14, 0x04, 0x14,
  0x06, 0x01, 0x06, 0x01, 0x80, 0x41, 0x80, 0x40, 0x10, 0x40, 0x10, 0x04,
  0x30, 0x04, 0x03, 0x0C, 0x03, 0x00, 0xC2, 0x00, 0x80, 0x20, 0x80, 0x20,
  0x08, 0x20, 0x08, 0x02, 0x18, 0x06, 0x01, 0x86, 0x01, 0x80, 0x61, 0x00,
  0x40, 0x10, 0x40, 0x10, 0x04, 0x10, 0x04, 0x01, 0x0C, 0x03, 0x00, 0xC2,
  0x00, 0x80, 0x20, 0x80, 0x20, 0x08, 0x20, 0x08, 0x02, 0x18, 0x06, 0x01,
  0x86, 0x01, 0x80, 0x61, 0x00, 0x40, 0x10, 0x40, 0x10, 0x04, 0x10, 0x04,
  0x01, 0x0C, 0x03, 0x00, 0xC0, 0x02, 0x7E, 0x01, 0x61, 0x81, 0xE0, 0x60,
  0xA0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x10, 0x04, 0x18, 0x02, 0x0C, 0x01,
  0x04, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x10, 0x40,
  0x18, 0x20, 0x0C, 0x10, 0x04, 0x18, 0x02, 0x08, 0x01, 0x04, 0x01, 0x82,
  0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0x80, 0x30, 0x40, 0x18, 0x20, 0x08,
  0x30, 0x04, 0x00, 0x00, 0xFC, 0x03, 0x86, 0x06, 0x02, 0x04, 0x02, 0x0C,
  0x03, 0x08, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20,
  0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40,
  0x06, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x40,
  0x10, 0x40, 0x30, 0x60, 0x60, 0x30, 0xC0, 0x1F, 0x80, 0x04, 0x00, 0x00,
  0x8F, 0x80, 0x09, 0x8C, 0x00, 0xA0, 0x60, 0x1C, 0x02, 0x01, 0x40, 0x20,
  0x18, 0x03, 0x01, 0x80, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03,
  0x02, 0x00, 0x30, 0x20, 0x02, 0x06, 0x00, 0x20, 0x60, 0x02, 0x04, 0x00,
  0x60, 0x40, 0x06, 0x04, 0x00, 0x40, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0xC0,
  0x08, 0x0C, 0x01, 0x80, 0x80, 0x10, 0x1C, 0x03, 0x01, 0x40, 0x20, 0x14,
  0x06, 0x01, 0x60, 0xC0, 0x33, 0xF0, 0x03, 0x0C, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x40, 0x61, 0xB0, 0x20, 0x28, 0x10, 0x0A, 0x0C, 0x01,
  0x82, 0x00, 0x61, 0x80, 0x18, 0x40, 0x04, 0x10, 0x01, 0x0C, 0x00, 0xC2,
  0x00, 0x30, 0x80, 0x08, 0x60, 0x02, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00,
  0x18, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C,
  0x10, 0x06, 0x04, 0x01, 0x81, 0x00, 0xA0, 0x60, 0x78, 0x0C, 0x36, 0x03,
  0xF9, 0x00, 0x10, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x7C, 0x0B, 0x00, 0x78, 0x01, 0x40,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x06, 0x0C, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x61, 0x01, 0x83, 0xFE, 0x00, 0x60, 0x00, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0xFE, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xF8, 0x10,
  0x00, 0x04, 0x01, 0x82, 0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0x80, 0x30,
  0x40, 0x18, 0x20, 0x08, 0x30, 0x04, 0x10, 0x02, 0x08, 0x03, 0x04, 0x01,
  0x86, 0x00, 0x83, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x40, 0x10, 0x60,
  0x08, 0x30, 0x04, 0x10, 0x06, 0x08, 0x03, 0x04, 0x01, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0xA0, 0xC0, 0xF0, 0x20, 0xD0, 0x0F, 0xC8, 0x01, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00, 0x68, 0x02, 0x40, 0x12, 0x01,
  0x90, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x61, 0x02, 0x08, 0x30, 0x41, 0x02,
  0x08, 0x10, 0xC0, 0x84, 0x04, 0x60, 0x22, 0x01, 0x30, 0x09, 0x00, 0x48,
  0x02, 0xC0, 0x14, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x18, 0x07,
  0x00, 0x20, 0x0A, 0x00, 0xC0, 0x14, 0x01, 0x80, 0x48, 0x07, 0x00, 0x90,
  0x0A, 0x03, 0x20, 0x14, 0x04, 0x40, 0x48, 0x08, 0x80, 0x90, 0x31, 0x03,
  0x20, 0x42, 0x04, 0x41, 0x84, 0x18, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x18, 0x21, 0x84, 0x20, 0x42, 0x08, 0xC0, 0x8C, 0x11, 0x01, 0x10, 0x22,
  0x02, 0x20, 0x4C, 0x04, 0xC0, 0x90, 0x09, 0x01, 0x20, 0x16, 0x02, 0x80,
  0x28, 0x05, 0x00, 0x50, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x40, 0x00, 0x02, 0x00, 0xC0, 0xC0, 0x20, 0x10, 0x18, 0x04, 0x04,
  0x01, 0x03, 0x00, 0x41, 0x80, 0x18, 0x40, 0x06, 0x30, 0x00, 0x88, 0x00,
  0x24, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0x88, 0x00, 0x62, 0x00, 0x30, 0x80,
  0x08, 0x20, 0x06, 0x0C, 0x01, 0x01, 0x00, 0x80, 0x40, 0x60, 0x10, 0x10,
  0x04, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x20, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x08, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30,
  0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x31, 0x00, 0x00, 0x33, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x36, 0x00, 0x00, 0x34, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x04, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0xE1, 0xC0, 0x60,
  0x38, 0xD0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 36, 10, 1, -36 },
  { 46, 10, 13, 13, 5, -36 },
  { 63, 19, 36, 19, 0, -36 },
  { 149, 20, 42, 17, -1, -39 },
  { 254, 22, 38, 27, 2, -37 },
  { 359, 16, 38, 16, -1, -37 },
  { 435, 4, 13, 7, 5, -36 },
  { 442, 14, 44, 12, 1, -36 },
  { 519, 14, 44, 12, -4, -36 },
  { 596, 13, 14, 16, 6, -39 },
  { 619, 18, 24, 20, 1, -30 },
  { 673, 6, 11, 8, -2, -5 },
  { 682, 11, 1, 13, 1, -14 },
  { 684, 2, 3, 8, 1, -3 },
  { 685, 20, 36, 15, -2, -36 },
  { 775, 16, 38, 18, 1, -37 },
  { 851, 9, 36, 18, 5, -36 },
  { 892, 20, 37, 18, -2, -37 },
  { 985, 19, 38, 18, -1, -37 },
  { 1076, 19, 37, 18, -1, -37 },
  { 1164, 19, 37, 18, -1, -36 },
  { 1252, 18, 38, 18, 1, -37 },
  { 1338, 17, 36, 18, 2, -36 },
  { 1415, 19, 38, 18, -1, -37 },
  { 1506, 17, 38, 18, 0, -37 },
  { 1587, 8, 27, 8, 0, -27 },
  { 1614, 10, 33, 8, -2, -27 },
  { 1656, 18, 20, 20, 1, -28 },
  { 1701, 18, 12, 20, 1, -24 },
  { 1728, 18, 20, 20, 1, -28 },
  { 1773, 13, 37, 12, 1, -37 },
  { 1834, 24, 42, 26, 1, -37 },
  { 1960, 16, 37, 17, -3, -37 },
  { 2034, 19, 36, 19, 0, -36 },
  { 2120, 19, 38, 17, 2, -37 },
  { 2211, 20, 36, 21, 0, -36 },
  { 2301, 19, 36, 17, 0, -36 },
  { 2387, 19, 36, 16, 0, -36 },
  { 2473, 22, 38, 23, 2, -37 },
  { 2578, 23, 36, 22, 0, -36 },
  { 2682, 15, 36, 8, -3, -36 },
  { 2750, 16, 45, 8, -7, -36 },
  { 2840, 21, 36, 18, 0, -36 },
  { 2935, 11, 36, 15, 0, -36 },
  { 2985, 31, 36, 30, 0, -36 },
  { 3125, 24, 36, 24, 0, -36 },
  { 3233, 20, 38, 23, 2, -37 },
  { 3328, 19, 36, 18, 0, -36 },
  { 3414, 20, 46, 23, 2, -37 },
  { 3529, 19, 36, 18, 0, -36 },
  { 3615, 20, 38, 17, -1, -37 },
  { 3710, 16, 36, 15, 3, -36 },
  { 3782, 21, 37, 22, 2, -36 },
  { 3880, 18, 36, 18, 4, -36 },
  { 3961, 30, 36, 31, 4, -36 },
  { 4096, 22, 36, 15, -3, -36 },
  { 4195, 16, 36, 15, 3, -36 },
  { 4267, 21, 36, 16, -2, -36 },
  { 4362, 18, 44, 14, -1, -36 },
  { 4461, 7, 36, 16, 5, -36 },
  { 4493, 18, 44, 14, -3, -36 },
  { 4592, 19, 17, 20, 1, -36 },
  { 4633, 13, 1, 13, -4, 5 },
  { 4635, 5, 8, 10, 7, -39 },
  { 4640, 18, 28, 19, 1, -27 },
  { 4703, 18, 40, 19, 0, -39 },
  { 4793, 13, 28, 14, 2, -27 },
  { 4839, 20, 40, 19, 1, -39 },
  { 4939, 15, 28, 17, 1, -27 },
  { 4992, 22, 51, 9, -7, -39 },
  { 5133, 20, 39, 19, -1, -27 },
  { 5231, 17, 39, 18, 0, -39 },
  { 5314, 10, 36, 8, 0, -36 },
  { 5359, 17, 48, 8, -7, -36 },
  { 5461, 17, 39, 15, 0, -39 },
  { 5544, 10, 39, 8, 0, -39 },
  { 5593, 26, 27, 28, 0, -27 },
  { 5681, 17, 27, 18, 0, -27 },
  { 5739, 16, 28, 18, 1, -27 },
  { 5795, 20, 39, 19, -2, -27 },
  { 5893, 18, 39, 19, 1, -27 },
  { 5981, 14, 27, 12, 0, -27 },
  { 6029, 15, 28, 14, -1, -27 },
  { 6082, 9, 34, 9, 1, -33 },
  { 6121, 17, 28, 18, 1, -27 },
  { 6181, 13, 27, 14, 3, -27 },
  { 6225, 23, 27, 23, 3, -27 },
  { 6303, 18, 27, 14, -2, -27 },
  { 6364, 24, 39, 15, -6, -27 },
  { 6481, 15, 27, 12, -2, -27 },
  { 6532, 17, 44, 16, 2, -36 },
  { 6626, 1, 51, 18, 8, -39 },
  { 6633, 17, 44, 16, -3, -36 },
  { 6727, 17, 4, 20, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC51PT7B_H_
