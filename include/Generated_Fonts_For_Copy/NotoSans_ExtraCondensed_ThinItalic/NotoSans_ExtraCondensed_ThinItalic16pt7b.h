#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x02, 0x00, 0xBB, 0x60, 0x14, 0x52, 0x9F, 0x29,
  0x25, 0x3E, 0x92, 0x8A, 0x00, 0x08, 0xF5, 0x14, 0x50, 0x81, 0x0C, 0x28,
  0xA5, 0x38, 0x40, 0x61, 0x4A, 0x95, 0x4A, 0x96, 0xF6, 0xD9, 0x32, 0xA5,
  0x54, 0xE0, 0x11, 0x4A, 0x53, 0x11, 0x95, 0x94, 0xA5, 0xE0, 0xF0, 0x18,
  0x88, 0x84, 0x22, 0x10, 0x84, 0x21, 0x04, 0x20, 0x11, 0x11, 0x11, 0x11,
  0x12, 0x24, 0x88, 0x2F, 0x4A, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x58,
  0xF0, 0x80, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x00,
  0x19, 0x4A, 0x94, 0xA6, 0x31, 0x8C, 0xA5, 0xC0, 0x79, 0x24, 0xA4, 0x92,
  0x00, 0x1C, 0x04, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x07, 0xC0,
  0x39, 0x10, 0x41, 0x08, 0x43, 0x02, 0x08, 0x21, 0x38, 0x04, 0x21, 0x86,
  0x28, 0xA4, 0xA4, 0x91, 0xE1, 0x08, 0x3D, 0x04, 0x10, 0x70, 0x20, 0x82,
  0x08, 0x4E, 0x00, 0x0C, 0xC2, 0x10, 0x41, 0xC4, 0xA2, 0x8A, 0x29, 0x1C,
  0xF8, 0x44, 0x22, 0x11, 0x08, 0x84, 0x20, 0x18, 0x94, 0x51, 0x48, 0xC5,
  0x24, 0x8A, 0x28, 0xBC, 0x11, 0x52, 0x94, 0xA5, 0x27, 0x08, 0x85, 0xC0,
  0x40, 0x02, 0x20, 0x00, 0x02, 0x50, 0x04, 0x66, 0x30, 0x30, 0x20, 0x40,
  0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0x83, 0x11, 0x88, 0x00, 0x70, 0x42, 0x11,
  0x11, 0x08, 0x40, 0x01, 0x00, 0x1F, 0x21, 0x41, 0x4D, 0x55, 0xA5, 0xA9,
  0xAA, 0xBE, 0x80, 0x80, 0x70, 0x08, 0xC6, 0x32, 0x95, 0x69, 0x4C, 0x62,
  0x3C, 0x92, 0x51, 0x69, 0x64, 0x92, 0x8A, 0x2F, 0x00, 0x1C, 0x84, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x3C, 0x92, 0x51, 0x45, 0x14, 0x61,
  0x8A, 0x2F, 0x00, 0x3C, 0x82, 0x10, 0x79, 0x04, 0x20, 0x82, 0x0F, 0x00,
  0x3C, 0x82, 0x10, 0x41, 0xE4, 0x20, 0x82, 0x08, 0x00, 0x1C, 0x45, 0x04,
  0x08, 0x10, 0x27, 0x42, 0x89, 0x12, 0x27, 0xC0, 0x22, 0x44, 0x8A, 0x17,
  0xA8, 0x91, 0x42, 0x85, 0x12, 0x20, 0x38, 0x84, 0x42, 0x10, 0x88, 0x42,
  0x30, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x40, 0x26, 0x48,
  0xA2, 0x86, 0x0C, 0x14, 0x48, 0x91, 0x22, 0x20, 0x22, 0x24, 0x44, 0x48,
  0x88, 0xF0, 0x20, 0xC8, 0x22, 0x19, 0x46, 0x52, 0x94, 0xA5, 0x52, 0x54,
  0x99, 0x26, 0x49, 0x10, 0x21, 0x22, 0x32, 0x52, 0x52, 0x52, 0x4C, 0x8C,
  0x8C, 0x88, 0x88, 0x18, 0x94, 0x61, 0x86, 0x18, 0x62, 0x8A, 0x29, 0x38,
  0x3C, 0x92, 0x51, 0x49, 0xC4, 0x20, 0x82, 0x08, 0x00, 0x18, 0x94, 0x61,
  0x86, 0x18, 0x62, 0x8A, 0x29, 0x38, 0x20, 0x82, 0x00, 0x3C, 0x92, 0x51,
  0x49, 0xC5, 0x24, 0x92, 0x49, 0x00, 0x1C, 0x84, 0x10, 0x40, 0x81, 0x04,
  0x08, 0x21, 0x3C, 0xF9, 0x08, 0x84, 0x21, 0x10, 0x84, 0x20, 0x22, 0x45,
  0x0A, 0x14, 0x48, 0x91, 0x42, 0x89, 0x11, 0xC0, 0x86, 0x28, 0xA4, 0x92,
  0x4A, 0x28, 0xC3, 0x08, 0x00, 0x88, 0x62, 0x29, 0x8A, 0x64, 0x99, 0x2A,
  0x4A, 0xA3, 0x28, 0xCC, 0x21, 0x08, 0x80, 0x12, 0x28, 0x50, 0xC1, 0x02,
  0x0C, 0x14, 0x48, 0x92, 0x20, 0x8C, 0xA5, 0x4A, 0x21, 0x10, 0x84, 0x20,
  0x1E, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x83, 0xE0, 0x39, 0x08,
  0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x60, 0xAA, 0xA9, 0x54, 0x1C, 0x10,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x23, 0x80, 0x30, 0xA4, 0x91,
  0x84, 0xF0, 0x90, 0x18, 0x94, 0x51, 0x8A, 0x28, 0xA2, 0x70, 0x20, 0x82,
  0x0E, 0x25, 0x14, 0x51, 0x4A, 0x28, 0xBC, 0x19, 0x10, 0x88, 0x42, 0x10,
  0x60, 0x02, 0x04, 0x10, 0xE2, 0x48, 0x91, 0x44, 0x89, 0x12, 0x23, 0x80,
  0x11, 0x52, 0x9F, 0x42, 0x10, 0x70, 0x06, 0x10, 0x20, 0x61, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x40, 0x18, 0x94, 0x51, 0x8A,
  0x28, 0xA2, 0x70, 0x41, 0x04, 0xE0, 0x21, 0x08, 0x62, 0xA5, 0x29, 0x4C,
  0x65, 0x20, 0x20, 0x24, 0x92, 0x92, 0x00, 0x08, 0x00, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x22, 0x00, 0x21, 0x08, 0x44, 0xA9, 0x8C, 0x64, 0xA5,
  0x20, 0x24, 0x94, 0x92, 0x52, 0x40, 0x1A, 0x25, 0x49, 0x49, 0x49, 0x49,
  0x91, 0x92, 0x92, 0x11, 0x52, 0x94, 0xA6, 0x32, 0x90, 0x11, 0x52, 0x98,
  0xC6, 0x32, 0x70, 0x0C, 0x24, 0x89, 0x12, 0x24, 0x91, 0x22, 0x78, 0x81,
  0x04, 0x08, 0x00, 0x18, 0x94, 0x51, 0x8A, 0x28, 0xA2, 0x70, 0x41, 0x04,
  0x10, 0x12, 0x44, 0x44, 0x88, 0x80, 0x3A, 0x10, 0x84, 0x10, 0x42, 0xE0,
  0x2D, 0x24, 0xA4, 0x98, 0x45, 0x24, 0x92, 0x4A, 0x29, 0x3C, 0x99, 0xAA,
  0xCC, 0x88, 0x93, 0x26, 0xD5, 0xAD, 0x93, 0x24, 0x48, 0x24, 0xA1, 0x04,
  0x30, 0xC5, 0x22, 0x13, 0x12, 0x14, 0x14, 0x14, 0x18, 0x10, 0x10, 0x10,
  0x20, 0x20, 0xC0, 0x38, 0x44, 0x42, 0x21, 0x1E, 0x39, 0x08, 0x44, 0x22,
  0x08, 0x84, 0x21, 0x08, 0x20, 0xFF, 0xFF, 0x18, 0x42, 0x11, 0x08, 0x22,
  0x11, 0x08, 0x42, 0x60, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 4, 2, -11 },
  { 8, 6, 11, 6, 0, -11 },
  { 17, 6, 13, 5, 0, -12 },
  { 27, 7, 12, 8, 1, -12 },
  { 38, 5, 12, 5, 0, -12 },
  { 46, 1, 4, 2, 2, -11 },
  { 47, 5, 14, 4, 0, -11 },
  { 56, 4, 14, 4, -1, -11 },
  { 63, 4, 4, 5, 2, -12 },
  { 65, 6, 7, 6, 0, -9 },
  { 71, 2, 3, 3, -1, -1 },
  { 72, 4, 1, 4, 0, -5 },
  { 73, 1, 1, 2, 0, -1 },
  { 74, 7, 11, 5, -1, -11 },
  { 84, 5, 12, 5, 0, -12 },
  { 92, 3, 11, 5, 2, -11 },
  { 97, 7, 12, 5, -1, -12 },
  { 108, 6, 12, 5, 0, -12 },
  { 117, 6, 12, 5, 0, -12 },
  { 126, 6, 11, 5, 0, -11 },
  { 135, 6, 12, 5, 0, -12 },
  { 144, 5, 11, 5, 1, -11 },
  { 151, 6, 12, 5, 0, -12 },
  { 160, 5, 12, 5, 0, -12 },
  { 168, 2, 8, 2, 0, -8 },
  { 170, 3, 10, 3, -1, -8 },
  { 174, 6, 7, 6, 0, -9 },
  { 180, 6, 4, 6, 0, -8 },
  { 183, 6, 7, 6, 0, -9 },
  { 189, 5, 12, 4, 0, -12 },
  { 197, 8, 12, 8, 0, -11 },
  { 209, 5, 11, 5, -1, -11 },
  { 216, 6, 11, 6, 0, -11 },
  { 225, 6, 12, 5, 1, -12 },
  { 234, 6, 11, 7, 0, -11 },
  { 243, 6, 11, 5, 0, -11 },
  { 252, 6, 11, 5, 0, -11 },
  { 261, 7, 12, 7, 1, -12 },
  { 272, 7, 11, 7, 0, -11 },
  { 282, 5, 11, 3, -1, -11 },
  { 289, 5, 14, 2, -2, -11 },
  { 298, 7, 11, 6, 0, -11 },
  { 308, 4, 11, 5, 0, -11 },
  { 314, 10, 11, 9, 0, -11 },
  { 328, 8, 11, 7, 0, -11 },
  { 339, 6, 12, 7, 1, -12 },
  { 348, 6, 11, 6, 0, -11 },
  { 357, 6, 15, 7, 1, -12 },
  { 369, 6, 11, 6, 0, -11 },
  { 378, 6, 12, 5, 0, -12 },
  { 387, 5, 11, 5, 1, -11 },
  { 394, 7, 11, 7, 0, -11 },
  { 404, 6, 11, 6, 1, -11 },
  { 413, 10, 11, 10, 1, -11 },
  { 427, 7, 11, 5, -1, -11 },
  { 437, 5, 11, 5, 1, -11 },
  { 444, 7, 11, 5, -1, -11 },
  { 454, 5, 14, 4, 0, -11 },
  { 463, 2, 11, 5, 2, -11 },
  { 466, 6, 14, 4, -1, -11 },
  { 477, 6, 5, 6, 0, -11 },
  { 481, 4, 1, 4, -1, 1 },
  { 482, 2, 2, 3, 2, -12 },
  { 483, 6, 9, 6, 0, -9 },
  { 490, 6, 12, 6, 0, -12 },
  { 499, 5, 9, 4, 0, -9 },
  { 505, 7, 12, 6, 0, -12 },
  { 516, 5, 9, 5, 0, -9 },
  { 522, 7, 16, 3, -2, -12 },
  { 536, 6, 13, 6, 0, -9 },
  { 546, 5, 12, 6, 0, -12 },
  { 554, 3, 11, 2, 0, -11 },
  { 559, 5, 15, 3, -2, -11 },
  { 569, 5, 12, 5, 0, -12 },
  { 577, 3, 12, 2, 0, -12 },
  { 582, 8, 9, 9, 0, -9 },
  { 591, 5, 9, 6, 0, -9 },
  { 597, 5, 9, 6, 0, -9 },
  { 603, 7, 13, 6, -1, -9 },
  { 615, 6, 13, 6, 0, -9 },
  { 625, 4, 9, 4, 0, -9 },
  { 630, 5, 9, 4, 0, -9 },
  { 636, 3, 10, 3, 0, -10 },
  { 640, 6, 8, 6, 0, -8 },
  { 646, 4, 8, 4, 1, -8 },
  { 650, 7, 8, 7, 1, -8 },
  { 657, 6, 8, 5, -1, -8 },
  { 663, 8, 12, 5, -2, -8 },
  { 675, 5, 8, 4, -1, -8 },
  { 680, 5, 14, 5, 1, -11 },
  { 689, 1, 16, 5, 2, -12 },
  { 691, 5, 14, 5, -1, -11 },
  { 700, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC16PT7B_H_
