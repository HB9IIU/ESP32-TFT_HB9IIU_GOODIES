#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x00, 0x00, 0x01, 0x02,
  0x04, 0x00, 0x22, 0x85, 0x0A, 0x24, 0x48, 0xA1, 0x42, 0x89, 0x10, 0x00,
  0x42, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x01, 0x04, 0x1F, 0xFE, 0x04, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00,
  0x84, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x21, 0x03, 0xFF, 0xC0, 0x84,
  0x02, 0x08, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x01,
  0x08, 0x04, 0x20, 0x00, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x03,
  0xFC, 0x11, 0x10, 0x84, 0x06, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04,
  0x40, 0x09, 0x00, 0x34, 0x00, 0x50, 0x00, 0xC0, 0x03, 0x00, 0x0A, 0x00,
  0x24, 0x00, 0x90, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20,
  0x11, 0x00, 0x88, 0x3F, 0xC0, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x0E, 0x03, 0x08, 0x81, 0x08, 0x41, 0x84, 0x20, 0x84, 0x10, 0xC2, 0x08,
  0x41, 0x04, 0x21, 0x82, 0x20, 0x81, 0x10, 0x41, 0x10, 0x20, 0x88, 0x10,
  0x48, 0xE8, 0x64, 0x94, 0x24, 0x86, 0x12, 0xC3, 0x12, 0x41, 0x71, 0x20,
  0x81, 0x20, 0xC0, 0x90, 0x40, 0x88, 0x20, 0x44, 0x10, 0x42, 0x08, 0x22,
  0x0C, 0x21, 0x04, 0x10, 0x82, 0x10, 0x42, 0x08, 0x11, 0x08, 0x0F, 0x00,
  0x01, 0xC0, 0x22, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x0C, 0x20, 0xC4,
  0x04, 0x40, 0x48, 0x04, 0x80, 0x50, 0x06, 0x00, 0x60, 0x0A, 0x01, 0x20,
  0x22, 0x14, 0x31, 0x41, 0x28, 0x12, 0x81, 0x28, 0x0C, 0x80, 0xC8, 0x08,
  0x81, 0x88, 0x14, 0x82, 0x47, 0xC4, 0x29, 0x24, 0xA4, 0x90, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x18, 0x00, 0x08, 0x02, 0x02, 0x11,
  0x06, 0x88, 0xF8, 0x60, 0x48, 0x44, 0x41, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x07,
  0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88, 0xC0, 0xFF, 0xE0, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x23, 0x04, 0x10,
  0x81, 0x08, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x60, 0x14,
  0x01, 0x40, 0x14, 0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48,
  0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x46, 0x07,
  0xC0, 0x06, 0x1C, 0x59, 0x2C, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x00, 0x03, 0xF0, 0x18, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x0C, 0x18, 0x10, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x82, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x0D, 0x00, 0x12, 0x00, 0x44, 0x00,
  0x88, 0x02, 0x30, 0x0C, 0x40, 0x10, 0x80, 0x41, 0x00, 0x82, 0x02, 0x08,
  0x0C, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x82, 0x02, 0x0F, 0xFF, 0x80,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0xFC, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x82, 0x06, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x18, 0x01, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x8F, 0x05, 0x8C, 0x30, 0x21, 0x80, 0x98, 0x04, 0xC0, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x48, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x0C,
  0x10, 0xC0, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x06, 0x18, 0x18, 0x10, 0x20,
  0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x60, 0x11, 0x80, 0x14, 0x00, 0x30, 0x01, 0xB0, 0x04, 0x20, 0x10,
  0x20, 0x40, 0x41, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x02, 0x30, 0x04,
  0x20, 0x08, 0x40, 0x30, 0x80, 0x40, 0x81, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x30, 0x83, 0x06, 0x10, 0x11, 0x80, 0x88, 0x04, 0x40, 0x26, 0x01, 0x20,
  0x09, 0x00, 0x48, 0x02, 0x40, 0x32, 0x01, 0x90, 0x08, 0x40, 0xC2, 0x0A,
  0x0F, 0x90, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x01, 0x81, 0xF8, 0x00, 0x04, 0x30, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x30, 0xC0,
  0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x00, 0x0F, 0xC2, 0x08,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0x00, 0x60, 0x00,
  0x00, 0x3E, 0x00, 0x30, 0x40, 0x10, 0x08, 0x08, 0x03, 0x04, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x3C, 0x48, 0x32, 0x12, 0x08,
  0x84, 0x84, 0x21, 0x42, 0x08, 0x50, 0x84, 0x14, 0x21, 0x09, 0x10, 0x42,
  0xC4, 0x10, 0xA1, 0x08, 0x28, 0x42, 0x12, 0x10, 0x84, 0x84, 0x63, 0x21,
  0x18, 0x88, 0x7B, 0xC2, 0x08, 0x20, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0x20,
  0x09, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10, 0x81, 0x04, 0x08,
  0x20, 0xC1, 0x07, 0xF8, 0x20, 0x42, 0x02, 0x10, 0x11, 0x80, 0x88, 0x04,
  0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x10, 0x03, 0xF0,
  0x04, 0x10, 0x18, 0x10, 0x20, 0x30, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x20, 0x40, 0xC1, 0x06, 0x03, 0xF0,
  0x04, 0x18, 0x08, 0x08, 0x10, 0x10, 0x40, 0x20, 0x80, 0x61, 0x00, 0x82,
  0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x18, 0x40, 0x20, 0x80, 0x82, 0x06,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0x04, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x04, 0x30,
  0x18, 0x10, 0x20, 0x30, 0x40, 0x20, 0x80, 0x41, 0x00, 0x86, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x31, 0x00, 0x42, 0x00, 0x88,
  0x02, 0x10, 0x04, 0x20, 0x10, 0x40, 0x40, 0x81, 0x02, 0x0C, 0x07, 0xE0,
  0x00, 0x03, 0xFE, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x07, 0xF8, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0xC0, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xF8, 0x80, 0x04, 0x40, 0x04, 0x60,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0xC6, 0x00, 0x41, 0x00, 0x20,
  0x80, 0x10, 0x40, 0x08, 0x10, 0x0C, 0x0C, 0x04, 0x01, 0xFE, 0x00, 0x02,
  0x00, 0x40, 0x80, 0x20, 0x60, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00,
  0x20, 0x40, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30,
  0x20, 0x08, 0x10, 0x02, 0x07, 0xFF, 0x81, 0x00, 0x20, 0x40, 0x10, 0x10,
  0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x10, 0x02,
  0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x18, 0x10, 0x04, 0x08, 0x01, 0x02,
  0x00, 0x40, 0x03, 0xE0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x80, 0x7C, 0x00, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x04, 0xC0,
  0x1C, 0x00, 0x02, 0x01, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x08,
  0x04, 0x10, 0x04, 0x30, 0x08, 0x20, 0x08, 0x40, 0x08, 0x80, 0x09, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x16, 0x00, 0x19, 0x00, 0x19, 0x00, 0x11, 0x00,
  0x21, 0x00, 0x20, 0x80, 0x20, 0x80, 0x20, 0x80, 0x40, 0x80, 0x40, 0xC0,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x60, 0x80, 0x20, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x1F, 0xF0, 0x03, 0x00, 0x02, 0x06, 0x00, 0x0C,
  0x14, 0x00, 0x18, 0x28, 0x00, 0x50, 0x50, 0x00, 0xC0, 0xA0, 0x02, 0x81,
  0x40, 0x05, 0x04, 0x80, 0x12, 0x09, 0x00, 0x24, 0x12, 0x00, 0x90, 0x24,
  0x01, 0x20, 0x48, 0x04, 0x41, 0x10, 0x08, 0x82, 0x20, 0x31, 0x04, 0x40,
  0x44, 0x08, 0x81, 0x88, 0x11, 0x02, 0x10, 0x42, 0x0C, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x21, 0x02, 0x08, 0x82, 0x08, 0x11, 0x04, 0x10, 0x24, 0x08,
  0x20, 0x48, 0x20, 0x40, 0xA0, 0x40, 0x81, 0x40, 0x82, 0x03, 0x01, 0x04,
  0x06, 0x06, 0x00, 0x02, 0x00, 0x60, 0x60, 0x08, 0x1C, 0x01, 0x02, 0x80,
  0x20, 0x50, 0x04, 0x0A, 0x01, 0x01, 0x40, 0x20, 0x44, 0x04, 0x08, 0x80,
  0x81, 0x10, 0x30, 0x22, 0x04, 0x04, 0x40, 0x81, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x80, 0x82, 0x10, 0x10, 0x42, 0x04, 0x08, 0x40, 0x80, 0x88,
  0x10, 0x12, 0x02, 0x02, 0x40, 0xC0, 0x48, 0x10, 0x09, 0x02, 0x00, 0xA0,
  0x40, 0x18, 0x08, 0x03, 0x02, 0x00, 0x60, 0x40, 0x0C, 0x00, 0x00, 0xF8,
  0x01, 0x04, 0x02, 0x02, 0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x03,
  0x10, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x10, 0x40, 0x20,
  0x40, 0x40, 0x20, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x08, 0x60, 0x60, 0xC1,
  0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x43, 0x01, 0x08, 0x04, 0x20, 0x10,
  0x80, 0x82, 0x02, 0x10, 0x18, 0x40, 0xC1, 0x06, 0x07, 0xE0, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x01, 0x04, 0x02,
  0x02, 0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0x03, 0x10, 0x03, 0x30,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40, 0x40, 0x20,
  0xC0, 0x3F, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x03, 0xE0, 0x08, 0x60, 0x60, 0x81, 0x01,
  0x04, 0x04, 0x10, 0x10, 0x40, 0x43, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x82, 0x02, 0x10, 0x10, 0x40, 0xC1, 0xFC, 0x04, 0x40, 0x11, 0x00, 0x84,
  0x02, 0x08, 0x08, 0x20, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x40,
  0x41, 0x01, 0x08, 0x04, 0x20, 0x10, 0x01, 0xFC, 0x06, 0x04, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x82, 0x03, 0x07, 0xF8, 0x00, 0xFF,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x00, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x02,
  0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x40, 0x08,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x10, 0x80, 0x20,
  0x80, 0x20, 0x80, 0x60, 0x40, 0x40, 0x40, 0x80, 0x3F, 0x00, 0x80, 0x0E,
  0x00, 0x28, 0x01, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x10,
  0x80, 0x42, 0x03, 0x08, 0x08, 0x20, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20,
  0x20, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00, 0x88, 0x02, 0x40,
  0x09, 0x00, 0x2C, 0x00, 0xA0, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x0E, 0x00, 0xC0, 0x14, 0x01, 0x80, 0x28, 0x03,
  0x00, 0x90, 0x0A, 0x01, 0x20, 0x14, 0x06, 0x40, 0x48, 0x08, 0x80, 0x90,
  0x11, 0x01, 0x20, 0x42, 0x04, 0x40, 0x84, 0x08, 0x83, 0x08, 0x21, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x84, 0x20, 0x42, 0x08, 0x40, 0x84, 0x11, 0x81,
  0x10, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40, 0x90, 0x09, 0x01, 0x20, 0x12,
  0x02, 0x80, 0x2C, 0x05, 0x00, 0x50, 0x0A, 0x00, 0xA0, 0x28, 0x01, 0x80,
  0x50, 0x03, 0x00, 0xA0, 0x06, 0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0x40, 0x10, 0x40, 0x08, 0x20, 0x04, 0x20, 0x02,
  0x30, 0x00, 0x90, 0x00, 0x50, 0x00, 0x28, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x10, 0x04, 0x00, 0x40, 0x1A, 0x00, 0x90,
  0x08, 0x40, 0x42, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x21, 0x01, 0x08,
  0x08, 0x80, 0x44, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0xF8, 0x00, 0x84, 0x21, 0x04, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x01, 0xF8, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x40, 0x21, 0x00, 0x82, 0x04, 0x08, 0x10, 0x30, 0x80, 0x46, 0x01, 0x90,
  0x02, 0xC0, 0x0C, 0xFF, 0xC0, 0x91, 0x22, 0x40, 0x03, 0xC8, 0x31, 0x42,
  0x0A, 0x20, 0x31, 0x01, 0x90, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x12, 0x01,
  0x90, 0x09, 0x80, 0x48, 0x02, 0x40, 0x32, 0x01, 0x10, 0x08, 0x80, 0xC4,
  0x06, 0x30, 0x50, 0x87, 0x03, 0xE8, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x13,
  0x80, 0x91, 0x02, 0x82, 0x0C, 0x08, 0x20, 0x21, 0x80, 0xC6, 0x02, 0x10,
  0x08, 0x40, 0x21, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x08,
  0x04, 0x60, 0x31, 0x80, 0x86, 0x02, 0x18, 0x10, 0xB0, 0x82, 0x7C, 0x00,
  0x03, 0xE0, 0xC4, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x07, 0x90,
  0x18, 0xA0, 0x41, 0x41, 0x01, 0x82, 0x03, 0x08, 0x04, 0x10, 0x08, 0x60,
  0x10, 0x80, 0x21, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x20, 0x18,
  0x40, 0x20, 0x80, 0x41, 0x01, 0x82, 0x03, 0x06, 0x0A, 0x04, 0x28, 0x07,
  0xD0, 0x00, 0x03, 0xC0, 0x8C, 0x20, 0x88, 0x11, 0x02, 0x40, 0x48, 0x12,
  0x02, 0x40, 0x88, 0x63, 0xF0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x83, 0xF0, 0x00, 0x07, 0x80, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x3E, 0x00, 0x68, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xF2, 0x03, 0x14, 0x08, 0x28,
  0x20, 0x30, 0x40, 0x61, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x20,
  0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x84, 0x03, 0x08, 0x04, 0x10, 0x08,
  0x20, 0x30, 0x40, 0x60, 0xC1, 0x40, 0x87, 0x00, 0xFA, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x08, 0x10,
  0x1F, 0xC0, 0x00, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x27, 0x02, 0xC4, 0x1C, 0x10, 0xC0,
  0x84, 0x04, 0x20, 0x23, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x60, 0x62,
  0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x04, 0x40, 0x40, 0x02, 0x0C, 0x08, 0x00, 0x00, 0x00, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x42, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x20, 0x62, 0x02, 0x20, 0x13, 0x00, 0x90, 0x05,
  0x80, 0x54, 0x03, 0x20, 0x18, 0x80, 0x84, 0x04, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x40, 0x81, 0x0C, 0x08, 0x40, 0x40, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x09, 0xE1, 0xC0, 0xA1, 0x63, 0x0C, 0x14, 0x10, 0xC1, 0x81, 0x08,
  0x18, 0x11, 0x81, 0x01, 0x10, 0x10, 0x11, 0x01, 0x02, 0x10, 0x10, 0x21,
  0x02, 0x02, 0x20, 0x20, 0x22, 0x02, 0x02, 0x20, 0x20, 0x42, 0x06, 0x04,
  0x20, 0x40, 0x44, 0x04, 0x04, 0x40, 0x40, 0xC4, 0x04, 0x08, 0x40, 0x80,
  0x84, 0x08, 0x08, 0x80, 0x80, 0x80, 0x08, 0xE0, 0x58, 0x83, 0x02, 0x18,
  0x10, 0x80, 0x8C, 0x08, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x88, 0x08,
  0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x88, 0x08, 0x40, 0x42, 0x02, 0x10,
  0x10, 0x80, 0x88, 0x08, 0x00, 0x03, 0xC0, 0x46, 0x08, 0x21, 0x01, 0x10,
  0x12, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x01, 0x40, 0x2C, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x68, 0x04, 0x80, 0x48, 0x08, 0xC1, 0x84, 0x30, 0x3E,
  0x00, 0x01, 0x38, 0x02, 0x44, 0x02, 0x82, 0x03, 0x02, 0x03, 0x02, 0x02,
  0x03, 0x06, 0x03, 0x04, 0x02, 0x04, 0x02, 0x04, 0x02, 0x08, 0x02, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x18, 0x04, 0x18, 0x08, 0x18,
  0x18, 0x18, 0x10, 0x18, 0x20, 0x27, 0xC0, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x03, 0xC8, 0x21, 0x42, 0x0A, 0x20, 0x31, 0x01, 0x90, 0x08, 0x80,
  0x4C, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x10, 0x08, 0x80, 0xC4, 0x06, 0x30, 0x50, 0x87, 0x03, 0xE8, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x08, 0xE1, 0x60, 0x28, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x03, 0xE0, 0x43, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x88,
  0x10, 0xFE, 0x00, 0x08, 0x10, 0x20, 0x41, 0x87, 0xD4, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0xC0, 0x08, 0x18, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x10,
  0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x21, 0x03, 0x10, 0x10, 0x80, 0x84, 0x0C, 0x20, 0x61, 0x05, 0x07, 0xD0,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x08, 0x82,
  0x21, 0x88, 0x42, 0x10, 0x88, 0x22, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A,
  0x03, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x60, 0x30, 0x28, 0x0C, 0x0A, 0x03,
  0x02, 0x81, 0x41, 0x20, 0x50, 0x48, 0x24, 0x22, 0x09, 0x08, 0x82, 0x42,
  0x21, 0x11, 0x08, 0x44, 0x42, 0x21, 0x20, 0x88, 0x48, 0x24, 0x12, 0x09,
  0x05, 0x02, 0x41, 0x40, 0xA0, 0x60, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0xC0, 0x40, 0x00, 0x04, 0x04, 0x10, 0x10, 0x20, 0x80, 0x86, 0x02,
  0x10, 0x08, 0x80, 0x22, 0x00, 0x90, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80, 0xC1, 0x02,
  0x04, 0x10, 0x10, 0xC0, 0x40, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04,
  0x00, 0x84, 0x00, 0x42, 0x00, 0x23, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x07, 0x80, 0x00, 0x07, 0xE1, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x0F, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x07, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x04, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x3C, 0x00, 0xE0, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x03, 0xC0, 0x00, 0x7E, 0x0C, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 28, 8, 1, -28 },
  { 26, 7, 10, 10, 4, -28 },
  { 35, 15, 28, 14, 0, -28 },
  { 88, 14, 32, 13, 0, -30 },
  { 144, 17, 28, 20, 2, -28 },
  { 204, 12, 28, 13, 0, -28 },
  { 246, 3, 10, 6, 4, -28 },
  { 250, 11, 34, 9, 1, -28 },
  { 297, 11, 34, 9, -3, -28 },
  { 344, 9, 11, 12, 5, -30 },
  { 357, 13, 18, 16, 1, -23 },
  { 387, 5, 9, 6, -2, -4 },
  { 393, 8, 1, 10, 1, -11 },
  { 394, 1, 3, 6, 1, -3 },
  { 395, 16, 28, 11, -2, -28 },
  { 451, 12, 28, 13, 1, -28 },
  { 493, 7, 28, 13, 4, -28 },
  { 518, 14, 28, 13, -1, -28 },
  { 567, 15, 28, 13, -1, -28 },
  { 620, 15, 28, 13, -1, -28 },
  { 673, 15, 28, 13, -1, -28 },
  { 726, 13, 28, 13, 1, -28 },
  { 772, 14, 28, 13, 1, -28 },
  { 821, 15, 28, 13, -1, -28 },
  { 874, 13, 28, 13, 0, -28 },
  { 920, 6, 21, 6, 0, -21 },
  { 936, 8, 26, 6, -2, -21 },
  { 962, 13, 16, 16, 1, -22 },
  { 988, 13, 9, 16, 1, -18 },
  { 1003, 13, 16, 16, 1, -22 },
  { 1029, 11, 28, 9, 0, -28 },
  { 1068, 18, 32, 20, 1, -28 },
  { 1140, 13, 28, 13, -3, -28 },
  { 1186, 15, 28, 15, 0, -28 },
  { 1239, 15, 28, 13, 1, -28 },
  { 1292, 15, 28, 16, 0, -28 },
  { 1345, 15, 28, 13, 0, -28 },
  { 1398, 15, 28, 12, 0, -28 },
  { 1451, 17, 28, 18, 1, -28 },
  { 1511, 18, 28, 17, 0, -28 },
  { 1574, 11, 28, 6, -2, -28 },
  { 1613, 13, 35, 6, -6, -28 },
  { 1670, 16, 28, 14, 0, -28 },
  { 1726, 9, 28, 12, 0, -28 },
  { 1758, 23, 28, 23, 0, -28 },
  { 1839, 19, 28, 18, 0, -28 },
  { 1906, 16, 28, 17, 1, -28 },
  { 1962, 14, 28, 14, 0, -28 },
  { 2011, 16, 35, 17, 1, -28 },
  { 2081, 14, 28, 14, 0, -28 },
  { 2130, 15, 28, 13, -1, -28 },
  { 2183, 11, 28, 11, 3, -28 },
  { 2222, 16, 28, 17, 1, -28 },
  { 2278, 14, 28, 13, 3, -28 },
  { 2327, 23, 28, 23, 3, -28 },
  { 2408, 17, 28, 12, -2, -28 },
  { 2468, 13, 28, 11, 2, -28 },
  { 2514, 16, 28, 12, -2, -28 },
  { 2570, 14, 34, 11, -1, -28 },
  { 2630, 5, 28, 12, 4, -28 },
  { 2648, 13, 34, 11, -2, -28 },
  { 2704, 14, 13, 15, 1, -28 },
  { 2727, 10, 1, 10, -3, 4 },
  { 2729, 3, 6, 8, 6, -30 },
  { 2732, 13, 21, 15, 1, -21 },
  { 2767, 14, 30, 15, 0, -30 },
  { 2820, 11, 21, 10, 1, -21 },
  { 2849, 15, 30, 15, 1, -30 },
  { 2906, 11, 21, 13, 1, -21 },
  { 2935, 17, 39, 7, -5, -30 },
  { 3018, 15, 30, 15, -1, -21 },
  { 3075, 13, 30, 14, 0, -30 },
  { 3124, 7, 28, 6, 0, -28 },
  { 3149, 13, 37, 6, -5, -28 },
  { 3210, 13, 30, 12, 0, -30 },
  { 3259, 8, 30, 6, 0, -30 },
  { 3289, 20, 21, 21, 0, -21 },
  { 3342, 13, 21, 14, 0, -21 },
  { 3377, 12, 21, 14, 1, -21 },
  { 3409, 16, 30, 15, -2, -21 },
  { 3469, 13, 30, 15, 1, -21 },
  { 3518, 11, 21, 9, 0, -21 },
  { 3547, 12, 21, 11, -1, -21 },
  { 3579, 7, 26, 7, 1, -26 },
  { 3602, 13, 21, 14, 1, -21 },
  { 3637, 10, 21, 11, 2, -21 },
  { 3664, 18, 21, 18, 2, -21 },
  { 3712, 14, 21, 11, -2, -21 },
  { 3749, 17, 30, 11, -4, -21 },
  { 3813, 11, 21, 9, -1, -21 },
  { 3842, 13, 34, 12, 1, -28 },
  { 3898, 1, 40, 13, 6, -30 },
  { 3903, 14, 34, 12, -3, -28 },
  { 3963, 13, 3, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC39PT7B_H_
