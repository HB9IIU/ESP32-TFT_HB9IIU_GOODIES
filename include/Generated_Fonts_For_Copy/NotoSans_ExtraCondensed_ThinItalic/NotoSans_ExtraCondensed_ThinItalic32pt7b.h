#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x00, 0x00, 0x08, 0x30, 0x00, 0x25, 0x14,
  0x51, 0x4A, 0x28, 0xA2, 0x01, 0x10, 0x11, 0x02, 0x10, 0x22, 0x02, 0x20,
  0x42, 0x04, 0x43, 0xFF, 0x08, 0x40, 0x88, 0x08, 0x80, 0x88, 0x11, 0x01,
  0x10, 0x11, 0x0E, 0xEC, 0x22, 0x02, 0x20, 0x42, 0x04, 0x40, 0x44, 0x08,
  0x40, 0x88, 0x00, 0x00, 0x80, 0x08, 0x03, 0xC0, 0xD3, 0x11, 0x01, 0x10,
  0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x0A, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x05, 0x00, 0x48, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88, 0x09, 0x09, 0x20,
  0x7C, 0x01, 0x00, 0x10, 0x01, 0x00, 0x0E, 0x0C, 0x48, 0x22, 0x21, 0x08,
  0x84, 0x42, 0x21, 0x08, 0x84, 0x24, 0x10, 0x90, 0x42, 0x82, 0x12, 0x78,
  0x52, 0x61, 0x51, 0x4A, 0x45, 0xC9, 0x10, 0x28, 0x41, 0x21, 0x04, 0x84,
  0x22, 0x10, 0x90, 0x84, 0x42, 0x11, 0x08, 0x82, 0x46, 0x0E, 0x00, 0x07,
  0x81, 0x20, 0x88, 0x22, 0x08, 0x82, 0x20, 0x90, 0x24, 0x0A, 0x02, 0x80,
  0xC0, 0x60, 0x34, 0x09, 0x14, 0x46, 0x0A, 0x82, 0xA0, 0xC8, 0x32, 0x08,
  0x83, 0x21, 0x47, 0x90, 0x29, 0x25, 0x24, 0x01, 0x01, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x60, 0x02,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x80, 0x08, 0x08, 0xD0, 0x37, 0x18, 0x28, 0xC8, 0x04, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07, 0xFF, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x12, 0x24, 0x48, 0x80,
  0xFE, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x00, 0x07, 0x82, 0x21, 0x04, 0x41, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40,
  0x50, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x48,
  0x22, 0x08, 0x84, 0x23, 0x07, 0x80, 0x04, 0x72, 0x52, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x00,
  0x07, 0xC0, 0x42, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xFF, 0x80, 0x03,
  0xE0, 0xC2, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x01, 0x80, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0xFE, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x50, 0x06, 0x00, 0xA0, 0x12, 0x01, 0x20, 0x22, 0x02, 0x40,
  0x44, 0x08, 0x40, 0x84, 0x10, 0x41, 0x08, 0x20, 0x84, 0x08, 0x40, 0x8F,
  0xFE, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x07, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x60,
  0x19, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0xFE, 0x00, 0x03, 0xE0, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x0B, 0xC1, 0x84, 0x60,
  0x4C, 0x09, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x22, 0x04, 0x40, 0x88,
  0x21, 0x0C, 0x1F, 0x00, 0x3F, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x00,
  0x07, 0xC1, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10,
  0x41, 0x10, 0x1C, 0x07, 0x03, 0x20, 0xC2, 0x10, 0x24, 0x04, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x09, 0x82, 0x1F, 0x80, 0x07, 0x81, 0x08, 0x40,
  0x88, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10,
  0x62, 0x14, 0x3C, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x3E, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x80, 0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x08, 0x21, 0x04, 0x20, 0x80, 0x00, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x08, 0x00, 0x1F, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x00, 0x00, 0x00, 0x02, 0x03, 0x00, 0x01, 0xF0, 0x04, 0x10,
  0x10, 0x10, 0x40, 0x21, 0x00, 0x22, 0x00, 0x48, 0x00, 0x90, 0xF1, 0x42,
  0x22, 0x88, 0x45, 0x11, 0x12, 0x22, 0x28, 0x84, 0x51, 0x10, 0xA2, 0x21,
  0x44, 0x44, 0x89, 0x89, 0x13, 0x22, 0x3B, 0x84, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x61, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x01, 0x40, 0x50, 0x24, 0x09, 0x02, 0x41, 0x10, 0x44, 0x21,
  0x08, 0x43, 0xF1, 0x04, 0x41, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x60,
  0x18, 0x04, 0x07, 0xC0, 0x42, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08,
  0x11, 0x01, 0x10, 0x21, 0x04, 0x1F, 0x82, 0x38, 0x20, 0x42, 0x04, 0x20,
  0x42, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x08, 0x40, 0x88, 0x30, 0xFC,
  0x00, 0x01, 0xF0, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x21, 0x02, 0x04, 0x10, 0x20, 0x81, 0x04, 0x04, 0x20, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x84, 0x04, 0x40, 0x22, 0x02, 0x10, 0x10, 0x81, 0x04, 0x10, 0x41, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xC2, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x3F, 0x82, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00,
  0x01, 0xF8, 0x18, 0x10, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0xF2, 0x00,
  0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x10, 0x10, 0x40,
  0x40, 0x81, 0x01, 0xFC, 0x00, 0x04, 0x02, 0x08, 0x08, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10,
  0x7F, 0xC1, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x82, 0x02, 0x04, 0x04, 0x10, 0x08, 0x20, 0x10,
  0x00, 0x07, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x0F, 0x80, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x48, 0x06, 0x00, 0x04, 0x08,
  0x20, 0x82, 0x04, 0x10, 0x40, 0x84, 0x04, 0x40, 0x42, 0x02, 0x20, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x58, 0x03, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x42, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x42, 0x02, 0x00,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x3F, 0x80, 0x04, 0x00, 0x20,
  0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x50, 0xC0, 0x0C, 0x14, 0x02, 0x84,
  0x80, 0x50, 0x90, 0x12, 0x12, 0x02, 0x42, 0x40, 0x90, 0x48, 0x12, 0x11,
  0x04, 0x42, 0x20, 0x88, 0x44, 0x22, 0x08, 0x84, 0x41, 0x11, 0x08, 0x42,
  0x21, 0x08, 0x44, 0x21, 0x09, 0x08, 0x21, 0x21, 0x04, 0x28, 0x21, 0x05,
  0x04, 0x20, 0xC0, 0x80, 0x04, 0x02, 0x08, 0x04, 0x28, 0x08, 0x50, 0x10,
  0xA0, 0x41, 0x40, 0x84, 0x81, 0x09, 0x02, 0x11, 0x08, 0x22, 0x10, 0x44,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x12, 0x08, 0x24, 0x10, 0x48, 0x40, 0x90,
  0x81, 0x21, 0x02, 0x82, 0x03, 0x04, 0x06, 0x10, 0x0C, 0x20, 0x10, 0x00,
  0x03, 0xE0, 0x20, 0x82, 0x04, 0x20, 0x21, 0x00, 0x90, 0x04, 0x80, 0x24,
  0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x20, 0x80,
  0xF8, 0x00, 0x07, 0x80, 0x46, 0x08, 0x20, 0x81, 0x08, 0x10, 0x81, 0x08,
  0x11, 0x02, 0x10, 0x21, 0x02, 0x10, 0x42, 0x08, 0x3F, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x00, 0x03, 0xE0, 0x20, 0x82, 0x04, 0x20, 0x21, 0x00, 0x90, 0x04, 0x80,
  0x24, 0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x20,
  0x80, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x07,
  0x80, 0x46, 0x08, 0x20, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x02, 0x10,
  0x21, 0x02, 0x10, 0x42, 0x18, 0x3E, 0x02, 0x20, 0x22, 0x02, 0x20, 0x42,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x10, 0x81, 0x00, 0x03, 0xF0,
  0x20, 0x42, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x83, 0xF8, 0x00,
  0x7F, 0xC1, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x00, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11,
  0x01, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x02, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x44, 0x04, 0x20, 0x21,
  0x01, 0x08, 0x10, 0x20, 0x81, 0xF8, 0x00, 0x80, 0x70, 0x0A, 0x01, 0x40,
  0x48, 0x09, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0x08,
  0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x00, 0x40, 0x20, 0x28, 0x0C, 0x05, 0x01, 0x00, 0xA0, 0x50,
  0x24, 0x0A, 0x04, 0x81, 0x81, 0x10, 0x50, 0x24, 0x0A, 0x04, 0x82, 0x41,
  0x10, 0x48, 0x22, 0x09, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x10, 0x88,
  0x22, 0x11, 0x04, 0x42, 0x40, 0x90, 0x48, 0x12, 0x09, 0x02, 0x81, 0x40,
  0x50, 0x28, 0x0A, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x10, 0x00, 0x02, 0x04,
  0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x08, 0x80, 0x22, 0x00, 0x90,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x14, 0x00, 0x50,
  0x02, 0x40, 0x08, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x20, 0x81, 0x02,
  0x08, 0x08, 0x00, 0x40, 0x50, 0x24, 0x09, 0x04, 0x41, 0x10, 0x84, 0x21,
  0x10, 0x44, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x00, 0x07, 0xF8, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0F, 0xC0, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22, 0x22,
  0x11, 0x11, 0x11, 0x10, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x7C, 0x00, 0x04, 0x00, 0xC0, 0x28, 0x04,
  0x81, 0x10, 0x21, 0x08, 0x21, 0x02, 0x40, 0x48, 0x06, 0x00, 0x80, 0xFF,
  0x91, 0x22, 0x0F, 0x23, 0x14, 0x41, 0x10, 0x24, 0x04, 0x80, 0x90, 0x14,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88, 0x11, 0x02, 0x20, 0xC4, 0x28,
  0x79, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x5E, 0x14, 0x23, 0x04, 0x40, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09, 0x01,
  0x20, 0x48, 0x09, 0x01, 0x20, 0x24, 0x08, 0x81, 0x28, 0x45, 0xF0, 0x0F,
  0x88, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0xF2, 0x18, 0xA1, 0x04, 0x20, 0x44,
  0x04, 0x40, 0x44, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x08,
  0x10, 0x81, 0x08, 0x30, 0x85, 0x07, 0x90, 0x0F, 0x08, 0x48, 0x24, 0x14,
  0x0A, 0x09, 0x0D, 0x08, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0x03,
  0xC8, 0x31, 0x41, 0x04, 0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x04,
  0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x82, 0x04, 0x10, 0x20, 0x83, 0x04,
  0x28, 0x1E, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x18, 0xC0, 0x38, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x5E, 0x14, 0x43, 0x04, 0x41, 0x08, 0x21, 0x04, 0x40, 0x88,
  0x11, 0x02, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x20, 0x44,
  0x08, 0x04, 0x30, 0x00, 0x00, 0x00, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x0C, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x43, 0x10, 0x42, 0x10,
  0x44, 0x09, 0x01, 0x20, 0x48, 0x0B, 0x01, 0xA0, 0x24, 0x04, 0x81, 0x08,
  0x21, 0x04, 0x20, 0x84, 0x20, 0x84, 0x10, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x0B, 0x8F, 0x14, 0x51, 0x18, 0x61, 0x10, 0x41, 0x10, 0x41, 0x10,
  0x41, 0x20, 0x41, 0x20, 0x81, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x40,
  0x82, 0x41, 0x02, 0x41, 0x04, 0x41, 0x04, 0x81, 0x04, 0x82, 0x04, 0x0B,
  0xC5, 0x11, 0x84, 0x41, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x88, 0x24,
  0x09, 0x02, 0x40, 0x90, 0x44, 0x12, 0x04, 0x81, 0x00, 0x0F, 0x04, 0x22,
  0x08, 0x81, 0x40, 0x50, 0x14, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x81, 0x20, 0x48, 0x22, 0x18, 0x7C, 0x00, 0x05, 0xE0, 0xA3, 0x0C, 0x10,
  0xC1, 0x08, 0x10, 0x81, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x22,
  0x02, 0x20, 0x22, 0x04, 0x20, 0x45, 0x08, 0x5F, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x22, 0x14, 0x41, 0x10,
  0x22, 0x04, 0x80, 0x90, 0x12, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88,
  0x11, 0x02, 0x20, 0xC4, 0x28, 0x7A, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x0B, 0x8A, 0x06, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x00,
  0x07, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0xFC, 0x00, 0x08, 0x20,
  0x82, 0x3C, 0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x70, 0x10, 0x48, 0x12, 0x04, 0x82, 0x20, 0x90, 0x24, 0x09, 0x02,
  0x41, 0x10, 0x48, 0x12, 0x04, 0x82, 0x20, 0x88, 0x22, 0x18, 0xFA, 0x00,
  0x81, 0x81, 0x82, 0x82, 0x84, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0xA0,
  0xA0, 0xC0, 0xC0, 0xC0, 0x80, 0x81, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42,
  0x85, 0x0A, 0x14, 0x48, 0x91, 0x22, 0x48, 0x91, 0x22, 0x44, 0x89, 0x14,
  0x28, 0x50, 0xA1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x00, 0x08,
  0x21, 0x08, 0x21, 0x04, 0x40, 0x88, 0x12, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x28, 0x09, 0x02, 0x20, 0x44, 0x10, 0x82, 0x08, 0x81, 0x00, 0x01,
  0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x01, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x60, 0x38, 0x01, 0x00, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x01, 0x80, 0x38, 0x08, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x70, 0x00, 0x30, 0x19, 0x86, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 23, 6, 0, -23 },
  { 22, 6, 8, 8, 3, -23 },
  { 28, 12, 23, 12, 0, -23 },
  { 63, 12, 26, 11, 0, -24 },
  { 102, 14, 23, 17, 1, -23 },
  { 143, 10, 23, 10, 0, -23 },
  { 172, 3, 8, 5, 3, -23 },
  { 175, 8, 28, 8, 1, -23 },
  { 203, 8, 28, 8, -2, -23 },
  { 231, 8, 8, 10, 4, -24 },
  { 239, 11, 15, 13, 1, -19 },
  { 260, 4, 7, 5, -1, -3 },
  { 264, 7, 1, 8, 1, -9 },
  { 265, 1, 2, 5, 1, -2 },
  { 266, 12, 23, 9, -1, -23 },
  { 301, 10, 23, 11, 1, -23 },
  { 330, 6, 23, 11, 3, -23 },
  { 348, 12, 23, 11, -1, -23 },
  { 383, 12, 23, 11, -1, -23 },
  { 418, 12, 23, 11, -1, -23 },
  { 453, 12, 23, 11, -1, -23 },
  { 488, 11, 23, 11, 1, -23 },
  { 520, 11, 23, 11, 1, -23 },
  { 552, 11, 23, 11, 0, -23 },
  { 584, 11, 23, 11, 0, -23 },
  { 616, 5, 17, 5, 0, -17 },
  { 627, 6, 21, 5, -1, -17 },
  { 643, 11, 13, 13, 1, -18 },
  { 661, 11, 8, 13, 1, -15 },
  { 672, 11, 13, 13, 1, -18 },
  { 690, 9, 23, 8, 0, -23 },
  { 716, 15, 26, 16, 1, -23 },
  { 765, 10, 23, 10, -2, -23 },
  { 794, 12, 23, 12, 0, -23 },
  { 829, 12, 23, 11, 1, -23 },
  { 864, 13, 23, 13, 0, -23 },
  { 902, 12, 23, 11, 0, -23 },
  { 937, 12, 23, 10, 0, -23 },
  { 972, 14, 23, 14, 1, -23 },
  { 1013, 15, 23, 14, 0, -23 },
  { 1057, 10, 23, 5, -2, -23 },
  { 1086, 11, 29, 5, -5, -23 },
  { 1126, 13, 23, 11, 0, -23 },
  { 1164, 7, 23, 10, 0, -23 },
  { 1185, 19, 23, 19, 0, -23 },
  { 1240, 15, 23, 15, 0, -23 },
  { 1284, 13, 23, 14, 1, -23 },
  { 1322, 12, 23, 11, 0, -23 },
  { 1357, 13, 28, 14, 1, -23 },
  { 1403, 12, 23, 11, 0, -23 },
  { 1438, 13, 23, 11, -1, -23 },
  { 1476, 10, 23, 9, 2, -23 },
  { 1505, 13, 23, 14, 1, -23 },
  { 1543, 11, 23, 11, 3, -23 },
  { 1575, 19, 23, 19, 2, -23 },
  { 1630, 14, 23, 10, -2, -23 },
  { 1671, 10, 23, 9, 2, -23 },
  { 1700, 13, 23, 10, -1, -23 },
  { 1738, 12, 28, 9, -1, -23 },
  { 1780, 4, 23, 10, 3, -23 },
  { 1792, 11, 28, 9, -2, -23 },
  { 1831, 11, 11, 13, 1, -23 },
  { 1847, 8, 1, 8, -2, 3 },
  { 1848, 3, 5, 7, 5, -24 },
  { 1850, 11, 17, 12, 1, -17 },
  { 1874, 11, 24, 12, 0, -24 },
  { 1907, 9, 17, 9, 1, -17 },
  { 1927, 12, 24, 12, 1, -24 },
  { 1963, 9, 17, 10, 1, -17 },
  { 1983, 14, 32, 6, -4, -24 },
  { 2039, 13, 25, 12, -1, -17 },
  { 2080, 11, 24, 11, 0, -24 },
  { 2113, 6, 23, 5, 0, -23 },
  { 2131, 10, 31, 5, -4, -23 },
  { 2170, 11, 24, 9, 0, -24 },
  { 2203, 6, 24, 5, 0, -24 },
  { 2221, 16, 17, 17, 0, -17 },
  { 2255, 10, 17, 11, 0, -17 },
  { 2277, 10, 17, 11, 1, -17 },
  { 2299, 12, 24, 12, -1, -17 },
  { 2335, 11, 24, 12, 1, -17 },
  { 2368, 9, 17, 7, 0, -17 },
  { 2388, 10, 17, 9, -1, -17 },
  { 2410, 6, 21, 6, 0, -21 },
  { 2426, 10, 17, 11, 1, -17 },
  { 2448, 8, 17, 9, 2, -17 },
  { 2465, 14, 17, 15, 2, -17 },
  { 2495, 11, 17, 9, -1, -17 },
  { 2519, 15, 25, 9, -4, -17 },
  { 2566, 9, 17, 7, -1, -17 },
  { 2586, 11, 28, 10, 1, -23 },
  { 2625, 1, 32, 11, 5, -24 },
  { 2629, 11, 28, 10, -2, -23 },
  { 2668, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC32PT7B_H_
