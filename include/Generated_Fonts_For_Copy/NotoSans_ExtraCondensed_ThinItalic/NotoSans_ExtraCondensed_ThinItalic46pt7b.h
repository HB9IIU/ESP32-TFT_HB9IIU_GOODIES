#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x80, 0x10, 0x98,
  0x48, 0x64, 0x32, 0x11, 0x09, 0x84, 0x82, 0x42, 0x21, 0x10, 0x90, 0x40,
  0x00, 0x20, 0x80, 0x08, 0x20, 0x06, 0x08, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x08, 0x30, 0x02, 0x08, 0x00, 0x82, 0x00, 0x61, 0x81, 0xFF,
  0xFC, 0x04, 0x10, 0x03, 0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x20,
  0x04, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x3F,
  0xFF, 0x01, 0x86, 0x00, 0x41, 0x00, 0x10, 0x40, 0x0C, 0x30, 0x02, 0x08,
  0x00, 0x82, 0x00, 0x60, 0x80, 0x10, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00,
  0x83, 0x00, 0x00, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x0F, 0xE0, 0x19, 0x8C, 0x18, 0x80, 0x18, 0x40, 0x08, 0x20, 0x04, 0x10,
  0x02, 0x18, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x11, 0x00, 0x09,
  0x80, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x16, 0x00,
  0x09, 0x80, 0x04, 0x40, 0x02, 0x30, 0x03, 0x08, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x21, 0x00, 0x30, 0x80, 0x10, 0x81, 0x08, 0xC0, 0xFF,
  0x80, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x07, 0x80, 0x60, 0xCC, 0x04, 0x18, 0x40, 0xC1, 0x04, 0x08, 0x30, 0x41,
  0x82, 0x04, 0x10, 0x20, 0x43, 0x06, 0x0C, 0x20, 0x40, 0xC2, 0x04, 0x08,
  0x40, 0x40, 0x84, 0x0C, 0x08, 0x80, 0xC1, 0x88, 0x08, 0x11, 0x1E, 0x81,
  0x13, 0x38, 0x32, 0x61, 0x82, 0x24, 0x1C, 0x64, 0xC1, 0x44, 0x48, 0x17,
  0x88, 0x81, 0x00, 0x98, 0x10, 0x11, 0x03, 0x01, 0x10, 0x30, 0x21, 0x02,
  0x02, 0x10, 0x20, 0x43, 0x02, 0x04, 0x30, 0x60, 0x82, 0x04, 0x08, 0x20,
  0x41, 0x02, 0x0C, 0x10, 0x30, 0x82, 0x01, 0x10, 0x60, 0x1F, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x01, 0x98, 0x06, 0x10, 0x08, 0x20, 0x10, 0x40, 0x60,
  0x80, 0xC1, 0x01, 0x86, 0x03, 0x08, 0x06, 0x10, 0x0C, 0x40, 0x18, 0x80,
  0x12, 0x00, 0x2C, 0x00, 0x70, 0x00, 0xC0, 0x02, 0x80, 0x09, 0x00, 0x32,
  0x00, 0xC6, 0x11, 0x04, 0x64, 0x08, 0x88, 0x11, 0x20, 0x36, 0x40, 0x28,
  0x80, 0x53, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x08, 0x0E, 0x10, 0x14, 0x30,
  0x4C, 0x3F, 0x08, 0x13, 0x22, 0x22, 0x64, 0x44, 0x48, 0x00, 0x18, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60,
  0x0C, 0x00, 0x02, 0x00, 0x80, 0x10, 0x42, 0x04, 0x40, 0x69, 0xC3, 0xC0,
  0xE0, 0x24, 0x08, 0x42, 0x04, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x0C, 0x20, 0x84, 0x10, 0xC2, 0x18, 0x42, 0x00, 0xFF, 0xC0, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x03, 0x18, 0x0C, 0x10, 0x30, 0x20, 0x40,
  0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x11,
  0x00, 0x22, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x06, 0x40, 0x0C, 0x80,
  0x11, 0x00, 0x26, 0x00, 0x4C, 0x01, 0x90, 0x02, 0x20, 0x04, 0x40, 0x08,
  0x80, 0x31, 0x00, 0x42, 0x01, 0x84, 0x02, 0x08, 0x04, 0x10, 0x10, 0x30,
  0x60, 0x21, 0x80, 0x3E, 0x00, 0x03, 0x07, 0x0E, 0x12, 0x62, 0xC2, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x80, 0x80, 0x00, 0x7E, 0x00, 0x60, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0x81, 0x80, 0x80, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x81, 0x01,
  0x80, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x4C, 0x00, 0x64, 0x00,
  0x22, 0x00, 0x31, 0x00, 0x10, 0x80, 0x10, 0xC0, 0x18, 0x40, 0x08, 0x20,
  0x0C, 0x10, 0x04, 0x18, 0x04, 0x08, 0x06, 0x04, 0x02, 0x02, 0x03, 0x01,
  0x01, 0x01, 0x81, 0x00, 0x81, 0x80, 0x40, 0x80, 0x20, 0xFF, 0xFE, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x3F,
  0x80, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x81, 0x01,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x23, 0xC0, 0x6C, 0x30, 0x58, 0x10,
  0x70, 0x18, 0x60, 0x08, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x08,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30,
  0x80, 0x20, 0xC0, 0x60, 0x40, 0x40, 0x61, 0x80, 0x3F, 0x00, 0x3F, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0x40, 0x10, 0x60, 0x08, 0x20,
  0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC1, 0x80, 0x40,
  0x40, 0x40, 0x20, 0x60, 0x08, 0x60, 0x06, 0x40, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0x10, 0x03, 0x04, 0x03, 0x03, 0x03, 0x00, 0x81, 0x00, 0x61, 0x00,
  0x10, 0x80, 0x08, 0x40, 0x04, 0x60, 0x02, 0x30, 0x01, 0x18, 0x00, 0x84,
  0x00, 0xC2, 0x00, 0x41, 0x80, 0x60, 0x60, 0x60, 0x1F, 0xC0, 0x00, 0x00,
  0xF8, 0x03, 0x04, 0x02, 0x06, 0x04, 0x02, 0x0C, 0x02, 0x08, 0x02, 0x08,
  0x02, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x30,
  0x02, 0x30, 0x06, 0x30, 0x06, 0x10, 0x06, 0x10, 0x0E, 0x18, 0x1C, 0x0C,
  0x34, 0x07, 0xC4, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0xFC, 0x00, 0x06, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x30, 0x60, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x0F, 0xC1, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xC1, 0x80, 0x0C, 0x03,
  0x00, 0x60, 0x06, 0x01, 0x00, 0x08, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81,
  0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x18, 0x31, 0x01, 0xF0, 0xC4, 0x08,
  0x43, 0x30, 0x43, 0x08, 0x83, 0x08, 0x22, 0x08, 0x20, 0x88, 0x60, 0x82,
  0x61, 0x06, 0x09, 0x04, 0x10, 0x64, 0x30, 0x41, 0x10, 0xC1, 0x04, 0x42,
  0x0C, 0x13, 0x08, 0x30, 0xCC, 0x20, 0x82, 0x30, 0x86, 0x08, 0x82, 0x18,
  0x42, 0x08, 0xA3, 0x08, 0x36, 0x58, 0x20, 0x70, 0x80, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80,
  0x19, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x20, 0x10,
  0x40, 0x60, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x3F, 0xF0,
  0x40, 0x20, 0x80, 0x43, 0x00, 0x84, 0x01, 0x18, 0x02, 0x20, 0x04, 0x40,
  0x09, 0x00, 0x12, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xE0, 0x01, 0x80, 0x02,
  0x01, 0xFC, 0x00, 0x87, 0x80, 0x40, 0x40, 0x60, 0x10, 0x20, 0x08, 0x10,
  0x04, 0x08, 0x02, 0x04, 0x01, 0x06, 0x00, 0x82, 0x00, 0x41, 0x00, 0x60,
  0x80, 0x20, 0xC0, 0x30, 0x60, 0x30, 0x20, 0x30, 0x1F, 0xE0, 0x08, 0x70,
  0x0C, 0x04, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x60, 0x80, 0x10, 0xC0,
  0x08, 0x40, 0x0C, 0x20, 0x06, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x84,
  0x00, 0x82, 0x00, 0xC1, 0x00, 0xC1, 0x81, 0xC0, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x60, 0x40, 0x60, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x47, 0x80, 0x10, 0x30, 0x0C, 0x06, 0x02, 0x00, 0x80, 0x80, 0x30,
  0x20, 0x04, 0x08, 0x01, 0x06, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x10,
  0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00,
  0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01, 0x04, 0x00, 0x43,
  0x00, 0x30, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x82, 0x00, 0xC1, 0x80,
  0x20, 0x40, 0x18, 0x10, 0x0C, 0x04, 0x06, 0x03, 0x0E, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0F, 0xFC, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x0E, 0x07, 0x01, 0x80, 0x10, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x01, 0xF8, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x20, 0x80,
  0x02, 0x08, 0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0x40, 0xC0, 0x04, 0x04,
  0x00, 0x40, 0x60, 0x04, 0x03, 0x00, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0x00,
  0x08, 0x08, 0x00, 0xC0, 0x40, 0x04, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01,
  0x00, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x04, 0x06, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x00, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x20, 0x20,
  0x01, 0x01, 0xFF, 0xF8, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x01, 0x01, 0x00, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x03, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0x80, 0x04, 0x04,
  0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0x80, 0x04,
  0x00, 0x01, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0xFE, 0x00, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x26, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x60, 0x20, 0x08, 0x04, 0x03, 0x01,
  0x80, 0xC0, 0x20, 0x10, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x60, 0x06,
  0x08, 0x00, 0x82, 0x00, 0x10, 0xC0, 0x02, 0x30, 0x00, 0xC4, 0x00, 0x11,
  0x00, 0x02, 0x60, 0x00, 0x5C, 0x00, 0x0A, 0x80, 0x03, 0x90, 0x00, 0x62,
  0x00, 0x08, 0x60, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x10, 0x01, 0x03,
  0x00, 0x20, 0x20, 0x04, 0x04, 0x01, 0x80, 0x80, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x06, 0x00, 0x80, 0x80, 0x18, 0x00, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0A, 0x02, 0x80, 0x00, 0xA0, 0x28,
  0x00, 0x16, 0x02, 0x80, 0x01, 0x40, 0x28, 0x00, 0x24, 0x06, 0x80, 0x02,
  0x40, 0x48, 0x00, 0x6C, 0x04, 0x80, 0x04, 0x80, 0x48, 0x00, 0xC8, 0x0C,
  0x80, 0x08, 0x80, 0x8C, 0x01, 0x88, 0x08, 0xC0, 0x11, 0x80, 0x8C, 0x03,
  0x10, 0x08, 0x40, 0x21, 0x01, 0x84, 0x06, 0x10, 0x10, 0x40, 0x41, 0x01,
  0x04, 0x0C, 0x30, 0x10, 0x40, 0x82, 0x01, 0x04, 0x18, 0x20, 0x30, 0x41,
  0x02, 0x02, 0x04, 0x10, 0x60, 0x20, 0x42, 0x04, 0x02, 0x04, 0x20, 0x40,
  0x60, 0x44, 0x04, 0x04, 0x04, 0x40, 0x40, 0x40, 0x48, 0x0C, 0x04, 0x04,
  0x80, 0x80, 0x40, 0x50, 0x08, 0x0C, 0x07, 0x00, 0x80, 0x80, 0x70, 0x18,
  0x00, 0x01, 0x80, 0x04, 0x06, 0x00, 0x30, 0x18, 0x00, 0x80, 0xE0, 0x02,
  0x02, 0x80, 0x08, 0x0B, 0x00, 0x60, 0x24, 0x01, 0x80, 0x90, 0x04, 0x06,
  0x40, 0x10, 0x11, 0x00, 0x40, 0x46, 0x03, 0x01, 0x18, 0x08, 0x0C, 0x20,
  0x20, 0x20, 0x80, 0x80, 0x82, 0x02, 0x02, 0x08, 0x18, 0x08, 0x30, 0x40,
  0x60, 0x41, 0x01, 0x01, 0x04, 0x04, 0x04, 0x30, 0x10, 0x10, 0xC0, 0x40,
  0x62, 0x03, 0x01, 0x88, 0x08, 0x02, 0x20, 0x20, 0x09, 0x80, 0x80, 0x24,
  0x06, 0x00, 0x90, 0x18, 0x03, 0x40, 0x40, 0x05, 0x01, 0x00, 0x1C, 0x04,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x60,
  0xC0, 0x30, 0x18, 0x18, 0x02, 0x04, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08,
  0x40, 0x02, 0x10, 0x00, 0xCC, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x60,
  0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00,
  0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80,
  0x18, 0x30, 0x0C, 0x04, 0x02, 0x01, 0x83, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x8F, 0x00, 0x40, 0xC0, 0x60, 0x20, 0x20, 0x18, 0x10, 0x0C,
  0x08, 0x02, 0x04, 0x01, 0x06, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80,
  0x20, 0xC0, 0x10, 0x40, 0x10, 0x20, 0x18, 0x10, 0x08, 0x08, 0x18, 0x0C,
  0x38, 0x07, 0xF0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x60, 0xC0, 0x30, 0x18, 0x18, 0x02, 0x04, 0x00, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0xCC, 0x00, 0x22, 0x00, 0x08, 0x80,
  0x02, 0x60, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x01,
  0xB0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x20, 0x00, 0xC8,
  0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00,
  0x20, 0x80, 0x18, 0x30, 0x0C, 0x04, 0x02, 0x01, 0x83, 0x00, 0x3F, 0x80,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x8F, 0x00,
  0x40, 0xC0, 0x60, 0x20, 0x20, 0x10, 0x10, 0x0C, 0x08, 0x06, 0x04, 0x03,
  0x06, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x20, 0xC0, 0x30, 0x60,
  0x10, 0x20, 0x18, 0x10, 0x18, 0x08, 0x18, 0x0F, 0xF0, 0x04, 0x30, 0x02,
  0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0xC0, 0x20, 0x60,
  0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x01, 0x81, 0x00,
  0x41, 0x80, 0x20, 0x80, 0x10, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x30, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x02, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x00, 0x02, 0x00, 0x20, 0x40, 0x04,
  0x18, 0x00, 0x82, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10,
  0x60, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x41,
  0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x01, 0x04,
  0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x04, 0x10,
  0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x83, 0x00, 0x20, 0x60,
  0x04, 0x0C, 0x01, 0x80, 0x80, 0x20, 0x10, 0x0C, 0x01, 0x03, 0x00, 0x1F,
  0xC0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0xD0,
  0x01, 0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x84, 0x03,
  0x08, 0x04, 0x10, 0x18, 0x20, 0x20, 0x40, 0x40, 0x81, 0x81, 0x02, 0x02,
  0x0C, 0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x46, 0x00, 0x88,
  0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x40, 0x02, 0x00, 0x34, 0x00, 0x60, 0x02, 0x40,
  0x06, 0x00, 0x24, 0x00, 0x60, 0x04, 0x40, 0x0A, 0x00, 0x44, 0x00, 0xA0,
  0x0C, 0x40, 0x1A, 0x00, 0x84, 0x01, 0x20, 0x08, 0x40, 0x12, 0x01, 0x04,
  0x02, 0x20, 0x10, 0x40, 0x22, 0x03, 0x04, 0x06, 0x20, 0x20, 0x40, 0x42,
  0x02, 0x04, 0x04, 0x60, 0x40, 0x40, 0x86, 0x04, 0x04, 0x08, 0x60, 0xC0,
  0x41, 0x86, 0x08, 0x04, 0x10, 0x40, 0x80, 0x41, 0x04, 0x10, 0x04, 0x20,
  0x41, 0x00, 0x42, 0x04, 0x30, 0x04, 0x60, 0x42, 0x00, 0x44, 0x04, 0x20,
  0x04, 0x40, 0x44, 0x00, 0x48, 0x04, 0x40, 0x0C, 0x80, 0x4C, 0x00, 0xD8,
  0x04, 0x80, 0x0D, 0x00, 0x48, 0x00, 0xD0, 0x05, 0x00, 0x0F, 0x00, 0x50,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x40,
  0x40, 0x04, 0x08, 0x00, 0x41, 0x80, 0x04, 0x10, 0x00, 0x63, 0x00, 0x06,
  0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x05, 0x00, 0x00, 0xD0, 0x00,
  0x09, 0x00, 0x01, 0x90, 0x00, 0x11, 0x00, 0x03, 0x10, 0x00, 0x21, 0x00,
  0x04, 0x10, 0x00, 0x41, 0x80, 0x08, 0x18, 0x01, 0x80, 0x80, 0x10, 0x08,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x80, 0xC0, 0x08, 0x00, 0x40,
  0x05, 0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x86, 0x02, 0x18,
  0x10, 0x20, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40, 0x23, 0x00, 0x88, 0x02,
  0x60, 0x09, 0x00, 0x2C, 0x00, 0xA0, 0x03, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x20, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF, 0x00,
  0x82, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x18, 0x20, 0x82, 0x08,
  0x20, 0x83, 0x04, 0x10, 0x41, 0x04, 0x10, 0x60, 0x82, 0x08, 0x20, 0x83,
  0x0C, 0x00, 0x7F, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x50, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10, 0x40,
  0x18, 0x30, 0x08, 0x08, 0x0C, 0x06, 0x04, 0x01, 0x06, 0x00, 0xC2, 0x00,
  0x23, 0x00, 0x19, 0x00, 0x05, 0x80, 0x03, 0xFF, 0xE0, 0x88, 0x44, 0x22,
  0x10, 0x00, 0x60, 0x01, 0xF9, 0x06, 0x09, 0x04, 0x06, 0x08, 0x06, 0x18,
  0x06, 0x10, 0x06, 0x30, 0x06, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40,
  0x0C, 0x40, 0x0C, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0,
  0x10, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0x40, 0x50, 0x40, 0xE0, 0x61,
  0xA0, 0x3F, 0x20, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x38, 0x04, 0xFC, 0x05, 0x86, 0x07, 0x02, 0x06, 0x03, 0x0C, 0x01, 0x0C,
  0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x03, 0x10, 0x03, 0x10,
  0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x0C, 0x60, 0x08, 0x60, 0x18, 0x60, 0x10, 0x70, 0x30, 0x50, 0x60, 0x8F,
  0x80, 0x00, 0x70, 0x1F, 0xC1, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x06, 0x10, 0x07, 0xE4, 0x06, 0x0B, 0x01,
  0x01, 0x80, 0x80, 0x60, 0x60, 0x18, 0x10, 0x06, 0x0C, 0x01, 0x82, 0x00,
  0x40, 0x80, 0x10, 0x60, 0x04, 0x10, 0x03, 0x04, 0x00, 0xC1, 0x00, 0x20,
  0x40, 0x08, 0x30, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0, 0x10, 0x30,
  0x0C, 0x0C, 0x03, 0x01, 0x01, 0xC0, 0x40, 0xE0, 0x18, 0x68, 0x03, 0xF2,
  0x00, 0x00, 0x60, 0x1F, 0x81, 0x86, 0x18, 0x10, 0x80, 0x8C, 0x04, 0x40,
  0x26, 0x03, 0x20, 0x11, 0x01, 0x98, 0x18, 0x83, 0x87, 0xF0, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x08, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x07, 0xF0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0x90, 0x18, 0x24, 0x04, 0x06, 0x02, 0x01,
  0x81, 0x80, 0x60, 0x40, 0x18, 0x30, 0x06, 0x08, 0x01, 0x02, 0x00, 0x41,
  0x80, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0,
  0x08, 0x30, 0x06, 0x0C, 0x01, 0x03, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x0C,
  0x04, 0x07, 0x01, 0x03, 0x80, 0x61, 0xA0, 0x0F, 0xC8, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x18, 0x00, 0xF8, 0x00, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x40, 0x27, 0xE0, 0x50, 0x60, 0xC0,
  0x41, 0x80, 0x86, 0x01, 0x0C, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x21,
  0x80, 0x42, 0x00, 0x84, 0x03, 0x08, 0x04, 0x10, 0x08, 0x60, 0x10, 0x80,
  0x21, 0x00, 0xC2, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x20, 0x18, 0x40, 0x20,
  0x80, 0x43, 0x00, 0x80, 0x01, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x07, 0x80, 0x00, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x30, 0x40, 0x40, 0x81, 0x01, 0x04, 0x06, 0x18, 0x08,
  0x20, 0x10, 0x80, 0x22, 0x00, 0x4C, 0x01, 0x90, 0x02, 0x60, 0x05, 0x60,
  0x0E, 0x40, 0x38, 0x80, 0x61, 0x00, 0x82, 0x01, 0x04, 0x02, 0x0C, 0x0C,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x83, 0x01, 0x80, 0x00,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x30, 0x00, 0x00, 0x30, 0x18, 0x04, 0xFC, 0xFE, 0x05, 0x05, 0x82,
  0x06, 0x07, 0x03, 0x06, 0x02, 0x03, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x02,
  0x08, 0x04, 0x02, 0x08, 0x04, 0x02, 0x08, 0x04, 0x02, 0x18, 0x0C, 0x06,
  0x10, 0x08, 0x04, 0x10, 0x08, 0x04, 0x10, 0x08, 0x04, 0x30, 0x08, 0x04,
  0x30, 0x18, 0x0C, 0x20, 0x10, 0x08, 0x20, 0x10, 0x08, 0x20, 0x10, 0x08,
  0x60, 0x30, 0x18, 0x40, 0x20, 0x10, 0x40, 0x20, 0x10, 0x40, 0x20, 0x10,
  0x40, 0x20, 0x10, 0xC0, 0x60, 0x30, 0x00, 0x18, 0x09, 0xF8, 0x14, 0x18,
  0x30, 0x10, 0x60, 0x21, 0x80, 0x43, 0x00, 0x84, 0x03, 0x08, 0x04, 0x10,
  0x08, 0x60, 0x10, 0x80, 0x21, 0x00, 0xC2, 0x01, 0x0C, 0x02, 0x18, 0x04,
  0x20, 0x18, 0x40, 0x30, 0x80, 0x43, 0x00, 0x84, 0x01, 0x08, 0x06, 0x10,
  0x08, 0x20, 0x10, 0xC0, 0x20, 0x00, 0x60, 0x0F, 0xE0, 0x60, 0x83, 0x03,
  0x08, 0x04, 0x60, 0x11, 0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x16, 0x00,
  0x58, 0x01, 0x40, 0x0D, 0x00, 0x34, 0x00, 0xB0, 0x02, 0xC0, 0x0B, 0x00,
  0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x21, 0x01, 0x84, 0x04, 0x18, 0x20, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x4F, 0xC0, 0x16, 0x18, 0x05, 0x02, 0x01, 0x80,
  0xC0, 0xE0, 0x10, 0x30, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10,
  0x60, 0x0C, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x30,
  0x06, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x60, 0x08, 0x18, 0x06,
  0x06, 0x01, 0x01, 0x40, 0x80, 0x50, 0x60, 0x33, 0xE0, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x03, 0xF9,
  0x06, 0x09, 0x04, 0x06, 0x08, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x06,
  0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x10, 0xC0, 0x30,
  0xC0, 0x30, 0x40, 0x70, 0x40, 0xE0, 0x61, 0xA0, 0x3F, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0x30, 0x27, 0xC1,
  0x40, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x40, 0x43, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x20, 0x60, 0xFF, 0x00, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x3F, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xF0, 0x0C, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x21, 0x80,
  0x42, 0x00, 0x84, 0x03, 0x08, 0x04, 0x30, 0x08, 0x40, 0x10, 0x80, 0x61,
  0x00, 0xC2, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x20, 0x18, 0x40, 0x20, 0x80,
  0x43, 0x01, 0x84, 0x03, 0x08, 0x0A, 0x10, 0x18, 0x10, 0x50, 0x3F, 0x20,
  0x80, 0x38, 0x02, 0x80, 0x68, 0x04, 0x80, 0xC8, 0x08, 0x80, 0x88, 0x10,
  0x81, 0x08, 0x20, 0x82, 0x08, 0x60, 0x84, 0x08, 0xC0, 0x88, 0x08, 0x80,
  0x90, 0x09, 0x00, 0xB0, 0x0A, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x48, 0x1A, 0x04, 0x81, 0x20, 0xC8, 0x12, 0x08, 0x82, 0x20, 0x88, 0x22,
  0x10, 0x86, 0x21, 0x08, 0x42, 0x30, 0x84, 0x22, 0x08, 0x82, 0x20, 0x88,
  0x24, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0B, 0x02, 0x80, 0xA0, 0x28, 0x0A,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x02, 0x01, 0x81, 0x01, 0x80, 0x80, 0x80, 0x60, 0x80, 0x10, 0xC0, 0x08,
  0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x04, 0x40,
  0x04, 0x20, 0x06, 0x18, 0x02, 0x04, 0x03, 0x02, 0x01, 0x01, 0x01, 0x00,
  0x81, 0x80, 0x60, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x00,
  0x80, 0x40, 0x04, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x10,
  0x00, 0x40, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x86, 0x00, 0x04,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x48, 0x00,
  0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x03, 0x80, 0x0E, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x1D, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0x61, 0x81, 0x80, 0x7E, 0x00, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 33, 9, 1, -33 },
  { 34, 9, 12, 12, 4, -33 },
  { 48, 18, 33, 17, 0, -33 },
  { 123, 17, 38, 16, 0, -35 },
  { 204, 20, 34, 24, 2, -33 },
  { 289, 15, 33, 15, -1, -33 },
  { 351, 4, 12, 7, 4, -33 },
  { 357, 13, 40, 11, 1, -33 },
  { 422, 12, 40, 11, -3, -33 },
  { 482, 11, 12, 15, 6, -35 },
  { 499, 16, 21, 18, 1, -27 },
  { 541, 6, 10, 7, -2, -4 },
  { 549, 10, 1, 12, 1, -13 },
  { 551, 2, 3, 7, 1, -3 },
  { 552, 18, 33, 13, -2, -33 },
  { 627, 15, 33, 16, 1, -33 },
  { 689, 8, 33, 16, 5, -33 },
  { 722, 18, 33, 16, -2, -33 },
  { 797, 17, 34, 16, -1, -33 },
  { 870, 17, 33, 16, -1, -33 },
  { 941, 17, 33, 16, -1, -33 },
  { 1012, 16, 33, 16, 1, -33 },
  { 1078, 15, 33, 16, 2, -33 },
  { 1140, 17, 33, 16, -1, -33 },
  { 1211, 16, 33, 16, 0, -33 },
  { 1277, 7, 24, 7, 0, -24 },
  { 1298, 9, 30, 7, -2, -24 },
  { 1332, 16, 19, 18, 1, -26 },
  { 1370, 16, 11, 18, 1, -22 },
  { 1392, 16, 19, 18, 1, -26 },
  { 1430, 12, 33, 11, 1, -33 },
  { 1480, 22, 37, 23, 1, -33 },
  { 1582, 15, 33, 15, -3, -33 },
  { 1644, 17, 33, 17, 0, -33 },
  { 1715, 17, 33, 16, 2, -33 },
  { 1786, 18, 33, 19, 0, -33 },
  { 1861, 17, 33, 16, 0, -33 },
  { 1932, 17, 33, 14, 0, -33 },
  { 2003, 20, 33, 21, 2, -33 },
  { 2086, 21, 33, 20, 0, -33 },
  { 2173, 14, 33, 8, -3, -33 },
  { 2231, 15, 41, 7, -7, -33 },
  { 2308, 19, 33, 16, 0, -33 },
  { 2387, 10, 33, 14, 0, -33 },
  { 2429, 28, 33, 27, 0, -33 },
  { 2545, 22, 33, 21, 0, -33 },
  { 2636, 18, 33, 20, 2, -33 },
  { 2711, 17, 33, 16, 0, -33 },
  { 2782, 18, 41, 20, 2, -33 },
  { 2875, 17, 33, 16, 0, -33 },
  { 2946, 18, 33, 16, -1, -33 },
  { 3021, 14, 33, 14, 3, -33 },
  { 3079, 19, 33, 19, 1, -33 },
  { 3158, 15, 33, 16, 4, -33 },
  { 3220, 28, 33, 28, 3, -33 },
  { 3336, 20, 33, 14, -3, -33 },
  { 3419, 14, 33, 13, 3, -33 },
  { 3477, 19, 33, 14, -2, -33 },
  { 3556, 16, 40, 13, -1, -33 },
  { 3636, 6, 33, 15, 5, -33 },
  { 3661, 16, 40, 13, -3, -33 },
  { 3741, 17, 16, 18, 1, -33 },
  { 3775, 11, 1, 12, -3, 4 },
  { 3777, 4, 7, 9, 7, -35 },
  { 3781, 16, 25, 17, 1, -25 },
  { 3831, 16, 35, 17, 0, -35 },
  { 3901, 13, 25, 12, 1, -25 },
  { 3942, 18, 35, 17, 1, -35 },
  { 4021, 13, 25, 15, 1, -25 },
  { 4062, 20, 46, 8, -6, -35 },
  { 4177, 18, 36, 17, -1, -25 },
  { 4258, 15, 35, 16, 0, -35 },
  { 4324, 9, 33, 7, 0, -33 },
  { 4362, 15, 44, 7, -6, -33 },
  { 4445, 15, 35, 14, 0, -35 },
  { 4511, 9, 35, 7, 0, -35 },
  { 4551, 24, 25, 25, 0, -25 },
  { 4626, 15, 25, 16, 0, -25 },
  { 4673, 14, 25, 17, 1, -25 },
  { 4717, 18, 35, 17, -2, -25 },
  { 4796, 16, 36, 17, 1, -25 },
  { 4868, 13, 25, 11, 0, -25 },
  { 4909, 14, 25, 13, -1, -25 },
  { 4953, 8, 30, 8, 1, -30 },
  { 4983, 15, 24, 16, 1, -24 },
  { 5028, 12, 24, 12, 3, -24 },
  { 5064, 20, 24, 21, 3, -24 },
  { 5124, 17, 24, 13, -2, -24 },
  { 5175, 21, 35, 14, -5, -24 },
  { 5267, 14, 24, 11, -2, -24 },
  { 5309, 15, 40, 14, 2, -33 },
  { 5384, 1, 46, 16, 7, -35 },
  { 5390, 16, 40, 14, -3, -33 },
  { 5470, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC46PT7B_H_
