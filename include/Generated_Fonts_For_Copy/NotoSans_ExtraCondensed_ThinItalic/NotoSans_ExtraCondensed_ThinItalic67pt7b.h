#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x18, 0xC0, 0xC6, 0x06,
  0x30, 0x31, 0x81, 0x08, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x21, 0x01, 0x08,
  0x18, 0x40, 0xC6, 0x04, 0x30, 0x21, 0x01, 0x08, 0x18, 0xC0, 0xC0, 0x00,
  0x01, 0x80, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04,
  0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x10,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x18, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40,
  0x00, 0x20, 0x30, 0x03, 0xFF, 0xFF, 0xE0, 0x06, 0x02, 0x00, 0x01, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x08, 0x00, 0x04, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3D, 0x9F,
  0x00, 0x70, 0xC1, 0x80, 0x70, 0x60, 0x00, 0x30, 0x20, 0x00, 0x30, 0x10,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x02, 0x02,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x30,
  0x40, 0x00, 0x18, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x20, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x18, 0x00, 0x04, 0x0C, 0x04, 0x06, 0x1C, 0x03, 0xE3,
  0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0xE7,
  0x00, 0x18, 0x0E, 0x18, 0x01, 0x80, 0x60, 0x40, 0x0C, 0x06, 0x02, 0x00,
  0xC0, 0x30, 0x10, 0x06, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x20, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x18, 0x02, 0x00,
  0xC0, 0xC0, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x01, 0x82,
  0x00, 0x60, 0x18, 0x30, 0x02, 0x00, 0xC1, 0x00, 0x30, 0x06, 0x18, 0x01,
  0x80, 0x30, 0x80, 0x0C, 0x03, 0x0C, 0x3E, 0x60, 0x18, 0x43, 0xFB, 0x00,
  0xC6, 0x38, 0x78, 0x0C, 0x21, 0x83, 0xC0, 0x63, 0x18, 0x1E, 0x06, 0x11,
  0x80, 0xF0, 0x31, 0x8C, 0x06, 0xC3, 0x08, 0x60, 0x36, 0x30, 0xC6, 0x01,
  0x9F, 0x04, 0x30, 0x0C, 0x20, 0x61, 0x80, 0x60, 0x02, 0x18, 0x03, 0x00,
  0x30, 0xC0, 0x18, 0x01, 0x06, 0x00, 0x80, 0x18, 0x30, 0x0C, 0x00, 0x83,
  0x00, 0x60, 0x0C, 0x18, 0x03, 0x00, 0x40, 0xC0, 0x18, 0x06, 0x06, 0x01,
  0x80, 0x30, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x06, 0x00,
  0xC0, 0xC0, 0x60, 0x06, 0x0C, 0x03, 0x00, 0x18, 0xC0, 0x30, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0x18, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x60,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x60, 0x80, 0x06, 0x06, 0x0C,
  0x70, 0x30, 0x63, 0x01, 0x83, 0x30, 0x04, 0x11, 0x80, 0x31, 0x98, 0x01,
  0x8C, 0xC0, 0x0C, 0x46, 0x00, 0x26, 0x20, 0x01, 0xB3, 0x00, 0x0F, 0x18,
  0x00, 0x78, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x0F,
  0x0C, 0x00, 0x68, 0x30, 0x06, 0x41, 0x80, 0x63, 0x07, 0x0E, 0x18, 0x1F,
  0xE0, 0x40, 0x3C, 0x00, 0x00, 0x0C, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30,
  0x82, 0x08, 0x61, 0x84, 0x10, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x80, 0x30, 0x80, 0x18, 0x81,
  0x06, 0x9F, 0x01, 0xE0, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0x40, 0x10, 0x60,
  0x60, 0x20, 0xC0, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x4F, 0xFC, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xC7, 0x00, 0x0E, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00,
  0x80, 0x20, 0x03, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18,
  0x04, 0x00, 0x60, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x03,
  0x03, 0x00, 0x0E, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x0F, 0x01, 0xA0, 0x36, 0x06, 0x61, 0xC6, 0x38, 0x66, 0x04, 0x40,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x07, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x02, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x1C, 0x01,
  0xC0, 0x3C, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xC4, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x10, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x04, 0x00, 0x38, 0x03, 0x80, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xFC, 0x00, 0x1E, 0x08, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x87, 0xE0, 0x03, 0x3F, 0xF0, 0x0C,
  0xE0, 0x70, 0x1B, 0x00, 0x60, 0x3C, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xE0,
  0x01, 0x83, 0x80, 0x01, 0x07, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x08, 0x30, 0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01,
  0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x0C,
  0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x8F, 0x00,
  0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x70, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xF1, 0xC0,
  0x03, 0x80, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00,
  0x60, 0x80, 0x00, 0xC1, 0x00, 0x03, 0x82, 0x00, 0x07, 0x06, 0x00, 0x1C,
  0x0C, 0x00, 0x38, 0x18, 0x00, 0xF0, 0x18, 0x03, 0x60, 0x38, 0x0C, 0xC0,
  0x3C, 0xF1, 0x00, 0x3F, 0xC6, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x40, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0x80, 0x78, 0x70, 0x10, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x3F, 0x81, 0x86, 0x00,
  0xE3, 0x03, 0x0C, 0x03, 0x06, 0x06, 0x30, 0x0C, 0x0C, 0x0C, 0x60, 0x30,
  0x30, 0x18, 0x80, 0x60, 0x60, 0x33, 0x01, 0x80, 0xC0, 0x66, 0x03, 0x01,
  0x80, 0x8C, 0x0C, 0x06, 0x03, 0x10, 0x18, 0x0C, 0x06, 0x60, 0x20, 0x18,
  0x0C, 0xC0, 0xC0, 0x30, 0x19, 0x81, 0x80, 0xC0, 0x23, 0x03, 0x01, 0x80,
  0xC4, 0x0C, 0x03, 0x01, 0x98, 0x18, 0x06, 0x03, 0x30, 0x30, 0x18, 0x0C,
  0x60, 0x60, 0x30, 0x18, 0xC0, 0xC0, 0x60, 0x31, 0x81, 0x81, 0xC0, 0xC3,
  0x03, 0x03, 0x81, 0x86, 0x06, 0x0F, 0x06, 0x0C, 0x0C, 0x16, 0x0C, 0x18,
  0x18, 0x6C, 0x30, 0x20, 0x19, 0x8D, 0xC0, 0x40, 0x3E, 0x1F, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00,
  0x06, 0x40, 0x00, 0x19, 0x00, 0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x0C,
  0x40, 0x00, 0x61, 0x00, 0x01, 0x84, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40,
  0x00, 0xC1, 0x00, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00, 0x40, 0x40, 0x03,
  0x01, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x10, 0x01, 0x80, 0x40, 0x0C, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0x00, 0x10, 0x0C, 0x00, 0x40, 0x60, 0x01, 0x01, 0x80,
  0x04, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x40, 0x80, 0x01, 0x06, 0x00, 0x04,
  0x18, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x0C, 0x03, 0x80, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x04, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80,
  0x18, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x06, 0x00, 0xE0,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x18, 0x00, 0x18, 0x08, 0x00,
  0x08, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x38, 0x03, 0x00, 0x78, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x02, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x18, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x40, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x10,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x20, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x08, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x10, 0x0F, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x06, 0x00, 0x07, 0xF8,
  0x18, 0x00, 0x20, 0x60, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x02, 0x00, 0x38, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xF4, 0x00, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x02,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x10, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x01, 0x0E, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x02, 0x78, 0x00, 0x00, 0x65, 0x80, 0x00,
  0x06, 0xD8, 0x00, 0x00, 0x78, 0x80, 0x00, 0x05, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18,
  0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x10, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x04, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1A, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x68, 0x00, 0x00, 0x36, 0x00, 0x48, 0x00, 0x00, 0x36, 0x00, 0x48,
  0x00, 0x00, 0x64, 0x00, 0xC8, 0x00, 0x00, 0x64, 0x00, 0xC8, 0x00, 0x00,
  0xCC, 0x00, 0xC8, 0x00, 0x00, 0xCC, 0x00, 0x8C, 0x00, 0x00, 0x8C, 0x01,
  0x8C, 0x00, 0x01, 0x88, 0x01, 0x8C, 0x00, 0x01, 0x18, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x01, 0x0C, 0x00, 0x06, 0x18,
  0x03, 0x0C, 0x00, 0x06, 0x10, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x02, 0x0C, 0x00, 0x18,
  0x30, 0x06, 0x0C, 0x00, 0x30, 0x20, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x06,
  0x04, 0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0x60, 0x60, 0x0C, 0x04, 0x00,
  0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0xC0, 0x0C, 0x04, 0x01, 0x80, 0xC0,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x03, 0x00, 0x80, 0x18, 0x06, 0x06, 0x01, 0x80, 0x18, 0x06, 0x06, 0x01,
  0x80, 0x18, 0x06, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x08, 0x01, 0x00, 0x30, 0x06, 0x18, 0x03, 0x00, 0x30, 0x06, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x30, 0x03, 0x00, 0x20, 0x06, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x60, 0x02, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0x60, 0x06,
  0xC0, 0x06, 0x00, 0x40, 0x02, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x04,
  0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x06, 0x00, 0x68,
  0x00, 0x06, 0x00, 0x6C, 0x00, 0x06, 0x00, 0x6C, 0x00, 0x04, 0x00, 0x6C,
  0x00, 0x0C, 0x00, 0x4C, 0x00, 0x0C, 0x00, 0xC4, 0x00, 0x0C, 0x00, 0xC4,
  0x00, 0x0C, 0x00, 0xC6, 0x00, 0x08, 0x00, 0x86, 0x00, 0x18, 0x01, 0x86,
  0x00, 0x18, 0x01, 0x86, 0x00, 0x18, 0x01, 0x82, 0x00, 0x18, 0x01, 0x83,
  0x00, 0x10, 0x01, 0x03, 0x00, 0x30, 0x03, 0x03, 0x00, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x03, 0x01, 0x00, 0x30, 0x03, 0x01, 0x00, 0x60, 0x02, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x60, 0x06, 0x01,
  0x80, 0x40, 0x06, 0x00, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x80, 0x08, 0x00,
  0x41, 0x80, 0x18, 0x00, 0x61, 0x80, 0x18, 0x00, 0x61, 0x80, 0x18, 0x00,
  0x61, 0x80, 0x18, 0x00, 0x63, 0x00, 0x10, 0x00, 0x63, 0x00, 0x30, 0x00,
  0x23, 0x00, 0x30, 0x00, 0x33, 0x00, 0x30, 0x00, 0x32, 0x00, 0x30, 0x00,
  0x36, 0x00, 0x20, 0x00, 0x36, 0x00, 0x60, 0x00, 0x16, 0x00, 0x60, 0x00,
  0x1E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02,
  0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0C, 0x07, 0x00, 0x04,
  0x01, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00, 0x80, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x08, 0x00,
  0xE0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x03, 0x03, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x30, 0x1C, 0x00, 0x20, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x40,
  0x03, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x02, 0x01, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x03,
  0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x04,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x02, 0x00, 0x18, 0x03, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x20, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x20, 0x00, 0xE0,
  0x07, 0x80, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x10, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x20, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x03, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x40, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00, 0x03,
  0x08, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80, 0x01, 0x82, 0x00, 0x06, 0x08,
  0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x06, 0x02, 0x00, 0x18, 0x08, 0x00,
  0x60, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x20,
  0x18, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x08, 0x00, 0x20, 0x60,
  0x00, 0x81, 0x80, 0x02, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x21, 0x80, 0x00,
  0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x23, 0x00, 0x00, 0x98,
  0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xA0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x40, 0x00, 0x18, 0x00, 0x06, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x40, 0x00, 0x38, 0x00, 0x06, 0x40, 0x00, 0x28, 0x00, 0x0C, 0x40, 0x00,
  0x78, 0x00, 0x0C, 0x40, 0x00, 0x78, 0x00, 0x18, 0xC0, 0x00, 0x58, 0x00,
  0x18, 0xC0, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x00, 0xD8, 0x00, 0x30, 0xC0,
  0x01, 0x98, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x60, 0xC0, 0x01, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x18, 0x01, 0x80, 0xC0, 0x04,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x06, 0x00, 0xC0,
  0x10, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x04, 0x00, 0xC0, 0x30, 0x10,
  0x0C, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x10, 0x18, 0x00,
  0xC0, 0x60, 0x10, 0x18, 0x00, 0xC0, 0xC0, 0x10, 0x10, 0x00, 0xC0, 0xC0,
  0x10, 0x30, 0x00, 0xC0, 0x80, 0x10, 0x30, 0x00, 0xC1, 0x80, 0x10, 0x60,
  0x00, 0xC1, 0x80, 0x10, 0x60, 0x00, 0xC3, 0x00, 0x10, 0x40, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x31, 0x00, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x00, 0xC8, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x34, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x10, 0x00, 0x30, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x06, 0x00, 0x40, 0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09, 0x00, 0x00, 0x58, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x63, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x81, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x04,
  0x18, 0x20, 0xC1, 0x06, 0x08, 0x10, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x8C,
  0x03, 0x83, 0x90, 0x0E, 0x03, 0x20, 0x30, 0x02, 0xC0, 0x60, 0x07, 0x81,
  0x80, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x60,
  0x06, 0x80, 0x60, 0x0B, 0x00, 0xC0, 0x36, 0x00, 0xE1, 0xCC, 0x00, 0xFE,
  0x10, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x61, 0xF0, 0x00, 0x8F, 0xF8, 0x03, 0x38, 0x30, 0x06, 0xC0, 0x30,
  0x0D, 0x00, 0x60, 0x1E, 0x00, 0x60, 0x38, 0x00, 0xC0, 0xE0, 0x01, 0x81,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0xC0, 0x03, 0x03,
  0x80, 0x06, 0x07, 0x00, 0x18, 0x1E, 0x00, 0x60, 0x34, 0x00, 0xC0, 0x4C,
  0x07, 0x00, 0x8C, 0x1C, 0x03, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xF0, 0x0E, 0x04, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x7F, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x18, 0x00, 0x7F, 0xC6, 0x00, 0x38, 0x39, 0x00, 0x1C, 0x06,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x07, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x07,
  0x80, 0x30, 0x01, 0x40, 0x0C, 0x00, 0xD0, 0x01, 0x80, 0x6C, 0x00, 0x60,
  0x3B, 0x00, 0x0E, 0x1C, 0xC0, 0x01, 0xFC, 0x20, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x03, 0x83, 0x00, 0xC0, 0x60, 0x30, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x18,
  0x60, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x06, 0x18, 0x01, 0x83,
  0x00, 0x60, 0x60, 0x78, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x80, 0xE0, 0x60, 0x0F,
  0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFE, 0x30, 0x01, 0xC1, 0xC8, 0x00, 0xE0, 0x32, 0x00, 0x60, 0x05, 0x80,
  0x18, 0x01, 0xE0, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x0E, 0x00,
  0x60, 0x06, 0x80, 0x0C, 0x03, 0x60, 0x03, 0x01, 0xD8, 0x00, 0x70, 0xE6,
  0x00, 0x0F, 0xE1, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x0E,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0xF8, 0x00, 0x8F, 0xF0, 0x02, 0x60, 0x60, 0x1B, 0x00,
  0xC0, 0x78, 0x03, 0x01, 0x40, 0x0C, 0x07, 0x00, 0x30, 0x38, 0x00, 0xC0,
  0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x02, 0x03, 0x00, 0x18, 0x08,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10, 0x10, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x80,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x04, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x10, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x01, 0x80, 0x60, 0x04, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x47, 0x00, 0x03, 0x34, 0x00, 0x0C,
  0x90, 0x00, 0x36, 0x60, 0x00, 0xF1, 0x80, 0x03, 0x86, 0x00, 0x1C, 0x18,
  0x00, 0x60, 0x20, 0x01, 0x80, 0x80, 0x06, 0x03, 0x00, 0x10, 0x0C, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x00, 0x18,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x11, 0xFE, 0x1F, 0xF0,
  0x06, 0x60, 0xE6, 0x07, 0x00, 0xD0, 0x0D, 0x80, 0x60, 0x1E, 0x00, 0xA0,
  0x04, 0x02, 0x80, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x10, 0x1C, 0x00,
  0x60, 0x02, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x00, 0x08,
  0x0C, 0x00, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x01, 0x81, 0x80, 0x04, 0x00, 0x20, 0x30, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x30, 0x01, 0x80, 0x80, 0x06, 0x00, 0x30, 0x30,
  0x00, 0x80, 0x06, 0x06, 0x00, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x02, 0x00,
  0x10, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x60, 0x03,
  0x00, 0x18, 0x08, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x00, 0x40, 0x60,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x3F, 0xC0, 0x19,
  0x81, 0x80, 0x6C, 0x03, 0x01, 0xE0, 0x0C, 0x05, 0x00, 0x30, 0x1C, 0x00,
  0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x80,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x08,
  0x08, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x40, 0x40, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0x80, 0xC0, 0x02, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x04, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x07,
  0xFC, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x03, 0x06,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33,
  0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x24, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x38, 0x70, 0x01,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x7F, 0xC0,
  0x01, 0x38, 0x30, 0x00, 0xD8, 0x06, 0x00, 0x36, 0x01, 0x80, 0x0F, 0x00,
  0x30, 0x02, 0x80, 0x0C, 0x01, 0xE0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x18,
  0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x01, 0x80, 0x34, 0x00,
  0xC0, 0x0D, 0x00, 0x70, 0x03, 0x60, 0x38, 0x00, 0xCC, 0x1C, 0x00, 0x21,
  0xFC, 0x00, 0x18, 0x18, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x8C, 0x03, 0x83, 0x90,
  0x0C, 0x03, 0x20, 0x30, 0x03, 0xC0, 0x60, 0x07, 0x81, 0x80, 0x0F, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x82, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x60, 0x06, 0x80, 0x60,
  0x0B, 0x00, 0xC0, 0x36, 0x00, 0xE1, 0xCC, 0x00, 0xFE, 0x10, 0x00, 0x70,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x11, 0xF8, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x02, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xFE, 0x01, 0xC0, 0x70, 0x38, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x08, 0x01, 0x80,
  0xE0, 0x70, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x01, 0xFF, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x80, 0x04, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x02, 0x00,
  0x78, 0x18, 0x02, 0xC0, 0xC0, 0x34, 0x03, 0x07, 0x20, 0x1F, 0xE3, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x26, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x06,
  0x18, 0x03, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x6C, 0x00, 0x70, 0x01, 0xB0, 0x01, 0xC0, 0x04, 0xC0, 0x05, 0x00,
  0x33, 0x00, 0x34, 0x00, 0xCC, 0x00, 0x90, 0x06, 0x30, 0x06, 0x40, 0x18,
  0xC0, 0x19, 0x00, 0x43, 0x00, 0x44, 0x03, 0x0C, 0x03, 0x10, 0x0C, 0x30,
  0x08, 0x40, 0x20, 0xC0, 0x61, 0x01, 0x83, 0x01, 0x84, 0x04, 0x0C, 0x04,
  0x10, 0x30, 0x30, 0x30, 0x40, 0xC0, 0xC0, 0x81, 0x02, 0x03, 0x06, 0x04,
  0x18, 0x0C, 0x18, 0x10, 0x40, 0x30, 0xC0, 0xC3, 0x00, 0xC3, 0x03, 0x0C,
  0x03, 0x08, 0x0C, 0x20, 0x0C, 0x60, 0x31, 0x80, 0x31, 0x80, 0xC6, 0x00,
  0xCC, 0x03, 0x10, 0x03, 0x30, 0x0C, 0xC0, 0x0C, 0x80, 0x32, 0x00, 0x36,
  0x00, 0xD8, 0x00, 0xD8, 0x03, 0x60, 0x03, 0xC0, 0x0D, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x20, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x11, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x44, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x01, 0x86, 0x00, 0x03, 0x02, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x08, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x30, 0x01, 0x00, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x10,
  0x06, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x9E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xE1, 0xE0, 0x0F, 0x00, 0xF0, 0x3C,
  0x00, 0x7F, 0xC8, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 48, 14, 1, -48 },
  { 79, 13, 17, 17, 6, -48 },
  { 107, 26, 48, 25, 0, -48 },
  { 263, 25, 55, 23, -1, -51 },
  { 435, 29, 50, 35, 3, -49 },
  { 617, 21, 50, 22, -1, -49 },
  { 749, 6, 17, 10, 6, -48 },
  { 762, 18, 59, 16, 2, -48 },
  { 895, 18, 59, 16, -5, -48 },
  { 1028, 16, 18, 21, 8, -51 },
  { 1064, 23, 31, 27, 2, -39 },
  { 1154, 8, 15, 10, -3, -6 },
  { 1169, 14, 2, 18, 2, -19 },
  { 1173, 3, 5, 10, 1, -5 },
  { 1175, 27, 48, 20, -3, -48 },
  { 1337, 22, 50, 23, 1, -49 },
  { 1475, 12, 48, 23, 7, -48 },
  { 1547, 25, 49, 23, -2, -49 },
  { 1701, 25, 50, 23, -2, -49 },
  { 1858, 24, 48, 23, -1, -48 },
  { 2002, 25, 49, 23, -2, -48 },
  { 2156, 23, 50, 23, 1, -49 },
  { 2300, 23, 48, 23, 2, -48 },
  { 2438, 25, 50, 23, -1, -49 },
  { 2595, 23, 50, 23, 0, -49 },
  { 2739, 10, 35, 10, 0, -35 },
  { 2783, 13, 44, 10, -3, -35 },
  { 2855, 23, 27, 27, 2, -37 },
  { 2933, 23, 16, 27, 2, -32 },
  { 2979, 23, 27, 27, 2, -37 },
  { 3057, 18, 49, 16, 1, -49 },
  { 3168, 31, 54, 34, 2, -48 },
  { 3378, 22, 48, 22, -5, -48 },
  { 3510, 25, 48, 25, 0, -48 },
  { 3660, 26, 50, 23, 2, -49 },
  { 3823, 26, 48, 28, 0, -48 },
  { 3979, 25, 48, 23, 0, -48 },
  { 4129, 25, 48, 21, 0, -48 },
  { 4279, 30, 50, 30, 2, -49 },
  { 4467, 30, 48, 29, 0, -48 },
  { 4647, 20, 48, 11, -4, -48 },
  { 4767, 22, 60, 10, -10, -48 },
  { 4932, 28, 48, 23, 0, -48 },
  { 5100, 15, 48, 20, 0, -48 },
  { 5190, 40, 48, 39, 0, -48 },
  { 5430, 32, 48, 31, 0, -48 },
  { 5622, 26, 50, 30, 2, -49 },
  { 5785, 25, 48, 24, 0, -48 },
  { 5935, 26, 60, 30, 2, -49 },
  { 6130, 24, 48, 24, 0, -48 },
  { 6274, 27, 50, 23, -2, -49 },
  { 6443, 21, 48, 20, 4, -48 },
  { 6569, 28, 49, 28, 2, -48 },
  { 6741, 22, 48, 23, 6, -48 },
  { 6873, 40, 48, 40, 5, -48 },
  { 7113, 29, 48, 20, -4, -48 },
  { 7287, 21, 48, 19, 4, -48 },
  { 7413, 27, 48, 20, -3, -48 },
  { 7575, 23, 59, 18, -1, -48 },
  { 7745, 9, 48, 21, 7, -48 },
  { 7799, 24, 59, 18, -4, -48 },
  { 7976, 24, 23, 26, 2, -48 },
  { 8045, 17, 2, 17, -5, 6 },
  { 8050, 6, 10, 14, 10, -51 },
  { 8058, 23, 37, 25, 2, -36 },
  { 8165, 23, 52, 25, 0, -51 },
  { 8315, 18, 37, 18, 2, -36 },
  { 8399, 26, 52, 25, 2, -51 },
  { 8568, 19, 37, 22, 2, -36 },
  { 8656, 29, 67, 12, -9, -51 },
  { 8899, 26, 52, 25, -1, -36 },
  { 9068, 22, 51, 24, 0, -51 },
  { 9209, 13, 48, 10, 0, -48 },
  { 9287, 22, 64, 11, -9, -48 },
  { 9463, 22, 51, 20, 0, -51 },
  { 9604, 13, 51, 10, 0, -51 },
  { 9687, 35, 36, 37, 0, -36 },
  { 9845, 22, 36, 24, 0, -36 },
  { 9944, 20, 37, 24, 2, -36 },
  { 10037, 26, 51, 25, -3, -36 },
  { 10203, 23, 52, 25, 2, -36 },
  { 10353, 19, 36, 16, 0, -36 },
  { 10439, 20, 37, 18, -1, -36 },
  { 10532, 12, 45, 12, 1, -44 },
  { 10600, 21, 36, 24, 2, -35 },
  { 10695, 17, 35, 18, 4, -35 },
  { 10770, 30, 35, 31, 4, -35 },
  { 10902, 24, 35, 19, -3, -35 },
  { 11007, 31, 51, 20, -8, -35 },
  { 11205, 20, 35, 15, -2, -35 },
  { 11293, 23, 59, 21, 2, -48 },
  { 11463, 2, 67, 23, 10, -51 },
  { 11480, 22, 59, 21, -4, -48 },
  { 11643, 23, 5, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC67PT7B_H_
