#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x60, 0x61, 0x81,
  0x86, 0x06, 0x30, 0x18, 0xC0, 0x43, 0x03, 0x0C, 0x0C, 0x20, 0x30, 0x80,
  0x86, 0x02, 0x18, 0x18, 0x40, 0x61, 0x01, 0x84, 0x04, 0x30, 0x10, 0xC0,
  0xC2, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x04, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x61, 0xE0, 0x07, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x30, 0x10, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x02, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x18,
  0x0C, 0x78, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x04, 0x01, 0xFE, 0x00, 0x18, 0x03, 0x86, 0x00, 0x18, 0x03, 0x02,
  0x00, 0x30, 0x06, 0x03, 0x00, 0x30, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x01, 0x80, 0x18, 0x03, 0x01, 0x80, 0x30, 0x02, 0x03, 0x00, 0x30, 0x06,
  0x03, 0x00, 0x30, 0x06, 0x06, 0x00, 0x70, 0x06, 0x06, 0x00, 0x60, 0x06,
  0x0C, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x60, 0x0C, 0x18, 0x00, 0x60, 0x0C,
  0x18, 0x00, 0x60, 0x0C, 0x30, 0x00, 0x40, 0x0C, 0x30, 0x00, 0xC0, 0x18,
  0x60, 0xFC, 0xC0, 0x18, 0x61, 0xFE, 0xC0, 0x18, 0xC3, 0x06, 0xC0, 0x30,
  0xC7, 0x06, 0xC0, 0x31, 0x86, 0x02, 0xC0, 0x61, 0x8C, 0x03, 0x40, 0x63,
  0x0C, 0x03, 0x60, 0xC3, 0x18, 0x03, 0x61, 0xC6, 0x18, 0x02, 0x3F, 0x86,
  0x18, 0x06, 0x1E, 0x0C, 0x30, 0x06, 0x00, 0x0C, 0x30, 0x06, 0x00, 0x18,
  0x30, 0x06, 0x00, 0x18, 0x60, 0x06, 0x00, 0x30, 0x60, 0x06, 0x00, 0x30,
  0x60, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x00, 0xC0,
  0x40, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x01, 0x80,
  0xC0, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x00,
  0xC0, 0xE0, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x61, 0x80, 0x38, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x38, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0xC0, 0x07, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x01, 0x86,
  0x03, 0x03, 0x1C, 0x06, 0x0C, 0x30, 0x0C, 0x18, 0xC0, 0x18, 0x31, 0x80,
  0x18, 0x46, 0x00, 0x31, 0x8C, 0x00, 0x63, 0x18, 0x00, 0xCC, 0x30, 0x00,
  0xD8, 0xC0, 0x01, 0xB1, 0x80, 0x03, 0xC3, 0x00, 0x07, 0x86, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0xD0, 0x70, 0x03, 0x30,
  0x60, 0x06, 0x60, 0xE0, 0x38, 0xC0, 0xE0, 0xE0, 0x80, 0xFF, 0x81, 0x80,
  0x78, 0x00, 0x00, 0x1C, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x20, 0x86, 0x18,
  0x41, 0x04, 0x30, 0xC2, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x04,
  0x06, 0x03, 0x83, 0x00, 0x61, 0x00, 0x0C, 0x83, 0x83, 0x5F, 0x80, 0x78,
  0x00, 0x70, 0x00, 0x64, 0x00, 0x62, 0x00, 0x60, 0x80, 0xE0, 0x60, 0xC0,
  0x10, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x81, 0x80, 0xFF, 0xFE,
  0x67, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x30, 0x70, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x70, 0x00, 0x61, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xB0, 0x72, 0x0E,
  0x61, 0xC6, 0x30, 0x6E, 0x06, 0x40, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x10, 0x00, 0xF0,
  0x03, 0xC0, 0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xE4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x07,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x01, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x38,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x07, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0xFF, 0x00, 0x31, 0xFF, 0x80, 0x33, 0x01, 0xC0, 0x66, 0x00, 0xE0, 0x6C,
  0x00, 0x60, 0x78, 0x00, 0x70, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60,
  0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x38, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xB0, 0x00,
  0x03, 0x86, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x38, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x16, 0x06, 0x00,
  0x34, 0x07, 0x00, 0x6C, 0x03, 0x81, 0xCC, 0x01, 0xFF, 0x8C, 0x00, 0x7C,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x81, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1C, 0x07, 0x01,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x3E, 0x03, 0x06, 0x00, 0x7F, 0x81, 0x86, 0x00, 0x60, 0xC0, 0xC3, 0x00,
  0x60, 0x60, 0x61, 0x80, 0x60, 0x60, 0x31, 0x80, 0x60, 0x30, 0x18, 0xC0,
  0x30, 0x18, 0x0C, 0x60, 0x30, 0x0C, 0x06, 0x60, 0x18, 0x0C, 0x03, 0x30,
  0x18, 0x06, 0x01, 0x98, 0x0C, 0x03, 0x01, 0x8C, 0x0C, 0x01, 0x80, 0xCC,
  0x06, 0x01, 0x80, 0x66, 0x03, 0x00, 0xC0, 0x33, 0x01, 0x80, 0x60, 0x19,
  0x81, 0x80, 0x70, 0x18, 0xC0, 0xC0, 0x30, 0x0C, 0xC0, 0x60, 0x18, 0x06,
  0x60, 0x30, 0x0C, 0x06, 0x30, 0x18, 0x0E, 0x03, 0x18, 0x0C, 0x06, 0x01,
  0x8C, 0x06, 0x07, 0x01, 0x86, 0x03, 0x03, 0x80, 0xC3, 0x01, 0x81, 0x40,
  0xC1, 0x80, 0xC1, 0xA0, 0x60, 0xC0, 0x61, 0x90, 0x60, 0x60, 0x39, 0xCC,
  0x60, 0x30, 0x0F, 0xC7, 0xE0, 0x18, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x01, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x33, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x01, 0x83, 0x00, 0x01, 0x83, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0x03, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x1E, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x03, 0x00,
  0x0E, 0x00, 0x60, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1C, 0x01, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0x87, 0xE0, 0x00, 0x30, 0x07, 0x80, 0x03,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00,
  0x60, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x20, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0xCF, 0x00, 0x00, 0x03, 0x6C, 0x00, 0x00, 0x09, 0xB0, 0x00, 0x00,
  0x6C, 0xC0, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x80,
  0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x60, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x01, 0xA0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x0D,
  0x80, 0x0B, 0x00, 0x00, 0x01, 0xB0, 0x03, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x64, 0x00, 0x00, 0x0D, 0x80, 0x0C, 0x80, 0x00, 0x03, 0xB0, 0x01, 0x90,
  0x00, 0x00, 0x66, 0x00, 0x22, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0x60, 0x00,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x00, 0x03, 0x18, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x40, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60,
  0x20, 0x03, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x0C, 0x03, 0x00, 0xE0,
  0x30, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x07, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x18, 0x02, 0x00, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x80, 0x18,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x06, 0x00, 0x60, 0x06, 0x00, 0x61, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x30, 0x03, 0x00, 0x18, 0x01, 0x8C, 0x00, 0x60,
  0x02, 0x00, 0x31, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x60, 0x01, 0x80, 0x18,
  0x00, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x0B, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x38, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x30,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x34, 0x00, 0x01,
  0x80, 0x0D, 0x80, 0x00, 0x60, 0x03, 0x60, 0x00, 0x18, 0x01, 0x98, 0x00,
  0x06, 0x00, 0x66, 0x00, 0x03, 0x00, 0x19, 0x80, 0x00, 0xC0, 0x06, 0x20,
  0x00, 0x30, 0x01, 0x0C, 0x00, 0x0C, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x30,
  0xC0, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x60, 0x03, 0x04, 0x00, 0x18, 0x01,
  0x81, 0x80, 0x06, 0x00, 0x60, 0x60, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x60, 0x04, 0x01, 0x00, 0x18, 0x01,
  0x80, 0xC0, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x30, 0x60, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x00, 0xC1, 0x80,
  0x18, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x04, 0x30, 0x01, 0x80, 0x01, 0x8C,
  0x00, 0x60, 0x00, 0x63, 0x00, 0x30, 0x00, 0x18, 0xC0, 0x0C, 0x00, 0x06,
  0x60, 0x03, 0x00, 0x01, 0x98, 0x00, 0xC0, 0x00, 0x36, 0x00, 0x20, 0x00,
  0x0D, 0x80, 0x18, 0x00, 0x03, 0x40, 0x06, 0x00, 0x00, 0xF0, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x06, 0x1F, 0x80,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x1C, 0x00, 0x60, 0x1E, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x38, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x06,
  0x1F, 0x80, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0x20, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0x60, 0x10, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x1C, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x66, 0x00, 0x01, 0xE0, 0x00, 0x18, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x18, 0x00, 0x05, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0xB0, 0x00, 0x18, 0x60, 0x00, 0x36, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x98, 0x00, 0x18, 0x30, 0x00, 0x33, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x60, 0x01,
  0x86, 0x00, 0x30, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x18,
  0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x20, 0x06, 0x00, 0x60, 0x08, 0x04, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x80, 0x30, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x20, 0x18, 0x02,
  0x01, 0x80, 0x04, 0x03, 0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x18, 0x0C,
  0x00, 0x10, 0x18, 0x03, 0x01, 0x80, 0x02, 0x03, 0x00, 0x60, 0x60, 0x00,
  0x40, 0xC0, 0x0C, 0x0C, 0x00, 0x08, 0x18, 0x01, 0x81, 0x80, 0x01, 0x03,
  0x00, 0x30, 0x60, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x01, 0xC0, 0x02,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x82, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x40, 0x60, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00,
  0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x01, 0x80,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x83, 0x0C, 0x18, 0x60,
  0x83, 0x04, 0x18, 0x20, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF0, 0xC0,
  0x1F, 0x3C, 0x40, 0x1C, 0x06, 0x60, 0x1C, 0x01, 0xB0, 0x0C, 0x00, 0x58,
  0x0C, 0x00, 0x28, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x83, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x07, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x03, 0xC0,
  0x20, 0x01, 0xE0, 0x18, 0x01, 0xB0, 0x0C, 0x01, 0x90, 0x03, 0x01, 0xD8,
  0x01, 0xC1, 0xCC, 0x00, 0x7F, 0x86, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x61, 0xFE, 0x00, 0x31, 0xC7, 0x80, 0x19, 0x80,
  0xC0, 0x0D, 0x80, 0x30, 0x0D, 0x80, 0x18, 0x07, 0x80, 0x0C, 0x03, 0xC0,
  0x03, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0x60, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x14, 0x00, 0x30, 0x1B, 0x00,
  0x30, 0x0D, 0x80, 0x38, 0x06, 0xE0, 0x38, 0x02, 0x38, 0x78, 0x03, 0x0F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x01, 0xE1,
  0x80, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x78, 0x30, 0x07,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x01, 0x80, 0x01, 0xFE, 0x10, 0x00, 0x7C, 0xF3, 0x00, 0x0E,
  0x03, 0x30, 0x01, 0xC0, 0x1B, 0x00, 0x18, 0x00, 0xB0, 0x03, 0x00, 0x0A,
  0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x0C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x10, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0,
  0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0xC0, 0x04, 0x00, 0x2C, 0x00, 0x60,
  0x06, 0xC0, 0x06, 0x00, 0xC8, 0x00, 0x30, 0x19, 0x80, 0x03, 0x83, 0x18,
  0x00, 0x1F, 0xE1, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01,
  0xFC, 0x00, 0x78, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x30, 0x38, 0x03, 0x03,
  0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31,
  0x80, 0x06, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x18,
  0x60, 0x07, 0x06, 0x00, 0xE0, 0x60, 0x78, 0x07, 0xFE, 0x00, 0x7F, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x02, 0x03, 0xC1, 0xC0, 0x0F, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0x0F,
  0x9E, 0x20, 0x01, 0xC0, 0x66, 0x00, 0x38, 0x03, 0x60, 0x03, 0x00, 0x16,
  0x00, 0x60, 0x01, 0x40, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x18,
  0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0,
  0x18, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x78, 0x00, 0x80,
  0x07, 0x80, 0x0C, 0x00, 0xD8, 0x00, 0xC0, 0x19, 0x00, 0x06, 0x03, 0xB0,
  0x00, 0x70, 0xF3, 0x00, 0x03, 0xFC, 0x30, 0x00, 0x07, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0xC3,
  0xFC, 0x00, 0xCF, 0x1E, 0x00, 0xD8, 0x06, 0x00, 0xF0, 0x06, 0x00, 0xB0,
  0x03, 0x01, 0xE0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x02, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x60, 0x10, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0x80, 0xC0, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x81, 0xC0, 0x03, 0x01, 0x80,
  0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x02, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x78, 0x00, 0x06, 0x78, 0x00,
  0x04, 0xC8, 0x00, 0x0D, 0x8C, 0x00, 0x0F, 0x0C, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x18, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x10, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x3F, 0xC0, 0xFF, 0x00, 0x33,
  0x87, 0x1E, 0x3C, 0x01, 0xB0, 0x19, 0xC0, 0x70, 0x0B, 0x00, 0x6C, 0x01,
  0x80, 0xD0, 0x03, 0xC0, 0x0C, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x38, 0x00,
  0xE0, 0x03, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xE0, 0x01, 0x80, 0x06, 0x06, 0x00, 0x08, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC0,
  0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x08, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x01,
  0x00, 0x04, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x00,
  0x04, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x03, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x20, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC7, 0xF8, 0x00, 0xCF, 0x1C, 0x00,
  0xD8, 0x06, 0x00, 0xB0, 0x06, 0x01, 0xA0, 0x03, 0x01, 0xE0, 0x03, 0x01,
  0xC0, 0x02, 0x01, 0xC0, 0x02, 0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x04,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x8F, 0x00, 0x38, 0x0C, 0x01, 0xC0,
  0x18, 0x0E, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x03, 0x0E, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00,
  0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x18,
  0x01, 0x80, 0x70, 0x0C, 0x00, 0xE0, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x87, 0xF8, 0x00, 0x18, 0xE3, 0xC0,
  0x01, 0x98, 0x0C, 0x00, 0x13, 0x00, 0x60, 0x01, 0x60, 0x06, 0x00, 0x34,
  0x00, 0x30, 0x03, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x03,
  0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x30, 0x07, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0xC0,
  0x0D, 0x00, 0x18, 0x00, 0xD8, 0x03, 0x80, 0x0C, 0xC0, 0x70, 0x00, 0xCE,
  0x1E, 0x00, 0x0C, 0x7F, 0x80, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0xC0, 0x1E, 0x3C, 0x40,
  0x1C, 0x06, 0x60, 0x1C, 0x01, 0xB0, 0x0C, 0x00, 0xD8, 0x0C, 0x00, 0x28,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x03, 0xC0, 0x60, 0x01, 0xE0,
  0x18, 0x01, 0xB0, 0x0C, 0x01, 0xB0, 0x03, 0x01, 0xD8, 0x01, 0xC1, 0xCC,
  0x00, 0x7F, 0x86, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x0C, 0x3F, 0x00, 0xCF, 0x10, 0x09, 0xC0, 0x00, 0xB0, 0x00, 0x1B, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0x80, 0x3C, 0x1E, 0x03, 0x80, 0x30, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x08, 0x01, 0xC0,
  0x70, 0x3C, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0xFF,
  0xC7, 0xFE, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x81, 0xF8,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x18,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x04, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x03, 0x80, 0xC0, 0x07,
  0x01, 0x80, 0x1E, 0x03, 0x00, 0x6C, 0x07, 0x01, 0x98, 0x07, 0x0F, 0x20,
  0x07, 0xF8, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x0C,
  0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x02, 0xC0, 0x01, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x02,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x08, 0xC0, 0x04,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x30, 0xC0, 0x18,
  0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0x60,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xC0, 0xC0, 0xC1, 0x80, 0xC0, 0x80,
  0xC1, 0x00, 0xC1, 0x80, 0xC3, 0x00, 0xC1, 0x80, 0xC3, 0x00, 0xC3, 0x00,
  0xC6, 0x00, 0xC3, 0x00, 0xC6, 0x00, 0xC2, 0x00, 0x84, 0x00, 0xC6, 0x00,
  0x8C, 0x00, 0xC6, 0x00, 0x8C, 0x00, 0xCC, 0x00, 0x88, 0x00, 0xCC, 0x00,
  0x98, 0x00, 0xC8, 0x00, 0x90, 0x00, 0xD8, 0x00, 0xB0, 0x00, 0xD8, 0x00,
  0xB0, 0x00, 0xF0, 0x00, 0xA0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x01, 0x88, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x04, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x9E,
  0x7C, 0x00, 0xF8, 0x07, 0x00, 0xF8, 0x01, 0xF3, 0xE8, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 51, 15, 1, -51 },
  { 91, 14, 18, 19, 7, -51 },
  { 123, 28, 51, 26, 0, -51 },
  { 302, 27, 59, 25, -1, -55 },
  { 502, 32, 53, 37, 3, -52 },
  { 714, 23, 53, 23, -1, -52 },
  { 867, 6, 18, 10, 7, -51 },
  { 881, 19, 62, 17, 2, -51 },
  { 1029, 19, 62, 17, -5, -51 },
  { 1177, 17, 20, 23, 9, -55 },
  { 1220, 25, 33, 29, 2, -42 },
  { 1324, 9, 16, 11, -3, -7 },
  { 1342, 15, 1, 19, 2, -20 },
  { 1344, 4, 5, 11, 1, -5 },
  { 1347, 29, 51, 21, -3, -51 },
  { 1532, 23, 53, 25, 1, -52 },
  { 1685, 12, 51, 25, 8, -51 },
  { 1762, 28, 52, 25, -3, -52 },
  { 1944, 27, 53, 25, -2, -52 },
  { 2123, 26, 52, 25, -1, -52 },
  { 2292, 27, 52, 25, -2, -51 },
  { 2468, 24, 53, 25, 2, -52 },
  { 2627, 24, 51, 25, 3, -51 },
  { 2780, 26, 53, 25, -1, -52 },
  { 2953, 24, 53, 25, 0, -52 },
  { 3112, 11, 38, 11, 0, -38 },
  { 3165, 14, 47, 11, -3, -38 },
  { 3248, 25, 29, 29, 2, -40 },
  { 3339, 25, 17, 29, 2, -34 },
  { 3393, 25, 29, 29, 2, -40 },
  { 3484, 19, 52, 17, 1, -52 },
  { 3608, 33, 58, 37, 2, -52 },
  { 3848, 24, 52, 23, -5, -52 },
  { 4004, 27, 51, 27, 0, -51 },
  { 4177, 27, 53, 24, 3, -52 },
  { 4356, 28, 51, 30, 0, -51 },
  { 4535, 27, 51, 24, 0, -51 },
  { 4708, 27, 51, 22, 0, -51 },
  { 4881, 31, 53, 33, 3, -52 },
  { 5087, 33, 51, 32, 0, -51 },
  { 5298, 21, 51, 12, -4, -51 },
  { 5432, 23, 63, 11, -10, -51 },
  { 5614, 30, 51, 25, 0, -51 },
  { 5806, 16, 51, 22, 0, -51 },
  { 5908, 43, 51, 42, 0, -51 },
  { 6183, 34, 51, 33, 0, -51 },
  { 6400, 29, 53, 32, 2, -52 },
  { 6593, 26, 51, 25, 0, -51 },
  { 6759, 29, 64, 32, 2, -52 },
  { 6991, 26, 51, 26, 0, -51 },
  { 7157, 28, 53, 25, -2, -52 },
  { 7343, 22, 51, 21, 5, -51 },
  { 7484, 30, 52, 30, 2, -51 },
  { 7679, 24, 51, 25, 6, -51 },
  { 7832, 43, 51, 43, 5, -51 },
  { 8107, 31, 51, 22, -4, -51 },
  { 8305, 22, 51, 21, 5, -51 },
  { 8446, 29, 51, 22, -3, -51 },
  { 8631, 25, 62, 20, -1, -51 },
  { 8825, 10, 51, 23, 7, -51 },
  { 8889, 25, 62, 20, -4, -51 },
  { 9083, 26, 24, 28, 2, -51 },
  { 9161, 18, 1, 19, -5, 7 },
  { 9164, 6, 11, 15, 11, -55 },
  { 9173, 25, 40, 27, 2, -39 },
  { 9298, 25, 56, 27, 0, -55 },
  { 9473, 19, 40, 19, 2, -39 },
  { 9568, 28, 56, 27, 2, -55 },
  { 9764, 20, 40, 23, 2, -39 },
  { 9864, 31, 72, 13, -9, -55 },
  { 10143, 28, 56, 27, -1, -39 },
  { 10339, 24, 55, 26, 0, -55 },
  { 10504, 13, 51, 11, 0, -51 },
  { 10587, 24, 68, 12, -10, -51 },
  { 10791, 24, 55, 21, 0, -55 },
  { 10956, 14, 55, 11, 0, -55 },
  { 11053, 37, 39, 39, 0, -39 },
  { 11234, 24, 39, 26, 0, -39 },
  { 11351, 22, 40, 26, 2, -39 },
  { 11461, 28, 55, 27, -3, -39 },
  { 11654, 25, 56, 27, 2, -39 },
  { 11829, 20, 39, 17, 0, -39 },
  { 11927, 21, 40, 20, -1, -39 },
  { 12032, 13, 48, 13, 1, -47 },
  { 12110, 23, 39, 26, 2, -38 },
  { 12223, 19, 38, 20, 4, -38 },
  { 12314, 32, 38, 33, 4, -38 },
  { 12466, 26, 38, 20, -3, -38 },
  { 12590, 33, 56, 21, -8, -38 },
  { 12821, 21, 38, 17, -2, -38 },
  { 12921, 25, 62, 22, 2, -51 },
  { 13115, 2, 73, 25, 11, -55 },
  { 13134, 25, 62, 22, -5, -51 },
  { 13328, 25, 5, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC72PT7B_H_
