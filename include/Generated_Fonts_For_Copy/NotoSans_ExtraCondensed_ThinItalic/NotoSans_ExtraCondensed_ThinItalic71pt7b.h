#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x60, 0x61, 0x81,
  0x86, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x20, 0x30, 0x80,
  0x86, 0x06, 0x18, 0x18, 0x40, 0x61, 0x01, 0x04, 0x04, 0x30, 0x10, 0xC0,
  0xC2, 0x02, 0x08, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x02,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x18, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x38, 0x61, 0xE0, 0x0E, 0x0C, 0x08, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x20, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x08, 0x00, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x06, 0x00, 0xC0, 0x43, 0x80, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x03, 0xBC, 0x00, 0x30, 0x0C, 0x18,
  0x00, 0xC0, 0x38, 0x30, 0x01, 0x80, 0x60, 0x20, 0x06, 0x01, 0x80, 0x40,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18,
  0x03, 0x00, 0x60, 0x60, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x01, 0x83, 0x00,
  0x30, 0x03, 0x06, 0x00, 0x60, 0x0C, 0x18, 0x00, 0xC0, 0x18, 0x30, 0x01,
  0x80, 0x30, 0xC0, 0x02, 0x00, 0x61, 0x80, 0x0C, 0x01, 0x86, 0x07, 0x98,
  0x03, 0x0C, 0x3F, 0xB0, 0x06, 0x30, 0xE3, 0x60, 0x18, 0x63, 0x83, 0xC0,
  0x31, 0x86, 0x07, 0x80, 0xC3, 0x18, 0x0F, 0x01, 0x8C, 0x30, 0x1B, 0x06,
  0x18, 0xC0, 0x36, 0x1C, 0x61, 0x80, 0x6F, 0xF0, 0xC6, 0x00, 0xCF, 0xC3,
  0x0C, 0x01, 0x80, 0x06, 0x18, 0x03, 0x00, 0x18, 0x60, 0x06, 0x00, 0x30,
  0xC0, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x01, 0x83, 0x00, 0x60, 0x06, 0x06,
  0x00, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x30, 0x30, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x03, 0x00, 0x30, 0x18, 0x06, 0x00, 0x60, 0x60, 0x18, 0x00, 0xC1, 0x80,
  0x30, 0x00, 0xC7, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60,
  0xE0, 0x00, 0xC1, 0x80, 0x00, 0x86, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30,
  0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0xC1, 0x80, 0x43, 0x83, 0x01, 0x06, 0x03, 0x06, 0x18, 0x06, 0x0C, 0x70,
  0x0C, 0x18, 0xC0, 0x18, 0x61, 0x80, 0x18, 0xC6, 0x00, 0x31, 0x8C, 0x00,
  0x66, 0x18, 0x00, 0x4C, 0x60, 0x00, 0xF0, 0xC0, 0x01, 0xE1, 0x80, 0x03,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x78,
  0x38, 0x01, 0x90, 0x30, 0x06, 0x30, 0x70, 0x1C, 0x60, 0x70, 0x70, 0xC0,
  0x7F, 0xC0, 0x80, 0x3C, 0x00, 0x00, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x21,
  0x18, 0xC4, 0x21, 0x18, 0xC4, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x04, 0x04, 0x01, 0x82, 0x00, 0x71,
  0x01, 0x0C, 0x87, 0x81, 0xFE, 0x00, 0x60, 0x00, 0x50, 0x00, 0xC4, 0x00,
  0xC2, 0x00, 0xC0, 0x80, 0xC0, 0x60, 0xC0, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x04, 0x06, 0x02, 0x03, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFE,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x60, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x0C, 0x02, 0x00, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x38, 0x00, 0x30, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x03, 0xA0,
  0x3B, 0x03, 0x18, 0x70, 0xC7, 0x06, 0x70, 0x61, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE7, 0x80, 0x03,
  0x80, 0x30, 0x00, 0x40, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x01, 0xE0, 0x0E,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x07, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x20, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x08, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xC6, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x7C, 0x00, 0x31, 0xFF, 0x00, 0x33, 0x81,
  0x80, 0x66, 0x00, 0xC0, 0x6C, 0x00, 0x60, 0x78, 0x00, 0x60, 0x70, 0x00,
  0x60, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x80, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xE7, 0x80, 0x01, 0x80, 0x70, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x1C,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x03, 0x81, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x38, 0x1C, 0x00,
  0x60, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x02, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x14, 0x06, 0x00, 0x3C, 0x06,
  0x00, 0x6C, 0x03, 0x01, 0xCC, 0x01, 0xFF, 0x8C, 0x00, 0xFE, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x81, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x40, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x00, 0x08, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0xF9, 0xF0, 0x08, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0xFF, 0x03, 0x0C, 0x00, 0xE3,
  0x81, 0x86, 0x00, 0xC1, 0x80, 0xC3, 0x00, 0xC0, 0xC0, 0x63, 0x00, 0xC0,
  0x60, 0x31, 0x80, 0x60, 0x30, 0x18, 0xC0, 0x60, 0x30, 0x08, 0xC0, 0x30,
  0x18, 0x0C, 0x60, 0x30, 0x0C, 0x06, 0x30, 0x18, 0x06, 0x03, 0x18, 0x18,
  0x06, 0x01, 0x98, 0x0C, 0x03, 0x00, 0xCC, 0x06, 0x01, 0x80, 0xC6, 0x02,
  0x00, 0xC0, 0x63, 0x03, 0x00, 0xC0, 0x31, 0x81, 0x80, 0x60, 0x19, 0x80,
  0xC0, 0x30, 0x18, 0xC0, 0x60, 0x38, 0x0C, 0x60, 0x30, 0x18, 0x06, 0x30,
  0x10, 0x0C, 0x06, 0x18, 0x08, 0x0E, 0x03, 0x0C, 0x04, 0x07, 0x01, 0x06,
  0x02, 0x07, 0x81, 0x83, 0x01, 0x83, 0xC1, 0x81, 0x80, 0xC3, 0x60, 0xC0,
  0xC0, 0x63, 0x18, 0xC0, 0x60, 0x1F, 0x8F, 0xC0, 0x30, 0x07, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x02,
  0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00,
  0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00,
  0x22, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88, 0x00, 0x06, 0x10, 0x00, 0x0C,
  0x20, 0x00, 0x10, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00, 0x03, 0x02,
  0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x3C,
  0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x60, 0x3C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x07, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x78, 0x7C, 0x00, 0x38, 0x01, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x30,
  0x1F, 0x00, 0x03, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x00, 0x07,
  0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x06,
  0x00, 0x70, 0x00, 0x60, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x20, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x06, 0x00, 0x03, 0xFE,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x3C, 0x00, 0x00,
  0x09, 0xB0, 0x00, 0x00, 0x6C, 0xC0, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0x0D, 0x80, 0x0B, 0x00, 0x00, 0x01, 0xA0, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x0D, 0x80, 0x00,
  0x03, 0x30, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x26, 0x00, 0x00, 0x19,
  0x80, 0x0C, 0x40, 0x00, 0x03, 0x30, 0x01, 0x88, 0x00, 0x00, 0xC6, 0x00,
  0x31, 0x00, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x00, 0x06, 0x10, 0x01, 0x86,
  0x00, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x10, 0x60, 0x00, 0x30,
  0xC0, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x40,
  0xC0, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x20, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x0C, 0x02, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x40, 0x18, 0x06, 0x00, 0x30,
  0x08, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x01, 0x80, 0x30,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC1, 0x80,
  0x18, 0x00, 0x80, 0x18, 0x30, 0x06, 0x00, 0x30, 0x03, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x61, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x8C, 0x00, 0x40, 0x02, 0x00, 0x33, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x1B, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x60, 0x01, 0x00, 0x18, 0x00, 0x78, 0x00, 0x60,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x20, 0x03, 0xC0, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x60, 0x03, 0x40, 0x00,
  0x30, 0x01, 0x98, 0x00, 0x0C, 0x00, 0x66, 0x00, 0x03, 0x00, 0x19, 0x80,
  0x00, 0xC0, 0x06, 0x60, 0x00, 0x30, 0x01, 0x08, 0x00, 0x18, 0x00, 0xC3,
  0x00, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x0C, 0x30, 0x00, 0x60, 0x03,
  0x0C, 0x00, 0x10, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x01, 0x81, 0x80, 0x08,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x18, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x30, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x03, 0x04, 0x00,
  0x60, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x0C, 0x30,
  0x01, 0x80, 0x03, 0x0C, 0x00, 0x60, 0x00, 0x66, 0x00, 0x30, 0x00, 0x19,
  0x80, 0x0C, 0x00, 0x06, 0x60, 0x03, 0x00, 0x01, 0x98, 0x00, 0xC0, 0x00,
  0x66, 0x00, 0x20, 0x00, 0x1B, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x06, 0x00,
  0x00, 0xF0, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x01, 0xE0, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x0E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0x01, 0xE0, 0x00,
  0xC0, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x1C, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0x40, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x20, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7C, 0x7F, 0x00, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x01, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x80,
  0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20,
  0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x30, 0x00, 0x07, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x3C, 0x00, 0x06, 0x18, 0x00, 0x05, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0xB0, 0x00, 0x18, 0x60, 0x00, 0x36, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x98, 0x00, 0x30, 0x30, 0x00, 0x22, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x40, 0x00, 0xC0, 0xC0, 0x01, 0x88, 0x00, 0x30,
  0x18, 0x00, 0x61, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x20, 0x01, 0x80, 0x60,
  0x01, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x80, 0x06, 0x01, 0x80, 0x0C,
  0x10, 0x01, 0x80, 0x30, 0x03, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x18, 0x01, 0x80, 0x10, 0x03, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x60, 0x0C, 0x00, 0x40, 0x18, 0x0C, 0x01, 0x80, 0x08,
  0x03, 0x01, 0x80, 0x60, 0x01, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x04, 0x03, 0x00, 0xC0, 0x60, 0x00, 0x80, 0xC0, 0x18,
  0x0C, 0x00, 0x10, 0x18, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x03,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x08, 0xC0,
  0x00, 0x18, 0xC0, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x23, 0x00, 0x00,
  0x66, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x01, 0xB0,
  0x00, 0x12, 0x00, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x58, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x08, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x09,
  0x80, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x38, 0x08, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x10, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x02, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x20, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x18, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x1C,
  0x00, 0x30, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0D,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0xC1, 0x81, 0x83, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xE3, 0x00, 0x70, 0x73, 0x00, 0xC0, 0x33, 0x01, 0x80,
  0x1A, 0x03, 0x00, 0x1A, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x02,
  0x80, 0x60, 0x06, 0x80, 0x60, 0x0D, 0x80, 0x30, 0x19, 0x80, 0x38, 0x71,
  0x80, 0x1F, 0xE1, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC1, 0xF0,
  0x00, 0x63, 0xFE, 0x00, 0x33, 0x03, 0x80, 0x1B, 0x00, 0xC0, 0x1B, 0x00,
  0x30, 0x0D, 0x00, 0x18, 0x07, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x01, 0xC0,
  0x01, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x10, 0x18, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x80, 0x01, 0x81, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0xC0, 0x28, 0x00, 0x60, 0x34, 0x00, 0x60, 0x1B, 0x00, 0x70, 0x0D, 0xC0,
  0x70, 0x04, 0x70, 0xF0, 0x06, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xC0, 0x80, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC1, 0x80, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xC3, 0x00, 0x03, 0xFE, 0x30, 0x00,
  0x70, 0x73, 0x00, 0x0C, 0x03, 0x30, 0x01, 0x80, 0x1A, 0x00, 0x30, 0x01,
  0xE0, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x1C,
  0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x02, 0x80, 0x06,
  0x00, 0x68, 0x00, 0x60, 0x0D, 0x80, 0x03, 0x01, 0x98, 0x00, 0x38, 0x71,
  0x80, 0x01, 0xFE, 0x10, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x00, 0xE0, 0x60, 0x1C, 0x07, 0x01, 0x80, 0x30, 0x30, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x70, 0x60, 0x0E, 0x06, 0x03, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x40, 0x3C, 0x1C, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x8C, 0x00, 0x38, 0x39,
  0x80, 0x0C, 0x03, 0x30, 0x03, 0x00, 0x34, 0x00, 0xC0, 0x06, 0x80, 0x18,
  0x00, 0x70, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x08, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0xC0,
  0x03, 0xC0, 0x18, 0x00, 0x50, 0x01, 0x80, 0x1A, 0x00, 0x30, 0x06, 0xC0,
  0x03, 0x01, 0x98, 0x00, 0x70, 0xE3, 0x00, 0x07, 0xF8, 0x40, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x40, 0x06, 0x00, 0x0C, 0x01, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC3, 0xF0, 0x01, 0x8F, 0xF8,
  0x03, 0x70, 0x38, 0x06, 0xC0, 0x30, 0x0B, 0x00, 0x60, 0x3C, 0x00, 0xC0,
  0x70, 0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0E,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x10, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00, 0x0C,
  0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x04, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x00, 0x00, 0x10, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x0E, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06,
  0x78, 0x00, 0x06, 0x78, 0x00, 0x04, 0xD8, 0x00, 0x0D, 0x88, 0x00, 0x0F,
  0x0C, 0x00, 0x0F, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x18, 0x04, 0x00, 0x18, 0x06, 0x00, 0x10, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x06, 0x7F, 0xC3,
  0xFF, 0x00, 0x37, 0x07, 0x38, 0x1C, 0x01, 0x60, 0x19, 0x80, 0x60, 0x1A,
  0x00, 0x58, 0x03, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x38, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x06, 0x00, 0x30, 0x1C, 0x00,
  0x20, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x02, 0x01, 0x00, 0x04, 0x00, 0x30, 0x18, 0x00, 0x60, 0x01,
  0x80, 0xC0, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x02, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x20, 0x00, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x40, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0x8F, 0xF8, 0x02, 0x70, 0x30, 0x05, 0xC0, 0x30,
  0x1B, 0x00, 0x60, 0x3C, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x01,
  0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x08, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70,
  0x0C, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x31,
  0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x01, 0x80, 0x1C, 0x06,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x8F, 0xF8, 0x00, 0x19, 0xC1,
  0xC0, 0x01, 0x30, 0x0C, 0x00, 0x16, 0x00, 0x60, 0x03, 0x60, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0x80, 0x02, 0x00, 0x38, 0x00, 0x30, 0x07, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x10,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0xD0, 0x01,
  0x80, 0x0D, 0x80, 0x38, 0x00, 0xD8, 0x07, 0x00, 0x0C, 0xE1, 0xE0, 0x00,
  0xC7, 0xF8, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xE3, 0x00, 0x70, 0x73, 0x00, 0xC0, 0x33, 0x01,
  0x80, 0x1A, 0x03, 0x00, 0x1A, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0xC0,
  0x02, 0xC0, 0x60, 0x07, 0x80, 0x60, 0x0D, 0x80, 0x70, 0x19, 0x80, 0x38,
  0x71, 0x80, 0x1F, 0xE1, 0x00, 0x07, 0x83, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x0C,
  0x7E, 0x00, 0x9C, 0x00, 0x09, 0x80, 0x01, 0xB0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0x80, 0x30, 0x0E, 0x03, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x01, 0x00, 0x38, 0x0E, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x07, 0xFE, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xF8, 0x03, 0x80, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x01, 0x80, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x00,
  0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30, 0x01,
  0xC0, 0x60, 0x03, 0x80, 0xC0, 0x0F, 0x01, 0x80, 0x36, 0x03, 0x00, 0xC8,
  0x03, 0x87, 0x10, 0x03, 0xFC, 0x60, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x06, 0xC0, 0x01,
  0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x04, 0xC0, 0x02, 0xC0, 0x0C, 0xC0, 0x06,
  0x80, 0x0C, 0xC0, 0x06, 0x80, 0x18, 0xC0, 0x0C, 0x80, 0x18, 0xC0, 0x0C,
  0x80, 0x10, 0xC0, 0x08, 0x80, 0x30, 0xC0, 0x18, 0x80, 0x30, 0xC0, 0x18,
  0x80, 0x60, 0xC0, 0x30, 0x80, 0x60, 0xC0, 0x30, 0x80, 0x40, 0xC0, 0x20,
  0x80, 0xC0, 0xC0, 0x60, 0x80, 0xC0, 0xC0, 0x60, 0x81, 0x80, 0xC0, 0xC0,
  0x81, 0x80, 0xC0, 0xC0, 0x81, 0x00, 0xC0, 0x80, 0x83, 0x00, 0xC1, 0x80,
  0x83, 0x00, 0xC1, 0x80, 0x82, 0x00, 0xC3, 0x00, 0x86, 0x00, 0xC3, 0x00,
  0x86, 0x00, 0xC6, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x8C, 0x00, 0xC6, 0x01,
  0x88, 0x00, 0xCC, 0x01, 0x98, 0x00, 0xCC, 0x01, 0x98, 0x00, 0xD8, 0x01,
  0xB0, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0xD0, 0x01, 0xA0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x04, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x08, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x08, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0x70, 0x38, 0x03,
  0xC0, 0x0E, 0x0F, 0x80, 0x07, 0xFC, 0x80, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 51, 14, 1, -51 },
  { 91, 14, 19, 18, 7, -51 },
  { 125, 27, 51, 26, 0, -51 },
  { 298, 27, 58, 24, -1, -54 },
  { 494, 31, 52, 37, 3, -51 },
  { 696, 23, 52, 23, -1, -51 },
  { 846, 5, 19, 10, 7, -51 },
  { 858, 19, 61, 17, 2, -50 },
  { 1003, 19, 61, 17, -5, -50 },
  { 1148, 17, 19, 23, 9, -54 },
  { 1189, 24, 32, 28, 2, -41 },
  { 1285, 9, 15, 11, -3, -6 },
  { 1302, 15, 2, 19, 2, -20 },
  { 1306, 3, 5, 11, 1, -5 },
  { 1308, 28, 51, 21, -3, -51 },
  { 1487, 23, 52, 24, 1, -51 },
  { 1637, 13, 51, 24, 7, -51 },
  { 1720, 26, 51, 24, -2, -51 },
  { 1886, 27, 52, 24, -2, -51 },
  { 2062, 26, 51, 24, -1, -51 },
  { 2228, 27, 52, 24, -2, -51 },
  { 2404, 24, 52, 24, 2, -51 },
  { 2560, 24, 51, 24, 3, -51 },
  { 2713, 26, 52, 24, -1, -51 },
  { 2882, 24, 52, 24, 0, -51 },
  { 3038, 10, 38, 11, 0, -38 },
  { 3086, 14, 47, 11, -3, -38 },
  { 3169, 24, 29, 28, 2, -40 },
  { 3256, 24, 18, 28, 2, -34 },
  { 3310, 24, 29, 28, 2, -40 },
  { 3397, 19, 51, 17, 1, -51 },
  { 3519, 33, 57, 36, 2, -51 },
  { 3755, 23, 51, 23, -5, -51 },
  { 3902, 27, 51, 27, 0, -51 },
  { 4075, 27, 52, 24, 3, -51 },
  { 4251, 28, 51, 29, 0, -51 },
  { 4430, 27, 51, 24, 0, -51 },
  { 4603, 27, 51, 22, 0, -51 },
  { 4776, 31, 52, 32, 3, -51 },
  { 4978, 32, 51, 31, 0, -51 },
  { 5182, 21, 51, 12, -4, -51 },
  { 5316, 23, 63, 11, -10, -51 },
  { 5498, 30, 51, 25, 0, -51 },
  { 5690, 16, 51, 21, 0, -51 },
  { 5792, 43, 51, 42, 0, -51 },
  { 6067, 34, 51, 33, 0, -51 },
  { 6284, 28, 52, 32, 2, -51 },
  { 6466, 26, 51, 25, 0, -51 },
  { 6632, 28, 63, 32, 2, -51 },
  { 6853, 26, 51, 25, 0, -51 },
  { 7019, 28, 52, 24, -2, -51 },
  { 7201, 21, 51, 21, 5, -51 },
  { 7335, 29, 52, 30, 2, -51 },
  { 7524, 24, 51, 24, 6, -51 },
  { 7677, 43, 51, 42, 5, -51 },
  { 7952, 31, 51, 22, -4, -51 },
  { 8150, 22, 51, 21, 4, -51 },
  { 8291, 29, 51, 22, -3, -51 },
  { 8476, 25, 62, 19, -1, -51 },
  { 8670, 10, 51, 23, 7, -51 },
  { 8734, 25, 62, 19, -4, -51 },
  { 8928, 25, 25, 28, 2, -51 },
  { 9007, 18, 2, 19, -5, 6 },
  { 9012, 7, 11, 15, 10, -54 },
  { 9022, 24, 39, 27, 2, -38 },
  { 9139, 25, 55, 26, 0, -54 },
  { 9311, 19, 39, 19, 2, -38 },
  { 9404, 28, 55, 27, 2, -54 },
  { 9597, 20, 39, 23, 2, -38 },
  { 9695, 30, 71, 13, -9, -54 },
  { 9962, 27, 55, 27, -1, -38 },
  { 10148, 23, 54, 25, 0, -54 },
  { 10304, 13, 51, 11, 0, -51 },
  { 10387, 23, 68, 11, -9, -51 },
  { 10583, 24, 54, 21, 0, -54 },
  { 10745, 14, 54, 11, 0, -54 },
  { 10840, 37, 38, 39, 0, -38 },
  { 11016, 23, 38, 25, 0, -38 },
  { 11126, 22, 39, 25, 2, -38 },
  { 11234, 28, 54, 26, -3, -38 },
  { 11423, 24, 55, 27, 2, -38 },
  { 11588, 20, 38, 17, 0, -38 },
  { 11683, 21, 39, 19, -1, -38 },
  { 11786, 13, 48, 13, 1, -47 },
  { 11864, 23, 38, 25, 2, -37 },
  { 11974, 19, 37, 19, 4, -37 },
  { 12062, 32, 37, 33, 4, -37 },
  { 12210, 26, 37, 20, -3, -37 },
  { 12331, 32, 54, 21, -8, -37 },
  { 12547, 21, 37, 16, -2, -37 },
  { 12645, 24, 62, 22, 2, -51 },
  { 12831, 2, 71, 24, 11, -54 },
  { 12849, 24, 62, 22, -5, -51 },
  { 13035, 24, 6, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC71PT7B_H_
