#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x00, 0x10, 0x4C, 0x13, 0x0C, 0x83, 0x20, 0x88, 0x26, 0x09, 0x86, 0x41,
  0x10, 0x44, 0x13, 0x04, 0x82, 0x20, 0x80, 0x00, 0x08, 0x10, 0x01, 0x83,
  0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20,
  0x40, 0x02, 0x04, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x08, 0x10, 0x01, 0x83, 0x00, 0x10, 0x20, 0x01,
  0x02, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x08, 0x10, 0x01, 0x83, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x30, 0x60,
  0x02, 0x04, 0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x08,
  0x00, 0x40, 0x80, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x07, 0xEF, 0x01, 0x84, 0x10,
  0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0xC0, 0x06, 0x08, 0x00, 0x60, 0x80,
  0x06, 0x08, 0x00, 0x60, 0x80, 0x02, 0x18, 0x00, 0x21, 0x00, 0x03, 0x10,
  0x00, 0x11, 0x00, 0x00, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x44, 0x00, 0x04, 0x60, 0x00,
  0x42, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00,
  0x08, 0x30, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x04, 0x08, 0x10, 0xC0,
  0xF9, 0x78, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x0C, 0x0C, 0x40, 0x10,
  0x30, 0xC0, 0x60, 0x41, 0x80, 0x81, 0x83, 0x03, 0x02, 0x06, 0x04, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x20, 0x20, 0x30, 0xC0, 0x40, 0x41, 0x01, 0x80,
  0x82, 0x03, 0x01, 0x08, 0x04, 0x06, 0x10, 0x08, 0x0C, 0x40, 0x10, 0x10,
  0x80, 0x20, 0x22, 0x1E, 0xC0, 0xC4, 0x67, 0x81, 0x11, 0x87, 0x06, 0x26,
  0x0A, 0x0C, 0xC8, 0x14, 0x31, 0x10, 0x2C, 0xC6, 0x60, 0x4F, 0x08, 0x80,
  0x80, 0x33, 0x01, 0x00, 0x46, 0x02, 0x01, 0x88, 0x0C, 0x02, 0x10, 0x18,
  0x0C, 0x20, 0x30, 0x10, 0xC0, 0x40, 0x61, 0x80, 0x80, 0x83, 0x03, 0x03,
  0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x30, 0x40, 0xC0,
  0x61, 0x81, 0x00, 0x46, 0x06, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x3E, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18, 0x20, 0x08, 0x10, 0x0C, 0x08,
  0x06, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x01, 0x60, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x68, 0x00, 0x64, 0x00, 0x63, 0x00, 0x20, 0x82,
  0x30, 0x43, 0x30, 0x21, 0x10, 0x18, 0x98, 0x04, 0xCC, 0x02, 0x44, 0x01,
  0x22, 0x00, 0xF3, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08, 0x60, 0x0E, 0x10,
  0x0D, 0x0C, 0x0C, 0x86, 0x0C, 0x41, 0xFC, 0x30, 0x10, 0x00, 0x13, 0x32,
  0x22, 0x66, 0x44, 0x4C, 0x88, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x82, 0x0E, 0x10, 0x09, 0x04, 0x3B, 0xC0, 0x60,
  0x05, 0x00, 0xC8, 0x0C, 0x20, 0xC1, 0x04, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x04, 0x30, 0xC2, 0x18, 0x43, 0x08, 0x21, 0x04,
  0x20, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x61,
  0x80, 0x60, 0x40, 0x20, 0x30, 0x30, 0x18, 0x10, 0x0C, 0x18, 0x02, 0x08,
  0x01, 0x0C, 0x00, 0x84, 0x00, 0x46, 0x00, 0x63, 0x00, 0x31, 0x00, 0x18,
  0x80, 0x0C, 0xC0, 0x06, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x98, 0x00,
  0xCC, 0x00, 0x64, 0x00, 0x32, 0x00, 0x11, 0x00, 0x09, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x02, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC2,
  0x00, 0x61, 0x00, 0x20, 0xC0, 0x30, 0x60, 0x10, 0x10, 0x18, 0x08, 0x18,
  0x06, 0x18, 0x01, 0xF8, 0x00, 0x20, 0x00, 0x01, 0x81, 0xC1, 0xC3, 0x23,
  0x13, 0x1B, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08,
  0x04, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x0C, 0x00, 0x80, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x38, 0x38, 0x0C, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x08, 0x06, 0x01, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x04,
  0x80, 0x01, 0x90, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03, 0x10, 0x00, 0x42,
  0x00, 0x18, 0x40, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0x40, 0x04, 0x08,
  0x01, 0x83, 0x00, 0x60, 0x60, 0x08, 0x08, 0x03, 0x01, 0x00, 0x40, 0x20,
  0x18, 0x0C, 0x06, 0x01, 0x80, 0x80, 0x20, 0x30, 0x04, 0x04, 0x00, 0x81,
  0x80, 0x30, 0x60, 0x06, 0x0F, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x40, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x80,
  0x60, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1C, 0x10,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC7, 0xC0, 0x27, 0x18, 0x0B, 0x03, 0x07,
  0x80, 0x61, 0xC0, 0x18, 0x60, 0x02, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00,
  0x08, 0xC0, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04,
  0x30, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x06, 0x04,
  0x03, 0x01, 0x80, 0x80, 0x30, 0xE0, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0E, 0x0C, 0x01, 0x80, 0x60, 0x10, 0x02, 0x03,
  0x00, 0x20, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x30,
  0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x06, 0x03, 0x00, 0x40, 0x10, 0x08,
  0x01, 0x81, 0x80, 0x08, 0x30, 0x00, 0xCC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x19, 0x80, 0x06, 0x08, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x03, 0x00,
  0x20, 0x20, 0x03, 0x06, 0x00, 0x30, 0x40, 0x01, 0x04, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x04,
  0x00, 0x20, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x30, 0xC0, 0x18, 0x18, 0x0C, 0x02,
  0x06, 0x00, 0x81, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC2,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x31, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x61, 0x80, 0x38, 0x60, 0x1E,
  0x0C, 0x0D, 0x01, 0x86, 0x40, 0x3F, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x83, 0x80, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x03, 0x07, 0x07, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xC0, 0xC0, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x30, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x02, 0x00, 0x01, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x21, 0x80,
  0xFC, 0x10, 0x80, 0xC6, 0x08, 0xC0, 0xC3, 0x04, 0x40, 0xC1, 0x06, 0x20,
  0x40, 0x83, 0x30, 0x60, 0xC1, 0x98, 0x20, 0x40, 0xC8, 0x30, 0x20, 0x44,
  0x18, 0x10, 0x26, 0x08, 0x18, 0x33, 0x04, 0x08, 0x19, 0x06, 0x04, 0x08,
  0x83, 0x06, 0x04, 0x41, 0x03, 0x06, 0x20, 0x81, 0x82, 0x10, 0x41, 0x81,
  0x18, 0x20, 0xC1, 0x8C, 0x10, 0xE0, 0x86, 0x0C, 0x58, 0x83, 0x06, 0x67,
  0xC1, 0x81, 0xC3, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C, 0xC0,
  0x02, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x02,
  0x0C, 0x00, 0x83, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x0C, 0x0C, 0x02, 0x03,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFC, 0x0C, 0x03, 0x02, 0x00, 0xC0,
  0x80, 0x30, 0x60, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0xF0, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x08, 0x7C, 0x00, 0x80,
  0x60, 0x18, 0x02, 0x01, 0x80, 0x30, 0x10, 0x03, 0x01, 0x00, 0x10, 0x10,
  0x01, 0x03, 0x00, 0x10, 0x30, 0x03, 0x02, 0x00, 0x30, 0x20, 0x02, 0x02,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x40, 0x18, 0x04, 0x03, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xC0, 0x60, 0x08, 0x03, 0x00, 0x80, 0x10,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x00,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00,
  0x30, 0x60, 0x02, 0x06, 0x00, 0x60, 0x40, 0x0C, 0x04, 0x01, 0x80, 0x41,
  0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0x83, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x10,
  0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x04, 0x7C, 0x00,
  0x20, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x80, 0x08, 0x04, 0x00,
  0x40, 0x20, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x04,
  0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03,
  0x04, 0x00, 0x10, 0x60, 0x00, 0x83, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80,
  0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x60,
  0x80, 0x02, 0x04, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0x80, 0x0C, 0x04, 0x00, 0x40, 0x60, 0x06, 0x02, 0x00, 0x60, 0x10,
  0x06, 0x00, 0x80, 0xE0, 0x0C, 0x3C, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x70, 0x1C, 0x01, 0x80, 0x08, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0x8C, 0x00, 0x7E, 0x18, 0x00, 0x04, 0x30,
  0x00, 0x18, 0x40, 0x00, 0x30, 0x80, 0x00, 0x61, 0x00, 0x00, 0x82, 0x00,
  0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x30, 0x00,
  0x20, 0x60, 0x00, 0x40, 0x40, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x80, 0x04,
  0x01, 0x80, 0x08, 0x01, 0xC0, 0x30, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80,
  0x02, 0x01, 0x80, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x06, 0x01, 0x00,
  0x06, 0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x02, 0x00,
  0x0C, 0x02, 0x00, 0x08, 0x06, 0x00, 0x08, 0x06, 0x00, 0x08, 0x04, 0x00,
  0x18, 0x04, 0x00, 0x18, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x08, 0x00,
  0x10, 0x08, 0x00, 0x30, 0x08, 0x00, 0x30, 0x18, 0x00, 0x20, 0x18, 0x00,
  0x20, 0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x40, 0x30, 0x00,
  0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x00,
  0x80, 0x60, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01,
  0x80, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x11, 0x80, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x0C,
  0x02, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x04,
  0x03, 0x00, 0x10, 0x08, 0x00, 0x40, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x08,
  0x00, 0x20, 0x60, 0x00, 0x83, 0x00, 0x02, 0x18, 0x00, 0x18, 0x40, 0x00,
  0x63, 0x00, 0x01, 0x18, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xD4,
  0x00, 0x02, 0xD0, 0x00, 0x0A, 0x60, 0x00, 0x30, 0x80, 0x01, 0x82, 0x00,
  0x06, 0x08, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x01, 0x00, 0x0C,
  0x04, 0x00, 0x30, 0x18, 0x00, 0x80, 0x60, 0x02, 0x00, 0x80, 0x18, 0x02,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x10, 0x01, 0x00,
  0xC0, 0x04, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0A, 0x01,
  0x40, 0x00, 0x1E, 0x01, 0x60, 0x00, 0x16, 0x01, 0x60, 0x00, 0x34, 0x03,
  0x60, 0x00, 0x24, 0x03, 0x60, 0x00, 0x6C, 0x02, 0x60, 0x00, 0x4C, 0x02,
  0x60, 0x00, 0xC8, 0x02, 0x20, 0x00, 0x88, 0x06, 0x20, 0x01, 0x88, 0x04,
  0x20, 0x01, 0x18, 0x04, 0x20, 0x03, 0x18, 0x04, 0x20, 0x02, 0x10, 0x0C,
  0x20, 0x06, 0x10, 0x0C, 0x20, 0x04, 0x10, 0x08, 0x20, 0x0C, 0x30, 0x08,
  0x20, 0x08, 0x30, 0x08, 0x20, 0x18, 0x20, 0x18, 0x20, 0x10, 0x20, 0x18,
  0x20, 0x30, 0x60, 0x10, 0x20, 0x20, 0x60, 0x10, 0x30, 0x60, 0x40, 0x10,
  0x30, 0x60, 0x40, 0x30, 0x30, 0xC0, 0x40, 0x30, 0x30, 0xC0, 0xC0, 0x20,
  0x30, 0x80, 0xC0, 0x20, 0x31, 0x80, 0x80, 0x60, 0x31, 0x00, 0x80, 0x60,
  0x13, 0x00, 0x80, 0x40, 0x12, 0x01, 0x80, 0x40, 0x16, 0x01, 0x80, 0x40,
  0x14, 0x01, 0x00, 0xC0, 0x1C, 0x01, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x3C, 0x00, 0x20,
  0x1E, 0x00, 0x10, 0x09, 0x00, 0x08, 0x04, 0x80, 0x0C, 0x02, 0x40, 0x06,
  0x03, 0x20, 0x02, 0x01, 0x98, 0x01, 0x00, 0x8C, 0x00, 0x80, 0x42, 0x00,
  0xC0, 0x21, 0x00, 0x60, 0x30, 0x80, 0x20, 0x18, 0x60, 0x10, 0x08, 0x30,
  0x18, 0x04, 0x08, 0x0C, 0x06, 0x04, 0x04, 0x03, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x00, 0x80, 0xC1, 0x80, 0x40, 0x60, 0xC0, 0x60, 0x10, 0x40, 0x30,
  0x08, 0x20, 0x10, 0x04, 0x10, 0x08, 0x03, 0x18, 0x04, 0x01, 0x8C, 0x06,
  0x00, 0x44, 0x03, 0x00, 0x22, 0x01, 0x00, 0x13, 0x00, 0x80, 0x0D, 0x80,
  0xC0, 0x06, 0xC0, 0x60, 0x03, 0x40, 0x20, 0x00, 0xA0, 0x10, 0x00, 0x70,
  0x08, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0x80, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x18, 0x03, 0x03, 0x00, 0x30, 0x60,
  0x01, 0x04, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01, 0x18,
  0x00, 0x11, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16,
  0x00, 0x01, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x02,
  0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x80, 0x00,
  0x48, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00,
  0x18, 0x80, 0x03, 0x08, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x40,
  0x0C, 0x06, 0x01, 0x80, 0x30, 0x70, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x13, 0xF0, 0x02, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x01, 0x03, 0x00, 0x20, 0x60, 0x04,
  0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x10,
  0x20, 0x06, 0x04, 0x00, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x04, 0x07, 0x00,
  0xFF, 0x80, 0x1F, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x0C,
  0x00, 0xC0, 0x60, 0x18, 0x03, 0x03, 0x00, 0x30, 0x60, 0x01, 0x04, 0x00,
  0x10, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00,
  0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x60,
  0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x0C,
  0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x03,
  0x08, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x40, 0x0C, 0x06, 0x01,
  0x80, 0x30, 0x70, 0x01, 0xFC, 0x00, 0x02, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x11, 0xF0, 0x02, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x01,
  0x03, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20, 0x06,
  0x0C, 0x00, 0x81, 0x80, 0x30, 0x20, 0x06, 0x04, 0x01, 0x81, 0x80, 0x20,
  0x30, 0x18, 0x06, 0x1E, 0x00, 0xFF, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00,
  0xC1, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0x40, 0x40, 0x18, 0x08, 0x03,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x08, 0x0C,
  0x01, 0x01, 0x00, 0x20, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x08, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0x80, 0xC0, 0x30, 0x02, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x01,
  0x80, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xA0, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x08, 0x10, 0x00, 0x41, 0x80, 0x02,
  0x0C, 0x00, 0x30, 0x40, 0x01, 0x82, 0x00, 0x08, 0x10, 0x00, 0x41, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x41,
  0x80, 0x06, 0x08, 0x00, 0x30, 0x40, 0x01, 0x02, 0x00, 0x08, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08,
  0x30, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00,
  0x18, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x60, 0x30, 0x06, 0x00,
  0x80, 0x20, 0x06, 0x06, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x4C, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x0C, 0x00, 0x43,
  0x00, 0x30, 0xC0, 0x08, 0x30, 0x06, 0x0C, 0x01, 0x03, 0x00, 0xC0, 0xC0,
  0x20, 0x30, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x20,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x03,
  0x18, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0xD8,
  0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x06, 0xC0, 0x03, 0x80,
  0x06, 0xC0, 0x03, 0x80, 0x04, 0xC0, 0x03, 0x80, 0x0C, 0xC0, 0x07, 0x80,
  0x08, 0xC0, 0x05, 0x80, 0x18, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x09, 0x80,
  0x10, 0xC0, 0x09, 0x00, 0x30, 0xC0, 0x19, 0x00, 0x20, 0xC0, 0x11, 0x00,
  0x60, 0xC0, 0x31, 0x00, 0x60, 0xC0, 0x31, 0x00, 0x40, 0xC0, 0x21, 0x00,
  0xC0, 0xC0, 0x61, 0x00, 0x80, 0xC0, 0x41, 0x01, 0x80, 0xC0, 0x41, 0x01,
  0x80, 0xC0, 0xC1, 0x01, 0x00, 0xC0, 0x81, 0x03, 0x00, 0xC1, 0x81, 0x02,
  0x00, 0xC1, 0x01, 0x06, 0x00, 0xC1, 0x01, 0x06, 0x00, 0x83, 0x01, 0x04,
  0x00, 0x82, 0x01, 0x0C, 0x00, 0x86, 0x01, 0x08, 0x00, 0x84, 0x01, 0x18,
  0x00, 0x84, 0x01, 0x10, 0x00, 0x8C, 0x01, 0x10, 0x00, 0x88, 0x01, 0x30,
  0x00, 0x98, 0x03, 0x20, 0x00, 0x90, 0x03, 0x60, 0x00, 0x90, 0x03, 0x40,
  0x00, 0xB0, 0x03, 0x40, 0x00, 0xA0, 0x03, 0xC0, 0x00, 0xA0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x30, 0x01, 0x00, 0x40, 0x02, 0x01, 0x00,
  0x04, 0x06, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30, 0x00, 0x30, 0x40, 0x00,
  0x61, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x60, 0x00, 0x04, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x0D, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x64, 0x00, 0x00, 0x88, 0x00, 0x02, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x10, 0x60, 0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x03,
  0x01, 0x00, 0x04, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60, 0x08, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x00, 0x60,
  0x01, 0xB0, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61, 0x00, 0x60,
  0x80, 0x30, 0x40, 0x30, 0x20, 0x10, 0x18, 0x18, 0x0C, 0x08, 0x06, 0x0C,
  0x03, 0x04, 0x00, 0x86, 0x00, 0x42, 0x00, 0x23, 0x00, 0x11, 0x00, 0x09,
  0x80, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xC0, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x06, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x02, 0x04, 0x08,
  0x18, 0x30, 0x60, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x40,
  0x00, 0x3F, 0xC0, 0x10, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0xC3,
  0x00, 0x10, 0x20, 0x06, 0x06, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x04, 0x00,
  0x81, 0x80, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00,
  0x78, 0x00, 0x0C, 0xFF, 0xFC, 0x86, 0x10, 0xC2, 0x18, 0x41, 0x01, 0xF8,
  0xC0, 0xC3, 0x20, 0x60, 0x68, 0x30, 0x0A, 0x08, 0x03, 0x86, 0x00, 0xC1,
  0x00, 0x30, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x03, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06, 0x08,
  0x01, 0x82, 0x00, 0xE0, 0x80, 0x70, 0x30, 0x14, 0x06, 0x19, 0x00, 0xFC,
  0x40, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x3F, 0x00, 0x98, 0x60,
  0x2C, 0x0C, 0x1E, 0x03, 0x07, 0x00, 0x41, 0x80, 0x10, 0x60, 0x04, 0x18,
  0x01, 0x0C, 0x00, 0x43, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00,
  0xC6, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x63,
  0x00, 0x10, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x00, 0x87, 0x00, 0x61, 0x40,
  0x10, 0x50, 0x0C, 0x14, 0x06, 0x05, 0x83, 0x03, 0x3F, 0x80, 0x01, 0x00,
  0x00, 0x01, 0xFC, 0x0C, 0x10, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x08,
  0x0F, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xF8,
  0x80, 0x30, 0xC8, 0x06, 0x06, 0x80, 0xC0, 0x38, 0x08, 0x03, 0x81, 0x80,
  0x30, 0x10, 0x03, 0x03, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08,
  0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0x80,
  0x80, 0x18, 0x08, 0x01, 0x80, 0x80, 0x38, 0x08, 0x03, 0x80, 0x80, 0x70,
  0x0C, 0x0D, 0x00, 0x61, 0x90, 0x03, 0xF1, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0x0C, 0x0C, 0x08, 0x30, 0x10, 0xC0, 0x21, 0x00, 0x46, 0x00,
  0x88, 0x03, 0x30, 0x04, 0x60, 0x18, 0x80, 0x61, 0x01, 0x86, 0x0E, 0x0F,
  0xF0, 0x1E, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x80, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x18, 0x03, 0x0C, 0x80,
  0x30, 0x34, 0x03, 0x00, 0xA0, 0x10, 0x07, 0x01, 0x80, 0x30, 0x08, 0x01,
  0x80, 0xC0, 0x0C, 0x04, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x10,
  0x00, 0x80, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x10,
  0x10, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20, 0x02, 0x01, 0x00,
  0x30, 0x08, 0x01, 0x80, 0x40, 0x1C, 0x02, 0x00, 0xE0, 0x10, 0x0E, 0x00,
  0xC0, 0xD0, 0x03, 0x0C, 0x80, 0x0F, 0xCC, 0x00, 0x10, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x02, 0x01, 0x80,
  0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x33, 0xF0, 0x13, 0x0C,
  0x0A, 0x02, 0x06, 0x01, 0x07, 0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0x80,
  0x10, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x04, 0x10, 0x02, 0x08, 0x01, 0x0C,
  0x01, 0x86, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x08, 0x20, 0x04, 0x10, 0x02, 0x08, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x21, 0x80, 0x30, 0x00, 0x80, 0x30, 0x1C, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x80, 0x60, 0x20, 0x30, 0x18, 0x18, 0x06, 0x04, 0x01, 0x03,
  0x00, 0x41, 0x80, 0x10, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0x8C, 0x00,
  0x27, 0x00, 0x09, 0xC0, 0x06, 0x90, 0x01, 0xE4, 0x00, 0x71, 0x00, 0x18,
  0x40, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x81, 0x80, 0x20, 0x20, 0x08, 0x08,
  0x06, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x10, 0x0C, 0x04, 0x01, 0x03,
  0x00, 0x40, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x02, 0x3F, 0x1F, 0xC0, 0x58, 0x66, 0x0C, 0x0A,
  0x07, 0x80, 0x83, 0x80, 0x60, 0x10, 0x60, 0x0C, 0x02, 0x0C, 0x01, 0x00,
  0x41, 0x80, 0x60, 0x08, 0x20, 0x0C, 0x03, 0x0C, 0x01, 0x00, 0x61, 0x80,
  0x20, 0x08, 0x20, 0x0C, 0x01, 0x04, 0x01, 0x80, 0x20, 0x80, 0x20, 0x0C,
  0x30, 0x04, 0x01, 0x86, 0x00, 0x80, 0x20, 0x80, 0x30, 0x04, 0x10, 0x06,
  0x00, 0x82, 0x00, 0x80, 0x30, 0xC0, 0x10, 0x06, 0x18, 0x02, 0x00, 0x82,
  0x00, 0xC0, 0x10, 0x40, 0x18, 0x06, 0x18, 0x02, 0x00, 0xC3, 0x00, 0x40,
  0x10, 0x40, 0x18, 0x02, 0x08, 0x03, 0x00, 0x41, 0x00, 0x40, 0x18, 0x60,
  0x08, 0x03, 0x00, 0x02, 0x3F, 0x01, 0x70, 0xC0, 0xA0, 0x20, 0xE0, 0x10,
  0x70, 0x08, 0x30, 0x04, 0x18, 0x02, 0x08, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x20,
  0x04, 0x10, 0x02, 0x08, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04, 0x10, 0x06,
  0x18, 0x03, 0x00, 0x00, 0xFC, 0x00, 0xC3, 0x00, 0xC0, 0xC0, 0xC0, 0x20,
  0xC0, 0x10, 0x40, 0x08, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00,
  0x8C, 0x00, 0x44, 0x00, 0x26, 0x00, 0x13, 0x00, 0x09, 0x80, 0x0C, 0x80,
  0x06, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x46,
  0x00, 0x61, 0x00, 0x20, 0x80, 0x30, 0x40, 0x10, 0x30, 0x10, 0x0C, 0x38,
  0x03, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x8F, 0xC0, 0x09, 0x86, 0x00, 0xB0,
  0x30, 0x0E, 0x03, 0x01, 0xC0, 0x10, 0x1C, 0x01, 0x01, 0x80, 0x10, 0x18,
  0x01, 0x03, 0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01, 0x02,
  0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20,
  0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x08,
  0x0C, 0x01, 0x81, 0xC0, 0x10, 0x14, 0x03, 0x01, 0x40, 0x60, 0x12, 0x0C,
  0x03, 0x3F, 0x80, 0x30, 0xC0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0xC0,
  0xC3, 0x20, 0x60, 0x68, 0x30, 0x0A, 0x08, 0x03, 0x86, 0x00, 0xC1, 0x00,
  0x30, 0xC0, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x00, 0x08,
  0x40, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x03, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06, 0x08, 0x03,
  0x82, 0x00, 0xE0, 0x80, 0x70, 0x30, 0x34, 0x06, 0x19, 0x00, 0xFC, 0xC0,
  0x08, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x02, 0x3E, 0x04, 0xC0, 0x0A, 0x00, 0x38, 0x00, 0x50,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x03,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0xC0, 0xC0, 0xFF, 0x80, 0x04, 0x00, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0xFF, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30,
  0x0F, 0x80, 0x80, 0x06, 0x00, 0x82, 0x00, 0x41, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0x40, 0x08, 0x20, 0x04, 0x10, 0x06, 0x18, 0x03, 0x0C, 0x01,
  0x04, 0x00, 0x82, 0x00, 0x43, 0x00, 0x61, 0x80, 0x30, 0x80, 0x10, 0x40,
  0x08, 0x20, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x04, 0x01, 0x82,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x28, 0x18, 0x64,
  0x07, 0xE6, 0x00, 0x80, 0x00, 0x80, 0x0E, 0x00, 0x28, 0x01, 0xA0, 0x04,
  0x80, 0x12, 0x00, 0xC8, 0x02, 0x20, 0x18, 0x80, 0x42, 0x03, 0x08, 0x08,
  0x20, 0x60, 0x81, 0x82, 0x04, 0x08, 0x30, 0x20, 0x80, 0x86, 0x02, 0x10,
  0x08, 0xC0, 0x22, 0x00, 0x88, 0x02, 0x60, 0x09, 0x00, 0x2C, 0x00, 0xA0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x03, 0xC0, 0x18, 0x02,
  0xC0, 0x18, 0x06, 0xC0, 0x38, 0x04, 0xC0, 0x28, 0x04, 0xC0, 0x28, 0x0C,
  0xC0, 0x48, 0x08, 0xC0, 0x48, 0x08, 0xC0, 0xC8, 0x10, 0xC0, 0x88, 0x10,
  0xC1, 0x88, 0x30, 0xC1, 0x08, 0x20, 0xC1, 0x08, 0x20, 0xC3, 0x08, 0x60,
  0xC2, 0x08, 0x40, 0xC6, 0x08, 0xC0, 0x84, 0x08, 0x80, 0x84, 0x08, 0x80,
  0x8C, 0x09, 0x80, 0x88, 0x09, 0x00, 0x98, 0x09, 0x00, 0x90, 0x0A, 0x00,
  0x90, 0x0A, 0x00, 0xA0, 0x1E, 0x00, 0xA0, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x20, 0x18, 0x04,
  0x02, 0x00, 0x80, 0xC0, 0x10, 0x10, 0x03, 0x04, 0x00, 0x61, 0x80, 0x04,
  0x20, 0x00, 0x8C, 0x00, 0x11, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0x20, 0x00, 0x64,
  0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0xC3, 0x00, 0x10, 0x20, 0x06, 0x04,
  0x00, 0x80, 0x80, 0x20, 0x10, 0x0C, 0x03, 0x01, 0x00, 0x60, 0x60, 0x04,
  0x00, 0x00, 0x30, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x30,
  0x08, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30,
  0x20, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x31, 0x80, 0x00, 0x11, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x16, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x5D, 0xE0, 0x18, 0x0E,
  0x1A, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 38, 11, 1, -38 },
  { 49, 10, 14, 14, 5, -38 },
  { 67, 20, 38, 19, 0, -38 },
  { 162, 20, 43, 18, -1, -40 },
  { 270, 23, 39, 28, 2, -38 },
  { 383, 17, 39, 17, -1, -38 },
  { 466, 4, 14, 8, 5, -38 },
  { 473, 15, 46, 13, 1, -38 },
  { 560, 15, 46, 13, -4, -38 },
  { 647, 13, 14, 17, 6, -40 },
  { 670, 18, 24, 21, 2, -31 },
  { 724, 6, 12, 8, -2, -5 },
  { 733, 11, 1, 14, 1, -15 },
  { 735, 2, 4, 8, 1, -4 },
  { 736, 21, 38, 15, -2, -38 },
  { 836, 17, 39, 18, 1, -38 },
  { 919, 9, 38, 18, 6, -38 },
  { 962, 20, 38, 18, -2, -38 },
  { 1057, 19, 39, 18, -1, -38 },
  { 1150, 19, 38, 18, -1, -38 },
  { 1241, 20, 39, 18, -1, -38 },
  { 1339, 18, 39, 18, 1, -38 },
  { 1427, 18, 38, 18, 2, -38 },
  { 1513, 20, 39, 18, -1, -38 },
  { 1611, 18, 39, 18, 0, -38 },
  { 1699, 8, 28, 8, 0, -28 },
  { 1727, 10, 35, 8, -2, -28 },
  { 1771, 18, 22, 21, 2, -30 },
  { 1821, 18, 13, 21, 2, -25 },
  { 1851, 18, 22, 21, 2, -30 },
  { 1901, 14, 38, 13, 1, -38 },
  { 1968, 25, 43, 27, 1, -38 },
  { 2103, 18, 38, 17, -4, -38 },
  { 2189, 20, 38, 20, 0, -38 },
  { 2284, 20, 39, 18, 2, -38 },
  { 2382, 21, 38, 22, 0, -38 },
  { 2482, 20, 38, 18, 0, -38 },
  { 2577, 20, 38, 17, 0, -38 },
  { 2672, 23, 39, 24, 2, -38 },
  { 2785, 24, 38, 23, 0, -38 },
  { 2899, 16, 38, 9, -3, -38 },
  { 2975, 18, 47, 8, -8, -38 },
  { 3081, 22, 38, 18, 0, -38 },
  { 3186, 12, 38, 16, 0, -38 },
  { 3243, 32, 38, 31, 0, -38 },
  { 3395, 25, 38, 24, 0, -38 },
  { 3514, 20, 39, 24, 2, -38 },
  { 3612, 19, 38, 19, 0, -38 },
  { 3703, 20, 47, 24, 2, -38 },
  { 3821, 19, 38, 19, 0, -38 },
  { 3912, 21, 39, 18, -2, -38 },
  { 4015, 17, 38, 16, 3, -38 },
  { 4096, 21, 39, 22, 2, -38 },
  { 4199, 18, 38, 18, 4, -38 },
  { 4285, 32, 38, 32, 4, -38 },
  { 4437, 23, 38, 16, -3, -38 },
  { 4547, 17, 38, 15, 3, -38 },
  { 4628, 21, 38, 16, -2, -38 },
  { 4728, 19, 46, 15, -1, -38 },
  { 4838, 7, 38, 17, 5, -38 },
  { 4872, 18, 46, 15, -3, -38 },
  { 4976, 19, 18, 21, 1, -38 },
  { 5019, 14, 1, 14, -4, 5 },
  { 5021, 5, 8, 11, 8, -40 },
  { 5026, 18, 29, 20, 2, -28 },
  { 5092, 18, 41, 20, 0, -40 },
  { 5185, 14, 29, 14, 2, -28 },
  { 5236, 20, 41, 20, 2, -40 },
  { 5339, 15, 29, 17, 1, -28 },
  { 5394, 23, 54, 10, -7, -41 },
  { 5550, 21, 41, 20, -1, -28 },
  { 5658, 17, 40, 19, 0, -40 },
  { 5743, 10, 38, 8, 0, -38 },
  { 5791, 17, 51, 9, -7, -38 },
  { 5900, 18, 40, 16, 0, -40 },
  { 5990, 10, 40, 8, 0, -40 },
  { 6040, 27, 28, 29, 0, -28 },
  { 6135, 17, 28, 19, 0, -28 },
  { 6195, 17, 29, 19, 1, -28 },
  { 6257, 20, 40, 20, -2, -28 },
  { 6357, 18, 40, 20, 2, -28 },
  { 6447, 15, 28, 12, 0, -28 },
  { 6500, 16, 29, 15, -1, -28 },
  { 6558, 10, 36, 10, 1, -35 },
  { 6603, 17, 29, 19, 1, -28 },
  { 6665, 14, 28, 14, 3, -28 },
  { 6714, 24, 28, 24, 3, -28 },
  { 6798, 19, 28, 15, -2, -28 },
  { 6865, 24, 41, 16, -6, -28 },
  { 6988, 16, 28, 12, -2, -28 },
  { 7044, 18, 46, 16, 2, -38 },
  { 7148, 2, 53, 18, 8, -40 },
  { 7162, 18, 46, 16, -4, -38 },
  { 7266, 18, 4, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC53PT7B_H_
