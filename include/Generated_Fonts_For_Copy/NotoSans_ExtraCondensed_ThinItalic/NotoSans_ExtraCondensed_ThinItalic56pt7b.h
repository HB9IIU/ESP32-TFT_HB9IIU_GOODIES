#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x18, 0x62, 0x0C, 0x41,
  0x98, 0x23, 0x04, 0x41, 0x88, 0x31, 0x04, 0x60, 0x8C, 0x11, 0x02, 0x20,
  0x84, 0x11, 0x82, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x40, 0xC0, 0x02, 0x06,
  0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x80, 0x06,
  0x04, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0x81, 0x80,
  0xFF, 0xFF, 0x80, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81,
  0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x04, 0x00, 0x30, 0x60, 0x01,
  0x03, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x0C, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x10, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x40,
  0xC0, 0x02, 0x06, 0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x08, 0x18, 0x00,
  0xC0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xE0, 0x01, 0xFB, 0xE0, 0x18, 0x41, 0x01, 0x86,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01,
  0x06, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x18, 0x40,
  0x00, 0x46, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x01, 0x60, 0x00, 0x09, 0x80,
  0x00, 0xC6, 0x00, 0x06, 0x10, 0x00, 0x20, 0x80, 0x01, 0x06, 0x00, 0x08,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00,
  0x08, 0x30, 0x00, 0xC3, 0x02, 0x06, 0x30, 0x1F, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x04, 0x0C, 0x60, 0x0C, 0x08,
  0x20, 0x08, 0x18, 0x30, 0x18, 0x10, 0x30, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x30, 0x20, 0x60, 0x20, 0x60, 0x60, 0x20, 0x40, 0x40, 0x20, 0xC0, 0x40,
  0x20, 0x80, 0xC0, 0x61, 0x80, 0xC0, 0x61, 0x00, 0xC0, 0x63, 0x00, 0x80,
  0x42, 0x00, 0x80, 0xC6, 0x00, 0x80, 0xC4, 0x3E, 0x80, 0x8C, 0x62, 0x81,
  0x88, 0xC3, 0x81, 0x99, 0x83, 0x83, 0x11, 0x03, 0x82, 0x33, 0x03, 0xC6,
  0x23, 0x03, 0x7C, 0x62, 0x03, 0x30, 0x46, 0x03, 0x00, 0xC6, 0x03, 0x00,
  0x84, 0x02, 0x01, 0x84, 0x02, 0x01, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x02,
  0x0C, 0x06, 0x06, 0x0C, 0x04, 0x04, 0x08, 0x0C, 0x0C, 0x08, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x08, 0x18, 0x10, 0x08, 0x10, 0x30, 0x0C, 0x30, 0x20,
  0x0C, 0x60, 0x60, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xC0, 0x03, 0x18, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08, 0x18,
  0x02, 0x06, 0x00, 0x81, 0x80, 0x60, 0x60, 0x18, 0x10, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x21, 0x80, 0x08, 0x60, 0x02, 0x30, 0x00, 0x98, 0x00, 0x34,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00,
  0x10, 0x80, 0x0C, 0x20, 0xC6, 0x0C, 0x33, 0x03, 0x08, 0xC0, 0x42, 0x20,
  0x11, 0x98, 0x06, 0x44, 0x01, 0x91, 0x00, 0x2C, 0xC0, 0x0A, 0x30, 0x03,
  0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x1C, 0x10, 0x05, 0x86, 0x02, 0x21,
  0xC3, 0x88, 0x3F, 0xC2, 0x01, 0x00, 0x00, 0x18, 0x84, 0x63, 0x10, 0x84,
  0x63, 0x10, 0x84, 0x60, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x08, 0x00, 0x41, 0x06, 0x0C, 0x20, 0x19, 0x04,
  0x3B, 0xE0, 0x60, 0x0E, 0x00, 0xC8, 0x0C, 0x60, 0x81, 0x08, 0x04, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x01, 0xFF, 0xFF,
  0xC0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x04, 0x30, 0xC2, 0x18, 0x41, 0x0C, 0x21,
  0x04, 0x20, 0xFF, 0xFF, 0xFF, 0x5F, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x06, 0x18, 0x03, 0x02, 0x01,
  0x80, 0xC0, 0x40, 0x30, 0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0x41, 0x00,
  0x30, 0xC0, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C,
  0x40, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x60,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x11, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00,
  0xCC, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x43,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0,
  0x30, 0x10, 0x18, 0x06, 0x04, 0x00, 0x86, 0x00, 0x3F, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0xE0, 0x68, 0x32, 0x19, 0x9C, 0x6C, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x18, 0x00,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x00, 0xC0, 0xE0, 0x18,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x0C, 0x07, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x05, 0x00, 0x00, 0xF0, 0x00, 0x0B, 0x00, 0x01,
  0xA0, 0x00, 0x12, 0x00, 0x03, 0x20, 0x00, 0x66, 0x00, 0x04, 0x60, 0x00,
  0xC4, 0x00, 0x08, 0x40, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00,
  0x60, 0x80, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x01, 0x00,
  0x30, 0x10, 0x06, 0x01, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x02, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0x40, 0x04,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x1F, 0xF8, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x0C, 0x03, 0x80, 0x1F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x01, 0xFC, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x3F, 0x00, 0x9C, 0x30, 0x16, 0x03, 0x06, 0x80, 0x30, 0xE0,
  0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00,
  0x04, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00,
  0x10, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x04, 0x00,
  0x80, 0xC0, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x1F, 0xC0, 0x00, 0x40,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x18,
  0x01, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x18,
  0x10, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x30, 0x03, 0x01, 0x80,
  0x10, 0x04, 0x01, 0x80, 0x30, 0x18, 0x00, 0x81, 0x80, 0x06, 0x18, 0x00,
  0x19, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xEC, 0x00, 0x0C, 0x30,
  0x01, 0x80, 0xC0, 0x18, 0x02, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x40, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0xC3, 0x00, 0x02, 0x18, 0x00, 0x10,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x02, 0x04, 0x00,
  0x30, 0x30, 0x01, 0x00, 0xC0, 0x18, 0x03, 0x03, 0x80, 0x0F, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xE0, 0x03, 0x06, 0x00, 0xC0,
  0x60, 0x30, 0x04, 0x04, 0x00, 0x81, 0x80, 0x18, 0x20, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x42, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x1C, 0x10, 0x07, 0x83, 0x01, 0xA0, 0x30, 0x64,
  0x03, 0xF9, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x04,
  0x1C, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01, 0x03, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0,
  0xC0, 0x00, 0x20, 0x07, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0x30, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x18, 0x00, 0x01,
  0x82, 0x00, 0xF0, 0x30, 0xC0, 0x7F, 0x06, 0x10, 0x18, 0x60, 0x86, 0x02,
  0x0C, 0x10, 0xC0, 0x81, 0x02, 0x10, 0x30, 0x60, 0x46, 0x04, 0x0C, 0x08,
  0xC1, 0x81, 0x83, 0x10, 0x20, 0x20, 0x62, 0x04, 0x0C, 0x0C, 0x41, 0x81,
  0x81, 0x18, 0x30, 0x20, 0x23, 0x04, 0x04, 0x0C, 0x60, 0x81, 0x81, 0x88,
  0x30, 0x30, 0x21, 0x06, 0x06, 0x0C, 0x20, 0xC1, 0x81, 0x04, 0x18, 0x30,
  0x21, 0x83, 0x0E, 0x0C, 0x30, 0x61, 0x43, 0x06, 0x04, 0x6C, 0xC0, 0xC0,
  0xF8, 0xF0, 0x18, 0x06, 0x08, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x06, 0xC0, 0x00, 0x90,
  0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x31, 0x00, 0x04, 0x20,
  0x01, 0x84, 0x00, 0x30, 0x80, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0x40,
  0x0C, 0x08, 0x01, 0x81, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x01, 0x00, 0x80,
  0x60, 0x10, 0x0F, 0xFE, 0x01, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x03,
  0x00, 0x20, 0x60, 0x04, 0x18, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x18,
  0x00, 0x42, 0x00, 0x08, 0xC0, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0xC0,
  0x00, 0x90, 0x00, 0x16, 0x00, 0x02, 0x00, 0x7F, 0x80, 0x06, 0x1F, 0x00,
  0x30, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x20, 0x30, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0xC0, 0x20, 0x1C, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xC0,
  0x70, 0x06, 0x00, 0xC0, 0x20, 0x02, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x04, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x60, 0x20, 0x0E, 0x01, 0x07, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x0E, 0x02, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x00,
  0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x0F, 0x00,
  0x0C, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x80, 0x60, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x40, 0x00, 0x83, 0x00,
  0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x04,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x18, 0x10,
  0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x01,
  0x80, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x80, 0x40, 0x1C, 0x01,
  0x00, 0xC0, 0x0C, 0x7E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x00, 0x07, 0x01, 0xE0,
  0x0E, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC3, 0x00,
  0x1F, 0xE1, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x20,
  0x10, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x18, 0x03, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x80, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60,
  0x10, 0x00, 0x30, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x04,
  0x03, 0x00, 0x06, 0x01, 0x00, 0x03, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x00,
  0x80, 0x60, 0x00, 0x40, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08, 0x00,
  0x10, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x20,
  0x00, 0x60, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x04,
  0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00,
  0xC0, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x30, 0x00, 0x20,
  0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x04,
  0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x06, 0x01,
  0x80, 0x08, 0x03, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x30,
  0x04, 0x00, 0x60, 0x18, 0x00, 0x80, 0x60, 0x01, 0x01, 0x80, 0x02, 0x02,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x00,
  0x00, 0x86, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0, 0x00,
  0x13, 0x80, 0x00, 0x6F, 0x00, 0x00, 0xD2, 0x00, 0x01, 0xC4, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x20, 0x00, 0x40,
  0x40, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x02,
  0x00, 0x10, 0x06, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x04, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30, 0x00, 0x80,
  0x60, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0F, 0xFF, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x38, 0x02, 0x80, 0x00, 0x0E, 0x00, 0xA0, 0x00, 0x07,
  0x80, 0x68, 0x00, 0x01, 0x40, 0x1A, 0x00, 0x00, 0xD0, 0x04, 0x80, 0x00,
  0x24, 0x01, 0x20, 0x00, 0x1B, 0x00, 0x48, 0x00, 0x04, 0xC0, 0x32, 0x00,
  0x03, 0x20, 0x0C, 0x80, 0x00, 0x88, 0x02, 0x20, 0x00, 0x62, 0x00, 0x88,
  0x00, 0x11, 0x80, 0x23, 0x00, 0x0C, 0x60, 0x18, 0xC0, 0x02, 0x10, 0x06,
  0x30, 0x01, 0x84, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x43, 0x00, 0x30, 0xC0,
  0x30, 0xC0, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x82,
  0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0x40, 0x30, 0x60, 0x18, 0x10, 0x08,
  0x10, 0x06, 0x04, 0x06, 0x04, 0x01, 0x01, 0x01, 0x01, 0x00, 0x40, 0x40,
  0xC0, 0xC0, 0x10, 0x10, 0x20, 0x30, 0x0C, 0x04, 0x18, 0x08, 0x03, 0x01,
  0x04, 0x02, 0x00, 0x80, 0x43, 0x01, 0x80, 0x20, 0x18, 0x80, 0x60, 0x18,
  0x06, 0x60, 0x18, 0x06, 0x01, 0x90, 0x04, 0x01, 0x80, 0x6C, 0x01, 0x00,
  0x40, 0x1A, 0x00, 0xC0, 0x10, 0x07, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x08,
  0x03, 0x00, 0x70, 0x02, 0x00, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x08,
  0x03, 0x80, 0x01, 0x00, 0x50, 0x00, 0x60, 0x0A, 0x00, 0x0C, 0x03, 0x40,
  0x01, 0x00, 0x6C, 0x00, 0x20, 0x0D, 0x80, 0x0C, 0x01, 0x10, 0x01, 0x80,
  0x22, 0x00, 0x30, 0x0C, 0x40, 0x04, 0x01, 0x8C, 0x00, 0x80, 0x21, 0x80,
  0x30, 0x04, 0x30, 0x06, 0x00, 0x82, 0x00, 0xC0, 0x30, 0x40, 0x10, 0x06,
  0x0C, 0x02, 0x00, 0x81, 0x80, 0xC0, 0x10, 0x30, 0x18, 0x06, 0x02, 0x02,
  0x00, 0xC0, 0x40, 0x40, 0x18, 0x08, 0x08, 0x02, 0x01, 0x83, 0x00, 0x40,
  0x30, 0x60, 0x18, 0x06, 0x08, 0x03, 0x00, 0x41, 0x00, 0x60, 0x08, 0x60,
  0x08, 0x01, 0x8C, 0x01, 0x00, 0x31, 0x80, 0x60, 0x06, 0x20, 0x0C, 0x00,
  0x44, 0x01, 0x00, 0x09, 0x80, 0x20, 0x01, 0x30, 0x0C, 0x00, 0x34, 0x01,
  0x80, 0x06, 0x80, 0x30, 0x00, 0xD0, 0x04, 0x00, 0x0E, 0x00, 0x80, 0x01,
  0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0x07, 0x00, 0x30, 0x04, 0x01, 0x80, 0x18, 0x04, 0x00,
  0x20, 0x30, 0x00, 0x81, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x26, 0x00, 0x00,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x00, 0x00, 0x64, 0x00, 0x01, 0x30,
  0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00,
  0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x30,
  0x80, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x40,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x0E, 0x0C, 0x00, 0x1F, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x3E, 0x00, 0x30, 0x18,
  0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x30,
  0x02, 0x01, 0x00, 0x18, 0x08, 0x00, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x20,
  0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x20, 0x06, 0x01, 0x00, 0x20, 0x18, 0x07, 0x00, 0xC0, 0x60, 0x07,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x07, 0x00, 0x30, 0x04,
  0x01, 0x80, 0x18, 0x04, 0x00, 0x20, 0x30, 0x00, 0x81, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x40, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x26, 0x00, 0x00, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x00,
  0x00, 0x64, 0x00, 0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xCC, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x30, 0x80, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x10, 0x30, 0x00, 0xC0, 0x40, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x0E, 0x0C, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0C, 0x7C, 0x00, 0xC0, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x18,
  0x01, 0x01, 0x80, 0x10, 0x18, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x03,
  0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x20,
  0x60, 0x06, 0x06, 0x00, 0x40, 0x40, 0x0C, 0x04, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x1E, 0x00, 0xFF, 0x80, 0x08, 0x30, 0x00, 0x83, 0x00, 0x18, 0x10,
  0x01, 0x81, 0x00, 0x18, 0x10, 0x01, 0x01, 0x80, 0x10, 0x18, 0x03, 0x01,
  0x80, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x02, 0x00, 0xC0, 0x60,
  0x0C, 0x06, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x38, 0x03,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x20, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x06, 0x06, 0x00, 0x08, 0x08, 0x00,
  0x10, 0x10, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x02,
  0x02, 0x00, 0x04, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x40, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x10, 0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80,
  0x03, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x01, 0x80,
  0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x18, 0x06, 0x00, 0x20, 0x0C,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x48,
  0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x02, 0x10,
  0x00, 0xC2, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20,
  0x06, 0x04, 0x00, 0x80, 0x80, 0x30, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x08, 0x0C, 0x01, 0x01, 0x80, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x81,
  0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x43, 0x00, 0x08, 0x60, 0x01, 0x08,
  0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x12, 0x00, 0x02, 0xC0,
  0x00, 0x58, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0x30, 0x00, 0x64, 0x00, 0x0C,
  0x00, 0x19, 0x00, 0x05, 0x00, 0x0C, 0x40, 0x01, 0xC0, 0x03, 0x10, 0x00,
  0xF0, 0x00, 0x84, 0x00, 0x2C, 0x00, 0x61, 0x00, 0x0B, 0x00, 0x18, 0x40,
  0x06, 0xC0, 0x0C, 0x10, 0x01, 0x30, 0x03, 0x04, 0x00, 0xCC, 0x00, 0x81,
  0x00, 0x23, 0x00, 0x60, 0x40, 0x08, 0xC0, 0x10, 0x30, 0x06, 0x30, 0x04,
  0x0C, 0x01, 0x08, 0x03, 0x03, 0x00, 0xC2, 0x00, 0x80, 0xC0, 0x20, 0x80,
  0x60, 0x30, 0x08, 0x20, 0x10, 0x0C, 0x06, 0x08, 0x04, 0x03, 0x01, 0x02,
  0x03, 0x00, 0xC0, 0xC0, 0x80, 0x80, 0x30, 0x30, 0x20, 0x60, 0x0C, 0x08,
  0x08, 0x10, 0x03, 0x06, 0x02, 0x04, 0x00, 0xC1, 0x00, 0x83, 0x00, 0x30,
  0xC0, 0x20, 0x80, 0x0C, 0x30, 0x08, 0x60, 0x03, 0x08, 0x02, 0x10, 0x00,
  0xC6, 0x00, 0x84, 0x00, 0x31, 0x00, 0x23, 0x00, 0x0C, 0xC0, 0x08, 0x80,
  0x03, 0x30, 0x02, 0x60, 0x00, 0xC8, 0x00, 0x90, 0x00, 0x36, 0x00, 0x64,
  0x00, 0x0D, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x06, 0x80, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x20, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10,
  0x00, 0x30, 0x30, 0x00, 0x10, 0x20, 0x00, 0x10, 0x60, 0x00, 0x10, 0x40,
  0x00, 0x10, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x11, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x84, 0x00,
  0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x06, 0x00,
  0x04, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x10, 0x06, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x02, 0x00, 0x40, 0x02, 0x00,
  0xC0, 0x02, 0x00, 0x40, 0x01, 0xA0, 0x01, 0x90, 0x00, 0xC8, 0x00, 0xC4,
  0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18,
  0x08, 0x08, 0x04, 0x0C, 0x02, 0x04, 0x01, 0x06, 0x00, 0x82, 0x00, 0x43,
  0x00, 0x21, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x02, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x20, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x81, 0x03, 0x06,
  0x0C, 0x08, 0x10, 0x20, 0x40, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x10, 0x30,
  0x60, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x83,
  0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x81, 0x00, 0x3F, 0xE0, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x16,
  0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x18, 0x00,
  0x60, 0xC0, 0x02, 0x03, 0x00, 0x30, 0x18, 0x01, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x0C, 0x20,
  0x00, 0x23, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xF0, 0xC2,
  0x10, 0xC2, 0x18, 0x41, 0x08, 0x00, 0x7C, 0x20, 0x3D, 0xC8, 0x0C, 0x0D,
  0x03, 0x00, 0xA0, 0xC0, 0x14, 0x10, 0x03, 0x86, 0x00, 0x60, 0x80, 0x0C,
  0x30, 0x01, 0x84, 0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x10,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x03, 0x04,
  0x00, 0x60, 0x80, 0x1C, 0x10, 0x03, 0x03, 0x00, 0xA0, 0x20, 0x24, 0x06,
  0x0C, 0x80, 0x7F, 0x30, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x3E, 0x00, 0xCE, 0xF0, 0x1B, 0x06, 0x02, 0xC0, 0x60,
  0x70, 0x0C, 0x1C, 0x00, 0x83, 0x80, 0x10, 0x60, 0x02, 0x0C, 0x00, 0x41,
  0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x20, 0x01, 0x84,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x10,
  0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0xE0,
  0x06, 0x1C, 0x01, 0x82, 0x80, 0x20, 0x58, 0x0C, 0x09, 0x87, 0x03, 0x1F,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xD8, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x04, 0x07, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x3E, 0x30, 0x07, 0xB9, 0x00, 0x60, 0x68, 0x06, 0x01, 0x40,
  0x60, 0x0E, 0x02, 0x00, 0x70, 0x30, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x80, 0x06, 0x04, 0x00, 0x30, 0x60, 0x01, 0x03, 0x00, 0x08, 0x10,
  0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x02, 0x00, 0x08,
  0x10, 0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00,
  0x18, 0x08, 0x01, 0xC0, 0x40, 0x0E, 0x02, 0x00, 0xE0, 0x18, 0x05, 0x00,
  0x40, 0x48, 0x03, 0x06, 0x40, 0x0F, 0xC6, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xB8, 0x0C, 0x18, 0x30, 0x10, 0xC0, 0x23, 0x00, 0x46, 0x00,
  0x98, 0x03, 0x30, 0x06, 0x40, 0x09, 0x80, 0x32, 0x00, 0xC4, 0x03, 0x18,
  0x1C, 0x37, 0xE0, 0x7E, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x06, 0x07, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x84, 0x00, 0xF7, 0x20, 0x06, 0x06, 0x80, 0x30, 0x0A, 0x01, 0x80, 0x28,
  0x04, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x10,
  0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x20, 0x01,
  0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x40, 0x40, 0x03, 0x01,
  0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x06, 0x01, 0x00,
  0x18, 0x04, 0x00, 0xE0, 0x10, 0x03, 0x80, 0x40, 0x1C, 0x01, 0x80, 0x50,
  0x02, 0x02, 0x40, 0x0C, 0x1B, 0x00, 0x1F, 0xCC, 0x00, 0x08, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x80, 0x30, 0x03, 0x03, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x47, 0xC0, 0x33, 0xB8, 0x0D, 0x03, 0x02, 0x80, 0x40,
  0xE0, 0x10, 0x30, 0x04, 0x18, 0x01, 0x06, 0x00, 0x41, 0x80, 0x30, 0x40,
  0x0C, 0x10, 0x02, 0x0C, 0x00, 0x83, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06,
  0x18, 0x01, 0x06, 0x00, 0x41, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x0C,
  0x00, 0x83, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01, 0x86, 0x00,
  0x41, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0x80, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x40, 0xC0, 0x30,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x60, 0x18, 0x18, 0x03, 0x06, 0x00,
  0x60, 0x80, 0x08, 0x30, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01,
  0x18, 0x00, 0x27, 0x00, 0x05, 0xA0, 0x01, 0xA6, 0x00, 0x38, 0xC0, 0x07,
  0x18, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0xC0, 0xC0, 0x10,
  0x18, 0x02, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x18, 0x08, 0x03, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x1B,
  0x9C, 0x77, 0x80, 0xB0, 0x26, 0x04, 0x05, 0x01, 0xE0, 0x30, 0x30, 0x06,
  0x01, 0x83, 0x80, 0x60, 0x0C, 0x18, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x03,
  0x06, 0x00, 0x80, 0x10, 0x20, 0x04, 0x00, 0x83, 0x00, 0x20, 0x0C, 0x18,
  0x03, 0x00, 0x60, 0xC0, 0x18, 0x02, 0x04, 0x00, 0x80, 0x10, 0x20, 0x04,
  0x00, 0x83, 0x00, 0x60, 0x0C, 0x18, 0x03, 0x00, 0x60, 0x80, 0x18, 0x02,
  0x04, 0x00, 0x80, 0x10, 0x20, 0x04, 0x00, 0x83, 0x00, 0x60, 0x0C, 0x18,
  0x03, 0x00, 0x60, 0x80, 0x10, 0x02, 0x04, 0x00, 0x80, 0x10, 0x60, 0x0C,
  0x01, 0x83, 0x00, 0x60, 0x0C, 0x18, 0x03, 0x00, 0x60, 0x80, 0x10, 0x02,
  0x04, 0x00, 0x80, 0x10, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x00, 0xDE,
  0xE0, 0x2C, 0x0C, 0x0A, 0x01, 0x03, 0x00, 0x41, 0xC0, 0x10, 0x60, 0x04,
  0x18, 0x01, 0x06, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x02, 0x0C,
  0x00, 0x82, 0x00, 0x60, 0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x04, 0x00,
  0xC1, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x60,
  0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x06, 0x00, 0x41, 0x00, 0x30, 0x40,
  0x0C, 0x30, 0x02, 0x00, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0xC0, 0x80, 0xC0,
  0x60, 0xC0, 0x10, 0xC0, 0x08, 0x60, 0x04, 0x60, 0x03, 0x30, 0x01, 0x90,
  0x00, 0xD8, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0xC8, 0x00,
  0x64, 0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0x80, 0x18, 0x40, 0x08, 0x30,
  0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xC0, 0x06, 0x77, 0x80, 0x26, 0x0C, 0x01, 0x60, 0x30, 0x0A, 0x01, 0x80,
  0x60, 0x04, 0x07, 0x00, 0x20, 0x30, 0x01, 0x01, 0x80, 0x08, 0x0C, 0x00,
  0x40, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x08,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x0C,
  0x08, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0xE0, 0x0C, 0x07, 0x00, 0x40, 0x2C, 0x06, 0x01,
  0x30, 0xE0, 0x18, 0xFC, 0x00, 0xC1, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7C, 0x20, 0x39, 0xC8, 0x0C, 0x0D, 0x03, 0x01,
  0xA0, 0xC0, 0x14, 0x10, 0x03, 0x86, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x01,
  0x84, 0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80, 0x02,
  0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0x42, 0x00, 0x18,
  0x40, 0x03, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0x60,
  0x80, 0x1C, 0x10, 0x07, 0x03, 0x00, 0xA0, 0x60, 0x34, 0x06, 0x0D, 0x80,
  0x7F, 0x30, 0x01, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0x03, 0x3A, 0x02, 0x40, 0x02, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0xF7, 0xC0, 0xC0, 0x40, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x0C, 0x0E, 0x07,
  0xFC, 0x00, 0x18, 0x00, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x3F, 0xC1, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x78, 0x04, 0x00, 0x06, 0x00, 0x41, 0x80, 0x10, 0x40, 0x0C, 0x10,
  0x03, 0x0C, 0x00, 0x83, 0x00, 0x20, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01,
  0x86, 0x00, 0x41, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x04, 0x00, 0xC3,
  0x00, 0x20, 0xC0, 0x08, 0x20, 0x06, 0x08, 0x01, 0x86, 0x00, 0x41, 0x80,
  0x10, 0x60, 0x0C, 0x10, 0x03, 0x04, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x18,
  0x30, 0x0A, 0x04, 0x07, 0x81, 0x83, 0x60, 0x3F, 0x90, 0x03, 0x00, 0x00,
  0xC0, 0x07, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x30,
  0x0C, 0x60, 0x10, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x06, 0x06, 0x0C, 0x08,
  0x18, 0x30, 0x30, 0x40, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x20, 0x0C, 0xC0, 0x19, 0x00, 0x36, 0x00, 0x68, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x0C, 0x01, 0xE0, 0x06,
  0x00, 0xF0, 0x07, 0x00, 0x58, 0x02, 0x80, 0x6C, 0x01, 0x40, 0x26, 0x01,
  0x20, 0x13, 0x00, 0x90, 0x19, 0x80, 0xC8, 0x08, 0xC0, 0x44, 0x0C, 0x60,
  0x62, 0x04, 0x30, 0x21, 0x02, 0x18, 0x10, 0x83, 0x0C, 0x18, 0x41, 0x06,
  0x08, 0x21, 0x83, 0x0C, 0x30, 0x81, 0x84, 0x18, 0x40, 0xC2, 0x0C, 0x60,
  0x63, 0x06, 0x20, 0x31, 0x03, 0x30, 0x19, 0x81, 0x90, 0x0C, 0x80, 0xC8,
  0x06, 0x40, 0x6C, 0x03, 0x60, 0x34, 0x01, 0xA0, 0x1A, 0x00, 0xF0, 0x0E,
  0x00, 0x70, 0x05, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x30, 0x10, 0x06, 0x01, 0x00, 0xC0, 0x18, 0x08,
  0x01, 0x81, 0x80, 0x08, 0x30, 0x00, 0x82, 0x00, 0x08, 0x60, 0x00, 0xC4,
  0x00, 0x0C, 0xC0, 0x00, 0x58, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xA0, 0x00, 0x13, 0x00, 0x03,
  0x30, 0x00, 0x61, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x01,
  0x81, 0x80, 0x30, 0x18, 0x02, 0x00, 0x80, 0x60, 0x08, 0x04, 0x00, 0x80,
  0xC0, 0x0C, 0x00, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0xC0, 0x02, 0x00, 0x60, 0x01, 0x00, 0x20, 0x00, 0x80, 0x30, 0x00, 0x40,
  0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x04,
  0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x60, 0x00, 0x02, 0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x2C, 0x78, 0x06, 0x01, 0x83, 0x40, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 40, 11, 1, -40 },
  { 56, 11, 14, 14, 5, -40 },
  { 76, 21, 40, 21, 0, -40 },
  { 181, 21, 46, 19, -1, -43 },
  { 302, 24, 42, 29, 3, -41 },
  { 428, 18, 42, 18, -1, -41 },
  { 523, 5, 14, 8, 5, -40 },
  { 532, 16, 49, 14, 1, -40 },
  { 630, 15, 49, 14, -4, -40 },
  { 722, 13, 15, 18, 7, -42 },
  { 747, 19, 26, 22, 2, -33 },
  { 809, 6, 12, 9, -2, -5 },
  { 818, 12, 2, 15, 1, -16 },
  { 821, 3, 4, 9, 1, -4 },
  { 823, 23, 40, 16, -3, -40 },
  { 938, 18, 42, 19, 1, -41 },
  { 1033, 10, 40, 19, 6, -40 },
  { 1083, 21, 41, 19, -2, -41 },
  { 1191, 20, 42, 19, -1, -41 },
  { 1296, 20, 40, 19, -1, -40 },
  { 1396, 22, 41, 19, -2, -40 },
  { 1509, 19, 42, 19, 1, -41 },
  { 1609, 19, 40, 19, 2, -40 },
  { 1704, 21, 42, 19, -1, -41 },
  { 1815, 19, 42, 19, 0, -41 },
  { 1915, 8, 30, 9, 0, -30 },
  { 1945, 12, 37, 9, -3, -30 },
  { 2001, 19, 23, 22, 2, -31 },
  { 2056, 19, 13, 22, 2, -26 },
  { 2087, 19, 23, 22, 2, -31 },
  { 2142, 15, 41, 14, 1, -41 },
  { 2219, 27, 45, 29, 1, -40 },
  { 2371, 19, 40, 18, -4, -40 },
  { 2466, 21, 40, 21, 0, -40 },
  { 2571, 21, 42, 19, 2, -41 },
  { 2682, 22, 40, 23, 0, -40 },
  { 2792, 21, 40, 19, 0, -40 },
  { 2897, 21, 40, 17, 0, -40 },
  { 3002, 25, 42, 25, 2, -41 },
  { 3134, 25, 40, 25, 0, -40 },
  { 3259, 16, 40, 9, -3, -40 },
  { 3339, 18, 50, 9, -8, -40 },
  { 3452, 23, 40, 19, 0, -40 },
  { 3567, 12, 40, 17, 0, -40 },
  { 3627, 34, 40, 33, 0, -40 },
  { 3797, 27, 40, 26, 0, -40 },
  { 3932, 22, 42, 25, 2, -41 },
  { 4048, 21, 40, 20, 0, -40 },
  { 4153, 22, 51, 25, 2, -41 },
  { 4294, 20, 40, 20, 0, -40 },
  { 4394, 23, 42, 19, -2, -41 },
  { 4515, 17, 40, 16, 4, -40 },
  { 4600, 23, 41, 24, 2, -40 },
  { 4718, 19, 40, 19, 5, -40 },
  { 4813, 34, 40, 33, 4, -40 },
  { 4983, 24, 40, 17, -3, -40 },
  { 5103, 17, 40, 16, 4, -40 },
  { 5188, 22, 40, 17, -2, -40 },
  { 5298, 20, 49, 15, -1, -40 },
  { 5421, 7, 40, 18, 6, -40 },
  { 5456, 19, 49, 15, -3, -40 },
  { 5573, 21, 19, 22, 1, -40 },
  { 5623, 14, 2, 15, -4, 5 },
  { 5627, 5, 9, 11, 8, -43 },
  { 5633, 19, 31, 21, 2, -30 },
  { 5707, 19, 44, 21, 0, -43 },
  { 5812, 15, 31, 15, 2, -30 },
  { 5871, 21, 44, 21, 2, -43 },
  { 5987, 15, 31, 18, 2, -30 },
  { 6046, 24, 56, 10, -7, -43 },
  { 6214, 22, 43, 21, -1, -30 },
  { 6333, 18, 43, 20, 0, -43 },
  { 6430, 10, 40, 9, 0, -40 },
  { 6480, 18, 53, 9, -7, -40 },
  { 6600, 19, 43, 17, 0, -43 },
  { 6703, 11, 43, 8, 0, -43 },
  { 6763, 29, 30, 31, 0, -30 },
  { 6872, 18, 30, 20, 0, -30 },
  { 6940, 17, 31, 20, 2, -30 },
  { 7006, 21, 43, 21, -2, -30 },
  { 7119, 19, 43, 21, 2, -30 },
  { 7222, 16, 30, 13, 0, -30 },
  { 7282, 17, 31, 15, -1, -30 },
  { 7348, 10, 38, 10, 1, -37 },
  { 7396, 18, 30, 20, 1, -29 },
  { 7464, 15, 29, 15, 3, -29 },
  { 7519, 25, 29, 26, 3, -29 },
  { 7610, 20, 29, 16, -2, -29 },
  { 7683, 25, 43, 16, -6, -29 },
  { 7818, 17, 29, 13, -2, -29 },
  { 7880, 19, 49, 17, 2, -40 },
  { 7997, 1, 57, 19, 9, -43 },
  { 8005, 19, 49, 17, -4, -40 },
  { 8122, 19, 4, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC56PT7B_H_
