#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x18,
  0xC1, 0x86, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x10, 0xC1, 0x84, 0x0C, 0x20,
  0x63, 0x02, 0x18, 0x10, 0xC1, 0x84, 0x0C, 0x20, 0x41, 0x02, 0x18, 0x10,
  0x81, 0x80, 0x00, 0x03, 0x01, 0x00, 0x03, 0x03, 0x00, 0x02, 0x03, 0x00,
  0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x04, 0x00,
  0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x08, 0x00,
  0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x10, 0x07, 0xFF, 0xFF, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00,
  0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0, 0x01, 0x80, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x00, 0x02,
  0x03, 0x00, 0x02, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x04,
  0x06, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18,
  0x08, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x10, 0x00, 0x20, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60,
  0x60, 0x00, 0x40, 0x60, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x3C, 0x8F, 0x00, 0x61, 0x83, 0x00,
  0xC1, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x00, 0x01, 0x01, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x02, 0x00, 0x03,
  0x02, 0x00, 0x01, 0x06, 0x00, 0x01, 0x86, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x44, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x11, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x20, 0x60, 0x00,
  0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0xC0, 0x00, 0xC1, 0x80, 0x80, 0xC3, 0x00, 0xE0, 0x8E, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xC0, 0x39, 0x80, 0x08, 0x06, 0x08, 0x01, 0x80, 0xC0, 0xC0,
  0x10, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x40, 0x30, 0x0C, 0x0C, 0x03, 0x00, 0x80, 0x80, 0x20, 0x08,
  0x18, 0x06, 0x01, 0x81, 0x80, 0x60, 0x18, 0x30, 0x06, 0x01, 0x83, 0x00,
  0x40, 0x18, 0x60, 0x0C, 0x01, 0x06, 0x00, 0xC0, 0x30, 0xC0, 0x0C, 0x03,
  0x0C, 0x00, 0xC0, 0x31, 0x83, 0xCC, 0x02, 0x18, 0xFE, 0xC0, 0x63, 0x1C,
  0x6C, 0x06, 0x31, 0x82, 0xC0, 0xC6, 0x30, 0x3C, 0x0C, 0x62, 0x03, 0xC1,
  0x8C, 0x60, 0x3C, 0x18, 0xC4, 0x03, 0x67, 0x18, 0xC0, 0x33, 0xE1, 0x8C,
  0x03, 0x00, 0x30, 0x80, 0x20, 0x03, 0x18, 0x02, 0x00, 0x61, 0x80, 0x60,
  0x06, 0x18, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x0C, 0x10, 0x06, 0x01, 0x83,
  0x00, 0x40, 0x18, 0x30, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x00, 0xC0,
  0x30, 0x30, 0x18, 0x03, 0x02, 0x01, 0x80, 0x30, 0x60, 0x30, 0x01, 0x8C,
  0x03, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xCE, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x60, 0x20, 0x06, 0x02, 0x00,
  0x60, 0x20, 0x04, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x04, 0x18,
  0x00, 0x43, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0x90, 0x00, 0x71,
  0x80, 0x06, 0x18, 0x00, 0xC1, 0x81, 0x18, 0x08, 0x31, 0x80, 0xC3, 0x30,
  0x0C, 0x23, 0x00, 0xC6, 0x60, 0x04, 0x66, 0x00, 0x64, 0x40, 0x06, 0xC4,
  0x00, 0x6C, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x07, 0x0C, 0x00, 0xD0, 0x60, 0x09, 0x86, 0x01, 0x98, 0x30, 0x70,
  0x81, 0xFE, 0x0C, 0x02, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23,
  0x18, 0xC4, 0x21, 0x18, 0x80, 0x00, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x0C, 0x18, 0x0C, 0x20, 0x06, 0x41,
  0x82, 0x9E, 0x03, 0xC0, 0x0E, 0x00, 0x32, 0x00, 0xC4, 0x03, 0x04, 0x08,
  0x0C, 0x20, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0xC0, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE7, 0x00, 0x0C, 0x0C, 0x00,
  0xC0, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x06, 0x00, 0x60, 0x20, 0x03,
  0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x00, 0x02, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x03,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80,
  0x40, 0x0C, 0x02, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x40, 0x60, 0x03, 0x0E,
  0x00, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x83,
  0xA0, 0xCC, 0x31, 0x8C, 0x37, 0x06, 0x40, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xF0, 0x03,
  0x80, 0x70, 0x04, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x04, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40,
  0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0x88, 0x00,
  0x03, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0x82, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x10, 0x01, 0x80, 0x20, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x04, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x06, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x06, 0x00, 0xE0, 0x3C,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3C,
  0x30, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x87, 0xC0, 0x04,
  0x7F, 0xC0, 0x33, 0x03, 0x80, 0xD8, 0x06, 0x03, 0xC0, 0x0C, 0x0E, 0x00,
  0x30, 0x70, 0x00, 0x41, 0xC0, 0x01, 0x07, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x18, 0x38, 0x00, 0x3F,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x02, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x00, 0x03, 0x01, 0x00, 0x03, 0x01, 0x00, 0x02, 0x01, 0x00, 0x06,
  0x01, 0x00, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x60, 0x00, 0x61, 0xC0,
  0x00, 0x33, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE6, 0x00,
  0x01, 0x87, 0x00, 0x07, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x30, 0x00, 0x40, 0x20, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x20,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x1C, 0x0E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xE3, 0x80, 0x06, 0x03, 0x00, 0x30, 0x04, 0x01, 0x80, 0x18, 0x04,
  0x00, 0x60, 0x30, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0x20, 0x00, 0xE0, 0xC0, 0x07,
  0x03, 0x00, 0x3C, 0x0C, 0x01, 0xB0, 0x18, 0x0C, 0xC0, 0x3D, 0xE2, 0x00,
  0x7F, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x81, 0xC0,
  0x03, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0xC0, 0xE0, 0x70,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x10,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xC7, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x86, 0x00, 0x7C, 0x04,
  0x30, 0x07, 0xF0, 0x21, 0x00, 0xE1, 0x81, 0x18, 0x06, 0x0C, 0x08, 0xC0,
  0x60, 0x40, 0x44, 0x06, 0x06, 0x06, 0x60, 0x20, 0x30, 0x33, 0x03, 0x01,
  0x81, 0x90, 0x18, 0x08, 0x0D, 0x81, 0x80, 0xC0, 0x6C, 0x0C, 0x06, 0x02,
  0x60, 0x60, 0x30, 0x32, 0x06, 0x03, 0x01, 0x90, 0x30, 0x18, 0x0D, 0x81,
  0x80, 0xC0, 0x4C, 0x0C, 0x06, 0x06, 0x60, 0x40, 0x60, 0x33, 0x02, 0x03,
  0x01, 0x18, 0x30, 0x18, 0x18, 0xC1, 0x81, 0xC0, 0xC4, 0x0C, 0x0E, 0x0C,
  0x20, 0x20, 0xF0, 0x61, 0x01, 0x85, 0x86, 0x08, 0x0C, 0x64, 0x60, 0x40,
  0x3E, 0x3E, 0x02, 0x00, 0xC0, 0x60, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x02,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00,
  0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x60, 0x01, 0x83,
  0x00, 0x08, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x10, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x18, 0x01, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x20, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x60, 0x00,
  0x46, 0x00, 0x02, 0x30, 0x00, 0x13, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x03, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x06, 0x01, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x06, 0x01, 0xC0, 0x04, 0x00, 0x60, 0x04, 0x00,
  0x20, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x08, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x20, 0x30, 0x00, 0x60, 0x20, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0x60, 0x03, 0x00, 0x40, 0x0E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC3, 0xC0, 0x07, 0x00, 0x40, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x18,
  0x0E, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x02, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x40,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x04, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x40, 0x03, 0x80, 0x60, 0x01, 0x80,
  0x30, 0x03, 0x80, 0x18, 0x03, 0x80, 0x08, 0x07, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x0E, 0x00, 0x30, 0x03, 0x80, 0x01, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xF0, 0x60, 0x00, 0xFF, 0x04, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x08, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x10, 0x03, 0x00, 0x01, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x18, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x01,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x20, 0x04, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x04, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x18, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x04, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08,
  0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xB4,
  0x00, 0x00, 0x34, 0xC0, 0x00, 0x05, 0x18, 0x00, 0x01, 0xE3, 0x00, 0x00,
  0x38, 0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x06, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x18, 0x01, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0xC0,
  0x0C, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0x60, 0x00, 0x01, 0xA0, 0x05, 0x80,
  0x00, 0x07, 0x80, 0x36, 0x00, 0x00, 0x36, 0x00, 0xD8, 0x00, 0x00, 0xD8,
  0x03, 0x60, 0x00, 0x06, 0x60, 0x09, 0x80, 0x00, 0x19, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x01, 0x98, 0x00, 0x03, 0x30, 0x06, 0x60, 0x00, 0x18, 0xC0,
  0x11, 0x80, 0x00, 0x62, 0x00, 0x46, 0x00, 0x03, 0x08, 0x03, 0x08, 0x00,
  0x0C, 0x60, 0x0C, 0x20, 0x00, 0x21, 0x80, 0x30, 0x80, 0x01, 0x86, 0x00,
  0x82, 0x00, 0x04, 0x10, 0x02, 0x08, 0x00, 0x30, 0xC0, 0x18, 0x20, 0x00,
  0x83, 0x00, 0x60, 0x80, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x10, 0x30, 0x04,
  0x0C, 0x00, 0xC0, 0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x00, 0x20,
  0x30, 0x0C, 0x04, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x0C, 0x03, 0x00, 0x40, 0x30, 0x30, 0x08, 0x01, 0x00,
  0xC1, 0x80, 0x20, 0x0C, 0x01, 0x06, 0x01, 0x80, 0x30, 0x04, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0xC0, 0x18, 0x02, 0x00, 0x46, 0x00, 0x40, 0x18, 0x01,
  0x18, 0x03, 0x00, 0x60, 0x04, 0xC0, 0x0C, 0x01, 0x80, 0x1B, 0x00, 0x30,
  0x06, 0x00, 0x68, 0x00, 0x80, 0x10, 0x01, 0xE0, 0x02, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x1E, 0x00, 0x03, 0x00,
  0x78, 0x00, 0x0C, 0x01, 0x60, 0x00, 0x20, 0x05, 0x80, 0x01, 0x80, 0x32,
  0x00, 0x06, 0x00, 0xC8, 0x00, 0x18, 0x03, 0x30, 0x00, 0x40, 0x08, 0xC0,
  0x03, 0x00, 0x63, 0x00, 0x0C, 0x01, 0x84, 0x00, 0x30, 0x06, 0x10, 0x00,
  0xC0, 0x18, 0x60, 0x02, 0x00, 0x41, 0x80, 0x18, 0x03, 0x06, 0x00, 0x60,
  0x0C, 0x18, 0x01, 0x80, 0x30, 0x20, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x02,
  0x03, 0x00, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80,
  0x40, 0x20, 0x04, 0x01, 0x00, 0x80, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18,
  0x18, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x01, 0x81, 0x00, 0x20, 0x02, 0x0C,
  0x01, 0x80, 0x0C, 0x30, 0x06, 0x00, 0x30, 0xC0, 0x18, 0x00, 0xC3, 0x00,
  0x60, 0x03, 0x08, 0x01, 0x00, 0x04, 0x60, 0x0C, 0x00, 0x11, 0x80, 0x30,
  0x00, 0x66, 0x00, 0xC0, 0x01, 0x90, 0x02, 0x00, 0x06, 0x40, 0x18, 0x00,
  0x1B, 0x00, 0x60, 0x00, 0x2C, 0x01, 0x80, 0x00, 0xF0, 0x06, 0x00, 0x03,
  0x80, 0x10, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x08, 0x06, 0x00, 0x06, 0x02,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x03,
  0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0x80,
  0xE0, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x10, 0x01,
  0x80, 0x60, 0x03, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08,
  0x0C, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00,
  0xE0, 0x04, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x8E, 0x00,
  0x0E, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x08,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x88, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0x80,
  0xE0, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x10, 0x01,
  0x80, 0x60, 0x03, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80,
  0x80, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18,
  0x00, 0xC0, 0x20, 0x03, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x01,
  0xC0, 0x07, 0xFF, 0x00, 0x08, 0x10, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x02, 0x00,
  0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x04, 0x02, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0x87, 0xC0,
  0x0E, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x10, 0x00, 0x60, 0x0F, 0x00,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x40,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x40, 0x20, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40,
  0x00, 0x20, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0x38, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83,
  0x00, 0x04, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x32,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0x00, 0x01, 0xB0, 0x00, 0x1C,
  0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x33, 0x00, 0x03, 0xC0, 0x00, 0xCC,
  0x00, 0x0F, 0x00, 0x02, 0x30, 0x00, 0x2C, 0x00, 0x18, 0xC0, 0x01, 0xB0,
  0x00, 0x63, 0x00, 0x04, 0xC0, 0x03, 0x0C, 0x00, 0x33, 0x00, 0x0C, 0x30,
  0x00, 0xCC, 0x00, 0x20, 0xC0, 0x02, 0x30, 0x01, 0x83, 0x00, 0x18, 0xC0,
  0x06, 0x0C, 0x00, 0x43, 0x00, 0x30, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x30, 0x02, 0x03, 0x00, 0x20, 0xC0, 0x18, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0x30, 0x06, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x20, 0x0C, 0x03, 0x00,
  0xC0, 0x80, 0x20, 0x0C, 0x02, 0x02, 0x01, 0x80, 0x30, 0x18, 0x08, 0x06,
  0x00, 0xC0, 0x60, 0x20, 0x30, 0x03, 0x03, 0x00, 0x80, 0xC0, 0x0C, 0x0C,
  0x02, 0x02, 0x00, 0x30, 0x20, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x20, 0x60,
  0x03, 0x06, 0x00, 0x83, 0x00, 0x0C, 0x30, 0x02, 0x0C, 0x00, 0x30, 0xC0,
  0x18, 0x20, 0x00, 0xC2, 0x00, 0x61, 0x80, 0x03, 0x18, 0x01, 0x86, 0x00,
  0x0C, 0x60, 0x06, 0x30, 0x00, 0x31, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00,
  0x62, 0x00, 0x02, 0x30, 0x01, 0x98, 0x00, 0x09, 0x80, 0x06, 0x40, 0x00,
  0x26, 0x00, 0x1B, 0x00, 0x00, 0x90, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x01,
  0xA0, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x30, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x62, 0x00,
  0x0C, 0x20, 0x00, 0xC2, 0x00, 0x18, 0x20, 0x01, 0x83, 0x00, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x10, 0x18, 0x01, 0x03, 0x00, 0x10, 0x30, 0x01, 0x06, 0x00,
  0x10, 0x40, 0x01, 0x8C, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x19, 0x00,
  0x01, 0xB0, 0x00, 0x1A, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60,
  0x60, 0x60, 0x60, 0x20, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x04, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xA0, 0x00, 0x03, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x21,
  0x80, 0x00, 0xC1, 0x80, 0x01, 0x03, 0x00, 0x06, 0x03, 0x00, 0x08, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x18,
  0x0C, 0x00, 0x10, 0x10, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0x80,
  0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x00, 0x3F, 0x0C, 0x03,
  0xCE, 0x20, 0x1C, 0x0C, 0x80, 0xC0, 0x12, 0x03, 0x00, 0x78, 0x18, 0x00,
  0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01,
  0xC0, 0xC0, 0x0F, 0x03, 0x00, 0x28, 0x04, 0x01, 0xA0, 0x18, 0x0C, 0x80,
  0x30, 0x66, 0x00, 0x7F, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x61, 0xF8, 0x01, 0x9E, 0x70, 0x06, 0xC0, 0x60, 0x16,
  0x01, 0x80, 0x50, 0x03, 0x03, 0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x02, 0x08, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x04,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x78, 0x01,
  0x81, 0xE0, 0x0C, 0x04, 0xC0, 0x60, 0x13, 0x83, 0x00, 0xC7, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x78, 0xC0, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x38,
  0x20, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x7E, 0x18, 0x00, 0xF3, 0x88, 0x00,
  0xE0, 0x6C, 0x00, 0xC0, 0x16, 0x00, 0x60, 0x0F, 0x00, 0x60, 0x03, 0x80,
  0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x08, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xE0, 0x0C,
  0x00, 0xA0, 0x02, 0x00, 0xD0, 0x01, 0x80, 0xC8, 0x00, 0x60, 0xCC, 0x00,
  0x1F, 0xC6, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x38, 0xE0,
  0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0x84, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x18, 0x03, 0x86, 0x01, 0xC1, 0x01, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x20, 0x38, 0x38, 0x07, 0xFC, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x27, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xE1, 0x80, 0x0F, 0x38, 0x80, 0x0E, 0x06, 0x40,
  0x0C, 0x01, 0x20, 0x06, 0x00, 0xF0, 0x06, 0x00, 0x38, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x38, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x1E, 0x00, 0xC0, 0x0A, 0x00,
  0x20, 0x0D, 0x00, 0x18, 0x0D, 0x80, 0x06, 0x0C, 0xC0, 0x01, 0xFC, 0x60,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x60, 0x01, 0xE1, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x11, 0xFC, 0x01, 0x9C, 0x70, 0x0D, 0x80, 0xC0,
  0x58, 0x06, 0x03, 0x80, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x10, 0x30, 0x01, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x01,
  0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x00, 0x00, 0x20, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x01, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x40,
  0x18, 0x02, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00,
  0x40, 0xC0, 0x02, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x60,
  0x00, 0x46, 0x00, 0x06, 0x38, 0x00, 0x33, 0xC0, 0x01, 0xB6, 0x00, 0x0B,
  0x30, 0x00, 0x50, 0x80, 0x07, 0x04, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80,
  0x08, 0x0C, 0x00, 0x40, 0x60, 0x06, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x02, 0x01,
  0x80, 0x10, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x8F,
  0xC0, 0xFE, 0x00, 0xCE, 0x71, 0xC7, 0x80, 0x68, 0x0D, 0xC0, 0xC0, 0x28,
  0x02, 0xC0, 0x30, 0x1C, 0x01, 0xC0, 0x18, 0x1C, 0x00, 0xC0, 0x0C, 0x0E,
  0x00, 0x60, 0x06, 0x06, 0x00, 0x30, 0x03, 0x03, 0x00, 0x30, 0x01, 0x81,
  0x00, 0x18, 0x00, 0x81, 0x80, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x60,
  0x60, 0x02, 0x00, 0x30, 0x20, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0x08,
  0x18, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x40, 0x06, 0x06, 0x00, 0x60, 0x03,
  0x02, 0x00, 0x30, 0x01, 0x03, 0x00, 0x18, 0x00, 0x81, 0x80, 0x0C, 0x00,
  0xC0, 0xC0, 0x04, 0x00, 0x60, 0x60, 0x06, 0x00, 0x30, 0x20, 0x03, 0x00,
  0x10, 0x30, 0x01, 0x80, 0x18, 0x18, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0x40,
  0x06, 0x04, 0x00, 0x60, 0x03, 0x02, 0x00, 0x30, 0x01, 0x03, 0x00, 0x18,
  0x01, 0x81, 0x80, 0x08, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x60, 0x40, 0x06,
  0x00, 0x20, 0x60, 0x03, 0x00, 0x30, 0x00, 0x01, 0x8F, 0xE0, 0x0C, 0xE3,
  0x80, 0x4C, 0x0C, 0x02, 0xC0, 0x30, 0x1C, 0x01, 0x81, 0xC0, 0x0C, 0x0E,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x10, 0x30, 0x00, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x02, 0x00, 0x10, 0x30, 0x00,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x10, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0x00, 0x1E, 0x70, 0x06, 0x03, 0x01, 0x80, 0x60, 0x60,
  0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18,
  0x10, 0x06, 0x03, 0x01, 0xC0, 0x30, 0x70, 0x03, 0xF8, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0xFC, 0x00, 0x19, 0xE7, 0x00, 0x0D, 0x80, 0xC0, 0x04,
  0x80, 0x60, 0x02, 0xC0, 0x18, 0x03, 0xC0, 0x0C, 0x01, 0xC0, 0x06, 0x00,
  0xE0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x02, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x78, 0x01, 0x80, 0x34,
  0x01, 0x80, 0x1B, 0x01, 0x80, 0x09, 0xC3, 0x80, 0x04, 0x7F, 0x80, 0x06,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x0C, 0x03, 0xCE, 0x20, 0x18, 0x0C, 0x80, 0xC0, 0x12, 0x06, 0x00,
  0x78, 0x18, 0x01, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x60, 0x00, 0xC1, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x80,
  0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0C, 0x00,
  0x70, 0x30, 0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x00, 0x28, 0x04, 0x01, 0xA0,
  0x18, 0x0D, 0x80, 0x30, 0x66, 0x00, 0x7F, 0x18, 0x00, 0x70, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x8F, 0xC0, 0x67, 0x10, 0x13, 0x00, 0x05, 0x80, 0x01,
  0x40, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1E, 0x3C,
  0x0E, 0x01, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x04, 0x00, 0xC0, 0xE0,
  0x70, 0x0F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x1F, 0xF1, 0xFF, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xC0, 0x18, 0x00,
  0x06, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00,
  0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0x61, 0x80,
  0x04, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x08, 0x30,
  0x00, 0x83, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x18, 0x20, 0x01, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x08, 0x00, 0xC0, 0x80, 0x1C,
  0x08, 0x01, 0x40, 0x80, 0x3C, 0x0C, 0x06, 0xC0, 0xE0, 0xC8, 0x07, 0xF8,
  0x80, 0x1C, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10,
  0x80, 0x30, 0x80, 0x30, 0x80, 0x60, 0x80, 0x60, 0x80, 0xC0, 0x80, 0xC0,
  0x80, 0x80, 0x81, 0x80, 0x81, 0x80, 0x83, 0x00, 0x83, 0x00, 0x86, 0x00,
  0x86, 0x00, 0x84, 0x00, 0x8C, 0x00, 0x88, 0x00, 0x98, 0x00, 0x98, 0x00,
  0xB0, 0x00, 0xB0, 0x00, 0xA0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x02, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x2C, 0x00,
  0xE0, 0x06, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xA0, 0x04, 0xC0, 0x1A, 0x00,
  0xCC, 0x01, 0x20, 0x0C, 0xC0, 0x32, 0x01, 0x8C, 0x03, 0x20, 0x18, 0x80,
  0x22, 0x01, 0x08, 0x06, 0x20, 0x30, 0x80, 0x42, 0x03, 0x08, 0x0C, 0x20,
  0x20, 0x80, 0xC2, 0x06, 0x08, 0x08, 0x20, 0x40, 0x81, 0x82, 0x0C, 0x08,
  0x10, 0x20, 0xC0, 0x83, 0x02, 0x08, 0x08, 0x30, 0x21, 0x80, 0x86, 0x02,
  0x10, 0x08, 0x60, 0x23, 0x00, 0x84, 0x02, 0x30, 0x08, 0xC0, 0x22, 0x00,
  0x88, 0x02, 0x60, 0x09, 0x80, 0x24, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00,
  0x2C, 0x00, 0xB0, 0x06, 0x80, 0x0A, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x06,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x20,
  0xC0, 0x00, 0x41, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00, 0x03, 0x30,
  0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x04, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x03, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x20, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x05, 0xC7, 0x80, 0x3C,
  0x03, 0x81, 0xA0, 0x07, 0xFC, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 46, 13, 1, -46 },
  { 70, 13, 17, 16, 6, -46 },
  { 98, 24, 46, 23, 0, -46 },
  { 236, 24, 53, 22, -1, -49 },
  { 395, 28, 47, 33, 3, -46 },
  { 560, 20, 47, 21, -1, -46 },
  { 678, 5, 17, 9, 6, -46 },
  { 689, 17, 55, 15, 2, -45 },
  { 806, 17, 55, 15, -4, -45 },
  { 923, 15, 17, 20, 8, -48 },
  { 955, 22, 29, 26, 2, -37 },
  { 1035, 8, 14, 10, -3, -6 },
  { 1049, 13, 1, 17, 2, -18 },
  { 1051, 3, 4, 10, 1, -4 },
  { 1053, 26, 46, 19, -3, -46 },
  { 1203, 21, 47, 22, 1, -46 },
  { 1327, 11, 46, 22, 7, -46 },
  { 1391, 24, 46, 22, -2, -46 },
  { 1529, 23, 47, 22, -1, -46 },
  { 1665, 23, 46, 22, -1, -46 },
  { 1798, 24, 47, 22, -2, -46 },
  { 1939, 22, 47, 22, 1, -46 },
  { 2069, 22, 46, 22, 2, -46 },
  { 2196, 24, 47, 22, -1, -46 },
  { 2337, 22, 47, 22, 0, -46 },
  { 2467, 9, 34, 10, 0, -34 },
  { 2506, 13, 42, 10, -3, -34 },
  { 2575, 22, 27, 26, 2, -36 },
  { 2650, 22, 15, 26, 2, -30 },
  { 2692, 22, 27, 26, 2, -36 },
  { 2767, 17, 46, 15, 1, -46 },
  { 2865, 29, 52, 33, 2, -46 },
  { 3054, 21, 46, 21, -4, -46 },
  { 3175, 24, 46, 24, 0, -46 },
  { 3313, 25, 47, 22, 2, -46 },
  { 3460, 25, 46, 26, 0, -46 },
  { 3604, 24, 46, 22, 0, -46 },
  { 3742, 24, 46, 20, 0, -46 },
  { 3880, 28, 47, 29, 2, -46 },
  { 4045, 29, 46, 28, 0, -46 },
  { 4212, 19, 46, 11, -4, -46 },
  { 4322, 21, 57, 10, -9, -46 },
  { 4472, 27, 46, 22, 0, -46 },
  { 4628, 14, 46, 19, 0, -46 },
  { 4709, 38, 46, 38, 0, -46 },
  { 4928, 30, 46, 30, 0, -46 },
  { 5101, 25, 47, 28, 2, -46 },
  { 5248, 23, 46, 23, 0, -46 },
  { 5381, 25, 57, 28, 2, -46 },
  { 5560, 23, 46, 23, 0, -46 },
  { 5693, 25, 47, 22, -2, -46 },
  { 5840, 20, 46, 19, 4, -46 },
  { 5955, 26, 47, 27, 2, -46 },
  { 6108, 22, 46, 22, 5, -46 },
  { 6235, 38, 46, 38, 5, -46 },
  { 6454, 28, 46, 19, -4, -46 },
  { 6615, 20, 46, 19, 4, -46 },
  { 6730, 26, 46, 20, -3, -46 },
  { 6880, 22, 56, 18, -1, -46 },
  { 7034, 8, 46, 20, 7, -46 },
  { 7080, 23, 56, 18, -4, -46 },
  { 7241, 23, 22, 25, 2, -46 },
  { 7305, 17, 1, 17, -5, 6 },
  { 7308, 6, 10, 13, 9, -49 },
  { 7316, 22, 35, 24, 2, -34 },
  { 7413, 22, 50, 24, 0, -49 },
  { 7551, 17, 35, 17, 2, -34 },
  { 7626, 25, 50, 24, 2, -49 },
  { 7783, 18, 35, 21, 2, -34 },
  { 7862, 27, 64, 12, -8, -49 },
  { 8078, 25, 49, 24, -1, -34 },
  { 8232, 21, 49, 23, 0, -49 },
  { 8361, 12, 46, 10, 0, -46 },
  { 8430, 21, 61, 10, -9, -46 },
  { 8591, 21, 49, 19, 0, -49 },
  { 8720, 12, 49, 9, 0, -49 },
  { 8794, 33, 34, 35, 0, -34 },
  { 8935, 21, 34, 23, 0, -34 },
  { 9025, 19, 35, 23, 2, -34 },
  { 9109, 25, 49, 24, -3, -34 },
  { 9263, 22, 49, 24, 2, -34 },
  { 9398, 18, 34, 15, 0, -34 },
  { 9475, 19, 35, 18, -1, -34 },
  { 9559, 12, 43, 12, 1, -42 },
  { 9624, 20, 35, 23, 2, -34 },
  { 9712, 16, 34, 17, 4, -34 },
  { 9780, 28, 34, 29, 4, -34 },
  { 9899, 23, 34, 18, -3, -34 },
  { 9997, 29, 50, 19, -7, -34 },
  { 10179, 19, 34, 15, -2, -34 },
  { 10260, 22, 56, 20, 2, -46 },
  { 10414, 2, 65, 22, 10, -49 },
  { 10431, 21, 56, 20, -4, -46 },
  { 10578, 22, 5, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC64PT7B_H_
