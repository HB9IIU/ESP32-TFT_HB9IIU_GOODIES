#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x00, 0x00, 0x10, 0xC0, 0x4A, 0x53, 0x18, 0xCA, 0x52, 0x02, 0x20,
  0x44, 0x09, 0x02, 0x20, 0x44, 0x08, 0x8F, 0xF8, 0x44, 0x08, 0x82, 0x20,
  0x44, 0x08, 0x81, 0x21, 0xFF, 0x08, 0x81, 0x20, 0x44, 0x08, 0x81, 0x10,
  0x44, 0x08, 0x80, 0x01, 0x00, 0x20, 0x1C, 0x05, 0x31, 0x20, 0x44, 0x08,
  0x81, 0x10, 0x24, 0x02, 0x80, 0x30, 0x02, 0x00, 0x60, 0x14, 0x02, 0x40,
  0x48, 0x09, 0x02, 0x20, 0x44, 0x49, 0x0F, 0xC0, 0x20, 0x08, 0x01, 0x00,
  0x1C, 0x11, 0x10, 0x88, 0x88, 0x84, 0x44, 0x24, 0x22, 0x21, 0x12, 0x10,
  0x90, 0x85, 0x34, 0x4A, 0x62, 0xA3, 0x25, 0x17, 0x48, 0x82, 0x84, 0x24,
  0x21, 0x22, 0x11, 0x10, 0x88, 0x88, 0x44, 0x42, 0x44, 0x1C, 0x00, 0x07,
  0x04, 0x82, 0x42, 0x21, 0x10, 0x88, 0x48, 0x24, 0x14, 0x04, 0x06, 0x05,
  0x04, 0x4A, 0x26, 0x15, 0x0A, 0x82, 0x41, 0x21, 0x90, 0xCF, 0x90, 0x56,
  0xAA, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x40, 0x80, 0x08, 0x08, 0xC8, 0x2F, 0x10, 0x28, 0x44,
  0x04, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x24, 0xA5, 0x20, 0xFC, 0x70, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x00, 0x07, 0x04, 0x44, 0x24, 0x12, 0x0A, 0x05, 0x02,
  0x81, 0x40, 0xC0, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x42,
  0x21, 0x11, 0x07, 0x00, 0x08, 0xCB, 0x91, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x21, 0x08, 0x00, 0x07, 0x81, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x0F, 0xF0, 0x07,
  0x81, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0,
  0x20, 0x38, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x0F, 0xC0, 0x00, 0x20, 0x0C, 0x02, 0x80, 0x60, 0x14, 0x04,
  0x80, 0x90, 0x22, 0x04, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08, 0x42, 0x10,
  0x47, 0xFE, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x07, 0xE0, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x03, 0xE0, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x0F, 0xC0, 0x07, 0xC2, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x58, 0x28, 0x8C, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x82, 0x20,
  0x88, 0x22, 0x10, 0x78, 0x00, 0x3F, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x07, 0x82, 0x11, 0x04,
  0x41, 0x20, 0x48, 0x11, 0x04, 0x42, 0x11, 0x02, 0x80, 0xC0, 0xC8, 0x42,
  0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x7C, 0x00, 0x07,
  0x02, 0x21, 0x04, 0x81, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50, 0x22,
  0x08, 0x86, 0x1E, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30,
  0xF0, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x80, 0x08, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x10, 0x88, 0x44, 0x20, 0x00, 0xC0,
  0xC0, 0xC0, 0x40, 0x60, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x02,
  0x00, 0x1E, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x01, 0xE0,
  0x30, 0x82, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x87, 0x28, 0x49, 0x44,
  0x4A, 0x44, 0x62, 0x23, 0x11, 0x19, 0x09, 0x48, 0x8A, 0x44, 0x52, 0x24,
  0x93, 0x24, 0x66, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x88, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x14, 0x05, 0x01, 0x40, 0x90, 0x24, 0x11, 0x04,
  0x41, 0x10, 0x84, 0x21, 0x1F, 0x84, 0x11, 0x04, 0x81, 0x20, 0x50, 0x14,
  0x05, 0x01, 0x80, 0x40, 0x0F, 0x01, 0x08, 0x20, 0x84, 0x11, 0x02, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x44, 0x30, 0xFC, 0x10, 0x42, 0x08, 0x41, 0x10,
  0x22, 0x04, 0x40, 0x88, 0x11, 0x04, 0x41, 0x0F, 0xC0, 0x03, 0xE0, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x03, 0xC0, 0x0F, 0x01, 0x18, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x90, 0x12, 0x02,
  0x40, 0x88, 0x22, 0x04, 0x43, 0x0F, 0x80, 0x0F, 0xE1, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x10, 0xFC, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x0F, 0xE0,
  0x0F, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x1F, 0x82, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x03, 0xF0, 0x20, 0x42, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x03,
  0xC8, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x10, 0x20,
  0x81, 0x03, 0xF8, 0x00, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x11, 0x01,
  0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x11, 0x01, 0x0F, 0xF8, 0x40, 0x42,
  0x02, 0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x20, 0x21, 0x01,
  0x08, 0x08, 0x00, 0x07, 0x81, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x0F, 0x80, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x70, 0x00, 0x08, 0x10, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x81, 0x10, 0x11, 0x01, 0x20, 0x14, 0x02, 0x80,
  0x2C, 0x03, 0x40, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20,
  0x81, 0x08, 0x10, 0x81, 0x00, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0xFC, 0x0C, 0x00, 0x86,
  0x00, 0x43, 0x00, 0x61, 0x80, 0x31, 0x40, 0x28, 0xA0, 0x18, 0x50, 0x14,
  0x28, 0x0A, 0x14, 0x09, 0x12, 0x04, 0x89, 0x04, 0x84, 0x82, 0x42, 0x42,
  0x21, 0x21, 0x11, 0x11, 0x08, 0x84, 0x88, 0x42, 0x84, 0x21, 0x42, 0x20,
  0xC1, 0x10, 0x61, 0x08, 0x20, 0x80, 0x08, 0x04, 0x30, 0x10, 0xC0, 0x83,
  0x02, 0x14, 0x08, 0x48, 0x21, 0x20, 0x84, 0x84, 0x12, 0x10, 0x88, 0x42,
  0x21, 0x08, 0x48, 0x21, 0x20, 0x84, 0x84, 0x12, 0x10, 0x48, 0x40, 0xC1,
  0x03, 0x08, 0x0C, 0x20, 0x30, 0x80, 0x80, 0x03, 0xC1, 0x84, 0x20, 0x88,
  0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x04, 0x21, 0x07, 0xC0,
  0x0F, 0x01, 0x18, 0x21, 0x04, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10,
  0x44, 0x10, 0x84, 0x1F, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x03, 0xC1, 0x84, 0x20, 0x88, 0x12, 0x02,
  0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x18, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x04, 0x21, 0x07, 0xC0, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0x01, 0x18, 0x21, 0x04, 0x11, 0x02,
  0x20, 0x44, 0x10, 0x82, 0x10, 0x44, 0x10, 0x84, 0x1F, 0x02, 0x40, 0x48,
  0x10, 0x82, 0x10, 0x42, 0x08, 0x42, 0x08, 0x40, 0x88, 0x10, 0x03, 0xE0,
  0x41, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0xFE, 0x00, 0xFF, 0x84, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x00, 0x10, 0x11, 0x01, 0x10, 0x21, 0x02,
  0x20, 0x22, 0x02, 0x20, 0x22, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04,
  0x40, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0x81, 0x08, 0x20,
  0x7C, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x08,
  0x82, 0x21, 0x08, 0x42, 0x10, 0x88, 0x22, 0x09, 0x02, 0x40, 0xA0, 0x28,
  0x0A, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x30, 0x28, 0x18, 0x14, 0x14, 0x12, 0x0A, 0x09, 0x05, 0x04, 0x84, 0x84,
  0x42, 0x42, 0x22, 0x22, 0x11, 0x11, 0x08, 0x88, 0x84, 0x84, 0x82, 0x42,
  0x41, 0x41, 0x40, 0xA0, 0xA0, 0x50, 0x50, 0x30, 0x30, 0x18, 0x18, 0x08,
  0x08, 0x00, 0x04, 0x08, 0x20, 0x80, 0x84, 0x04, 0x40, 0x22, 0x01, 0x20,
  0x09, 0x00, 0x50, 0x03, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x50, 0x04,
  0x80, 0x24, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x40, 0x82, 0x0C, 0x08,
  0x00, 0x80, 0xC0, 0xA0, 0x48, 0x44, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28,
  0x14, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x00, 0x0F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1F, 0x00, 0x88, 0x88, 0x84,
  0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x10, 0x07, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x3E, 0x00, 0x04, 0x03, 0x00, 0xA0, 0x48, 0x11, 0x08,
  0x42, 0x11, 0x02, 0x40, 0xA0, 0x10, 0xFE, 0x89, 0x10, 0x06, 0x06, 0x52,
  0x14, 0x82, 0x40, 0x90, 0x24, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08,
  0x82, 0x20, 0x88, 0x61, 0xE8, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x30, 0x52, 0x18, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48, 0x12, 0x05,
  0x02, 0x40, 0x90, 0x24, 0x11, 0x04, 0xC2, 0x2F, 0x00, 0x06, 0x19, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x78, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x81, 0x90, 0xCA,
  0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x09, 0x02, 0x20, 0x44, 0x08, 0x81,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x60, 0xF4, 0x00, 0x04, 0x13, 0x21, 0x21,
  0x41, 0x42, 0x82, 0x8C, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C,
  0x00, 0x38, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x68, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x65, 0x08, 0x50, 0x82, 0x10, 0x21, 0x02, 0x10, 0x22, 0x04,
  0x20, 0x42, 0x04, 0x20, 0x42, 0x08, 0x20, 0x82, 0x18, 0x21, 0x81, 0xE8,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x08, 0x60, 0x78, 0x00, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x30, 0x52, 0x18, 0x44, 0x11,
  0x08, 0x82, 0x20, 0x88, 0x22, 0x09, 0x04, 0x41, 0x10, 0x44, 0x11, 0x04,
  0x82, 0x20, 0x80, 0x08, 0x40, 0x00, 0x00, 0x42, 0x10, 0x88, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x01, 0x03, 0x80, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x04, 0x42, 0x11, 0x04, 0x42, 0x20, 0x90, 0x28, 0x0A, 0x03, 0x40, 0x90,
  0x44, 0x11, 0x04, 0x41, 0x10, 0x82, 0x20, 0x80, 0x04, 0x20, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x00, 0x03, 0x18, 0x29, 0x4C, 0x61, 0x08, 0x82, 0x11, 0x08, 0x24, 0x10,
  0x48, 0x21, 0x10, 0x42, 0x21, 0x04, 0x82, 0x09, 0x04, 0x12, 0x08, 0x44,
  0x20, 0x88, 0x41, 0x20, 0x82, 0x41, 0x04, 0x03, 0x0A, 0x46, 0x22, 0x11,
  0x09, 0x04, 0x82, 0x41, 0x20, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x09,
  0x04, 0x06, 0x0C, 0x88, 0x44, 0x14, 0x0A, 0x05, 0x03, 0x02, 0x81, 0x40,
  0xA0, 0x50, 0x28, 0x24, 0x12, 0x10, 0xF0, 0x01, 0x81, 0x48, 0x30, 0x84,
  0x10, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10, 0x24, 0x04, 0x81, 0x10, 0x22,
  0x08, 0x41, 0x18, 0x42, 0xF0, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x00, 0x06, 0x06, 0x52, 0x14, 0x82, 0x40, 0x90, 0x24, 0x0A,
  0x04, 0x81, 0x20, 0x48, 0x12, 0x08, 0x82, 0x20, 0x88, 0x61, 0xE8, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x03, 0x14, 0x18, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x0E, 0x11, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x04, 0xF8, 0x08, 0x21, 0x04, 0x3C, 0x42, 0x08, 0x20, 0x82,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x07, 0x00, 0x20, 0x90, 0x48, 0x28, 0x24,
  0x12, 0x09, 0x04, 0x82, 0x82, 0x41, 0x20, 0x90, 0x48, 0x44, 0x63, 0xD0,
  0x83, 0x06, 0x14, 0x28, 0x91, 0x24, 0x48, 0x91, 0x42, 0x86, 0x0C, 0x10,
  0x20, 0x00, 0x82, 0x1C, 0x30, 0xA1, 0x85, 0x14, 0x48, 0xA2, 0x45, 0x12,
  0x49, 0x12, 0x48, 0xA2, 0x85, 0x14, 0x30, 0xA1, 0x86, 0x0C, 0x30, 0x41,
  0x02, 0x08, 0x00, 0x10, 0x42, 0x20, 0x88, 0x24, 0x0A, 0x02, 0x80, 0x40,
  0x30, 0x0C, 0x05, 0x02, 0x40, 0x88, 0x42, 0x10, 0x88, 0x20, 0x04, 0x08,
  0x20, 0x81, 0x04, 0x08, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04,
  0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x70, 0x00, 0x0F, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x03, 0xF0, 0x01, 0xC0, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x18, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x68, 0x04, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xC0, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x30, 0x30,
  0x00, 0xF8, 0x60, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 21, 6, 0, -21 },
  { 17, 5, 8, 7, 3, -21 },
  { 22, 11, 21, 11, 0, -21 },
  { 51, 11, 24, 10, 0, -22 },
  { 84, 13, 21, 15, 1, -21 },
  { 119, 9, 21, 9, 0, -21 },
  { 143, 2, 8, 4, 3, -21 },
  { 145, 8, 26, 7, 1, -21 },
  { 171, 8, 26, 7, -2, -21 },
  { 197, 8, 8, 9, 3, -22 },
  { 205, 10, 13, 12, 1, -17 },
  { 222, 3, 7, 5, -1, -3 },
  { 225, 6, 1, 8, 1, -8 },
  { 226, 2, 2, 4, 0, -2 },
  { 227, 11, 21, 8, -1, -21 },
  { 256, 9, 21, 10, 1, -21 },
  { 280, 5, 21, 10, 3, -21 },
  { 294, 11, 21, 10, -1, -21 },
  { 323, 11, 21, 10, -1, -21 },
  { 352, 11, 21, 10, -1, -21 },
  { 381, 11, 21, 10, -1, -21 },
  { 410, 10, 21, 10, 1, -21 },
  { 437, 10, 21, 10, 1, -21 },
  { 464, 10, 21, 10, 0, -21 },
  { 491, 10, 21, 10, 0, -21 },
  { 518, 4, 15, 4, 0, -15 },
  { 526, 5, 19, 5, -1, -15 },
  { 538, 10, 12, 12, 1, -16 },
  { 553, 10, 7, 12, 1, -14 },
  { 562, 10, 12, 12, 1, -16 },
  { 577, 8, 21, 7, 0, -21 },
  { 598, 13, 24, 15, 1, -21 },
  { 637, 10, 21, 9, -2, -21 },
  { 664, 11, 21, 11, 0, -21 },
  { 693, 11, 21, 10, 1, -21 },
  { 722, 11, 21, 12, 0, -21 },
  { 751, 11, 21, 10, 0, -21 },
  { 780, 11, 21, 9, 0, -21 },
  { 809, 13, 21, 13, 1, -21 },
  { 844, 13, 21, 13, 0, -21 },
  { 879, 9, 21, 5, -2, -21 },
  { 903, 9, 26, 4, -4, -21 },
  { 933, 12, 21, 10, 0, -21 },
  { 965, 6, 21, 9, 0, -21 },
  { 981, 17, 21, 17, 0, -21 },
  { 1026, 14, 21, 13, 0, -21 },
  { 1063, 11, 21, 13, 1, -21 },
  { 1092, 11, 21, 10, 0, -21 },
  { 1121, 11, 26, 13, 1, -21 },
  { 1157, 11, 21, 10, 0, -21 },
  { 1186, 12, 21, 10, -1, -21 },
  { 1218, 9, 21, 9, 2, -21 },
  { 1242, 12, 21, 12, 1, -21 },
  { 1274, 10, 21, 10, 2, -21 },
  { 1301, 17, 21, 17, 2, -21 },
  { 1346, 13, 21, 9, -2, -21 },
  { 1381, 9, 21, 8, 2, -21 },
  { 1405, 12, 21, 9, -1, -21 },
  { 1437, 11, 26, 8, -1, -21 },
  { 1473, 4, 21, 9, 3, -21 },
  { 1484, 10, 26, 8, -2, -21 },
  { 1517, 10, 10, 11, 1, -21 },
  { 1530, 7, 1, 8, -2, 2 },
  { 1531, 3, 4, 6, 4, -22 },
  { 1533, 10, 16, 11, 1, -16 },
  { 1553, 10, 22, 11, 0, -22 },
  { 1581, 8, 16, 8, 1, -16 },
  { 1597, 11, 22, 11, 1, -22 },
  { 1628, 8, 16, 9, 1, -16 },
  { 1644, 13, 29, 5, -4, -22 },
  { 1692, 12, 23, 11, -1, -16 },
  { 1727, 10, 22, 10, 0, -22 },
  { 1755, 5, 21, 5, 0, -21 },
  { 1769, 10, 28, 5, -4, -21 },
  { 1804, 10, 22, 9, 0, -22 },
  { 1832, 6, 22, 4, 0, -22 },
  { 1849, 15, 16, 16, 0, -16 },
  { 1879, 9, 16, 10, 0, -16 },
  { 1897, 9, 16, 10, 1, -16 },
  { 1915, 11, 23, 11, -1, -16 },
  { 1947, 10, 23, 11, 1, -16 },
  { 1976, 8, 16, 7, 0, -16 },
  { 1992, 8, 16, 8, 0, -16 },
  { 2008, 6, 19, 5, 0, -19 },
  { 2023, 9, 15, 10, 1, -15 },
  { 2040, 7, 15, 8, 2, -15 },
  { 2054, 13, 15, 13, 2, -15 },
  { 2079, 10, 15, 8, -1, -15 },
  { 2098, 13, 22, 9, -3, -15 },
  { 2134, 9, 15, 7, -1, -15 },
  { 2151, 10, 26, 9, 1, -21 },
  { 2184, 1, 29, 10, 4, -22 },
  { 2188, 10, 26, 9, -2, -21 },
  { 2221, 10, 2, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC29PT7B_H_
