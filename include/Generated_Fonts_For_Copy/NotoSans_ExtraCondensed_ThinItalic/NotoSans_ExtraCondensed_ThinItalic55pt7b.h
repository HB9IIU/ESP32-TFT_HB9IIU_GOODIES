#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x18, 0x62, 0x08, 0xC1, 0x18, 0x22, 0x0C, 0x41, 0x88, 0x23,
  0x04, 0x60, 0x88, 0x31, 0x04, 0x20, 0x8C, 0x11, 0x02, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00,
  0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06,
  0x00, 0x10, 0x30, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x40, 0xC0, 0x02,
  0x04, 0x00, 0x30, 0x20, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80,
  0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81,
  0x80, 0x04, 0x08, 0x07, 0xFF, 0xFC, 0x02, 0x06, 0x00, 0x10, 0x20, 0x01,
  0x81, 0x00, 0x08, 0x18, 0x00, 0x40, 0x80, 0x06, 0x04, 0x00, 0x30, 0x60,
  0x01, 0x03, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x20,
  0x40, 0x03, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x01, 0x88, 0xE0,
  0x30, 0xC1, 0x01, 0x06, 0x00, 0x18, 0x20, 0x00, 0x81, 0x00, 0x04, 0x08,
  0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0x64, 0x00, 0x01, 0x20, 0x00, 0x0D, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x2C, 0x00, 0x01,
  0x30, 0x00, 0x18, 0x80, 0x00, 0xC6, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80,
  0x01, 0x04, 0x00, 0x18, 0x20, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x20,
  0xC0, 0x03, 0x04, 0x00, 0x18, 0x60, 0x40, 0x86, 0x03, 0xF7, 0xE0, 0x03,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x18, 0x31, 0x80,
  0x20, 0xC1, 0x00, 0xC1, 0x02, 0x01, 0x06, 0x04, 0x06, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x30, 0x60, 0x20, 0x40, 0x80, 0x41, 0x81, 0x01, 0x82, 0x06,
  0x03, 0x0C, 0x0C, 0x06, 0x10, 0x18, 0x08, 0x60, 0x20, 0x10, 0x80, 0x40,
  0x63, 0x00, 0x80, 0xC4, 0x3D, 0x01, 0x18, 0xDE, 0x06, 0x23, 0x0C, 0x0C,
  0xCC, 0x18, 0x31, 0x10, 0x30, 0x46, 0x60, 0x71, 0x88, 0x80, 0xFE, 0x31,
  0x01, 0x30, 0x46, 0x02, 0x01, 0x88, 0x04, 0x02, 0x10, 0x18, 0x0C, 0x60,
  0x30, 0x10, 0xC0, 0x60, 0x61, 0x80, 0x80, 0x82, 0x01, 0x03, 0x04, 0x06,
  0x04, 0x08, 0x0C, 0x18, 0x10, 0x10, 0x20, 0x20, 0x60, 0xC0, 0x40, 0xC1,
  0x00, 0x83, 0x06, 0x01, 0x04, 0x08, 0x03, 0x18, 0x30, 0x03, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x06, 0x10, 0x01, 0x06, 0x00,
  0xC1, 0x80, 0x20, 0x60, 0x08, 0x18, 0x06, 0x06, 0x01, 0x81, 0x00, 0x60,
  0x40, 0x18, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x61, 0x00, 0x08, 0xC0,
  0x02, 0x20, 0x00, 0x98, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x40, 0x00, 0x98, 0x00, 0x66, 0x00, 0x30, 0x81, 0x18, 0x20, 0x84, 0x0C,
  0x23, 0x03, 0x18, 0x80, 0x46, 0x60, 0x11, 0x10, 0x06, 0xC4, 0x00, 0xA3,
  0x00, 0x28, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0x40,
  0x14, 0x18, 0x09, 0x87, 0x0C, 0x20, 0xFE, 0x08, 0x04, 0x00, 0x00, 0x18,
  0x8C, 0x62, 0x10, 0x8C, 0x62, 0x10, 0x8C, 0x40, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x08, 0x20, 0x31, 0x00, 0x48, 0x61, 0xFC, 0x06, 0x00, 0x50,
  0x04, 0x40, 0xC3, 0x0C, 0x08, 0x40, 0x60, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x30, 0xC2, 0x18, 0x41, 0x0C,
  0x21, 0x04, 0x20, 0xFF, 0xFF, 0xFF, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0,
  0x0C, 0x18, 0x02, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x30, 0x20, 0x0C, 0x18,
  0x03, 0x04, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x18, 0x00,
  0xC4, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x00, 0x88, 0x00, 0x62,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x18, 0x00, 0x44, 0x00, 0x31, 0x00,
  0x0C, 0x40, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04,
  0x30, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x04, 0x0C,
  0x03, 0x03, 0x00, 0x80, 0x40, 0x60, 0x18, 0x30, 0x02, 0x18, 0x00, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x78, 0x66, 0x31, 0xB8, 0x44,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0x60, 0x10, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x80, 0x70, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0A, 0x00, 0x01, 0xA0, 0x00, 0x12,
  0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x04, 0x40, 0x00, 0xC4, 0x00, 0x08,
  0x40, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x60, 0x80, 0x04,
  0x18, 0x00, 0xC1, 0x80, 0x18, 0x10, 0x01, 0x01, 0x00, 0x30, 0x10, 0x02,
  0x03, 0x00, 0x60, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x02, 0x01,
  0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x40, 0x40, 0x04, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x41, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x08, 0x06, 0x00,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x31, 0xF0, 0x04, 0x7F, 0x80,
  0x90, 0x18, 0x14, 0x03, 0x07, 0x00, 0x20, 0xE0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x18,
  0x01, 0x83, 0x00, 0x30, 0x20, 0x0C, 0x04, 0x01, 0x80, 0xC0, 0x60, 0x0C,
  0x18, 0x00, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0xE0, 0x60,
  0x18, 0x03, 0x01, 0x80, 0x30, 0x30, 0x01, 0x03, 0x00, 0x10, 0x20, 0x01,
  0x02, 0x00, 0x10, 0x20, 0x01, 0x02, 0x00, 0x10, 0x20, 0x03, 0x03, 0x00,
  0x20, 0x30, 0x06, 0x01, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x83, 0x00, 0x0C,
  0x60, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xD8, 0x00, 0x30, 0xC0, 0x06,
  0x0C, 0x00, 0xC0, 0x60, 0x18, 0x02, 0x03, 0x00, 0x30, 0x20, 0x01, 0x06,
  0x00, 0x10, 0x40, 0x01, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x01, 0x04, 0x00, 0x30, 0x60, 0x06,
  0x03, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0xE0, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C,
  0x00, 0x81, 0x80, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x20,
  0x01, 0x8C, 0x00, 0x21, 0x80, 0x04, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80,
  0x06, 0x10, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x07, 0x0C, 0x00, 0xE1, 0x80,
  0x38, 0x18, 0x0D, 0x03, 0x03, 0x60, 0x3F, 0xCC, 0x00, 0xC1, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x20, 0xE0, 0x07, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x03, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0xE0, 0xE0, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x20, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0x01, 0x80, 0x03, 0x80, 0x30, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x20, 0x00, 0x20, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x02, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x10, 0x40, 0x00, 0x04, 0x30, 0x0F, 0xC1, 0x08,
  0x06, 0x30, 0x42, 0x02, 0x08, 0x31, 0x81, 0x82, 0x0C, 0x40, 0xC1, 0x83,
  0x10, 0x20, 0x60, 0xCC, 0x18, 0x10, 0x32, 0x04, 0x0C, 0x08, 0x81, 0x03,
  0x02, 0x20, 0xC0, 0x81, 0x98, 0x20, 0x20, 0x66, 0x08, 0x18, 0x11, 0x82,
  0x06, 0x04, 0x41, 0x81, 0x83, 0x10, 0x60, 0x40, 0xC4, 0x18, 0x30, 0x21,
  0x06, 0x0C, 0x18, 0xC1, 0x85, 0x04, 0x30, 0x61, 0x43, 0x0C, 0x18, 0xD1,
  0x83, 0x03, 0xE7, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x19, 0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x18,
  0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0x81, 0x00, 0x60, 0x40, 0x18, 0x10,
  0x04, 0x04, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x10, 0x1F, 0xFC, 0x04,
  0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04, 0x18, 0x01, 0x04, 0x00,
  0x43, 0x00, 0x10, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13,
  0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x04, 0x00,
  0xFF, 0x80, 0x06, 0x07, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x20, 0x03, 0x01, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x04, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x10,
  0x18, 0x01, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x80, 0x20, 0xF0, 0x01, 0xFE,
  0x00, 0x18, 0x1C, 0x00, 0xC0, 0x30, 0x04, 0x00, 0xC0, 0x20, 0x02, 0x03,
  0x00, 0x10, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x30, 0x20, 0x01,
  0x83, 0x00, 0x08, 0x18, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x30, 0x20,
  0x01, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0x80, 0x08, 0x04, 0x01, 0x80,
  0x20, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x0C, 0x04, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x40,
  0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x07, 0x00,
  0x08, 0x06, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x80, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x00, 0x81,
  0x80, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x40, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x06, 0x04, 0x00, 0x10, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0x60, 0x20, 0x03,
  0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x40, 0x30, 0x03,
  0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x38, 0x07, 0x00, 0x60, 0x01, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x07, 0xF0, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0xC0, 0x40, 0x00, 0x80, 0x60, 0x00, 0x80, 0x30, 0x00, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x03, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20,
  0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x04,
  0x01, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x40, 0x00,
  0x80, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x03, 0xFF, 0xFE, 0x01, 0x80,
  0x03, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0x40, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x00, 0x08, 0x02,
  0x00, 0x04, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x00,
  0x40, 0x00, 0x80, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x18, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80, 0x18, 0x02, 0x00, 0x30, 0x0C,
  0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x10, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x43, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x10, 0x00, 0x04, 0x60, 0x00, 0x09, 0x80, 0x00, 0x37,
  0x80, 0x00, 0x6B, 0x00, 0x00, 0xE2, 0x00, 0x01, 0x84, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40,
  0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x01, 0x00, 0x08, 0x02, 0x00,
  0x10, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0xA0, 0x1E, 0x00, 0x00, 0xD0, 0x0D, 0x00, 0x00, 0x78,
  0x04, 0x80, 0x00, 0x6C, 0x02, 0x40, 0x00, 0x34, 0x01, 0x20, 0x00, 0x12,
  0x01, 0x90, 0x00, 0x19, 0x00, 0xC8, 0x00, 0x09, 0x80, 0x44, 0x00, 0x0C,
  0xC0, 0x22, 0x00, 0x04, 0x40, 0x11, 0x00, 0x06, 0x20, 0x18, 0x80, 0x02,
  0x30, 0x0C, 0x40, 0x03, 0x18, 0x04, 0x20, 0x01, 0x0C, 0x02, 0x18, 0x01,
  0x84, 0x03, 0x0C, 0x00, 0x82, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x83, 0x00,
  0x41, 0x80, 0x41, 0x80, 0x60, 0x80, 0x20, 0xC0, 0x20, 0x40, 0x30, 0x60,
  0x30, 0x20, 0x18, 0x30, 0x10, 0x30, 0x08, 0x08, 0x18, 0x18, 0x04, 0x04,
  0x08, 0x08, 0x02, 0x02, 0x0C, 0x04, 0x03, 0x01, 0x06, 0x06, 0x01, 0x80,
  0x86, 0x03, 0x00, 0x80, 0x43, 0x01, 0x80, 0x40, 0x21, 0x00, 0x80, 0x60,
  0x11, 0x80, 0x40, 0x30, 0x08, 0x80, 0x60, 0x18, 0x04, 0xC0, 0x30, 0x08,
  0x03, 0x40, 0x10, 0x04, 0x01, 0xE0, 0x08, 0x06, 0x00, 0xE0, 0x04, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x0E,
  0x00, 0x0C, 0x02, 0x80, 0x02, 0x01, 0xA0, 0x00, 0x80, 0x68, 0x00, 0x60,
  0x1B, 0x00, 0x18, 0x04, 0xC0, 0x04, 0x01, 0x30, 0x01, 0x00, 0xC4, 0x00,
  0x40, 0x31, 0x00, 0x30, 0x08, 0x40, 0x0C, 0x02, 0x18, 0x02, 0x00, 0x86,
  0x00, 0x80, 0x60, 0x80, 0x60, 0x18, 0x20, 0x18, 0x04, 0x08, 0x06, 0x01,
  0x03, 0x01, 0x00, 0xC0, 0xC0, 0x40, 0x30, 0x30, 0x30, 0x0C, 0x04, 0x0C,
  0x02, 0x01, 0x03, 0x00, 0x80, 0x40, 0x80, 0x60, 0x18, 0x20, 0x18, 0x06,
  0x18, 0x04, 0x00, 0x86, 0x01, 0x00, 0x21, 0x00, 0x40, 0x08, 0x40, 0x30,
  0x03, 0x10, 0x0C, 0x00, 0xCC, 0x02, 0x00, 0x33, 0x00, 0x80, 0x04, 0x80,
  0x60, 0x01, 0x20, 0x18, 0x00, 0x78, 0x06, 0x00, 0x1E, 0x01, 0x00, 0x07,
  0x80, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x60, 0x18, 0x01,
  0x81, 0x80, 0x0C, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x08, 0x60,
  0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04,
  0xC0, 0x00, 0x26, 0x00, 0x01, 0x20, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x30, 0x00, 0x19, 0x00, 0x00,
  0xC8, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x86, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0C, 0x1C, 0x00, 0x80, 0x60, 0x08, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x03, 0x01, 0x80, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01,
  0x03, 0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x30, 0x20, 0x02, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x08, 0x0C, 0x01, 0x80, 0xC0,
  0x70, 0x0C, 0x3C, 0x00, 0xFF, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x60,
  0x18, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00,
  0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00, 0x88,
  0x00, 0x04, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x20, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x0B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x30, 0x00, 0x19,
  0x00, 0x00, 0xC8, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00,
  0x30, 0x80, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0x00, 0x0C, 0x1C, 0x00, 0x80, 0x60, 0x08, 0x02, 0x01, 0x80, 0x30, 0x18,
  0x03, 0x01, 0x80, 0x30, 0x10, 0x01, 0x01, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x20, 0x03, 0x02, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x60,
  0x60, 0x04, 0x04, 0x00, 0xC0, 0x40, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0xE0,
  0x0F, 0xFC, 0x00, 0x83, 0x00, 0x08, 0x30, 0x01, 0x83, 0x00, 0x18, 0x10,
  0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x80, 0x30, 0x18, 0x03, 0x01,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x04, 0x00, 0xC0, 0x40, 0x04, 0x0C, 0x00, 0x40, 0xC0, 0x06, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x0E, 0x01, 0xC0, 0x1F,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x10,
  0x30, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x60,
  0x00, 0x81, 0x80, 0x02, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01,
  0x03, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0xC0, 0x80, 0x03, 0x06,
  0x00, 0x08, 0x18, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00,
  0x18, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x30,
  0x20, 0x00, 0x80, 0x80, 0x06, 0x02, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x30,
  0x02, 0x00, 0x40, 0x18, 0x01, 0xC0, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01,
  0x20, 0x00, 0xC8, 0x00, 0x22, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x08,
  0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x04, 0x08, 0x03, 0x02, 0x00,
  0xC0, 0x80, 0x20, 0x20, 0x18, 0x08, 0x04, 0x02, 0x03, 0x00, 0x80, 0x80,
  0x20, 0x60, 0x08, 0x18, 0x02, 0x04, 0x00, 0x83, 0x00, 0x20, 0x80, 0x08,
  0x60, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x60,
  0x00, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xA0, 0x00, 0xE0,
  0x00, 0x90, 0x00, 0x60, 0x00, 0xC8, 0x00, 0x30, 0x00, 0x44, 0x00, 0x38,
  0x00, 0x62, 0x00, 0x14, 0x00, 0x31, 0x00, 0x1A, 0x00, 0x11, 0x80, 0x09,
  0x00, 0x18, 0xC0, 0x04, 0x80, 0x08, 0x60, 0x06, 0x40, 0x0C, 0x30, 0x02,
  0x20, 0x06, 0x18, 0x03, 0x10, 0x02, 0x0C, 0x01, 0x88, 0x03, 0x06, 0x00,
  0x84, 0x01, 0x03, 0x00, 0xC2, 0x01, 0x81, 0x80, 0x41, 0x00, 0xC0, 0xC0,
  0x60, 0x80, 0x40, 0x60, 0x30, 0x40, 0x60, 0x30, 0x10, 0x20, 0x20, 0x18,
  0x18, 0x10, 0x30, 0x0C, 0x08, 0x08, 0x10, 0x06, 0x04, 0x0C, 0x08, 0x03,
  0x06, 0x06, 0x0C, 0x01, 0x82, 0x03, 0x04, 0x00, 0xC3, 0x01, 0x86, 0x00,
  0x61, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x61, 0x00, 0x18, 0xC0, 0x31, 0x80,
  0x0C, 0x40, 0x18, 0x80, 0x06, 0x60, 0x0C, 0xC0, 0x03, 0x20, 0x06, 0x40,
  0x01, 0x90, 0x02, 0x20, 0x00, 0xD8, 0x01, 0x30, 0x00, 0x68, 0x00, 0x90,
  0x00, 0x2C, 0x00, 0x58, 0x00, 0x16, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x20, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x20,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30, 0x00, 0x30, 0x20, 0x00, 0x30,
  0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x11,
  0x80, 0x00, 0x11, 0x00, 0x00, 0x13, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x06, 0x04, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x10, 0x06, 0x00, 0x30, 0x06, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x40, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x00, 0xC8, 0x00, 0x62,
  0x00, 0x30, 0x80, 0x0C, 0x20, 0x06, 0x08, 0x01, 0x83, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x18, 0x0C, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x60,
  0x04, 0x10, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01,
  0xB0, 0x00, 0x68, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x02,
  0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10,
  0x20, 0x40, 0xC1, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x58, 0x00, 0x0D, 0x80, 0x00, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x04, 0x00, 0x30, 0x60, 0x02, 0x02, 0x00, 0x60, 0x30, 0x0C,
  0x01, 0x00, 0xC0, 0x18, 0x18, 0x00, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x43,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xFC,
  0xC6, 0x10, 0xC2, 0x08, 0x41, 0x08, 0x00, 0xFC, 0x40, 0xE1, 0x90, 0x60,
  0x24, 0x10, 0x07, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x88, 0x00, 0x46, 0x00, 0x11, 0x80, 0x0C, 0x40, 0x03, 0x30,
  0x00, 0x8C, 0x00, 0x23, 0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00,
  0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x01, 0xC2, 0x00, 0x60,
  0x80, 0x38, 0x30, 0x0A, 0x0C, 0x05, 0x81, 0x83, 0x60, 0x3F, 0x10, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x7F, 0x00,
  0xD8, 0x70, 0x16, 0x06, 0x02, 0x80, 0x60, 0xE0, 0x0C, 0x1C, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x02, 0x08, 0x00, 0x43, 0x00, 0x18, 0x60, 0x03, 0x08,
  0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20,
  0x01, 0x84, 0x00, 0x30, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x04, 0x18, 0x01, 0x87, 0x00, 0x20, 0xE0, 0x0C, 0x14, 0x03, 0x02, 0xC0,
  0x40, 0x4C, 0x38, 0x18, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x0E,
  0x10, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x10, 0x3F, 0x80,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x7E, 0x20, 0x0E, 0x19, 0x00, 0xC0, 0x58, 0x04, 0x01, 0xC0, 0x60,
  0x0C, 0x06, 0x00, 0x60, 0x20, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x80, 0x04, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00,
  0x81, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x18, 0x10,
  0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20, 0x03, 0x01, 0x00, 0x38,
  0x08, 0x01, 0x80, 0x40, 0x14, 0x03, 0x00, 0xA0, 0x18, 0x0B, 0x00, 0x61,
  0x98, 0x01, 0xF8, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x01, 0x86, 0x03,
  0x03, 0x06, 0x03, 0x04, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x10,
  0x02, 0x30, 0x06, 0x30, 0x0C, 0x20, 0x18, 0x60, 0x70, 0x63, 0xE0, 0x7F,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x30, 0x1F, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x72, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x9C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x88, 0x03, 0x86, 0x40, 0x30, 0x12,
  0x01, 0x00, 0x70, 0x18, 0x03, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00,
  0xC0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08,
  0x00, 0xC0, 0x40, 0x0E, 0x02, 0x00, 0x60, 0x10, 0x07, 0x00, 0xC0, 0x68,
  0x06, 0x02, 0xC0, 0x18, 0x74, 0x00, 0x7E, 0x20, 0x00, 0x81, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x04,
  0x00, 0xE1, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xCF, 0xE0, 0x36, 0x18, 0x0B, 0x03, 0x03, 0x80, 0x40, 0xC0, 0x10,
  0x70, 0x04, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x08, 0x30,
  0x02, 0x0C, 0x01, 0x82, 0x00, 0x60, 0x80, 0x10, 0x60, 0x04, 0x18, 0x01,
  0x04, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x08, 0x30, 0x02, 0x0C, 0x01, 0x82,
  0x00, 0x60, 0x80, 0x10, 0x20, 0x04, 0x18, 0x01, 0x06, 0x00, 0xC1, 0x00,
  0x30, 0x40, 0x08, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x09,
  0xC0, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x30,
  0x30, 0x08, 0x08, 0x04, 0x02, 0x03, 0x01, 0x81, 0x80, 0x60, 0x40, 0x18,
  0x20, 0x04, 0x18, 0x01, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x08, 0xC0,
  0x02, 0x70, 0x00, 0xB4, 0x00, 0x69, 0x00, 0x1C, 0x60, 0x07, 0x18, 0x01,
  0x86, 0x00, 0x40, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x02, 0x03, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x00, 0x03, 0x3F, 0x0F, 0xE0, 0x26, 0x19, 0x83, 0x02, 0x80, 0xB0, 0x10,
  0x30, 0x0E, 0x01, 0x07, 0x00, 0xC0, 0x10, 0x60, 0x0C, 0x01, 0x06, 0x00,
  0xC0, 0x10, 0x60, 0x08, 0x03, 0x04, 0x00, 0x80, 0x30, 0xC0, 0x18, 0x02,
  0x0C, 0x01, 0x80, 0x20, 0xC0, 0x10, 0x02, 0x08, 0x01, 0x00, 0x60, 0x80,
  0x30, 0x06, 0x18, 0x03, 0x00, 0x41, 0x80, 0x30, 0x04, 0x10, 0x02, 0x00,
  0x41, 0x00, 0x20, 0x0C, 0x10, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x08, 0x30,
  0x04, 0x00, 0x82, 0x00, 0x40, 0x18, 0x20, 0x04, 0x01, 0x86, 0x00, 0xC0,
  0x18, 0x60, 0x0C, 0x01, 0x06, 0x00, 0x80, 0x10, 0x40, 0x08, 0x03, 0x04,
  0x01, 0x80, 0x30, 0xC0, 0x18, 0x02, 0x00, 0x03, 0x3F, 0x80, 0x98, 0x60,
  0x2C, 0x0C, 0x0E, 0x01, 0x07, 0x00, 0x41, 0x80, 0x30, 0x60, 0x0C, 0x18,
  0x03, 0x04, 0x00, 0x83, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x06, 0x08, 0x01,
  0x82, 0x00, 0x41, 0x80, 0x10, 0x60, 0x0C, 0x10, 0x03, 0x04, 0x00, 0xC1,
  0x00, 0x20, 0xC0, 0x08, 0x30, 0x06, 0x08, 0x01, 0x82, 0x00, 0x41, 0x80,
  0x10, 0x60, 0x04, 0x18, 0x03, 0x04, 0x00, 0xC1, 0x00, 0x20, 0xC0, 0x08,
  0x00, 0x01, 0xFC, 0x03, 0x06, 0x06, 0x02, 0x0C, 0x03, 0x08, 0x03, 0x18,
  0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x60, 0x01, 0x60,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x10, 0xC0, 0x30, 0xC0, 0x60, 0x60, 0xC0, 0x3F, 0x80, 0x04,
  0x00, 0x00, 0xCF, 0xE0, 0x04, 0xC3, 0x80, 0x2C, 0x0C, 0x01, 0x40, 0x30,
  0x0C, 0x01, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x20, 0x30, 0x01, 0x01, 0x80,
  0x08, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x81,
  0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x02, 0x04, 0x00, 0x30, 0x20, 0x01,
  0x81, 0x00, 0x08, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x30,
  0x03, 0x01, 0x80, 0x10, 0x1C, 0x01, 0x80, 0xE0, 0x18, 0x05, 0x81, 0x80,
  0x26, 0x18, 0x03, 0x1F, 0x80, 0x18, 0x20, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x40, 0xC1, 0x90, 0x60, 0x24, 0x30,
  0x0F, 0x08, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01,
  0x88, 0x00, 0x46, 0x00, 0x11, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0x8C,
  0x00, 0x23, 0x00, 0x08, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x01, 0xC2, 0x00, 0x60, 0x80, 0x38,
  0x30, 0x0A, 0x0C, 0x05, 0x81, 0x83, 0x60, 0x3F, 0x10, 0x02, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x03, 0x3E, 0x04, 0xC0, 0x0B, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0x01, 0x81, 0xC1, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x18, 0x1C, 0x0F, 0xF8, 0x00,
  0x20, 0x00, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0xFF,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xE0, 0x10,
  0x00, 0x06, 0x00, 0x41, 0x80, 0x30, 0x40, 0x0C, 0x10, 0x02, 0x0C, 0x00,
  0x83, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x08, 0x01, 0x06, 0x00, 0x41,
  0x80, 0x30, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x20, 0xC0,
  0x18, 0x20, 0x06, 0x08, 0x01, 0x06, 0x00, 0x41, 0x80, 0x30, 0x40, 0x0C,
  0x10, 0x03, 0x04, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x04,
  0x07, 0x81, 0x83, 0x40, 0x3F, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x07, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x10,
  0xC0, 0x61, 0x80, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x30,
  0x40, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0,
  0x19, 0x00, 0x36, 0x00, 0x68, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xB0, 0x07,
  0x00, 0xD8, 0x03, 0x80, 0x4C, 0x03, 0xC0, 0x26, 0x01, 0x60, 0x33, 0x00,
  0xB0, 0x11, 0x80, 0xD8, 0x18, 0xC0, 0x4C, 0x08, 0x60, 0x66, 0x04, 0x30,
  0x23, 0x06, 0x18, 0x11, 0x82, 0x0C, 0x18, 0xC1, 0x06, 0x08, 0x61, 0x83,
  0x0C, 0x30, 0x81, 0x84, 0x10, 0xC0, 0xC2, 0x08, 0x40, 0x63, 0x04, 0x20,
  0x31, 0x02, 0x30, 0x19, 0x81, 0x10, 0x0C, 0x80, 0x98, 0x06, 0xC0, 0x48,
  0x03, 0x40, 0x24, 0x01, 0xA0, 0x16, 0x00, 0xF0, 0x0A, 0x00, 0x70, 0x05,
  0x00, 0x38, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x20, 0x20, 0x0C, 0x04, 0x03, 0x00, 0x80, 0x40, 0x18, 0x18, 0x03,
  0x02, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x19, 0x80, 0x03,
  0x20, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x41,
  0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0xC0, 0x80, 0x30, 0x18, 0x04, 0x03,
  0x01, 0x80, 0x20, 0x20, 0x04, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x03, 0x00, 0x60,
  0x00, 0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x10, 0x08,
  0x00, 0x08, 0x0C, 0x00, 0x04, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10,
  0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00, 0x02, 0x20, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1C,
  0x0C, 0x0E, 0x01, 0xFE, 0x80, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 39, 11, 1, -39 },
  { 50, 11, 14, 14, 5, -39 },
  { 70, 21, 39, 20, 0, -39 },
  { 173, 21, 45, 19, -1, -42 },
  { 292, 23, 41, 29, 3, -40 },
  { 410, 18, 41, 18, -1, -40 },
  { 503, 5, 14, 8, 5, -39 },
  { 512, 15, 48, 13, 1, -39 },
  { 602, 15, 48, 13, -4, -39 },
  { 692, 13, 15, 17, 7, -42 },
  { 717, 18, 25, 22, 2, -32 },
  { 774, 6, 12, 9, -2, -5 },
  { 783, 12, 2, 14, 1, -16 },
  { 786, 2, 4, 8, 1, -4 },
  { 787, 22, 39, 16, -2, -39 },
  { 895, 18, 41, 19, 1, -40 },
  { 988, 10, 39, 19, 6, -39 },
  { 1037, 21, 40, 19, -2, -40 },
  { 1142, 20, 41, 19, -1, -40 },
  { 1245, 20, 40, 19, -1, -40 },
  { 1345, 20, 40, 19, -1, -39 },
  { 1445, 19, 41, 19, 1, -40 },
  { 1543, 19, 39, 19, 2, -39 },
  { 1636, 20, 41, 19, -1, -40 },
  { 1739, 19, 41, 19, 0, -40 },
  { 1837, 8, 29, 8, 0, -29 },
  { 1866, 10, 36, 9, -2, -29 },
  { 1911, 18, 23, 22, 2, -31 },
  { 1963, 18, 13, 22, 2, -26 },
  { 1993, 18, 23, 22, 2, -31 },
  { 2045, 15, 40, 13, 1, -40 },
  { 2120, 26, 44, 28, 1, -39 },
  { 2263, 18, 39, 18, -4, -39 },
  { 2351, 21, 39, 21, 0, -39 },
  { 2454, 21, 41, 19, 2, -40 },
  { 2562, 22, 39, 23, 0, -39 },
  { 2670, 21, 39, 19, 0, -39 },
  { 2773, 21, 39, 17, 0, -39 },
  { 2876, 24, 41, 25, 2, -40 },
  { 2999, 25, 39, 24, 0, -39 },
  { 3121, 16, 39, 9, -3, -39 },
  { 3199, 18, 48, 8, -8, -39 },
  { 3307, 23, 39, 19, 0, -39 },
  { 3420, 12, 39, 17, 0, -39 },
  { 3479, 33, 39, 32, 0, -39 },
  { 3640, 26, 39, 25, 0, -39 },
  { 3767, 21, 41, 24, 2, -40 },
  { 3875, 20, 39, 19, 0, -39 },
  { 3973, 21, 49, 24, 2, -40 },
  { 4102, 20, 39, 20, 0, -39 },
  { 4200, 22, 41, 19, -2, -40 },
  { 4313, 16, 39, 16, 4, -39 },
  { 4391, 22, 40, 23, 2, -39 },
  { 4501, 18, 39, 19, 5, -39 },
  { 4589, 33, 39, 33, 4, -39 },
  { 4750, 24, 39, 17, -3, -39 },
  { 4867, 18, 39, 16, 3, -39 },
  { 4955, 22, 39, 17, -2, -39 },
  { 5063, 19, 48, 15, -1, -39 },
  { 5177, 7, 39, 18, 6, -39 },
  { 5212, 19, 48, 15, -3, -39 },
  { 5326, 20, 19, 22, 1, -39 },
  { 5374, 14, 1, 14, -4, 5 },
  { 5376, 5, 9, 11, 8, -42 },
  { 5382, 18, 30, 21, 2, -29 },
  { 5450, 19, 43, 20, 0, -42 },
  { 5553, 14, 30, 15, 2, -29 },
  { 5606, 21, 43, 21, 2, -42 },
  { 5719, 16, 30, 18, 1, -29 },
  { 5779, 24, 55, 10, -7, -42 },
  { 5944, 21, 42, 21, -1, -29 },
  { 6055, 18, 42, 20, 0, -42 },
  { 6150, 10, 39, 9, 0, -39 },
  { 6199, 18, 52, 9, -7, -39 },
  { 6316, 18, 42, 16, 0, -42 },
  { 6411, 11, 42, 8, 0, -42 },
  { 6469, 28, 29, 30, 0, -29 },
  { 6571, 18, 29, 20, 0, -29 },
  { 6637, 16, 30, 20, 2, -29 },
  { 6697, 21, 42, 21, -2, -29 },
  { 6808, 18, 42, 21, 2, -29 },
  { 6903, 15, 29, 13, 0, -29 },
  { 6958, 17, 30, 15, -1, -29 },
  { 7022, 10, 37, 10, 1, -36 },
  { 7069, 18, 30, 20, 1, -29 },
  { 7137, 15, 29, 15, 3, -29 },
  { 7192, 25, 29, 25, 3, -29 },
  { 7283, 19, 29, 16, -2, -29 },
  { 7352, 25, 42, 16, -6, -29 },
  { 7484, 16, 29, 13, -2, -29 },
  { 7542, 18, 48, 17, 2, -39 },
  { 7650, 1, 55, 19, 9, -42 },
  { 7657, 19, 48, 17, -4, -39 },
  { 7771, 18, 5, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC55PT7B_H_
