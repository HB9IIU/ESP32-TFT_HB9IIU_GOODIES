#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0x68, 0x69, 0x2C, 0xFB, 0xBE, 0x7B, 0xC0, 0xC0,
  0x6A, 0xA0, 0xFC, 0xD0, 0x5D, 0x00, 0xC0, 0xC0, 0x00, 0x29, 0x48, 0x7F,
  0xC0, 0xF8, 0x56, 0xC0, 0x55, 0xC0, 0x5F, 0x40, 0xE5, 0xC0, 0x73, 0x6C,
  0x69, 0x28, 0xF7, 0xC0, 0xFD, 0xC0, 0x80, 0x98, 0x71, 0x80, 0xE0, 0xC7,
  0x00, 0x5A, 0x00, 0x77, 0xDC, 0x80, 0x5F, 0xC0, 0x77, 0x5C, 0x72, 0x4C,
  0x76, 0xDC, 0x73, 0x4C, 0x73, 0x48, 0x72, 0x5E, 0x77, 0xDA, 0x6A, 0x80,
  0x55, 0x60, 0x7A, 0x6C, 0x6A, 0xC0, 0x59, 0x9F, 0xD0, 0x6F, 0xDA, 0x76,
  0xDC, 0x57, 0x48, 0x76, 0xDC, 0x80, 0x57, 0x6C, 0xF1, 0x2C, 0x69, 0x48,
  0x76, 0xDC, 0xEA, 0x80, 0xDE, 0xEC, 0xC0, 0xA9, 0x4C, 0xBA, 0x48, 0x69,
  0x4C, 0x6A, 0xA0, 0xF8, 0x55, 0xA0, 0x54, 0xC0, 0x80, 0x76, 0xE0, 0x7F,
  0xC0, 0x6A, 0x2E, 0xDC, 0x7B, 0x2D, 0x24, 0xA0, 0x76, 0xE5, 0x00, 0x7F,
  0xC0, 0xF8, 0x55, 0x58, 0x7A, 0xC0, 0xF8, 0xFB, 0xDE, 0xFF, 0x7F, 0xFF,
  0xA0, 0x76, 0xE4, 0x80, 0xEA, 0xE7, 0xF8, 0xFF, 0xFA, 0xDE, 0xAC, 0xEA,
  0x6D, 0x25, 0x00, 0x5A, 0x69, 0x49, 0x00, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 1, 2, 2, 1, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 2, 0, -5 },
  { 7, 3, 5, 4, 0, -5 },
  { 9, 2, 5, 2, 0, -5 },
  { 11, 1, 2, 1, 0, -5 },
  { 12, 2, 6, 2, 0, -5 },
  { 14, 1, 6, 2, 0, -5 },
  { 15, 2, 2, 2, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 3, 5, 2, 0, -5 },
  { 23, 2, 5, 2, 0, -5 },
  { 25, 1, 5, 2, 1, -5 },
  { 26, 2, 5, 2, 0, -5 },
  { 28, 2, 5, 2, 0, -5 },
  { 30, 2, 5, 2, 0, -5 },
  { 32, 2, 5, 2, 0, -5 },
  { 34, 3, 5, 2, 0, -5 },
  { 36, 3, 5, 2, 0, -5 },
  { 38, 2, 5, 2, 0, -5 },
  { 40, 2, 5, 2, 0, -5 },
  { 42, 1, 4, 1, 0, -4 },
  { 43, 1, 5, 1, 0, -4 },
  { 44, 3, 3, 3, 0, -4 },
  { 46, 3, 1, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 2, 5, 2, 0, -5 },
  { 51, 3, 6, 4, 0, -5 },
  { 54, 2, 5, 2, 0, -5 },
  { 56, 3, 5, 3, 0, -5 },
  { 58, 3, 5, 2, 0, -5 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 3, 5, 2, 0, -5 },
  { 64, 3, 5, 2, 0, -5 },
  { 66, 3, 5, 3, 0, -5 },
  { 68, 3, 5, 3, 0, -5 },
  { 70, 2, 5, 1, 0, -5 },
  { 72, 2, 6, 1, -1, -5 },
  { 74, 3, 5, 2, 0, -5 },
  { 76, 2, 5, 2, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 3, 5, 3, 0, -5 },
  { 83, 3, 5, 3, 0, -5 },
  { 85, 3, 5, 2, 0, -5 },
  { 87, 3, 6, 3, 0, -5 },
  { 90, 3, 5, 3, 0, -5 },
  { 92, 3, 5, 2, 0, -5 },
  { 94, 3, 5, 2, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 2, 5, 2, 1, -5 },
  { 100, 4, 5, 4, 1, -5 },
  { 103, 3, 5, 2, 0, -5 },
  { 105, 3, 5, 2, 0, -5 },
  { 107, 3, 5, 2, 0, -5 },
  { 109, 2, 6, 2, 0, -5 },
  { 111, 1, 5, 2, 1, -5 },
  { 112, 2, 6, 2, 0, -5 },
  { 114, 3, 2, 3, 0, -5 },
  { 115, 2, 1, 2, -1, 0 },
  { 116, 1, 1, 1, 1, -5 },
  { 117, 3, 4, 3, 0, -4 },
  { 119, 2, 5, 3, 0, -5 },
  { 121, 2, 4, 2, 0, -4 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 2, 4, 2, 0, -4 },
  { 125, 3, 7, 1, -1, -5 },
  { 128, 3, 6, 3, 0, -4 },
  { 131, 2, 5, 3, 0, -5 },
  { 133, 1, 5, 1, 0, -5 },
  { 134, 2, 7, 1, -1, -5 },
  { 136, 2, 5, 2, 0, -5 },
  { 138, 1, 5, 1, 0, -5 },
  { 139, 4, 4, 4, 0, -4 },
  { 141, 2, 4, 3, 0, -4 },
  { 142, 2, 4, 3, 0, -4 },
  { 143, 2, 6, 3, 0, -4 },
  { 145, 3, 6, 3, 0, -4 },
  { 148, 2, 4, 2, 0, -4 },
  { 149, 2, 4, 2, 0, -4 },
  { 150, 1, 5, 1, 0, -5 },
  { 151, 2, 4, 3, 0, -4 },
  { 152, 2, 4, 2, 0, -4 },
  { 153, 4, 4, 3, 0, -4 },
  { 155, 2, 4, 2, 0, -4 },
  { 156, 3, 6, 2, -1, -4 },
  { 159, 2, 4, 2, 0, -4 },
  { 160, 3, 6, 2, 0, -5 },
  { 163, 1, 7, 2, 1, -5 },
  { 164, 2, 6, 2, 0, -5 },
  { 166, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC7PT7B_H_
