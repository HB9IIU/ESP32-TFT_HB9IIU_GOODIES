#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x00, 0x00, 0x43, 0x00, 0x45, 0x14, 0x92, 0x8A, 0x28, 0xA4,
  0x01, 0x10, 0x22, 0x02, 0x20, 0x22, 0x04, 0x40, 0x44, 0x3F, 0xF0, 0x84,
  0x08, 0x80, 0x88, 0x08, 0x81, 0x10, 0x11, 0x01, 0x10, 0xFF, 0xC2, 0x20,
  0x22, 0x04, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x80, 0x00, 0x80, 0x10,
  0x04, 0x03, 0xE0, 0x92, 0x22, 0x04, 0x81, 0x10, 0x22, 0x02, 0x40, 0x48,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x28, 0x08, 0x81, 0x10, 0x22, 0x04,
  0x41, 0x11, 0x24, 0x1F, 0x00, 0x80, 0x10, 0x04, 0x00, 0x1E, 0x08, 0x88,
  0x42, 0x21, 0x08, 0x88, 0x42, 0x21, 0x09, 0x04, 0x24, 0x10, 0xA0, 0x84,
  0x92, 0x14, 0xB8, 0x54, 0x62, 0x91, 0x52, 0x84, 0x92, 0x10, 0x48, 0x42,
  0x22, 0x09, 0x08, 0x44, 0x21, 0x10, 0x88, 0x44, 0x21, 0x11, 0x03, 0x80,
  0x07, 0x84, 0x42, 0x21, 0x10, 0x88, 0x88, 0x24, 0x14, 0x0A, 0x06, 0x02,
  0x02, 0x82, 0x42, 0x26, 0x13, 0x05, 0x83, 0x41, 0xA0, 0x90, 0x48, 0x53,
  0xC8, 0x55, 0xAA, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x10, 0x23, 0x41,
  0xF3, 0x09, 0x22, 0x02, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x43, 0xFF, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x24, 0xA5,
  0x20, 0xFC, 0x70, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x07, 0x82, 0x21, 0x04, 0x41, 0x20, 0x48, 0x14, 0x05, 0x02, 0x40, 0x90,
  0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x82, 0x20, 0x88, 0x22,
  0x10, 0x88, 0x1C, 0x00, 0x0C, 0x62, 0x92, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x00, 0x0F, 0xC0, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x0F, 0xF0, 0x07, 0xE0, 0x82, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x0F, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x0F, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0A, 0x01, 0x20, 0x12,
  0x02, 0x40, 0x24, 0x04, 0x40, 0x84, 0x08, 0x41, 0x08, 0x10, 0x82, 0x08,
  0x40, 0x84, 0x10, 0xFF, 0xC0, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x07, 0xF0, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x0F, 0xC0, 0x07, 0xC2, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x4C, 0x14, 0x8A, 0x13, 0x04,
  0x80, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0x84, 0x1E,
  0x00, 0x3F, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x00, 0x07, 0xC1, 0x04, 0x40,
  0x88, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x08, 0x81, 0x60, 0x30, 0x09,
  0x02, 0x10, 0x82, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x88,
  0x10, 0xFC, 0x00, 0x07, 0x82, 0x11, 0x04, 0x41, 0x20, 0x48, 0x12, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x0C, 0x83, 0x1F, 0x40, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x04, 0x3E, 0x00, 0x18, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x10, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x82, 0x08, 0x41, 0x08, 0x20, 0x00, 0x40, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0x0C, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00,
  0x1F, 0x00, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x00, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x01, 0xF0, 0x18, 0x20, 0x80, 0x42, 0x01, 0x10, 0x04, 0x80, 0x12,
  0x1E, 0x48, 0x89, 0x44, 0x45, 0x11, 0x14, 0x84, 0x62, 0x11, 0x88, 0x8A,
  0x22, 0x28, 0x88, 0xA2, 0x64, 0x89, 0x92, 0x2A, 0x88, 0x44, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x80, 0x1C, 0x00, 0x00, 0x40, 0x30,
  0x0C, 0x05, 0x01, 0x40, 0x50, 0x24, 0x09, 0x04, 0x41, 0x10, 0x44, 0x21,
  0x0F, 0xC4, 0x11, 0x04, 0x81, 0x20, 0x48, 0x14, 0x05, 0x01, 0x80, 0x60,
  0x10, 0x07, 0xC0, 0x82, 0x08, 0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x21,
  0x02, 0x10, 0x41, 0x08, 0x1F, 0x02, 0x08, 0x20, 0x42, 0x04, 0x20, 0x44,
  0x04, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x83, 0x0F, 0xC0, 0x03, 0xF0,
  0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x03, 0xE0, 0x07, 0xC0, 0x82, 0x08, 0x10,
  0x81, 0x08, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x22, 0x02, 0x20, 0x24, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84,
  0x10, 0x86, 0x0F, 0x80, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0x82, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x03, 0xF8, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x03, 0xFC,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x3C, 0x80, 0x22, 0x00, 0x88, 0x02,
  0x20, 0x08, 0x80, 0x22, 0x01, 0x08, 0x04, 0x10, 0x10, 0x60, 0x40, 0xFE,
  0x00, 0x04, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x40, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x41, 0xFF, 0x08, 0x04, 0x20, 0x20,
  0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x20, 0x10,
  0x80, 0x42, 0x01, 0x00, 0x07, 0x81, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x07, 0xC0, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x0E, 0x00, 0x04, 0x18, 0x40, 0x82, 0x08, 0x10, 0x80, 0x84, 0x08,
  0x40, 0x44, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x0B, 0x00, 0x68, 0x02, 0x20,
  0x11, 0x00, 0x88, 0x08, 0x40, 0x42, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08,
  0x10, 0x40, 0x40, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x1F, 0xC0, 0x04,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x14, 0x28,
  0x02, 0x85, 0x00, 0xA0, 0xA0, 0x14, 0x12, 0x04, 0x82, 0x40, 0x90, 0x88,
  0x24, 0x11, 0x04, 0x82, 0x21, 0x10, 0x44, 0x22, 0x08, 0x88, 0x42, 0x11,
  0x10, 0x42, 0x42, 0x08, 0x48, 0x41, 0x0A, 0x08, 0x41, 0x41, 0x08, 0x30,
  0x41, 0x06, 0x08, 0x00, 0x04, 0x02, 0x18, 0x08, 0x30, 0x10, 0x50, 0x20,
  0xA0, 0x42, 0x40, 0x84, 0x82, 0x09, 0x04, 0x12, 0x08, 0x22, 0x10, 0x84,
  0x21, 0x08, 0x82, 0x11, 0x04, 0x22, 0x08, 0x24, 0x20, 0x50, 0x40, 0xA0,
  0x81, 0x41, 0x02, 0x82, 0x05, 0x08, 0x04, 0x10, 0x08, 0x00, 0x03, 0xE0,
  0xC1, 0x08, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x04, 0x80, 0x88, 0x10, 0x41, 0x03, 0xE0, 0x07, 0xC1, 0x0C, 0x20, 0x84,
  0x10, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10, 0x22, 0x08, 0x82, 0x11, 0x83,
  0xC0, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x00, 0x03, 0xE0, 0xC1, 0x08, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x10, 0x41, 0x03, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x07, 0xC1, 0x0C, 0x20, 0x84,
  0x10, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0x82, 0x1F, 0x82,
  0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x88, 0x11,
  0x02, 0x00, 0x03, 0xF0, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x0F, 0xE0, 0x7F,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x00, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10,
  0x08, 0x80, 0x84, 0x04, 0x20, 0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04,
  0x20, 0x22, 0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x02, 0x08,
  0x20, 0x3E, 0x00, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x22,
  0x08, 0x82, 0x21, 0x08, 0x42, 0x20, 0x88, 0x24, 0x09, 0x02, 0x40, 0xA0,
  0x28, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x80, 0x40, 0x30, 0x08, 0x0A,
  0x03, 0x01, 0x40, 0x60, 0x48, 0x14, 0x09, 0x02, 0x81, 0x20, 0x50, 0x44,
  0x12, 0x08, 0x82, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x22, 0x08,
  0x84, 0x41, 0x10, 0x90, 0x24, 0x12, 0x04, 0x82, 0x40, 0x90, 0x50, 0x14,
  0x0A, 0x02, 0x81, 0x80, 0x50, 0x30, 0x0C, 0x04, 0x01, 0x80, 0x80, 0x00,
  0x02, 0x0C, 0x08, 0x20, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x24,
  0x00, 0xA0, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x05, 0x00, 0x14,
  0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x42, 0x02, 0x08, 0x08, 0x20, 0x40,
  0x82, 0x02, 0x00, 0x40, 0xD0, 0x24, 0x11, 0x04, 0x42, 0x10, 0x84, 0x41,
  0x10, 0x48, 0x12, 0x05, 0x01, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xF0, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x0F, 0xF0, 0x03, 0xE0, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x03, 0xF0, 0x00, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22,
  0x22, 0x22, 0x11, 0x11, 0x11, 0x03, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x83, 0xE0, 0x00, 0x04, 0x01, 0x40, 0x28, 0x08,
  0x81, 0x10, 0x41, 0x08, 0x22, 0x02, 0x40, 0x50, 0x0C, 0xFF, 0xA9, 0x40,
  0x06, 0x02, 0x71, 0x0C, 0x81, 0x20, 0x50, 0x24, 0x09, 0x02, 0x80, 0xA0,
  0x28, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x32, 0x18, 0x7A, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x48, 0x16, 0x43, 0x08,
  0x60, 0x88, 0x11, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x48, 0x09, 0x01,
  0x20, 0x44, 0x08, 0x82, 0x28, 0x45, 0xF0, 0x07, 0x09, 0x10, 0x20, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x62,
  0x09, 0xC1, 0x0C, 0x20, 0x42, 0x04, 0x40, 0x84, 0x08, 0x40, 0x88, 0x08,
  0x80, 0x88, 0x10, 0x81, 0x08, 0x10, 0x83, 0x08, 0x30, 0x86, 0x07, 0xA0,
  0x02, 0x04, 0x84, 0x24, 0x14, 0x12, 0x09, 0x09, 0x0C, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x18, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x03, 0xE0, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x27, 0x04, 0x30, 0x81, 0x08, 0x11, 0x02, 0x10, 0x21, 0x02, 0x20,
  0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x42, 0x0C, 0x20, 0xC2, 0x18, 0x1E,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x0F, 0xC0, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x2E, 0x14, 0x46, 0x11,
  0x04, 0x41, 0x10, 0x48, 0x12, 0x08, 0x82, 0x20, 0x90, 0x24, 0x09, 0x04,
  0x41, 0x10, 0x48, 0x12, 0x04, 0x04, 0x30, 0x00, 0x00, 0x01, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0xE0, 0x00, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x44, 0x21,
  0x10, 0x48, 0x12, 0x09, 0x02, 0xC0, 0xD0, 0x34, 0x09, 0x04, 0x41, 0x08,
  0x42, 0x10, 0x88, 0x22, 0x08, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x03,
  0x04, 0x14, 0xD3, 0x18, 0x61, 0x10, 0x41, 0x10, 0x41, 0x10, 0x41, 0x20,
  0x82, 0x20, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x41, 0x04, 0x41,
  0x04, 0x41, 0x04, 0x41, 0x04, 0x82, 0x04, 0x82, 0x08, 0x03, 0x85, 0x11,
  0x84, 0x41, 0x10, 0x44, 0x12, 0x04, 0x82, 0x20, 0x88, 0x24, 0x09, 0x02,
  0x41, 0x10, 0x44, 0x12, 0x04, 0x81, 0x00, 0x02, 0x0C, 0x84, 0x24, 0x14,
  0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x0A, 0x09,
  0x08, 0x78, 0x00, 0x00, 0xC0, 0xB2, 0x0C, 0x20, 0xC1, 0x08, 0x10, 0x81,
  0x10, 0x11, 0x01, 0x10, 0x21, 0x02, 0x10, 0x22, 0x02, 0x20, 0x42, 0x04,
  0x20, 0x85, 0x08, 0x5F, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x02, 0x02, 0x71, 0x0C, 0x83, 0x20, 0x50, 0x24, 0x09,
  0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x32, 0x18, 0x7A,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x03, 0x8A, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x00, 0x06, 0x02, 0x31, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x20,
  0x08, 0xFC, 0x00, 0x08, 0x20, 0x84, 0x3C, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x1C, 0x20, 0x48, 0x22, 0x08, 0x82, 0x40,
  0x90, 0x24, 0x11, 0x04, 0x41, 0x20, 0x48, 0x12, 0x08, 0x82, 0x21, 0x88,
  0x63, 0xE8, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x88, 0x90, 0x90,
  0xA0, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x82, 0x0E, 0x08, 0x28, 0x50, 0xA1,
  0x44, 0x86, 0x12, 0x28, 0x88, 0xA2, 0x24, 0x88, 0x92, 0x42, 0x89, 0x0A,
  0x24, 0x28, 0xA0, 0xC2, 0x83, 0x0C, 0x08, 0x30, 0x20, 0x80, 0x18, 0x61,
  0x08, 0x22, 0x04, 0x40, 0x90, 0x14, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x48, 0x11, 0x02, 0x20, 0x84, 0x10, 0x84, 0x08, 0x02, 0x06, 0x04, 0x08,
  0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x01, 0x10, 0x02,
  0x20, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x24, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x01,
  0xE0, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x03, 0x01, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x30, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x0E, 0x00, 0x78, 0x61, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 22, 6, 0, -22 },
  { 18, 6, 8, 8, 3, -22 },
  { 24, 12, 22, 11, 0, -22 },
  { 57, 11, 26, 11, 0, -24 },
  { 93, 14, 22, 16, 1, -22 },
  { 132, 9, 22, 10, 0, -22 },
  { 157, 2, 8, 4, 3, -22 },
  { 159, 8, 27, 7, 1, -22 },
  { 186, 8, 27, 8, -2, -22 },
  { 213, 7, 8, 10, 4, -23 },
  { 220, 10, 14, 12, 1, -18 },
  { 238, 3, 7, 5, -1, -3 },
  { 241, 6, 1, 8, 1, -9 },
  { 242, 2, 2, 5, 0, -2 },
  { 243, 12, 22, 9, -1, -22 },
  { 276, 10, 22, 11, 1, -22 },
  { 304, 6, 22, 11, 3, -22 },
  { 321, 12, 22, 11, -1, -22 },
  { 354, 12, 22, 11, -1, -22 },
  { 387, 12, 22, 11, -1, -22 },
  { 420, 12, 22, 11, -1, -22 },
  { 453, 10, 22, 11, 1, -22 },
  { 481, 11, 22, 11, 1, -22 },
  { 512, 11, 22, 11, 0, -22 },
  { 543, 10, 22, 11, 0, -22 },
  { 571, 5, 16, 5, 0, -16 },
  { 581, 6, 20, 5, -1, -16 },
  { 596, 10, 12, 12, 1, -17 },
  { 611, 10, 8, 12, 1, -15 },
  { 621, 10, 12, 12, 1, -17 },
  { 636, 9, 22, 7, 0, -22 },
  { 661, 14, 25, 16, 1, -22 },
  { 705, 10, 22, 10, -2, -22 },
  { 733, 12, 22, 12, 0, -22 },
  { 766, 12, 22, 10, 1, -22 },
  { 799, 12, 22, 13, 0, -22 },
  { 832, 12, 22, 10, 0, -22 },
  { 865, 12, 22, 10, 0, -22 },
  { 898, 14, 22, 14, 1, -22 },
  { 937, 14, 22, 14, 0, -22 },
  { 976, 9, 22, 5, -2, -22 },
  { 1001, 10, 27, 5, -4, -22 },
  { 1035, 13, 22, 11, 0, -22 },
  { 1071, 7, 22, 9, 0, -22 },
  { 1091, 19, 22, 18, 0, -22 },
  { 1144, 15, 22, 14, 0, -22 },
  { 1186, 12, 22, 14, 1, -22 },
  { 1219, 11, 22, 11, 0, -22 },
  { 1250, 12, 27, 14, 1, -22 },
  { 1291, 11, 22, 11, 0, -22 },
  { 1322, 12, 22, 11, -1, -22 },
  { 1355, 10, 22, 9, 2, -22 },
  { 1383, 13, 22, 13, 1, -22 },
  { 1419, 10, 22, 11, 3, -22 },
  { 1447, 19, 22, 19, 2, -22 },
  { 1500, 14, 22, 9, -2, -22 },
  { 1539, 10, 22, 9, 2, -22 },
  { 1567, 12, 22, 9, -1, -22 },
  { 1600, 11, 27, 9, -1, -22 },
  { 1638, 4, 22, 10, 3, -22 },
  { 1649, 11, 27, 9, -2, -22 },
  { 1687, 11, 10, 12, 1, -22 },
  { 1701, 8, 1, 8, -2, 3 },
  { 1702, 2, 5, 6, 5, -24 },
  { 1704, 10, 17, 12, 1, -17 },
  { 1726, 11, 24, 12, 0, -24 },
  { 1759, 8, 17, 8, 1, -17 },
  { 1776, 12, 24, 12, 1, -24 },
  { 1812, 9, 17, 10, 1, -17 },
  { 1832, 13, 31, 6, -4, -24 },
  { 1883, 12, 24, 12, -1, -17 },
  { 1919, 10, 24, 11, 0, -24 },
  { 1949, 6, 22, 5, 0, -22 },
  { 1966, 10, 29, 5, -4, -22 },
  { 2003, 10, 24, 9, 0, -24 },
  { 2033, 6, 24, 5, 0, -24 },
  { 2051, 16, 17, 17, 0, -17 },
  { 2085, 10, 17, 11, 0, -17 },
  { 2107, 9, 17, 11, 1, -17 },
  { 2127, 12, 24, 12, -1, -17 },
  { 2163, 10, 24, 12, 1, -17 },
  { 2193, 9, 17, 7, 0, -17 },
  { 2213, 10, 17, 9, -1, -17 },
  { 2235, 6, 20, 6, 0, -20 },
  { 2250, 10, 16, 11, 1, -16 },
  { 2270, 8, 16, 8, 2, -16 },
  { 2286, 14, 16, 14, 2, -16 },
  { 2314, 11, 16, 9, -1, -16 },
  { 2336, 15, 24, 9, -4, -16 },
  { 2381, 9, 16, 7, -1, -16 },
  { 2399, 11, 27, 10, 1, -22 },
  { 2437, 1, 32, 11, 5, -24 },
  { 2441, 10, 27, 10, -2, -22 },
  { 2475, 10, 2, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC31PT7B_H_
