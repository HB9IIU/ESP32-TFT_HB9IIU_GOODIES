#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x30, 0x18, 0x00, 0x30, 0x90, 0x48, 0x24, 0x36, 0x12,
  0x09, 0x04, 0x82, 0x43, 0x61, 0x20, 0x90, 0x48, 0x60, 0x00, 0x10, 0x20,
  0x02, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x00,
  0x18, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x18, 0x20, 0x02, 0x04, 0x07,
  0xFF, 0xF0, 0x18, 0x20, 0x02, 0x04, 0x00, 0x41, 0x80, 0x18, 0x20, 0x02,
  0x04, 0x00, 0x41, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00, 0x41, 0x80, 0x08,
  0x20, 0x03, 0x04, 0x07, 0xFF, 0xF8, 0x08, 0x30, 0x03, 0x04, 0x00, 0x40,
  0x80, 0x08, 0x30, 0x03, 0x04, 0x00, 0x40, 0x80, 0x08, 0x30, 0x03, 0x04,
  0x00, 0x40, 0x80, 0x08, 0x30, 0x01, 0x04, 0x00, 0x60, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x03, 0xF0, 0x01,
  0xEB, 0xC0, 0x63, 0x08, 0x18, 0x40, 0x02, 0x08, 0x00, 0xC1, 0x00, 0x18,
  0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x11,
  0x80, 0x03, 0x20, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x16, 0x00, 0x02, 0x60, 0x00, 0x44, 0x00, 0x10,
  0xC0, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x41,
  0x80, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x23, 0x03, 0x8D, 0xC0, 0x1F, 0xE0,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xC0, 0x18, 0x19, 0x80, 0x40, 0xC2, 0x03, 0x06, 0x08, 0x08,
  0x10, 0x20, 0x60, 0xC0, 0x81, 0x02, 0x02, 0x0C, 0x08, 0x08, 0x20, 0x60,
  0x61, 0x81, 0x81, 0x84, 0x04, 0x04, 0x30, 0x10, 0x10, 0x80, 0x40, 0x46,
  0x01, 0x03, 0x10, 0x0C, 0x0C, 0xC7, 0x30, 0x22, 0x3E, 0xC1, 0x99, 0x8F,
  0x04, 0x44, 0x1C, 0x33, 0x20, 0x50, 0x88, 0x81, 0x66, 0x66, 0x04, 0xF1,
  0x10, 0x10, 0x0C, 0x40, 0xC0, 0x23, 0x03, 0x01, 0x88, 0x08, 0x04, 0x20,
  0x20, 0x30, 0x80, 0x80, 0x82, 0x06, 0x06, 0x18, 0x18, 0x10, 0x60, 0x40,
  0xC1, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x18, 0x20, 0x40, 0x61, 0x83, 0x00,
  0x8C, 0x08, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x66, 0x00,
  0xC2, 0x00, 0x82, 0x01, 0x82, 0x01, 0x02, 0x01, 0x02, 0x01, 0x02, 0x01,
  0x06, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01,
  0xB0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x40, 0x0C,
  0x40, 0x18, 0x41, 0x10, 0x61, 0x30, 0x23, 0x20, 0x22, 0x60, 0x22, 0x40,
  0x34, 0x40, 0x14, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x40,
  0x28, 0x40, 0x68, 0x60, 0xCC, 0x3F, 0x84, 0x04, 0x00, 0x32, 0x22, 0x64,
  0x44, 0x4C, 0x88, 0x80, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x00, 0x01, 0x00, 0x20,
  0x02, 0x08, 0x20, 0x42, 0x03, 0x21, 0x0D, 0xE0, 0x60, 0x0A, 0x01, 0x10,
  0x61, 0x0C, 0x08, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x04, 0x30, 0x82, 0x18, 0x43,
  0x08, 0x21, 0x0C, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xC6, 0x01, 0x82, 0x03, 0x03, 0x02, 0x03, 0x04,
  0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x10, 0x03, 0x10,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60,
  0x02, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80,
  0x30, 0x80, 0x20, 0xC0, 0x60, 0xC0, 0x40, 0x40, 0x80, 0x61, 0x00, 0x3E,
  0x00, 0x08, 0x00, 0x01, 0x81, 0xC1, 0xE1, 0xA3, 0x13, 0x09, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x18,
  0x30, 0x02, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x70, 0xE0, 0x30, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x08, 0x06, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x0F, 0x00, 0x06, 0x80, 0x01, 0x20,
  0x00, 0xC8, 0x00, 0x22, 0x00, 0x19, 0x80, 0x0C, 0x40, 0x02, 0x10, 0x01,
  0x84, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x18, 0x20, 0x04, 0x08, 0x03, 0x02,
  0x00, 0x81, 0x80, 0x60, 0x40, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0xC0, 0xC0, 0x20, 0x60, 0x08, 0x10, 0x02, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x0C, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x08,
  0x0E, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x40,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x87, 0x00, 0x4F, 0xE0, 0x6C, 0x18, 0x38, 0x06, 0x1C, 0x01, 0x0C,
  0x00, 0x86, 0x00, 0x42, 0x00, 0x23, 0x00, 0x11, 0x80, 0x08, 0xC0, 0x04,
  0x60, 0x02, 0x20, 0x03, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x20, 0x40, 0x30, 0x20, 0x30, 0x08, 0x30, 0x07, 0xF0, 0x00,
  0x40, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x30,
  0x06, 0x03, 0x01, 0x80, 0x20, 0x20, 0x04, 0x04, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x03, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x03, 0x01, 0x00, 0x40,
  0x20, 0x18, 0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x60, 0x00, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0xC0, 0x03, 0x0C, 0x00, 0xC0, 0x80, 0x30, 0x18, 0x0C,
  0x01, 0x01, 0x00, 0x30, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60,
  0x01, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x30, 0x01, 0x82, 0x00, 0x30, 0x60,
  0x04, 0x04, 0x01, 0x00, 0xC0, 0xC0, 0x07, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x7C, 0x00, 0xC3, 0x00, 0xC0, 0xC0, 0x40, 0x20, 0x60, 0x18, 0x20, 0x0C,
  0x30, 0x06, 0x10, 0x03, 0x08, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00,
  0x31, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x04, 0x20, 0x06, 0x10, 0x03, 0x08,
  0x03, 0x86, 0x01, 0xC1, 0x01, 0x60, 0xE3, 0x20, 0x1F, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0xC0, 0x1F, 0xC0, 0x02, 0x00, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0xC1, 0x80, 0x00, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0xC1, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x30,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x80, 0x06, 0x01, 0x00, 0x02, 0x03, 0x00,
  0x02, 0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x08, 0x03,
  0x03, 0x08, 0x0F, 0xC3, 0x18, 0x10, 0xC3, 0x10, 0x20, 0x82, 0x10, 0x60,
  0x82, 0x30, 0x41, 0x82, 0x20, 0xC1, 0x02, 0x20, 0x81, 0x02, 0x60, 0x81,
  0x06, 0x61, 0x83, 0x06, 0x41, 0x02, 0x04, 0x41, 0x02, 0x04, 0x41, 0x06,
  0x0C, 0x41, 0x06, 0x08, 0xC3, 0x06, 0x08, 0xC3, 0x0C, 0x18, 0xC3, 0x0C,
  0x10, 0xC1, 0x1C, 0x30, 0xC1, 0x12, 0x60, 0xC1, 0xE3, 0xC0, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x05, 0x00, 0x0D, 0x00, 0x09, 0x00, 0x09, 0x00, 0x19, 0x00,
  0x11, 0x00, 0x31, 0x00, 0x21, 0x00, 0x21, 0x00, 0x61, 0x00, 0x41, 0x00,
  0xC1, 0x00, 0x81, 0x00, 0x81, 0x01, 0x81, 0x01, 0x01, 0x03, 0x01, 0x02,
  0x01, 0x03, 0xFF, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x18,
  0x01, 0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40,
  0x01, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x00, 0xFC, 0x00, 0x3F, 0xF0,
  0x06, 0x03, 0x00, 0x80, 0x20, 0x10, 0x06, 0x02, 0x00, 0xC0, 0xC0, 0x08,
  0x18, 0x01, 0x02, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x03, 0x00, 0x20,
  0x40, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x40, 0x60, 0x30, 0x0C, 0x3C, 0x01,
  0xFE, 0x00, 0x20, 0x30, 0x04, 0x03, 0x01, 0x80, 0x20, 0x30, 0x06, 0x04,
  0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x0C, 0x10,
  0x01, 0x82, 0x00, 0x20, 0x40, 0x04, 0x18, 0x01, 0x82, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x03, 0x01, 0x03, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x0E, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x0F, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0x81, 0x80, 0x10, 0x0C, 0x01,
  0x00, 0x60, 0x10, 0x02, 0x03, 0x00, 0x20, 0x30, 0x02, 0x02, 0x00, 0x20,
  0x20, 0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30, 0x40, 0x02,
  0x04, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00,
  0x60, 0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x04, 0x10, 0x00, 0xC1, 0x00,
  0x0C, 0x10, 0x00, 0x83, 0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x30, 0x20,
  0x02, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x04, 0x00, 0x80, 0x40, 0x30, 0x04,
  0x06, 0x00, 0xC3, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0xC0, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xC0, 0xF0, 0x0C, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xFC, 0x30, 0x03, 0xF0, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08,
  0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00,
  0x18, 0x20, 0x00, 0x40, 0x80, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x10, 0x00, 0xC0, 0x60, 0x02, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x60, 0x03,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x80, 0x06, 0x03, 0x00, 0x08, 0x06,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0,
  0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x30, 0x08, 0x00,
  0x60, 0x30, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x0C,
  0x06, 0x00, 0x10, 0x0C, 0x00, 0x20, 0x1F, 0xFF, 0xC0, 0x20, 0x00, 0x80,
  0x40, 0x03, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x08,
  0x00, 0x60, 0x10, 0x00, 0xC0, 0x60, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00,
  0x04, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x40, 0x20, 0x00,
  0x80, 0x40, 0x01, 0x00, 0x80, 0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x10,
  0x00, 0x00, 0xFE, 0x02, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x07, 0xF0, 0x00, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0xFC,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x10, 0x0C, 0x00, 0x80, 0xC0, 0x0C, 0x04, 0x00, 0x40, 0x60,
  0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x43,
  0x00, 0x02, 0x10, 0x00, 0x11, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00,
  0x4E, 0x00, 0x02, 0x90, 0x00, 0x18, 0x80, 0x01, 0xC4, 0x00, 0x0C, 0x30,
  0x00, 0x41, 0x80, 0x02, 0x04, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x08,
  0x0C, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC0, 0x50, 0x00, 0x0E, 0x01, 0x40, 0x00, 0x28, 0x05,
  0x00, 0x01, 0xA0, 0x34, 0x00, 0x05, 0x80, 0x90, 0x00, 0x36, 0x02, 0x40,
  0x00, 0x90, 0x09, 0x00, 0x02, 0x40, 0x24, 0x00, 0x11, 0x01, 0x90, 0x00,
  0x4C, 0x04, 0x40, 0x03, 0x20, 0x11, 0x00, 0x08, 0x80, 0x44, 0x00, 0x62,
  0x03, 0x10, 0x01, 0x18, 0x0C, 0x40, 0x0C, 0x60, 0x21, 0x80, 0x21, 0x00,
  0x86, 0x01, 0x84, 0x02, 0x18, 0x04, 0x10, 0x18, 0x60, 0x30, 0xC0, 0x41,
  0x80, 0x83, 0x01, 0x02, 0x06, 0x08, 0x04, 0x08, 0x10, 0x20, 0x10, 0x20,
  0xC0, 0x80, 0xC0, 0x82, 0x06, 0x02, 0x02, 0x18, 0x10, 0x08, 0x08, 0x40,
  0x40, 0x20, 0x23, 0x01, 0x01, 0x80, 0x88, 0x04, 0x06, 0x02, 0x60, 0x30,
  0x10, 0x09, 0x00, 0x80, 0x40, 0x2C, 0x02, 0x01, 0x00, 0xA0, 0x08, 0x0C,
  0x03, 0x80, 0x60, 0x30, 0x0E, 0x01, 0x80, 0x00, 0x80, 0x03, 0x01, 0xC0,
  0x03, 0x01, 0xC0, 0x02, 0x01, 0x40, 0x02, 0x01, 0x40, 0x02, 0x01, 0x40,
  0x06, 0x03, 0x40, 0x04, 0x03, 0x60, 0x04, 0x02, 0x20, 0x04, 0x02, 0x20,
  0x0C, 0x02, 0x20, 0x0C, 0x06, 0x20, 0x08, 0x04, 0x30, 0x08, 0x04, 0x30,
  0x08, 0x04, 0x10, 0x18, 0x0C, 0x10, 0x18, 0x0C, 0x10, 0x10, 0x08, 0x18,
  0x10, 0x08, 0x18, 0x10, 0x08, 0x08, 0x30, 0x18, 0x08, 0x20, 0x18, 0x08,
  0x20, 0x10, 0x08, 0x20, 0x10, 0x0C, 0x60, 0x10, 0x0C, 0x60, 0x30, 0x04,
  0x40, 0x20, 0x04, 0x40, 0x20, 0x04, 0x40, 0x20, 0x06, 0xC0, 0x60, 0x06,
  0xC0, 0x60, 0x02, 0x80, 0x40, 0x02, 0x80, 0x40, 0x02, 0x80, 0x40, 0x03,
  0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x30,
  0x06, 0x03, 0x01, 0x80, 0x20, 0x20, 0x06, 0x08, 0x00, 0x43, 0x00, 0x08,
  0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00, 0x12,
  0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x68,
  0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x0D, 0x00, 0x01, 0xA0,
  0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x01, 0x88, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x06, 0x00, 0x60, 0x40,
  0x18, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xC0, 0x18, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x40,
  0x10, 0x30, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04,
  0x18, 0x03, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x18, 0x30, 0x04, 0x0C,
  0x03, 0x02, 0x01, 0x80, 0x80, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1C,
  0x30, 0x06, 0x03, 0x01, 0x80, 0x20, 0x20, 0x06, 0x08, 0x00, 0x43, 0x00,
  0x08, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x98, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00,
  0x68, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x0D, 0x00, 0x01,
  0xA0, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x06, 0x00, 0x60,
  0x40, 0x18, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0x0F, 0xE0, 0x00, 0x50, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0,
  0x18, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x40, 0x10, 0x30, 0x04, 0x0C,
  0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x18, 0x03, 0x04, 0x00,
  0xC1, 0x00, 0x20, 0x40, 0x18, 0x30, 0x04, 0x0C, 0x03, 0x02, 0x01, 0x80,
  0x83, 0x80, 0x3F, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x02, 0x00, 0x40,
  0x80, 0x10, 0x20, 0x0C, 0x08, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x06, 0x01, 0x01, 0x00, 0x40, 0x40, 0x18, 0x10, 0x06, 0x0C,
  0x00, 0x83, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x1C, 0x1C, 0x06, 0x00, 0x81,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x02, 0x01, 0xC0, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0x7F, 0xFE,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x10, 0x60,
  0x01, 0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08,
  0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41,
  0x00, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x08,
  0x20, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01, 0x06, 0x00, 0x10, 0x40, 0x03,
  0x04, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00,
  0x60, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x80,
  0x08, 0x08, 0x01, 0x80, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x03,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x58,
  0x00, 0x6C, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19, 0x00, 0x08, 0x80, 0x0C,
  0x40, 0x04, 0x20, 0x06, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00,
  0x81, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x18, 0x04, 0x08, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x86, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x11, 0x80, 0x08, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01, 0x20,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x70, 0x01, 0xA0, 0x01, 0xC0,
  0x04, 0x80, 0x06, 0x00, 0x32, 0x00, 0x38, 0x00, 0x88, 0x00, 0xA0, 0x02,
  0x20, 0x06, 0x80, 0x18, 0x80, 0x12, 0x00, 0x42, 0x00, 0x48, 0x03, 0x08,
  0x03, 0x20, 0x08, 0x20, 0x08, 0x80, 0x20, 0x80, 0x62, 0x01, 0x82, 0x01,
  0x08, 0x04, 0x08, 0x04, 0x20, 0x30, 0x20, 0x30, 0x80, 0x80, 0x80, 0x82,
  0x02, 0x02, 0x06, 0x08, 0x18, 0x08, 0x10, 0x20, 0x40, 0x20, 0x40, 0x83,
  0x00, 0x83, 0x02, 0x08, 0x02, 0x08, 0x08, 0x20, 0x08, 0x20, 0x21, 0x80,
  0x21, 0x00, 0x84, 0x00, 0x84, 0x02, 0x30, 0x02, 0x30, 0x08, 0x80, 0x08,
  0x80, 0x22, 0x00, 0x22, 0x01, 0x98, 0x00, 0x98, 0x06, 0x40, 0x02, 0x40,
  0x1B, 0x00, 0x0B, 0x00, 0x68, 0x00, 0x28, 0x01, 0xA0, 0x00, 0xA0, 0x07,
  0x80, 0x03, 0x80, 0x14, 0x00, 0x0C, 0x00, 0x50, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x18, 0x04,
  0x00, 0x60, 0x20, 0x01, 0x81, 0x80, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00,
  0x20, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x22,
  0x00, 0x00, 0xD0, 0x00, 0x01, 0x40, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x58, 0x00, 0x03,
  0x60, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00, 0x08, 0x20,
  0x00, 0x60, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x20, 0x01,
  0x80, 0xC0, 0x04, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x10, 0x04, 0x00,
  0x40, 0x30, 0x01, 0x00, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x60, 0x04,
  0x60, 0x08, 0x20, 0x08, 0x20, 0x10, 0x20, 0x10, 0x20, 0x20, 0x20, 0x60,
  0x20, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x31, 0x80, 0x31, 0x00, 0x33, 0x00,
  0x12, 0x00, 0x16, 0x00, 0x14, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0xFE,
  0x00, 0x81, 0x83, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x02,
  0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x03, 0x06, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xC1, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x03, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0xC0, 0x01, 0x10, 0x00,
  0xC6, 0x00, 0x20, 0x80, 0x18, 0x30, 0x04, 0x04, 0x03, 0x01, 0x80, 0x80,
  0x60, 0x60, 0x08, 0x10, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x19, 0x80, 0x02,
  0xC0, 0x00, 0xC0, 0xFF, 0xF8, 0xC2, 0x18, 0x42, 0x08, 0x41, 0x00, 0x78,
  0x00, 0xFE, 0x40, 0xC1, 0xA0, 0xC0, 0x50, 0x40, 0x28, 0x40, 0x18, 0x60,
  0x0C, 0x20, 0x06, 0x10, 0x03, 0x18, 0x01, 0x88, 0x00, 0x84, 0x00, 0x46,
  0x00, 0x23, 0x00, 0x31, 0x00, 0x18, 0x80, 0x08, 0x40, 0x04, 0x20, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC1, 0x00, 0xE0, 0x80,
  0x70, 0x60, 0x50, 0x10, 0x68, 0x0F, 0xE4, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x43, 0x80,
  0x27, 0xF0, 0x34, 0x08, 0x1C, 0x06, 0x0A, 0x01, 0x06, 0x00, 0x83, 0x00,
  0x43, 0x00, 0x21, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x30,
  0x03, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0x46, 0x00, 0x23, 0x00, 0x31,
  0x80, 0x10, 0x80, 0x08, 0x40, 0x0C, 0x60, 0x04, 0x30, 0x06, 0x14, 0x02,
  0x0A, 0x02, 0x05, 0x83, 0x04, 0x7E, 0x00, 0x04, 0x00, 0x00, 0x78, 0x07,
  0xF0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC1, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x07, 0x88, 0x01, 0xFC, 0x80, 0x30, 0x68, 0x06, 0x02, 0x80,
  0x40, 0x38, 0x08, 0x03, 0x01, 0x80, 0x30, 0x10, 0x03, 0x01, 0x00, 0x30,
  0x30, 0x03, 0x02, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06,
  0x04, 0x00, 0x60, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x0C, 0x0C, 0x00,
  0xC0, 0xC0, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x04, 0x02, 0x80, 0x40,
  0x38, 0x06, 0x05, 0x00, 0x20, 0xD0, 0x03, 0xF1, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x70, 0x07, 0x70, 0x30, 0x41, 0x81, 0x0C, 0x04, 0x20, 0x11, 0x80,
  0x44, 0x01, 0x30, 0x0C, 0x80, 0x22, 0x01, 0x18, 0x18, 0x41, 0xC1, 0xFC,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC1, 0x01, 0xFC, 0x01,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x9C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xE4,
  0x03, 0x06, 0x80, 0xC0, 0x50, 0x10, 0x0A, 0x04, 0x01, 0x81, 0x80, 0x30,
  0x20, 0x06, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x02, 0x04, 0x00, 0x41,
  0x80, 0x08, 0x30, 0x03, 0x04, 0x00, 0x60, 0x80, 0x08, 0x10, 0x01, 0x02,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x04,
  0x03, 0x80, 0x80, 0x70, 0x18, 0x14, 0x01, 0x06, 0x80, 0x3F, 0x90, 0x00,
  0x82, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x08, 0x06, 0x01, 0xC3,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x3C, 0x02, 0x7F, 0x02, 0x81, 0x07, 0x01, 0x06, 0x01,
  0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x08, 0x03, 0x08, 0x02,
  0x08, 0x02, 0x18, 0x02, 0x18, 0x06, 0x10, 0x06, 0x10, 0x04, 0x10, 0x04,
  0x30, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x60, 0x08,
  0x40, 0x18, 0x40, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x02, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x10, 0x20, 0x10, 0x30,
  0x10, 0x18, 0x18, 0x08, 0x18, 0x04, 0x18, 0x02, 0x08, 0x03, 0x08, 0x01,
  0x8C, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x26, 0x00, 0x37, 0x00, 0x16, 0x80,
  0x0A, 0x60, 0x06, 0x30, 0x06, 0x08, 0x03, 0x04, 0x01, 0x02, 0x00, 0x81,
  0x00, 0x40, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x30, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0xBB, 0x8E, 0xE0, 0x78,
  0x34, 0x08, 0x14, 0x06, 0x03, 0x06, 0x01, 0x80, 0xC1, 0x80, 0x40, 0x30,
  0x40, 0x10, 0x0C, 0x30, 0x0C, 0x02, 0x0C, 0x02, 0x00, 0x82, 0x00, 0x80,
  0x20, 0x80, 0x20, 0x18, 0x20, 0x18, 0x06, 0x18, 0x06, 0x01, 0x04, 0x01,
  0x00, 0x41, 0x00, 0x40, 0x10, 0x40, 0x10, 0x0C, 0x30, 0x0C, 0x02, 0x0C,
  0x03, 0x00, 0x82, 0x00, 0x80, 0x20, 0x80, 0x20, 0x18, 0x20, 0x18, 0x06,
  0x18, 0x06, 0x01, 0x06, 0x01, 0x00, 0x41, 0x00, 0x40, 0x10, 0x40, 0x10,
  0x0C, 0x10, 0x0C, 0x03, 0x0C, 0x03, 0x00, 0x80, 0x00, 0x3C, 0x02, 0x7E,
  0x06, 0x81, 0x05, 0x01, 0x06, 0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01,
  0x0C, 0x03, 0x08, 0x03, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x10, 0x06,
  0x10, 0x06, 0x10, 0x04, 0x30, 0x04, 0x30, 0x04, 0x20, 0x0C, 0x20, 0x08,
  0x20, 0x08, 0x60, 0x08, 0x60, 0x18, 0x40, 0x18, 0x40, 0x10, 0x40, 0x10,
  0xC0, 0x10, 0x00, 0x70, 0x01, 0xDC, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x02,
  0x08, 0x02, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x20, 0x02,
  0x60, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04,
  0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0x40, 0x10,
  0x40, 0x30, 0x60, 0x60, 0x20, 0xC0, 0x3F, 0x80, 0x04, 0x00, 0x00, 0x07,
  0x00, 0x13, 0xB8, 0x02, 0xC1, 0x00, 0xB0, 0x30, 0x14, 0x02, 0x03, 0x00,
  0x40, 0x60, 0x08, 0x18, 0x01, 0x03, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x10, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x02,
  0x04, 0x00, 0x41, 0x80, 0x18, 0x30, 0x02, 0x06, 0x00, 0x40, 0x80, 0x18,
  0x10, 0x02, 0x06, 0x00, 0xC0, 0xA0, 0x10, 0x14, 0x04, 0x02, 0xC3, 0x00,
  0xCF, 0xC0, 0x18, 0x40, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xEE, 0x40, 0xC1, 0xA0,
  0xC0, 0x50, 0xC0, 0x28, 0x40, 0x18, 0x60, 0x0C, 0x20, 0x06, 0x10, 0x03,
  0x18, 0x01, 0x88, 0x00, 0x84, 0x00, 0x46, 0x00, 0x23, 0x00, 0x11, 0x00,
  0x18, 0x80, 0x08, 0x40, 0x04, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x01, 0x86, 0x00, 0xC1, 0x00, 0xE0, 0x80, 0x70, 0x60, 0x50, 0x10, 0x68,
  0x0F, 0xC4, 0x00, 0x82, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x09, 0xD0, 0x68, 0x01, 0x40, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x18, 0x08, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x41, 0x01, 0x83, 0xFE, 0x00, 0x40, 0x00, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x7F, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xF8, 0x10, 0x00,
  0x04, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x02, 0x08, 0x02,
  0x18, 0x02, 0x10, 0x06, 0x10, 0x06, 0x10, 0x04, 0x30, 0x04, 0x30, 0x04,
  0x20, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x60, 0x08, 0x60, 0x18, 0x40, 0x18,
  0x40, 0x10, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0xE0,
  0x41, 0xA0, 0x7F, 0x20, 0x08, 0x00, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x00,
  0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x20, 0x41,
  0x06, 0x08, 0x20, 0x41, 0x02, 0x18, 0x10, 0x80, 0x8C, 0x04, 0x40, 0x26,
  0x01, 0x20, 0x0B, 0x00, 0x50, 0x02, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x38, 0x03, 0x00, 0xA0, 0x1C, 0x06,
  0x80, 0x50, 0x12, 0x01, 0x40, 0x48, 0x09, 0x03, 0x20, 0x24, 0x08, 0x81,
  0x90, 0x22, 0x04, 0x41, 0x08, 0x31, 0x04, 0x20, 0x84, 0x30, 0x82, 0x10,
  0x82, 0x10, 0x42, 0x08, 0x41, 0x10, 0x23, 0x04, 0x40, 0x88, 0x13, 0x02,
  0x20, 0x48, 0x09, 0x01, 0x20, 0x24, 0x05, 0x00, 0xB0, 0x14, 0x02, 0x80,
  0x50, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x00, 0x02, 0x00, 0xC0, 0xC0, 0x60, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x06,
  0x00, 0x41, 0x00, 0x18, 0xC0, 0x06, 0x20, 0x00, 0x90, 0x00, 0x2C, 0x00,
  0x0A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x14, 0x00, 0x0D,
  0x00, 0x02, 0x60, 0x01, 0x88, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20,
  0x04, 0x0C, 0x02, 0x01, 0x01, 0x80, 0x40, 0x40, 0x10, 0x30, 0x06, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x60,
  0x02, 0x00, 0x80, 0x04, 0x03, 0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x00,
  0x20, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02,
  0x0C, 0x00, 0x04, 0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x23,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40,
  0x00, 0x07, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x07,
  0xC0, 0x03, 0x80, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0x40, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x70, 0x38,
  0x70, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 36, 10, 1, -36 },
  { 42, 9, 13, 13, 5, -36 },
  { 57, 19, 36, 18, 0, -36 },
  { 143, 19, 41, 17, -1, -38 },
  { 241, 22, 37, 26, 2, -36 },
  { 343, 16, 37, 16, -1, -36 },
  { 417, 4, 13, 7, 5, -36 },
  { 424, 14, 44, 12, 1, -36 },
  { 501, 13, 44, 12, -3, -36 },
  { 573, 12, 14, 16, 6, -38 },
  { 594, 17, 23, 20, 1, -29 },
  { 643, 6, 11, 8, -2, -5 },
  { 652, 11, 1, 13, 1, -14 },
  { 654, 2, 3, 8, 1, -3 },
  { 655, 20, 36, 15, -2, -36 },
  { 745, 16, 37, 17, 1, -36 },
  { 819, 9, 36, 17, 5, -36 },
  { 860, 19, 36, 17, -2, -36 },
  { 946, 18, 37, 17, -1, -36 },
  { 1030, 18, 36, 17, -1, -36 },
  { 1111, 18, 37, 17, -1, -36 },
  { 1195, 17, 37, 17, 1, -36 },
  { 1274, 17, 36, 17, 2, -36 },
  { 1351, 19, 37, 17, -1, -36 },
  { 1439, 17, 37, 17, 0, -36 },
  { 1518, 7, 26, 8, 0, -26 },
  { 1541, 10, 32, 8, -2, -26 },
  { 1581, 17, 21, 20, 1, -28 },
  { 1626, 17, 12, 20, 1, -24 },
  { 1652, 17, 21, 20, 1, -28 },
  { 1697, 13, 36, 12, 1, -36 },
  { 1756, 24, 41, 25, 1, -36 },
  { 1879, 16, 36, 16, -3, -36 },
  { 1951, 19, 36, 19, 0, -36 },
  { 2037, 19, 37, 17, 2, -36 },
  { 2125, 20, 36, 21, 0, -36 },
  { 2215, 19, 36, 17, 0, -36 },
  { 2301, 19, 36, 16, 0, -36 },
  { 2387, 22, 37, 23, 2, -36 },
  { 2489, 23, 36, 22, 0, -36 },
  { 2593, 15, 36, 8, -3, -36 },
  { 2661, 16, 45, 8, -7, -36 },
  { 2751, 21, 36, 17, 0, -36 },
  { 2846, 11, 36, 15, 0, -36 },
  { 2896, 30, 36, 29, 0, -36 },
  { 3031, 24, 36, 23, 0, -36 },
  { 3139, 19, 37, 22, 2, -36 },
  { 3227, 18, 36, 18, 0, -36 },
  { 3308, 19, 45, 22, 2, -36 },
  { 3415, 18, 36, 18, 0, -36 },
  { 3496, 19, 37, 17, -1, -36 },
  { 3584, 16, 36, 15, 3, -36 },
  { 3656, 20, 37, 21, 2, -36 },
  { 3749, 17, 36, 17, 4, -36 },
  { 3826, 30, 36, 30, 4, -36 },
  { 3961, 22, 36, 15, -3, -36 },
  { 4060, 16, 36, 14, 3, -36 },
  { 4132, 20, 36, 15, -2, -36 },
  { 4222, 18, 44, 14, -1, -36 },
  { 4321, 7, 36, 16, 5, -36 },
  { 4353, 18, 44, 14, -3, -36 },
  { 4452, 18, 17, 20, 1, -36 },
  { 4491, 13, 1, 13, -4, 5 },
  { 4493, 5, 8, 10, 7, -38 },
  { 4498, 17, 28, 19, 1, -27 },
  { 4558, 17, 39, 19, 0, -38 },
  { 4641, 14, 28, 13, 1, -27 },
  { 4690, 20, 39, 19, 1, -38 },
  { 4788, 14, 28, 16, 1, -27 },
  { 4837, 22, 50, 9, -7, -38 },
  { 4975, 19, 39, 19, -1, -27 },
  { 5068, 16, 38, 18, 0, -38 },
  { 5144, 9, 36, 8, 0, -36 },
  { 5185, 17, 48, 8, -7, -36 },
  { 5287, 17, 38, 15, 0, -38 },
  { 5368, 10, 38, 7, 0, -38 },
  { 5416, 26, 27, 27, 0, -27 },
  { 5504, 16, 27, 18, 0, -27 },
  { 5558, 16, 28, 18, 1, -27 },
  { 5614, 19, 38, 19, -2, -27 },
  { 5705, 17, 39, 19, 1, -27 },
  { 5788, 14, 27, 12, 0, -27 },
  { 5836, 15, 28, 14, -1, -27 },
  { 5889, 9, 34, 9, 1, -33 },
  { 5928, 16, 27, 18, 1, -26 },
  { 5982, 13, 26, 14, 3, -26 },
  { 6025, 22, 26, 23, 3, -26 },
  { 6097, 18, 26, 14, -2, -26 },
  { 6156, 23, 38, 15, -6, -26 },
  { 6266, 15, 26, 12, -2, -26 },
  { 6315, 17, 44, 16, 2, -36 },
  { 6409, 1, 50, 17, 8, -38 },
  { 6416, 17, 44, 15, -3, -36 },
  { 6510, 17, 4, 20, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC50PT7B_H_
