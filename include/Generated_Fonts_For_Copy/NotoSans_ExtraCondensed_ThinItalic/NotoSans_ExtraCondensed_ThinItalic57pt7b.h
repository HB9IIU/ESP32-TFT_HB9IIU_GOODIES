#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x38, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x23,
  0x04, 0x41, 0x88, 0x33, 0x04, 0x60, 0x88, 0x11, 0x06, 0x20, 0xCC, 0x11,
  0x82, 0x20, 0x44, 0x18, 0x82, 0x30, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x30,
  0x20, 0x00, 0x81, 0x80, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40,
  0x01, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x10, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x0C, 0x08,
  0x00, 0x20, 0x60, 0x00, 0x81, 0x80, 0x06, 0x04, 0x00, 0x18, 0x10, 0x00,
  0x40, 0xC0, 0x03, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x10, 0x30, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x08, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00, 0x10,
  0x30, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xC0, 0x0E, 0x21, 0xC0, 0x60, 0x80, 0x01, 0x82,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00,
  0x08, 0x10, 0x00, 0x20, 0xC0, 0x00, 0x82, 0x00, 0x03, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x19, 0x80, 0x00, 0x26, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x98, 0x00,
  0x02, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x61, 0x00, 0x01, 0x86, 0x00, 0x04,
  0x18, 0x00, 0x10, 0x20, 0x00, 0x41, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18,
  0x00, 0x20, 0x40, 0x00, 0x83, 0x00, 0x06, 0x18, 0x0C, 0x18, 0xC0, 0x3F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x06, 0x60,
  0x04, 0x0C, 0x30, 0x0C, 0x18, 0x30, 0x08, 0x10, 0x30, 0x18, 0x30, 0x30,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x30, 0x20, 0x60, 0x30, 0x60, 0x60, 0x30,
  0x40, 0x40, 0x20, 0xC0, 0x40, 0x20, 0x80, 0xC0, 0x61, 0x80, 0xC0, 0x61,
  0x00, 0xC0, 0x63, 0x00, 0x80, 0x42, 0x00, 0x80, 0x46, 0x1C, 0x80, 0xC4,
  0x3E, 0x80, 0x8C, 0x63, 0x81, 0x88, 0xC1, 0x81, 0x98, 0x81, 0x83, 0x11,
  0x81, 0xC2, 0x31, 0x01, 0xC6, 0x23, 0x01, 0x7C, 0x63, 0x01, 0x00, 0x42,
  0x01, 0x00, 0xC6, 0x03, 0x00, 0x86, 0x03, 0x01, 0x84, 0x03, 0x01, 0x04,
  0x02, 0x03, 0x04, 0x02, 0x03, 0x0C, 0x06, 0x06, 0x0C, 0x06, 0x06, 0x0C,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x08, 0x18, 0x0C,
  0x18, 0x30, 0x0C, 0x10, 0x30, 0x04, 0x20, 0x60, 0x07, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x02, 0x00, 0xC0,
  0x80, 0x30, 0x20, 0x08, 0x08, 0x02, 0x02, 0x00, 0x81, 0x80, 0x20, 0x60,
  0x08, 0x10, 0x02, 0x0C, 0x00, 0x83, 0x00, 0x21, 0x80, 0x08, 0x40, 0x02,
  0x30, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xE0,
  0x00, 0xD8, 0x00, 0x62, 0x00, 0x30, 0x80, 0x08, 0x30, 0x46, 0x0C, 0x33,
  0x01, 0x0C, 0xC0, 0x42, 0x60, 0x18, 0x98, 0x06, 0x64, 0x00, 0x91, 0x00,
  0x2C, 0xC0, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x1E,
  0x10, 0x04, 0x86, 0x03, 0x20, 0xC1, 0x88, 0x3F, 0xC3, 0x01, 0x00, 0x00,
  0x18, 0xC4, 0x23, 0x18, 0x84, 0x23, 0x18, 0x84, 0x23, 0x00, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x20, 0x40, 0xC1, 0x00, 0xC8, 0x01, 0xA3, 0xC1, 0xF0, 0x06, 0x00,
  0x24, 0x01, 0x08, 0x08, 0x20, 0xC0, 0x42, 0x01, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x06, 0x18, 0x30, 0x41, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x04, 0x00,
  0xFF, 0xF0, 0x5F, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x60, 0x0C, 0x08, 0x02, 0x03, 0x01,
  0x80, 0x40, 0xC0, 0x10, 0x20, 0x04, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x10, 0xC0, 0x04, 0x20, 0x01, 0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x0C,
  0x40, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x60,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x43,
  0x00, 0x10, 0xC0, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0,
  0x30, 0x10, 0x18, 0x06, 0x04, 0x00, 0xC7, 0x00, 0x1F, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1A, 0x18, 0x8C, 0x6E, 0x19, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xC3, 0x80, 0x04,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0x07, 0x00, 0x60, 0x08, 0x02, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0,
  0x00, 0x0B, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x06,
  0x20, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00,
  0x18, 0x60, 0x00, 0x83, 0x00, 0x0C, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x04,
  0x00, 0x60, 0x60, 0x02, 0x03, 0x00, 0x30, 0x10, 0x03, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0x80,
  0x40, 0x0C, 0x06, 0x00, 0x60, 0x20, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0xC0,
  0x30, 0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xC2, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0xF0, 0x03, 0x3F, 0xC0, 0x26, 0x06, 0x02, 0xC0, 0x30, 0x78,
  0x03, 0x07, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0x60, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x04,
  0x0C, 0x00, 0xC0, 0x40, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x03, 0x06,
  0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0x87, 0x00, 0x30, 0x0C, 0x01, 0x00, 0x20,
  0x18, 0x01, 0x80, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x30, 0x03, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x80, 0x30, 0x18, 0x00, 0xC1, 0x80, 0x02, 0x18,
  0x00, 0x1B, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xC6, 0x00, 0x1C,
  0x10, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60,
  0xC0, 0x03, 0x04, 0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00,
  0x10, 0xC0, 0x00, 0x86, 0x00, 0x04, 0x30, 0x00, 0x60, 0x80, 0x03, 0x04,
  0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x03, 0x80, 0x0F, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1C, 0x30, 0x07, 0x03, 0x00,
  0xC0, 0x20, 0x30, 0x06, 0x04, 0x00, 0xC1, 0x80, 0x08, 0x20, 0x01, 0x0C,
  0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x02, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x14, 0x18, 0x07, 0x83, 0x01, 0xB0, 0x39,
  0xE4, 0x03, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x04, 0x0C, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0xE0, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x03, 0xF0, 0x1C, 0x38, 0x20, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x0C,
  0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0xC0, 0x3F, 0x86, 0x18, 0x0E, 0x20, 0xC2, 0x03, 0x0C, 0x18, 0xC0, 0xC1,
  0x83, 0x18, 0x10, 0x30, 0x62, 0x06, 0x04, 0x0C, 0xC0, 0x81, 0x81, 0x98,
  0x30, 0x30, 0x22, 0x06, 0x06, 0x04, 0x40, 0x80, 0x81, 0x98, 0x30, 0x30,
  0x33, 0x06, 0x06, 0x04, 0x60, 0x80, 0x80, 0x8C, 0x10, 0x10, 0x31, 0x02,
  0x06, 0x06, 0x20, 0xC0, 0xC0, 0x84, 0x18, 0x18, 0x30, 0x83, 0x07, 0x04,
  0x30, 0x60, 0xE1, 0x86, 0x04, 0x2C, 0x20, 0xC0, 0xCC, 0x8C, 0x18, 0x1F,
  0x1F, 0x03, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0xD8,
  0x00, 0x13, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06, 0x30,
  0x00, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x00, 0x83, 0x00, 0x30, 0x60,
  0x04, 0x0C, 0x01, 0x81, 0x80, 0x20, 0x30, 0x04, 0x06, 0x01, 0x80, 0xC0,
  0x20, 0x18, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x60, 0x0C, 0x0C, 0x01, 0x81,
  0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x08,
  0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x40,
  0x00, 0xD8, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x06, 0x00, 0x80, 0x18, 0x02,
  0x00, 0x20, 0x18, 0x00, 0x80, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x04, 0x00,
  0x20, 0x10, 0x00, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x40,
  0x20, 0x03, 0x00, 0x80, 0x08, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40,
  0x70, 0x01, 0xFF, 0x00, 0x04, 0x1E, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x04, 0x06,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x18, 0x18, 0x00, 0x40,
  0x60, 0x03, 0x01, 0x00, 0x18, 0x04, 0x01, 0xC0, 0x10, 0x7C, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x70, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x02, 0x00, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x18,
  0x02, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x04,
  0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00,
  0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x40, 0x00, 0xC1, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0,
  0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x60, 0x00, 0x41, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x40, 0x01, 0x83, 0x00, 0x06, 0x0C,
  0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x06, 0x02, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x60, 0x06, 0x01, 0x00, 0x70, 0x04, 0x03, 0x80, 0x31, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xE0, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xC3, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x10,
  0x00, 0x10, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x1C, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x08, 0x03,
  0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x04, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x20,
  0x00, 0x60, 0x08, 0x00, 0x18, 0x06, 0x00, 0x04, 0x01, 0x80, 0x01, 0x00,
  0x40, 0x00, 0x40, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x60, 0x08, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x30, 0x04,
  0x00, 0x0C, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x20,
  0x08, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00,
  0x40, 0x10, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x40, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x00,
  0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01,
  0x01, 0x80, 0x01, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0xE0, 0x00, 0x0D, 0xA0, 0x00, 0x0F,
  0x20, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x18,
  0x10, 0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10,
  0x08, 0x00, 0x30, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x0C, 0x00, 0x20,
  0x04, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x06, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0xA0, 0x00, 0x02, 0x80, 0x28, 0x00, 0x01, 0xA0, 0x1A, 0x00, 0x00, 0x78,
  0x06, 0x80, 0x00, 0x36, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x48, 0x00, 0x06,
  0x40, 0x12, 0x00, 0x01, 0x90, 0x0C, 0xC0, 0x00, 0xCC, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x8C, 0x00, 0x08, 0x80, 0x23, 0x00, 0x06, 0x20, 0x08, 0xC0,
  0x01, 0x08, 0x06, 0x30, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x43,
  0x00, 0x18, 0x40, 0x10, 0x40, 0x04, 0x10, 0x0C, 0x10, 0x03, 0x0C, 0x03,
  0x04, 0x00, 0x83, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x20, 0x40, 0x10, 0x20,
  0x08, 0x10, 0x0C, 0x08, 0x06, 0x04, 0x02, 0x06, 0x01, 0x81, 0x01, 0x81,
  0x80, 0x40, 0x40, 0x40, 0x40, 0x10, 0x10, 0x30, 0x10, 0x04, 0x06, 0x08,
  0x04, 0x03, 0x01, 0x86, 0x03, 0x00, 0xC0, 0x61, 0x80, 0xC0, 0x20, 0x18,
  0xC0, 0x20, 0x08, 0x06, 0x30, 0x08, 0x06, 0x01, 0x98, 0x06, 0x01, 0x80,
  0x66, 0x01, 0x80, 0x60, 0x1B, 0x00, 0x60, 0x10, 0x06, 0xC0, 0x10, 0x04,
  0x01, 0xA0, 0x04, 0x03, 0x00, 0x38, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80,
  0x70, 0x00, 0x20, 0x0A, 0x00, 0x04, 0x01, 0x60, 0x01, 0x80, 0x6C, 0x00,
  0x30, 0x0C, 0x80, 0x06, 0x01, 0x90, 0x00, 0x80, 0x22, 0x00, 0x10, 0x04,
  0x60, 0x06, 0x01, 0x8C, 0x00, 0xC0, 0x31, 0x80, 0x10, 0x06, 0x10, 0x02,
  0x00, 0x82, 0x00, 0x40, 0x10, 0x40, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC1,
  0x80, 0x40, 0x10, 0x10, 0x08, 0x02, 0x02, 0x03, 0x00, 0xC0, 0x40, 0x60,
  0x18, 0x0C, 0x0C, 0x03, 0x01, 0x81, 0x00, 0x40, 0x30, 0x20, 0x08, 0x02,
  0x0C, 0x03, 0x00, 0x41, 0x80, 0x60, 0x08, 0x30, 0x0C, 0x01, 0x84, 0x01,
  0x00, 0x30, 0x80, 0x20, 0x02, 0x30, 0x0C, 0x00, 0x46, 0x01, 0x80, 0x08,
  0x80, 0x20, 0x01, 0x90, 0x04, 0x00, 0x36, 0x01, 0x80, 0x06, 0xC0, 0x30,
  0x00, 0x58, 0x06, 0x00, 0x0A, 0x00, 0x80, 0x01, 0xC0, 0x10, 0x00, 0x38,
  0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xE1, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x08, 0x0C, 0x00,
  0x30, 0x20, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00,
  0x98, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x64, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x08, 0xC0, 0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x40,
  0x02, 0x01, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x0E, 0x0E, 0x00, 0x1F, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x30, 0x38,
  0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x06, 0x00, 0x60, 0x30,
  0x03, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00,
  0x20, 0x30, 0x03, 0x01, 0x00, 0x30, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x06,
  0x07, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE1, 0xC0, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1,
  0x80, 0x03, 0x04, 0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00,
  0x01, 0x18, 0x00, 0x04, 0x40, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x20, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60,
  0x00, 0x09, 0x00, 0x00, 0x64, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x13, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x22,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x40, 0x02, 0x01, 0x80, 0x18,
  0x02, 0x00, 0xC0, 0x0E, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x30, 0x38, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x01,
  0x80, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x00, 0x30, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x07, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x01, 0x80, 0x08, 0x04, 0x00, 0xC0, 0x20, 0x06, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x08, 0x06,
  0x00, 0x40, 0x20, 0x02, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x3C, 0x01, 0x80, 0x10, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x20, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x02, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x40, 0xC0, 0x00, 0x81,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10, 0x30,
  0x00, 0x20, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x81, 0x00, 0x02, 0x06, 0x00,
  0x04, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x20, 0x00, 0x60, 0x40, 0x00,
  0x81, 0x80, 0x01, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00, 0x03, 0x02,
  0x00, 0x04, 0x04, 0x00, 0x08, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x40, 0x00, 0x68, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x18, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40, 0x02, 0x08,
  0x00, 0xC1, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x10,
  0x06, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x01, 0x80, 0x20,
  0x30, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x41,
  0x80, 0x08, 0x20, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0x88,
  0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x40,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xD0, 0x00, 0x30, 0x00, 0x34, 0x00, 0x0C, 0x00, 0x09, 0x00, 0x03,
  0x00, 0x06, 0x40, 0x01, 0xC0, 0x01, 0x90, 0x00, 0x50, 0x00, 0xC4, 0x00,
  0x34, 0x00, 0x31, 0x00, 0x09, 0x00, 0x08, 0x40, 0x02, 0x40, 0x06, 0x10,
  0x01, 0x90, 0x01, 0x04, 0x00, 0x44, 0x00, 0xC1, 0x00, 0x31, 0x00, 0x30,
  0x40, 0x0C, 0x40, 0x08, 0x10, 0x02, 0x10, 0x06, 0x04, 0x01, 0x8C, 0x01,
  0x01, 0x00, 0x43, 0x00, 0xC0, 0x40, 0x30, 0xC0, 0x30, 0x10, 0x0C, 0x30,
  0x08, 0x04, 0x02, 0x0C, 0x06, 0x03, 0x01, 0x83, 0x01, 0x00, 0xC0, 0x40,
  0xC0, 0xC0, 0x30, 0x30, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x08, 0x03, 0x02,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0xC1, 0x00, 0x30, 0x40, 0x30, 0xC0, 0x0C,
  0x30, 0x08, 0x30, 0x03, 0x0C, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x86, 0x00,
  0x31, 0x80, 0x21, 0x00, 0x0C, 0x60, 0x08, 0xC0, 0x03, 0x10, 0x02, 0x30,
  0x00, 0xCC, 0x00, 0x88, 0x00, 0x32, 0x00, 0x26, 0x00, 0x0D, 0x80, 0x09,
  0x00, 0x03, 0x60, 0x02, 0xC0, 0x00, 0xD0, 0x00, 0xB0, 0x00, 0x3C, 0x00,
  0x28, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x01, 0x00, 0x20, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x30,
  0x18, 0x00, 0x10, 0x10, 0x00, 0x10, 0x30, 0x00, 0x10, 0x20, 0x00, 0x10,
  0x60, 0x00, 0x10, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x64, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x04, 0x00, 0x03, 0x06, 0x00, 0x02, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x02,
  0x00, 0x10, 0x02, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x02,
  0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x01, 0xA0, 0x00, 0xD0,
  0x00, 0xC8, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x18, 0x10, 0x0C, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x06, 0x01, 0x02,
  0x00, 0x83, 0x00, 0x41, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06,
  0x40, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x81, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x83,
  0x02, 0x04, 0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x18,
  0x10, 0x20, 0x40, 0x81, 0x83, 0x06, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC1,
  0x81, 0x02, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x42, 0x00, 0x06,
  0x18, 0x00, 0x20, 0xC0, 0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x60, 0x60, 0x01, 0x02, 0x00,
  0x0C, 0x30, 0x00, 0x21, 0x00, 0x01, 0x98, 0x00, 0x05, 0x80, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0x06, 0x08, 0x10, 0x40, 0x83, 0x00, 0x10,
  0x00, 0x1F, 0xC4, 0x06, 0x0D, 0x81, 0x80, 0xB0, 0x60, 0x14, 0x18, 0x03,
  0x82, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0x86, 0x00, 0x30, 0x80, 0x06,
  0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x10, 0x00, 0x46, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x08, 0x40, 0x03, 0x08, 0x00, 0x61,
  0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x03, 0x83,
  0x00, 0x70, 0x60, 0x14, 0x04, 0x06, 0x80, 0xC1, 0x90, 0x0F, 0xE2, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x02, 0x00, 0x11,
  0xF8, 0x03, 0x30, 0xC0, 0x34, 0x06, 0x02, 0x80, 0x20, 0x38, 0x02, 0x07,
  0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x06, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00,
  0xC3, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x18, 0x30, 0x01, 0x07, 0x00,
  0x30, 0x70, 0x02, 0x05, 0x00, 0x60, 0x58, 0x0C, 0x04, 0xC1, 0x80, 0xC7,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x10, 0x01, 0xFC, 0x0E, 0x08, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0E, 0x08,
  0x0F, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x10, 0x20, 0x03, 0xF9, 0x80, 0x18, 0x36, 0x00, 0xC0, 0x58,
  0x06, 0x01, 0x40, 0x30, 0x07, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x10,
  0x01, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x18, 0x08, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x80, 0x04, 0x04, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x20, 0x20, 0x01, 0x80, 0x80, 0x06, 0x02, 0x00,
  0x18, 0x08, 0x00, 0xE0, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x70,
  0x0C, 0x01, 0xC0, 0x30, 0x0A, 0x00, 0x40, 0x68, 0x01, 0x83, 0x20, 0x03,
  0xF8, 0x80, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFC, 0x03, 0x86, 0x06,
  0x02, 0x04, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x02, 0x30, 0x02, 0x30,
  0x06, 0x20, 0x04, 0x60, 0x0C, 0x60, 0x18, 0x40, 0x30, 0xC1, 0xE0, 0xFF,
  0x80, 0xF8, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x70, 0x60, 0x3F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x22, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x10, 0x03, 0x06, 0xC0,
  0x18, 0x0B, 0x00, 0xC0, 0x28, 0x06, 0x00, 0xE0, 0x10, 0x01, 0x80, 0xC0,
  0x06, 0x02, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00,
  0xC0, 0x40, 0x03, 0x01, 0x00, 0x18, 0x04, 0x00, 0x60, 0x10, 0x01, 0x80,
  0x40, 0x0E, 0x01, 0x00, 0x38, 0x06, 0x01, 0x40, 0x08, 0x0D, 0x00, 0x30,
  0x64, 0x00, 0x7F, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x20, 0x02, 0x7F, 0x00, 0xD8, 0x30, 0x1E, 0x03, 0x02, 0x80, 0x60,
  0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x00, 0x81,
  0x00, 0x30, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x10, 0x20, 0x02, 0x04,
  0x00, 0xC1, 0x80, 0x18, 0x30, 0x02, 0x06, 0x00, 0x40, 0x80, 0x08, 0x10,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0x40,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x83, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C,
  0x02, 0x01, 0x00, 0x40, 0x60, 0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0x80,
  0x08, 0x30, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00,
  0x27, 0x80, 0x05, 0xB0, 0x01, 0xE6, 0x00, 0x38, 0x40, 0x06, 0x08, 0x00,
  0xC1, 0x00, 0x10, 0x20, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x18, 0x02,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x40, 0x18, 0x08,
  0x03, 0x03, 0x00, 0x20, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x80, 0x09, 0xFC, 0x3F,
  0x80, 0xD8, 0x33, 0x0E, 0x05, 0x81, 0xA0, 0x30, 0x28, 0x07, 0x00, 0x81,
  0x80, 0x30, 0x04, 0x0C, 0x01, 0x80, 0x20, 0xC0, 0x08, 0x01, 0x06, 0x00,
  0xC0, 0x18, 0x30, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x06, 0x18, 0x01, 0x00,
  0x20, 0xC0, 0x08, 0x01, 0x06, 0x00, 0xC0, 0x18, 0x20, 0x06, 0x00, 0xC1,
  0x00, 0x20, 0x04, 0x18, 0x01, 0x00, 0x20, 0xC0, 0x18, 0x01, 0x06, 0x00,
  0xC0, 0x18, 0x20, 0x06, 0x00, 0xC1, 0x00, 0x20, 0x04, 0x18, 0x01, 0x00,
  0x20, 0xC0, 0x18, 0x03, 0x04, 0x00, 0xC0, 0x18, 0x20, 0x04, 0x00, 0xC3,
  0x00, 0x20, 0x04, 0x18, 0x03, 0x00, 0x20, 0xC0, 0x18, 0x03, 0x04, 0x00,
  0xC0, 0x18, 0x20, 0x04, 0x00, 0xC3, 0x00, 0x20, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x27, 0xF0, 0x0D, 0x83, 0x01, 0x60, 0x20, 0x28, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0x18, 0x30, 0x02, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C,
  0x18, 0x01, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x81, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x10, 0x30, 0x02, 0x04, 0x00, 0x40, 0x80, 0x18, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x00, 0xFE, 0x00, 0xE1, 0x80, 0xC0, 0x60, 0xC0, 0x10, 0x60,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01,
  0x60, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x24, 0x00, 0x32, 0x00,
  0x11, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x04, 0x30, 0x06, 0x18, 0x06, 0x0C,
  0x06, 0x03, 0x06, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x01,
  0x1F, 0x80, 0x0C, 0xC3, 0x00, 0x34, 0x06, 0x00, 0xB0, 0x08, 0x02, 0x80,
  0x20, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x20,
  0x00, 0x80, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x02, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x40, 0x30, 0x03, 0x01, 0xC0, 0x18, 0x07, 0x00,
  0x60, 0x16, 0x03, 0x00, 0x4C, 0x38, 0x03, 0x1F, 0xC0, 0x0C, 0x10, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x1F, 0xC4, 0x06, 0x1D, 0x81, 0x81, 0xB0, 0x60, 0x14, 0x18, 0x03, 0x82,
  0x00, 0x70, 0xC0, 0x06, 0x10, 0x00, 0x86, 0x00, 0x30, 0x80, 0x06, 0x10,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x61, 0x00,
  0x0C, 0x20, 0x01, 0x84, 0x00, 0x60, 0x80, 0x0C, 0x10, 0x03, 0x83, 0x00,
  0x70, 0x60, 0x14, 0x04, 0x06, 0x80, 0xC1, 0x90, 0x0F, 0xE6, 0x00, 0x20,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x01, 0x3F, 0x03, 0x60,
  0x02, 0xC0, 0x02, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0xE0, 0x60, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x06, 0x07, 0x03,
  0xFF, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x7F, 0x24, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x78, 0x04, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x01, 0x02,
  0x00, 0x20, 0x40, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x20, 0x60, 0x04, 0x08,
  0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x00, 0x10, 0x20,
  0x06, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x02, 0x04, 0x00, 0x40, 0x80,
  0x18, 0x30, 0x03, 0x06, 0x00, 0x40, 0xC0, 0x18, 0x10, 0x03, 0x02, 0x00,
  0x60, 0x40, 0x1C, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x20, 0x34, 0x06, 0x0C,
  0x80, 0x7F, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x16,
  0x00, 0x6C, 0x00, 0x98, 0x03, 0x30, 0x04, 0x60, 0x18, 0xC0, 0x31, 0x80,
  0x43, 0x01, 0x86, 0x02, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0x80,
  0xC3, 0x01, 0x86, 0x03, 0x08, 0x06, 0x30, 0x0C, 0x40, 0x19, 0x80, 0x32,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x04, 0x00, 0xD0, 0x03, 0x00, 0x24, 0x00, 0xC0,
  0x19, 0x00, 0x70, 0x04, 0x40, 0x14, 0x01, 0x10, 0x05, 0x00, 0xC4, 0x03,
  0x40, 0x21, 0x00, 0x90, 0x18, 0x40, 0x64, 0x04, 0x30, 0x11, 0x01, 0x0C,
  0x04, 0x40, 0xC3, 0x03, 0x10, 0x20, 0xC0, 0x84, 0x18, 0x30, 0x61, 0x06,
  0x0C, 0x10, 0x41, 0x03, 0x0C, 0x10, 0xC0, 0xC3, 0x04, 0x20, 0x30, 0x81,
  0x08, 0x0C, 0x60, 0x46, 0x03, 0x10, 0x11, 0x00, 0xCC, 0x04, 0xC0, 0x32,
  0x01, 0x20, 0x0C, 0x80, 0x48, 0x03, 0x60, 0x16, 0x00, 0xD0, 0x05, 0x00,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x00, 0x30, 0x10, 0x02, 0x01, 0x80,
  0x60, 0x18, 0x0C, 0x01, 0x80, 0x80, 0x08, 0x18, 0x00, 0x83, 0x00, 0x08,
  0x20, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0x4C, 0x00, 0x05, 0x80, 0x00,
  0x50, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1B, 0x00, 0x01, 0x30, 0x00, 0x31, 0x00, 0x06, 0x10, 0x00, 0x41, 0x00,
  0x0C, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x00, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0x40, 0x00, 0x80,
  0x18, 0x00, 0x10, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00,
  0x08, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x30, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x07, 0xF0, 0x07, 0x83, 0x01,
  0xC0, 0x3C, 0xE8, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 41, 12, 1, -41 },
  { 58, 11, 15, 15, 5, -41 },
  { 79, 22, 41, 21, 0, -41 },
  { 192, 22, 46, 19, -1, -43 },
  { 319, 24, 42, 30, 3, -41 },
  { 445, 18, 42, 18, -1, -41 },
  { 540, 5, 15, 8, 5, -41 },
  { 550, 16, 49, 14, 1, -40 },
  { 648, 15, 49, 14, -4, -40 },
  { 740, 14, 15, 18, 7, -43 },
  { 767, 19, 26, 23, 2, -33 },
  { 829, 7, 12, 9, -2, -5 },
  { 840, 12, 1, 15, 1, -16 },
  { 842, 3, 4, 9, 1, -4 },
  { 844, 23, 41, 17, -3, -41 },
  { 962, 18, 42, 20, 1, -41 },
  { 1057, 10, 41, 20, 6, -41 },
  { 1109, 22, 41, 20, -2, -41 },
  { 1222, 21, 42, 20, -1, -41 },
  { 1333, 21, 41, 20, -1, -41 },
  { 1441, 22, 42, 20, -2, -41 },
  { 1557, 20, 42, 20, 1, -41 },
  { 1662, 20, 41, 20, 2, -41 },
  { 1765, 21, 42, 20, -1, -41 },
  { 1876, 19, 42, 20, 0, -41 },
  { 1976, 8, 30, 9, 0, -30 },
  { 2006, 12, 37, 9, -3, -30 },
  { 2062, 19, 24, 23, 2, -32 },
  { 2119, 19, 14, 23, 2, -27 },
  { 2153, 19, 24, 23, 2, -32 },
  { 2210, 15, 41, 14, 1, -41 },
  { 2287, 27, 46, 29, 1, -41 },
  { 2443, 19, 41, 19, -4, -41 },
  { 2541, 22, 41, 21, 0, -41 },
  { 2654, 22, 42, 19, 2, -41 },
  { 2770, 22, 41, 23, 0, -41 },
  { 2883, 22, 41, 19, 0, -41 },
  { 2996, 22, 41, 18, 0, -41 },
  { 3109, 25, 42, 26, 2, -41 },
  { 3241, 26, 41, 25, 0, -41 },
  { 3375, 16, 41, 9, -3, -41 },
  { 3457, 18, 51, 9, -8, -41 },
  { 3572, 24, 41, 20, 0, -41 },
  { 3695, 13, 41, 17, 0, -41 },
  { 3762, 34, 41, 33, 0, -41 },
  { 3937, 27, 41, 26, 0, -41 },
  { 4076, 22, 42, 25, 2, -41 },
  { 4192, 21, 41, 20, 0, -41 },
  { 4300, 22, 51, 25, 2, -41 },
  { 4441, 21, 41, 20, 0, -41 },
  { 4549, 23, 42, 19, -2, -41 },
  { 4670, 17, 41, 17, 4, -41 },
  { 4758, 23, 42, 24, 2, -41 },
  { 4879, 19, 41, 20, 5, -41 },
  { 4977, 34, 41, 34, 4, -41 },
  { 5152, 24, 41, 17, -3, -41 },
  { 5275, 17, 41, 16, 4, -41 },
  { 5363, 23, 41, 17, -2, -41 },
  { 5481, 20, 50, 16, -1, -41 },
  { 5606, 7, 41, 18, 6, -41 },
  { 5642, 20, 50, 16, -3, -41 },
  { 5767, 21, 20, 22, 1, -41 },
  { 5820, 14, 2, 15, -4, 5 },
  { 5824, 6, 8, 12, 8, -43 },
  { 5830, 19, 32, 22, 2, -31 },
  { 5906, 20, 44, 21, 0, -43 },
  { 6016, 15, 32, 15, 2, -31 },
  { 6076, 22, 44, 22, 2, -43 },
  { 6197, 16, 32, 19, 2, -31 },
  { 6261, 24, 58, 10, -7, -44 },
  { 6435, 22, 45, 21, -1, -31 },
  { 6559, 19, 43, 20, 0, -43 },
  { 6662, 11, 41, 9, 0, -41 },
  { 6719, 19, 55, 9, -8, -41 },
  { 6850, 19, 43, 17, 0, -43 },
  { 6953, 11, 43, 8, 0, -43 },
  { 7013, 29, 31, 31, 0, -31 },
  { 7126, 19, 31, 20, 0, -31 },
  { 7200, 17, 32, 20, 2, -31 },
  { 7268, 22, 44, 21, -2, -31 },
  { 7389, 19, 44, 22, 2, -31 },
  { 7494, 16, 31, 13, 0, -31 },
  { 7556, 17, 32, 16, -1, -31 },
  { 7624, 10, 38, 10, 1, -37 },
  { 7672, 19, 31, 20, 1, -30 },
  { 7746, 15, 30, 15, 3, -30 },
  { 7803, 26, 30, 26, 3, -30 },
  { 7901, 20, 30, 16, -2, -30 },
  { 7976, 27, 44, 17, -7, -30 },
  { 8125, 17, 30, 13, -2, -30 },
  { 8189, 19, 50, 18, 2, -41 },
  { 8308, 1, 57, 20, 9, -43 },
  { 8316, 20, 50, 18, -4, -41 },
  { 8441, 19, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC57PT7B_H_
