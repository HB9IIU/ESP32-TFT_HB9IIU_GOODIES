#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41,
  0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x04, 0x08, 0x00, 0x23, 0x22, 0x42, 0x42, 0x42, 0x44, 0x44, 0x84, 0x84,
  0x84, 0x88, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x04, 0x20, 0x08, 0x40,
  0x20, 0x80, 0x42, 0x00, 0x84, 0x02, 0x08, 0x3F, 0xFC, 0x08, 0x40, 0x30,
  0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80,
  0x41, 0x07, 0xFF, 0x81, 0x08, 0x04, 0x10, 0x08, 0x40, 0x10, 0x80, 0x61,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x08, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x0F, 0xC0, 0x64, 0x61, 0x88, 0x02, 0x10, 0x0C, 0x40,
  0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x44, 0x00, 0x90, 0x00, 0xA0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x05, 0x00, 0x09, 0x00, 0x11, 0x00, 0x22,
  0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x08, 0x82, 0x23, 0x07,
  0xF8, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x0E, 0x01, 0x0C,
  0x80, 0x84, 0x40, 0x84, 0x20, 0x42, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20,
  0x82, 0x10, 0xC1, 0x10, 0x40, 0x88, 0x20, 0xC8, 0x10, 0x44, 0x08, 0x24,
  0x7C, 0x32, 0x46, 0x12, 0x43, 0x19, 0x21, 0xC9, 0x20, 0xB8, 0x90, 0x40,
  0x88, 0x20, 0x48, 0x10, 0x44, 0x08, 0x22, 0x08, 0x21, 0x04, 0x10, 0x82,
  0x10, 0x43, 0x08, 0x21, 0x08, 0x10, 0x84, 0x08, 0x84, 0x07, 0x80, 0x01,
  0xC0, 0x32, 0x06, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04,
  0x40, 0x44, 0x04, 0x80, 0x58, 0x05, 0x00, 0x60, 0x0E, 0x01, 0xA0, 0x12,
  0x02, 0x21, 0x41, 0x14, 0x12, 0x81, 0x28, 0x1A, 0x80, 0xC8, 0x0C, 0x80,
  0x88, 0x0C, 0x81, 0x48, 0x24, 0x7C, 0x40, 0x25, 0x24, 0x94, 0x92, 0x00,
  0x00, 0x60, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x18, 0x00, 0x04, 0x01,
  0x08, 0x41, 0x20, 0x3B, 0xC3, 0x01, 0x41, 0x90, 0x82, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x08, 0x46, 0x21, 0x10, 0x88,
  0xC0, 0xFF, 0xB8, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x00, 0x01,
  0xE0, 0x19, 0x81, 0x04, 0x18, 0x20, 0x81, 0x8C, 0x0C, 0x40, 0x62, 0x03,
  0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48,
  0x06, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x04, 0x40, 0x22, 0x03,
  0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0xC0, 0x84, 0x07, 0xC0, 0x00, 0x02,
  0x0C, 0x29, 0x96, 0x48, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x00, 0x01, 0xF0, 0x0E, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x06, 0x18,
  0x10, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x04, 0x04,
  0x0F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x14, 0x00, 0x30, 0x00, 0xA0, 0x01,
  0x40, 0x04, 0x80, 0x19, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20,
  0x18, 0xC0, 0x21, 0x00, 0x82, 0x01, 0x04, 0x04, 0x08, 0x18, 0x20, 0x20,
  0x40, 0x80, 0x81, 0x01, 0x04, 0x02, 0x1F, 0xFF, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x01, 0xFE,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0xF8, 0x01, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x04, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x4F, 0xC1, 0x41, 0x06, 0x02, 0x10, 0x08, 0xC0, 0x23, 0x00,
  0x88, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x06, 0x20, 0x10, 0x80,
  0x42, 0x02, 0x0C, 0x08, 0x10, 0x40, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00,
  0xF8, 0x02, 0x18, 0x08, 0x18, 0x20, 0x10, 0x40, 0x20, 0x80, 0x43, 0x00,
  0x86, 0x01, 0x04, 0x06, 0x08, 0x08, 0x10, 0x20, 0x10, 0xC0, 0x32, 0x00,
  0x38, 0x00, 0xE0, 0x02, 0x20, 0x18, 0x20, 0x60, 0x40, 0x80, 0x42, 0x00,
  0x84, 0x01, 0x08, 0x02, 0x30, 0x04, 0x60, 0x08, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x81, 0x02, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x10, 0x81, 0x02, 0x10,
  0x10, 0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x30, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x12, 0x00, 0x90, 0x0C, 0xC0, 0x62, 0x06, 0x18, 0xD0, 0x38, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x0C, 0x0F, 0xC0, 0x00, 0x0C, 0x30, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x30, 0xC0, 0x03, 0x03,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x80,
  0x00, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x00, 0x0F, 0x0C, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0C, 0x60, 0x06, 0x02, 0x01, 0x80,
  0x20, 0x60, 0x04, 0x08, 0x00, 0x82, 0x00, 0x18, 0x40, 0x01, 0x10, 0x10,
  0x22, 0x0F, 0x84, 0x82, 0x10, 0x90, 0xC4, 0x32, 0x10, 0x84, 0x86, 0x10,
  0x90, 0x82, 0x12, 0x10, 0x82, 0x46, 0x10, 0x58, 0x82, 0x12, 0x10, 0xC2,
  0x42, 0x18, 0x48, 0x42, 0x11, 0x08, 0xC2, 0x21, 0x18, 0x84, 0x3C, 0xE0,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x00,
  0x48, 0x04, 0x40, 0x22, 0x03, 0x10, 0x10, 0x80, 0x84, 0x08, 0x20, 0x41,
  0x06, 0x08, 0x3F, 0xC1, 0x02, 0x10, 0x10, 0x80, 0x8C, 0x04, 0x40, 0x22,
  0x01, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x1C, 0x00, 0x80, 0x03, 0xE0,
  0x04, 0x70, 0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x0C, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x40, 0x81, 0x03, 0xFC,
  0x04, 0x70, 0x08, 0x18, 0x10, 0x10, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x00, 0x84, 0x01, 0x08, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x41, 0x01,
  0x86, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xC3, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x02, 0x78, 0x02, 0x04, 0x06, 0x06, 0x04,
  0x02, 0x04, 0x02, 0x04, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08,
  0x03, 0x08, 0x03, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x60,
  0x18, 0x40, 0x10, 0x40, 0x20, 0x40, 0x60, 0x40, 0xC0, 0x83, 0x00, 0xFC,
  0x00, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0xFE, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x0F, 0xF8, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x30, 0x30, 0x10, 0x04, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0xF8, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x10,
  0xC0, 0x04, 0x30, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x02, 0x02, 0x00, 0x80, 0xC0, 0x20, 0x0F, 0xF0, 0x00, 0x02, 0x00, 0x40,
  0x80, 0x10, 0x20, 0x04, 0x18, 0x03, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40,
  0x08, 0x10, 0x02, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04,
  0x08, 0x01, 0x07, 0xFF, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04,
  0x01, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00,
  0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x82, 0x00, 0x40,
  0x80, 0x10, 0x00, 0x03, 0xE0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x22, 0x01, 0xE0, 0x00, 0x02, 0x01, 0x81, 0x00, 0x80, 0x80,
  0x80, 0xC0, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x08, 0x60, 0x0C,
  0x60, 0x04, 0x20, 0x02, 0x20, 0x01, 0x30, 0x00, 0x90, 0x00, 0x98, 0x00,
  0x54, 0x00, 0x32, 0x00, 0x19, 0x00, 0x08, 0x80, 0x08, 0x20, 0x04, 0x10,
  0x02, 0x08, 0x01, 0x04, 0x01, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x18, 0x10, 0x04, 0x08, 0x02, 0x00, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x0F, 0xF8, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x07, 0x07, 0x00, 0x06, 0x05, 0x00, 0x0E, 0x05, 0x00, 0x0A, 0x05,
  0x00, 0x1A, 0x05, 0x00, 0x16, 0x09, 0x00, 0x34, 0x09, 0x00, 0x24, 0x09,
  0x00, 0x24, 0x09, 0x00, 0x44, 0x09, 0x00, 0x48, 0x11, 0x00, 0x88, 0x11,
  0x00, 0x88, 0x11, 0x01, 0x08, 0x10, 0x81, 0x08, 0x10, 0x82, 0x10, 0x20,
  0x82, 0x10, 0x20, 0x84, 0x10, 0x20, 0x84, 0x10, 0x20, 0x88, 0x10, 0x60,
  0x88, 0x20, 0x40, 0x90, 0x20, 0x40, 0x90, 0x20, 0x40, 0xA0, 0x20, 0x40,
  0xA0, 0x40, 0x80, 0xE0, 0x40, 0x80, 0xC0, 0x40, 0x03, 0x00, 0x20, 0x60,
  0x04, 0x0C, 0x01, 0x83, 0x80, 0x20, 0x50, 0x04, 0x0A, 0x00, 0x81, 0x20,
  0x10, 0x24, 0x06, 0x0C, 0x80, 0x81, 0x10, 0x10, 0x22, 0x02, 0x04, 0x40,
  0x40, 0x84, 0x10, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x08, 0x10, 0x43,
  0x02, 0x04, 0x40, 0x80, 0x88, 0x10, 0x11, 0x02, 0x02, 0x20, 0x40, 0x4C,
  0x18, 0x0D, 0x02, 0x00, 0xA0, 0x40, 0x14, 0x08, 0x02, 0x81, 0x00, 0x60,
  0x40, 0x0C, 0x08, 0x00, 0x80, 0x00, 0x78, 0x01, 0x84, 0x03, 0x02, 0x06,
  0x02, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x08, 0xC0, 0x18, 0x40, 0x10, 0x40, 0x20, 0x40, 0x60, 0x20,
  0xC0, 0x1F, 0x80, 0x03, 0x80, 0x04, 0xF0, 0x08, 0x30, 0x30, 0x20, 0x40,
  0x40, 0x80, 0xC1, 0x01, 0x82, 0x03, 0x0C, 0x04, 0x10, 0x08, 0x20, 0x10,
  0x40, 0x60, 0x80, 0x82, 0x03, 0x04, 0x0C, 0x08, 0x60, 0x1F, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00, 0x78,
  0x01, 0x84, 0x03, 0x02, 0x06, 0x02, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x03,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04,
  0xC0, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0xC0, 0x18, 0x40, 0x10,
  0x40, 0x20, 0x40, 0x60, 0x20, 0xC0, 0x1F, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x03, 0xC0,
  0x04, 0xF0, 0x08, 0x30, 0x30, 0x20, 0x40, 0x40, 0x80, 0xC1, 0x01, 0x82,
  0x03, 0x0C, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x60, 0x80, 0x82, 0x02,
  0x04, 0x08, 0x0F, 0xE0, 0x11, 0x00, 0x21, 0x00, 0x82, 0x01, 0x04, 0x02,
  0x08, 0x04, 0x10, 0x18, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x81, 0x01,
  0x04, 0x02, 0x08, 0x06, 0x00, 0x00, 0xFC, 0x01, 0x83, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x80,
  0xC0, 0xFF, 0x80, 0x7F, 0xF8, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x82, 0x00, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x08,
  0x20, 0x08, 0x30, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00,
  0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x20, 0x08, 0x20,
  0x04, 0x10, 0x02, 0x08, 0x03, 0x04, 0x01, 0x02, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x60, 0x80, 0x20, 0x40, 0x10, 0x10, 0x10, 0x0C, 0x18, 0x03, 0xF0,
  0x00, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00, 0x48,
  0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82,
  0x04, 0x08, 0x10, 0x20, 0xC0, 0x82, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00,
  0x88, 0x02, 0x20, 0x09, 0x80, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x02, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x06, 0x80, 0x28, 0x04, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x08, 0x80, 0x50, 0x08, 0x80, 0xD0, 0x18, 0x80, 0x90, 0x10, 0x80, 0x90,
  0x10, 0x81, 0x10, 0x20, 0x81, 0x10, 0x20, 0x83, 0x10, 0x60, 0x82, 0x10,
  0x40, 0x82, 0x10, 0x40, 0x84, 0x10, 0x80, 0x84, 0x10, 0x80, 0x84, 0x11,
  0x80, 0x88, 0x11, 0x00, 0x88, 0x11, 0x00, 0x90, 0x12, 0x00, 0x90, 0x12,
  0x00, 0x90, 0x16, 0x00, 0xA0, 0x14, 0x00, 0xA0, 0x14, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x00, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x40, 0x10, 0x20, 0x08, 0x20, 0x04, 0x10, 0x01, 0x10,
  0x00, 0x98, 0x00, 0x48, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x08, 0x02, 0x00, 0x80, 0x18, 0x02,
  0x80, 0x24, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x42, 0x04, 0x40, 0x44, 0x04, 0x80, 0x28, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x84, 0x20, 0x84,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x30, 0x84, 0x21, 0x08, 0x43,
  0x08, 0x42, 0x10, 0x80, 0x01, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x0F, 0xC0, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01,
  0xA0, 0x04, 0x40, 0x31, 0x00, 0x82, 0x06, 0x08, 0x10, 0x10, 0xC0, 0x42,
  0x01, 0x98, 0x02, 0x40, 0x0F, 0x00, 0x10, 0xFF, 0xC0, 0x88, 0x44, 0x22,
  0x10, 0x03, 0xE4, 0x10, 0xE0, 0x81, 0x84, 0x06, 0x10, 0x18, 0x80, 0x62,
  0x01, 0x18, 0x04, 0x40, 0x11, 0x00, 0x44, 0x03, 0x30, 0x08, 0x80, 0x22,
  0x00, 0x88, 0x06, 0x20, 0x10, 0x80, 0x42, 0x03, 0x04, 0x14, 0x10, 0x50,
  0x3E, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x17, 0xC0, 0xA0, 0x82, 0x82, 0x0C,
  0x04, 0x20, 0x11, 0x80, 0x46, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x88,
  0x02, 0x20, 0x08, 0x80, 0x22, 0x01, 0x88, 0x04, 0x60, 0x11, 0x80, 0x86,
  0x02, 0x18, 0x10, 0xB0, 0x82, 0x7C, 0x00, 0x03, 0xE1, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x03, 0xE0,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x03, 0xE4, 0x04, 0x38, 0x08, 0x18,
  0x10, 0x18, 0x10, 0x18, 0x20, 0x18, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x30, 0xC0, 0x20, 0x80, 0x20, 0x80, 0x20, 0x80, 0x60,
  0x80, 0x40, 0x80, 0x40, 0x80, 0xC0, 0x41, 0x40, 0x43, 0x40, 0x3E, 0x80,
  0x07, 0xE1, 0x84, 0x20, 0x88, 0x13, 0x02, 0x40, 0x48, 0x1A, 0x02, 0x41,
  0x88, 0xE3, 0xF0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x43, 0xF0, 0x00, 0x01, 0x00, 0x03, 0x40, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x7F, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x01, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF9, 0x01,
  0x0E, 0x02, 0x06, 0x04, 0x06, 0x04, 0x06, 0x08, 0x06, 0x08, 0x04, 0x18,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x30, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0x18, 0x20, 0x10, 0x20, 0x10, 0x20, 0x30, 0x10, 0x50, 0x10,
  0xD0, 0x0F, 0xA0, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x81, 0x80, 0xE7, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x2F, 0x82, 0x82, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20, 0x23,
  0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x60, 0x22, 0x03, 0x10, 0x10, 0x80,
  0x84, 0x04, 0x60, 0x22, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x40, 0x60,
  0x02, 0x04, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x0B,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x42, 0x04, 0x10, 0x40, 0x86,
  0x04, 0x20, 0x62, 0x02, 0x20, 0x13, 0x00, 0x90, 0x05, 0x80, 0x52, 0x03,
  0x10, 0x18, 0x80, 0x84, 0x04, 0x20, 0x41, 0x02, 0x0C, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x40, 0x40, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x05, 0xF3,
  0xF0, 0x50, 0xF0, 0x83, 0x03, 0x02, 0x18, 0x10, 0x10, 0x80, 0x81, 0x04,
  0x0C, 0x08, 0x40, 0x40, 0x42, 0x02, 0x02, 0x10, 0x10, 0x10, 0x80, 0x81,
  0x0C, 0x08, 0x08, 0x40, 0x40, 0x42, 0x02, 0x02, 0x10, 0x10, 0x10, 0x81,
  0x81, 0x08, 0x08, 0x08, 0x40, 0x40, 0x42, 0x02, 0x02, 0x10, 0x10, 0x30,
  0x81, 0x01, 0x08, 0x08, 0x08, 0x00, 0x0D, 0xF0, 0x50, 0x43, 0x02, 0x18,
  0x10, 0x80, 0x84, 0x04, 0x40, 0x62, 0x02, 0x10, 0x10, 0x80, 0x8C, 0x04,
  0x40, 0x62, 0x02, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x42, 0x02, 0x10,
  0x10, 0x80, 0x88, 0x0C, 0x00, 0x07, 0xE0, 0xC2, 0x18, 0x11, 0x01, 0x30,
  0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x1C, 0x03, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0xC0, 0x84, 0x10, 0x3E,
  0x00, 0x01, 0x7C, 0x02, 0xC2, 0x02, 0x82, 0x03, 0x01, 0x02, 0x01, 0x02,
  0x01, 0x06, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x03, 0x0C, 0x02, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x18, 0x04, 0x18, 0x08, 0x18,
  0x08, 0x18, 0x10, 0x1C, 0x20, 0x27, 0xC0, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x03, 0xE4, 0x30, 0xE0, 0x81, 0x84, 0x06, 0x10, 0x18, 0x80, 0x62,
  0x01, 0x18, 0x04, 0x40, 0x11, 0x00, 0x44, 0x01, 0x10, 0x08, 0x80, 0x22,
  0x00, 0x88, 0x06, 0x20, 0x18, 0x80, 0x42, 0x03, 0x0C, 0x14, 0x10, 0xD0,
  0x3E, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x0D, 0xE1, 0x40, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x07,
  0xF0, 0xC1, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x88, 0x10, 0xFE, 0x00, 0x0C, 0x10, 0x20, 0x41, 0x8F,
  0xC4, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0xE0, 0x08, 0x08, 0x80, 0x44, 0x04, 0x20,
  0x21, 0x01, 0x18, 0x08, 0x80, 0xC4, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08,
  0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x18, 0x80, 0x84, 0x0C, 0x20,
  0x61, 0x05, 0x07, 0xC8, 0x00, 0x80, 0x70, 0x0A, 0x01, 0x40, 0x48, 0x09,
  0x02, 0x20, 0x44, 0x18, 0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10,
  0x24, 0x04, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x00, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x0A, 0x03, 0x02, 0x81, 0x41, 0x20, 0x50, 0x48,
  0x24, 0x12, 0x09, 0x08, 0x82, 0x42, 0x21, 0x11, 0x08, 0x44, 0x42, 0x21,
  0x10, 0x88, 0x48, 0x22, 0x12, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x50,
  0x28, 0x18, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x00, 0x04, 0x06,
  0x04, 0x08, 0x08, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x44, 0x00, 0x88, 0x00,
  0xA0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90,
  0x02, 0x20, 0x04, 0x40, 0x10, 0x40, 0x60, 0x80, 0x81, 0x02, 0x02, 0x0C,
  0x04, 0x00, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x40,
  0x08, 0x08, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x10, 0x00, 0x82, 0x00,
  0x10, 0xC0, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00,
  0x24, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x01, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x04, 0x01,
  0xE0, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x03, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x03, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x70,
  0x03, 0x80, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x38, 0x01, 0x98, 0x18, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 29, 8, 1, -29 },
  { 27, 8, 11, 10, 4, -29 },
  { 38, 15, 29, 15, 0, -29 },
  { 93, 15, 32, 14, 0, -30 },
  { 153, 17, 29, 21, 2, -29 },
  { 215, 12, 29, 13, 0, -29 },
  { 259, 3, 11, 6, 4, -29 },
  { 264, 11, 34, 10, 1, -28 },
  { 311, 11, 34, 10, -3, -28 },
  { 358, 10, 10, 13, 5, -30 },
  { 371, 14, 18, 16, 1, -23 },
  { 403, 5, 9, 6, -2, -4 },
  { 409, 8, 1, 10, 1, -11 },
  { 410, 2, 3, 6, 1, -3 },
  { 411, 16, 28, 12, -2, -28 },
  { 467, 13, 29, 14, 1, -29 },
  { 515, 7, 29, 14, 4, -29 },
  { 541, 15, 29, 14, -1, -29 },
  { 596, 15, 29, 14, -1, -29 },
  { 651, 15, 29, 14, -1, -29 },
  { 706, 15, 29, 14, -1, -29 },
  { 761, 14, 29, 14, 1, -29 },
  { 812, 14, 29, 14, 1, -29 },
  { 863, 15, 29, 14, -1, -29 },
  { 918, 13, 29, 14, 0, -29 },
  { 966, 6, 21, 6, 0, -21 },
  { 982, 8, 26, 6, -2, -21 },
  { 1008, 14, 16, 16, 1, -22 },
  { 1036, 14, 10, 16, 1, -19 },
  { 1054, 14, 16, 16, 1, -22 },
  { 1082, 10, 29, 10, 1, -29 },
  { 1119, 19, 33, 20, 1, -29 },
  { 1198, 13, 29, 13, -3, -29 },
  { 1246, 15, 29, 15, 0, -29 },
  { 1301, 16, 29, 13, 1, -29 },
  { 1359, 16, 29, 16, 0, -29 },
  { 1417, 15, 29, 14, 0, -29 },
  { 1472, 15, 29, 12, 0, -29 },
  { 1527, 18, 29, 18, 1, -29 },
  { 1593, 18, 29, 18, 0, -29 },
  { 1659, 11, 29, 7, -2, -29 },
  { 1699, 13, 36, 6, -6, -29 },
  { 1758, 17, 29, 14, 0, -29 },
  { 1820, 9, 29, 12, 0, -29 },
  { 1853, 24, 29, 23, 0, -29 },
  { 1940, 19, 29, 18, 0, -29 },
  { 2009, 16, 29, 18, 1, -29 },
  { 2067, 15, 29, 14, 0, -29 },
  { 2122, 16, 36, 18, 1, -29 },
  { 2194, 15, 29, 14, 0, -29 },
  { 2249, 16, 29, 14, -1, -29 },
  { 2307, 12, 29, 12, 3, -29 },
  { 2351, 17, 29, 17, 1, -29 },
  { 2413, 14, 29, 14, 3, -29 },
  { 2464, 24, 29, 24, 3, -29 },
  { 2551, 17, 29, 12, -2, -29 },
  { 2613, 12, 29, 12, 3, -29 },
  { 2657, 17, 29, 12, -2, -29 },
  { 2719, 14, 35, 11, -1, -29 },
  { 2781, 5, 29, 13, 4, -29 },
  { 2800, 14, 35, 11, -2, -29 },
  { 2862, 14, 14, 16, 1, -29 },
  { 2887, 10, 1, 10, -3, 4 },
  { 2889, 4, 7, 8, 6, -31 },
  { 2893, 14, 21, 15, 1, -21 },
  { 2930, 14, 30, 15, 0, -30 },
  { 2983, 11, 21, 11, 1, -21 },
  { 3012, 16, 30, 15, 1, -30 },
  { 3072, 11, 21, 13, 1, -21 },
  { 3101, 17, 41, 7, -5, -31 },
  { 3189, 16, 31, 15, -1, -21 },
  { 3251, 13, 30, 14, 0, -30 },
  { 3300, 7, 28, 6, 0, -28 },
  { 3325, 13, 38, 6, -5, -28 },
  { 3387, 13, 30, 12, 0, -30 },
  { 3436, 8, 30, 6, 0, -30 },
  { 3466, 21, 21, 22, 0, -21 },
  { 3522, 13, 21, 14, 0, -21 },
  { 3557, 12, 21, 14, 1, -21 },
  { 3589, 16, 30, 15, -2, -21 },
  { 3649, 14, 30, 15, 1, -21 },
  { 3702, 11, 21, 9, 0, -21 },
  { 3731, 12, 21, 11, -1, -21 },
  { 3763, 7, 26, 7, 1, -26 },
  { 3786, 13, 21, 14, 1, -21 },
  { 3821, 11, 21, 11, 2, -21 },
  { 3850, 18, 21, 18, 2, -21 },
  { 3898, 15, 21, 11, -2, -21 },
  { 3938, 19, 31, 12, -5, -21 },
  { 4012, 11, 21, 9, -1, -21 },
  { 4041, 14, 35, 12, 1, -29 },
  { 4103, 1, 40, 14, 6, -30 },
  { 4108, 14, 35, 12, -3, -29 },
  { 4170, 14, 3, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC40PT7B_H_
