#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x00, 0x00, 0x10, 0xC0, 0x45, 0x24, 0xA2, 0x8A, 0x49, 0x00, 0x02,
  0x20, 0x44, 0x08, 0x82, 0x20, 0x44, 0x08, 0x8F, 0xF8, 0x44, 0x08, 0x82,
  0x20, 0x44, 0x08, 0x81, 0x11, 0xFF, 0x08, 0x81, 0x10, 0x44, 0x08, 0x81,
  0x10, 0x44, 0x08, 0x80, 0x01, 0x00, 0x20, 0x04, 0x07, 0xF1, 0x10, 0x24,
  0x08, 0x81, 0x10, 0x22, 0x02, 0x40, 0x50, 0x06, 0x00, 0x40, 0x0C, 0x02,
  0x40, 0x48, 0x08, 0x81, 0x10, 0x24, 0x08, 0x89, 0x20, 0xF0, 0x04, 0x00,
  0x80, 0x20, 0x00, 0x0C, 0x08, 0x90, 0x88, 0x84, 0x44, 0x44, 0x22, 0x21,
  0x21, 0x09, 0x08, 0x90, 0x84, 0x84, 0x29, 0xE2, 0x53, 0x14, 0x95, 0x28,
  0xB2, 0x44, 0x14, 0x21, 0x21, 0x09, 0x08, 0x88, 0x44, 0x44, 0x42, 0x22,
  0x12, 0x20, 0xF0, 0x02, 0x02, 0x82, 0x21, 0x11, 0x08, 0x88, 0x44, 0x24,
  0x0A, 0x06, 0x02, 0x03, 0x02, 0x42, 0x25, 0x13, 0x0A, 0x83, 0x41, 0xA0,
  0x90, 0x48, 0x53, 0xC8, 0x56, 0xA8, 0x03, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x06, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x10, 0x22,
  0x42, 0xB3, 0x8E, 0x22, 0x04, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x24, 0xA5,
  0x20, 0xFC, 0x70, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x00, 0x07,
  0x04, 0x44, 0x22, 0x12, 0x09, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x60, 0x30,
  0x18, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x21, 0x10, 0x88, 0x83, 0x80,
  0x19, 0x53, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x11,
  0x08, 0x00, 0x03, 0x81, 0x88, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0xFE, 0x00, 0x01, 0x81, 0x8C,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x3C,
  0x01, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x31, 0xF8, 0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x02,
  0x80, 0x90, 0x12, 0x04, 0x40, 0x88, 0x22, 0x08, 0x41, 0x08, 0x41, 0x08,
  0x22, 0x08, 0xFF, 0xC0, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x07,
  0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x1E, 0x02,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x0F, 0xC0, 0x03, 0xC1, 0x00, 0x80, 0x40, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x17, 0x8A, 0x13, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04,
  0x81, 0x20, 0x48, 0x22, 0x08, 0x84, 0x1E, 0x00, 0x3F, 0xC0, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x00, 0x07,
  0x01, 0x18, 0x41, 0x08, 0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x81,
  0x20, 0x18, 0x0F, 0x02, 0x20, 0x82, 0x20, 0x44, 0x04, 0x80, 0x90, 0x12,
  0x04, 0x40, 0x88, 0x20, 0xF8, 0x00, 0x07, 0x02, 0x21, 0x04, 0x41, 0x20,
  0x48, 0x12, 0x04, 0x81, 0x20, 0x50, 0x12, 0x0C, 0x82, 0x33, 0x82, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x10, 0x04, 0x3E, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x88, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x41, 0x08, 0x20, 0x00, 0x40, 0x20,
  0x30, 0x30, 0x30, 0x30, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x40, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x04, 0x06, 0x06, 0x02,
  0x03, 0x00, 0x80, 0x00, 0x0E, 0x11, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x00, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0xC0, 0x0C, 0xC0, 0x40, 0x82, 0x02, 0x10, 0x04, 0x40,
  0x12, 0x00, 0x48, 0xF1, 0x42, 0x45, 0x11, 0x14, 0x84, 0x62, 0x22, 0x88,
  0x8A, 0x22, 0x29, 0x10, 0xA4, 0x44, 0x91, 0x12, 0x2A, 0x88, 0x44, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x80, 0x1C, 0x00, 0x00, 0x40,
  0x30, 0x0C, 0x05, 0x01, 0x40, 0x50, 0x24, 0x09, 0x04, 0x41, 0x10, 0x44,
  0x21, 0x08, 0x45, 0xF1, 0x04, 0x41, 0x20, 0x48, 0x14, 0x05, 0x01, 0x80,
  0x60, 0x10, 0x0F, 0xC1, 0x04, 0x20, 0x84, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x82, 0x10, 0x83, 0xE0, 0x84, 0x10, 0x42, 0x04, 0x40, 0x90, 0x12, 0x02,
  0x40, 0x88, 0x11, 0x04, 0x41, 0x8F, 0xC0, 0x01, 0xE0, 0xC4, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x82, 0x08, 0x20, 0x81, 0x10, 0x11, 0x01, 0x10,
  0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x40,
  0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x08, 0x60, 0xF8, 0x00, 0x0F, 0xE1,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x07, 0xF0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x0F, 0xE0, 0x0F, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x00, 0x01, 0xF0, 0x10, 0x43,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x03, 0xC8, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0x44,
  0x02, 0x20, 0x10, 0x80, 0x84, 0x08, 0x1F, 0xC0, 0x08, 0x04, 0x20, 0x20,
  0x80, 0x82, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x04, 0x04, 0x10, 0x10,
  0xFF, 0xC2, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x10,
  0x40, 0x41, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x80, 0x07, 0x81, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x0F, 0x80, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x70, 0x00, 0x08, 0x18, 0x41, 0x02, 0x10, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x48, 0x02, 0x40, 0x14, 0x01, 0x60, 0x0D, 0x00, 0x68, 0x02, 0x40,
  0x11, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x00, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x0F, 0xE0, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x14, 0x30, 0x06, 0x14, 0x02, 0x85, 0x00, 0xA1, 0x40,
  0x48, 0x50, 0x14, 0x14, 0x09, 0x09, 0x02, 0x42, 0x41, 0x10, 0x88, 0x44,
  0x22, 0x22, 0x08, 0x88, 0x84, 0x22, 0x21, 0x09, 0x08, 0x42, 0x42, 0x10,
  0xA1, 0x08, 0x28, 0x42, 0x0C, 0x10, 0x83, 0x04, 0x00, 0x0C, 0x04, 0x30,
  0x10, 0xC0, 0x43, 0x01, 0x12, 0x08, 0x48, 0x21, 0x20, 0x84, 0x82, 0x12,
  0x10, 0x84, 0x42, 0x11, 0x08, 0x44, 0x21, 0x10, 0x84, 0x84, 0x12, 0x10,
  0x28, 0x40, 0xA1, 0x02, 0x84, 0x0C, 0x20, 0x30, 0x80, 0x40, 0x03, 0x80,
  0x46, 0x08, 0x21, 0x01, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48,
  0x08, 0x80, 0x88, 0x10, 0x42, 0x03, 0xC0, 0x0F, 0xC1, 0x08, 0x20, 0x84,
  0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10, 0x44, 0x10, 0x84, 0x1F, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00,
  0x03, 0x80, 0x46, 0x08, 0x21, 0x01, 0x10, 0x12, 0x01, 0x20, 0x14, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x42, 0x03, 0xC0, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x0F, 0xC1, 0x08, 0x20, 0x84, 0x11, 0x02,
  0x20, 0x44, 0x08, 0x82, 0x10, 0x44, 0x10, 0x8C, 0x1E, 0x02, 0x20, 0x44,
  0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x04, 0x40, 0x88, 0x10, 0x01, 0xE0,
  0x61, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x0F, 0xE0, 0x7F, 0x84, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x00, 0x10, 0x11, 0x01, 0x10, 0x11,
  0x01, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44,
  0x04, 0x40, 0x48, 0x08, 0x80, 0x88, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08,
  0x20, 0x7C, 0x00, 0x80, 0xE0, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x82, 0x20, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xA0,
  0x30, 0x0C, 0x02, 0x00, 0x80, 0x00, 0x80, 0x40, 0x60, 0x30, 0x28, 0x0C,
  0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0x50, 0x48, 0x24, 0x22, 0x09, 0x08,
  0x84, 0x42, 0x21, 0x11, 0x08, 0x44, 0x42, 0x22, 0x20, 0x88, 0x88, 0x24,
  0x22, 0x09, 0x09, 0x02, 0x42, 0x40, 0xA0, 0xA0, 0x28, 0x28, 0x0C, 0x0A,
  0x03, 0x03, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x08, 0x10, 0x80, 0x84, 0x04,
  0x40, 0x22, 0x01, 0x20, 0x09, 0x00, 0x50, 0x03, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08,
  0x20, 0x81, 0x08, 0x08, 0x00, 0x80, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21,
  0x10, 0x90, 0x48, 0x28, 0x14, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0xFF,
  0x00, 0x03, 0xE0, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x1F,
  0x80, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x21, 0x11, 0x10,
  0x03, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x00,
  0x04, 0x01, 0x40, 0x48, 0x08, 0x82, 0x10, 0x41, 0x10, 0x22, 0x04, 0x80,
  0x50, 0x0C, 0xFE, 0x89, 0x12, 0x0F, 0x44, 0x32, 0x0C, 0x82, 0x40, 0x90,
  0x24, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x12, 0x04, 0x82, 0x20, 0x88, 0x61,
  0xE8, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x4E, 0x14,
  0x46, 0x11, 0x04, 0x41, 0x20, 0x48, 0x12, 0x04, 0x81, 0x40, 0x50, 0x24,
  0x09, 0x02, 0x41, 0x28, 0x8B, 0xC0, 0x0F, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x78, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0xF4, 0x10, 0xC2,
  0x0C, 0x20, 0x84, 0x08, 0x40, 0x84, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08,
  0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x60, 0x7A, 0x00, 0x0F, 0x11, 0x21,
  0x21, 0x41, 0x42, 0x86, 0x98, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x7C, 0x00, 0x38, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x7C, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x70, 0x00, 0x03, 0xD0, 0x43, 0x08, 0x30, 0x82, 0x10, 0x21, 0x02, 0x10,
  0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08, 0x21,
  0x81, 0xE8, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0xFC,
  0x00, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x5E, 0x18,
  0x44, 0x11, 0x04, 0x41, 0x20, 0x88, 0x22, 0x08, 0x82, 0x40, 0x90, 0x44,
  0x11, 0x04, 0x41, 0x20, 0x48, 0x20, 0x0C, 0x20, 0x00, 0x00, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x03, 0x80, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x41, 0x10, 0x84, 0x41, 0x10, 0x88,
  0x24, 0x0A, 0x03, 0x40, 0xD0, 0x24, 0x11, 0x04, 0x41, 0x10, 0x42, 0x20,
  0x88, 0x20, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x00, 0x17, 0x9E, 0x31, 0xC4,
  0x41, 0x08, 0x82, 0x11, 0x08, 0x24, 0x10, 0x48, 0x20, 0x90, 0x41, 0x20,
  0x84, 0x82, 0x09, 0x04, 0x12, 0x08, 0x24, 0x10, 0x48, 0x41, 0x20, 0x82,
  0x41, 0x04, 0x17, 0x86, 0x11, 0x04, 0x41, 0x10, 0x48, 0x22, 0x08, 0x82,
  0x20, 0x90, 0x24, 0x11, 0x04, 0x41, 0x10, 0x48, 0x12, 0x08, 0x0F, 0x08,
  0x88, 0x24, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x28,
  0x24, 0x12, 0x10, 0xF0, 0x09, 0xC1, 0x44, 0x30, 0x84, 0x10, 0x82, 0x20,
  0x44, 0x08, 0x81, 0x10, 0x24, 0x04, 0x81, 0x10, 0x22, 0x04, 0x41, 0x14,
  0x42, 0xF0, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x0F, 0x44, 0x32, 0x0C, 0x82, 0x40, 0x90, 0x24, 0x0A, 0x02, 0x81, 0x20,
  0x48, 0x12, 0x04, 0x82, 0x20, 0x88, 0x61, 0xE8, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x17, 0x18, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x1F, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0xF8, 0x08, 0x20, 0x84, 0x3C, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x1C, 0x20, 0x90, 0x48, 0x24, 0x14, 0x0A, 0x09, 0x04,
  0x82, 0x41, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x32, 0x29, 0xF8, 0x81, 0x82,
  0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90, 0x90, 0xA0, 0xA0, 0xC0, 0xC0,
  0x80, 0x80, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x0C, 0x28, 0xA1, 0x45, 0x12,
  0x28, 0x92, 0x48, 0x92, 0x45, 0x12, 0x28, 0xA1, 0x45, 0x0C, 0x30, 0x61,
  0x82, 0x0C, 0x10, 0x40, 0x10, 0x61, 0x08, 0x22, 0x04, 0x40, 0x90, 0x14,
  0x02, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x50, 0x11, 0x02, 0x20, 0x84, 0x10,
  0x84, 0x10, 0x04, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x41, 0x02, 0x10,
  0x10, 0x80, 0x88, 0x04, 0x40, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x01, 0xC0,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x00, 0xC0, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x38, 0x00, 0x70, 0x63, 0x10, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 21, 6, 0, -21 },
  { 17, 6, 7, 8, 3, -21 },
  { 23, 11, 21, 11, 0, -21 },
  { 52, 11, 25, 10, 0, -23 },
  { 87, 13, 22, 16, 1, -22 },
  { 123, 9, 22, 10, 0, -22 },
  { 148, 2, 7, 4, 3, -21 },
  { 150, 8, 26, 7, 1, -21 },
  { 176, 8, 26, 7, -2, -21 },
  { 202, 7, 8, 10, 4, -23 },
  { 209, 10, 13, 12, 1, -17 },
  { 226, 3, 7, 5, -1, -3 },
  { 229, 6, 1, 8, 1, -9 },
  { 230, 2, 2, 5, 0, -2 },
  { 231, 12, 21, 9, -1, -21 },
  { 263, 9, 22, 10, 1, -22 },
  { 288, 5, 21, 10, 3, -21 },
  { 302, 11, 22, 10, -1, -22 },
  { 333, 11, 22, 10, -1, -22 },
  { 364, 11, 22, 10, -1, -22 },
  { 395, 11, 21, 10, -1, -21 },
  { 424, 10, 22, 10, 1, -22 },
  { 452, 10, 21, 10, 1, -21 },
  { 479, 11, 22, 10, 0, -22 },
  { 510, 10, 22, 10, 0, -22 },
  { 538, 4, 16, 5, 0, -16 },
  { 546, 6, 20, 5, -1, -16 },
  { 561, 10, 13, 12, 1, -17 },
  { 578, 10, 7, 12, 1, -14 },
  { 587, 10, 13, 12, 1, -17 },
  { 604, 8, 22, 7, 0, -22 },
  { 626, 14, 25, 15, 1, -22 },
  { 670, 10, 22, 10, -2, -22 },
  { 698, 11, 21, 11, 0, -21 },
  { 727, 11, 22, 10, 1, -22 },
  { 758, 12, 21, 12, 0, -21 },
  { 790, 11, 21, 10, 0, -21 },
  { 819, 11, 21, 9, 0, -21 },
  { 848, 13, 22, 14, 1, -22 },
  { 884, 14, 21, 13, 0, -21 },
  { 921, 9, 21, 5, -2, -21 },
  { 945, 9, 26, 5, -4, -21 },
  { 975, 13, 21, 10, 0, -21 },
  { 1010, 7, 21, 9, 0, -21 },
  { 1029, 18, 21, 18, 0, -21 },
  { 1077, 14, 21, 14, 0, -21 },
  { 1114, 12, 22, 13, 1, -22 },
  { 1147, 11, 21, 11, 0, -21 },
  { 1176, 12, 27, 13, 1, -22 },
  { 1217, 11, 21, 11, 0, -21 },
  { 1246, 12, 22, 10, -1, -22 },
  { 1279, 9, 21, 9, 2, -21 },
  { 1303, 12, 21, 13, 1, -21 },
  { 1335, 10, 21, 10, 3, -21 },
  { 1362, 18, 21, 18, 2, -21 },
  { 1410, 13, 21, 9, -2, -21 },
  { 1445, 9, 21, 9, 2, -21 },
  { 1469, 12, 21, 9, -1, -21 },
  { 1501, 11, 26, 8, -1, -21 },
  { 1537, 4, 21, 10, 3, -21 },
  { 1548, 11, 26, 8, -2, -21 },
  { 1584, 11, 10, 12, 1, -21 },
  { 1598, 7, 1, 8, -2, 3 },
  { 1599, 3, 5, 6, 4, -23 },
  { 1601, 10, 16, 11, 1, -16 },
  { 1621, 10, 23, 11, 0, -23 },
  { 1650, 8, 16, 8, 1, -16 },
  { 1666, 12, 23, 11, 1, -23 },
  { 1701, 8, 16, 10, 1, -16 },
  { 1717, 13, 30, 6, -4, -23 },
  { 1766, 12, 23, 11, -1, -16 },
  { 1801, 10, 23, 11, 0, -23 },
  { 1830, 6, 21, 5, 0, -21 },
  { 1846, 10, 28, 5, -4, -21 },
  { 1881, 10, 23, 9, 0, -23 },
  { 1910, 6, 23, 4, 0, -23 },
  { 1928, 15, 16, 16, 0, -16 },
  { 1958, 10, 16, 11, 0, -16 },
  { 1978, 9, 16, 11, 1, -16 },
  { 1996, 11, 23, 11, -1, -16 },
  { 2028, 10, 23, 11, 1, -16 },
  { 2057, 8, 16, 7, 0, -16 },
  { 2073, 8, 16, 8, 0, -16 },
  { 2089, 6, 20, 5, 0, -20 },
  { 2104, 9, 16, 11, 1, -16 },
  { 2122, 8, 16, 8, 2, -16 },
  { 2138, 13, 16, 14, 2, -16 },
  { 2164, 11, 16, 9, -1, -16 },
  { 2186, 13, 23, 9, -3, -16 },
  { 2224, 9, 16, 7, -1, -16 },
  { 2242, 10, 26, 9, 1, -21 },
  { 2275, 1, 30, 10, 5, -23 },
  { 2279, 10, 26, 9, -2, -21 },
  { 2312, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC30PT7B_H_
