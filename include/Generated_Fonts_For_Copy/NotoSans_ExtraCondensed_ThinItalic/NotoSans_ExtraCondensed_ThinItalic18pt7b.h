#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x00, 0x80, 0xB6, 0xDA, 0x0A, 0x24,
  0x50, 0xA6, 0xE5, 0x0A, 0x24, 0xFC, 0xA1, 0x44, 0x8A, 0x00, 0x08, 0x10,
  0xFA, 0x45, 0x0A, 0x0C, 0x08, 0x10, 0x50, 0xA1, 0x4B, 0x08, 0x10, 0x00,
  0x72, 0x52, 0x94, 0x94, 0x98, 0xAA, 0xB5, 0xD9, 0x29, 0x29, 0x4A, 0x4A,
  0x8C, 0x19, 0x4A, 0x52, 0x98, 0x8A, 0x9C, 0xE3, 0x2E, 0x80, 0xF8, 0x08,
  0x44, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x21, 0x08, 0x10, 0x82, 0x10,
  0x84, 0x21, 0x08, 0x84, 0x42, 0x21, 0x10, 0x25, 0x16, 0xC9, 0x00, 0x20,
  0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x56, 0xF0, 0x80, 0x02, 0x04, 0x10,
  0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x00, 0x1C, 0x92, 0x51,
  0x45, 0x14, 0x61, 0x86, 0x28, 0xA4, 0x70, 0x2E, 0x94, 0x92, 0x52, 0x48,
  0x1C, 0x04, 0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x20, 0x82, 0x0F, 0x80,
  0x3C, 0x10, 0x41, 0x04, 0x23, 0x02, 0x08, 0x20, 0x82, 0xF0, 0x04, 0x10,
  0xC5, 0x14, 0xA4, 0x92, 0x8B, 0xE1, 0x04, 0x10, 0x3C, 0x82, 0x10, 0x41,
  0xC0, 0x82, 0x08, 0x20, 0x82, 0xF0, 0x1E, 0x40, 0x82, 0x04, 0x0F, 0x11,
  0x42, 0x85, 0x0A, 0x24, 0x47, 0x00, 0x7C, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x41, 0x04, 0x20, 0x80, 0x1C, 0x94, 0x51, 0x24, 0xA3, 0x12, 0x8A, 0x28,
  0xA2, 0xF0, 0x18, 0x94, 0x51, 0x45, 0x14, 0x4F, 0x08, 0x20, 0x84, 0xE0,
  0x24, 0x00, 0x00, 0x10, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x0C, 0xC4,
  0x20, 0x40, 0xC0, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x19,
  0x88, 0x00, 0x38, 0x42, 0x11, 0x08, 0x88, 0x42, 0x00, 0x08, 0x00, 0x0F,
  0x08, 0x48, 0x24, 0x14, 0xEA, 0x95, 0x53, 0x29, 0xA5, 0x52, 0xA7, 0x90,
  0x08, 0x02, 0x00, 0xE0, 0x04, 0x30, 0xC5, 0x14, 0x52, 0x4F, 0x45, 0x14,
  0x61, 0x84, 0x1C, 0x44, 0x89, 0x12, 0x28, 0x9E, 0x22, 0x44, 0x8A, 0x14,
  0x4F, 0x00, 0x1C, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0,
  0x1C, 0x44, 0x89, 0x12, 0x28, 0x50, 0xA1, 0x42, 0x8A, 0x14, 0x4F, 0x00,
  0x1E, 0x40, 0x81, 0x02, 0x08, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x0F, 0x00,
  0x1E, 0x40, 0x81, 0x02, 0x08, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x00,
  0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x88, 0x84, 0x84, 0x84, 0x84, 0x84,
  0x78, 0x21, 0x21, 0x21, 0x21, 0x21, 0x42, 0x7E, 0x42, 0x42, 0x44, 0x84,
  0x84, 0x84, 0x18, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x8E, 0x00, 0x04,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x38, 0x23,
  0x22, 0x24, 0x28, 0x28, 0x50, 0x70, 0x50, 0x50, 0x50, 0x88, 0x88, 0x88,
  0x22, 0x22, 0x24, 0x44, 0x44, 0x88, 0xF0, 0x10, 0x26, 0x0C, 0xC1, 0x18,
  0x63, 0x0C, 0xA2, 0x94, 0x52, 0x92, 0x52, 0x8A, 0x92, 0x52, 0x4C, 0x48,
  0x90, 0x10, 0x98, 0x4C, 0x46, 0x23, 0x12, 0x49, 0x28, 0x94, 0x4A, 0x25,
  0x21, 0x10, 0x88, 0x40, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC2, 0x85,
  0x0A, 0x24, 0x4F, 0x00, 0x1C, 0x44, 0x89, 0x12, 0x28, 0x92, 0x38, 0x40,
  0x82, 0x04, 0x08, 0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC2, 0x85,
  0x0A, 0x24, 0x4D, 0x04, 0x08, 0x08, 0x1C, 0x44, 0x89, 0x12, 0x28, 0x9A,
  0x28, 0x50, 0xA2, 0x24, 0x48, 0x80, 0x0F, 0x10, 0x20, 0x20, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0xF8, 0x7C, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x80, 0x42, 0x85, 0x0A, 0x28, 0x50, 0xA1, 0x42,
  0x89, 0x12, 0x24, 0x4F, 0x00, 0x86, 0x28, 0xA4, 0x92, 0x4A, 0x28, 0xC3,
  0x08, 0x20, 0x80, 0x84, 0x30, 0x86, 0x31, 0x46, 0x28, 0xC5, 0x29, 0x25,
  0x25, 0x28, 0xA5, 0x14, 0xA3, 0x18, 0x62, 0x08, 0x40, 0x11, 0x12, 0x12,
  0x14, 0x14, 0x08, 0x10, 0x10, 0x28, 0x28, 0x48, 0x48, 0x88, 0x86, 0x28,
  0xA4, 0x51, 0x84, 0x10, 0x41, 0x08, 0x20, 0x80, 0x1F, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0xF8, 0x1C, 0x82, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x38, 0xAA, 0xA5, 0x55,
  0x40, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x38, 0x10, 0x30, 0xA1, 0x24, 0x58, 0x40, 0xF0, 0xE0, 0x35, 0x28, 0xA2,
  0x8A, 0x28, 0xA4, 0x93, 0xC0, 0x10, 0x82, 0x08, 0x38, 0x92, 0x51, 0x45,
  0x14, 0x61, 0x8B, 0xC0, 0x34, 0x88, 0x88, 0x88, 0x8E, 0x02, 0x04, 0x10,
  0x23, 0x49, 0x22, 0x44, 0x89, 0x12, 0x24, 0x89, 0x1E, 0x00, 0x18, 0x94,
  0x52, 0x52, 0x88, 0x20, 0x81, 0xC0, 0x02, 0x08, 0x20, 0x41, 0xC1, 0x02,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x41, 0x80, 0x1A, 0x49,
  0x12, 0x24, 0x50, 0xA1, 0x44, 0x88, 0xF0, 0x20, 0x41, 0x1E, 0x00, 0x10,
  0x82, 0x08, 0x38, 0x92, 0x51, 0x45, 0x24, 0xA2, 0x8A, 0x20, 0x20, 0x02,
  0x92, 0x4A, 0x48, 0x08, 0x00, 0x00, 0x84, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x88, 0xC0, 0x10, 0x82, 0x08, 0x24, 0xA4, 0x94, 0x61, 0x45, 0x24, 0x92,
  0x40, 0x24, 0x92, 0x52, 0x49, 0x49, 0x00, 0x1B, 0x12, 0x51, 0x28, 0x94,
  0x4A, 0x45, 0x23, 0x12, 0x89, 0x48, 0x80, 0x18, 0x92, 0x51, 0x45, 0x24,
  0xA2, 0x8A, 0x20, 0x18, 0x94, 0x51, 0x46, 0x18, 0x62, 0x89, 0xC0, 0x0C,
  0x24, 0x49, 0x12, 0x24, 0x48, 0xA1, 0x44, 0xF1, 0x02, 0x08, 0x10, 0x00,
  0x35, 0x28, 0xA2, 0x8A, 0x28, 0xA4, 0x93, 0xC1, 0x04, 0x20, 0x80, 0x19,
  0x08, 0x84, 0x21, 0x10, 0x84, 0x00, 0x3A, 0x10, 0x84, 0x10, 0x42, 0x17,
  0x00, 0x22, 0x72, 0x44, 0x44, 0x88, 0x8C, 0x25, 0x14, 0x51, 0x49, 0x28,
  0xA2, 0xF0, 0x8C, 0xA5, 0x4A, 0x63, 0x10, 0x80, 0x91, 0x91, 0xAA, 0xAA,
  0xAC, 0xCC, 0xC8, 0x88, 0x88, 0x26, 0x28, 0x60, 0x81, 0x06, 0x0A, 0x24,
  0x88, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18, 0x08, 0x10, 0x10, 0x10,
  0x20, 0xE0, 0x1C, 0x20, 0x84, 0x20, 0x84, 0x10, 0xF0, 0x0C, 0x42, 0x08,
  0x20, 0x84, 0x10, 0xC1, 0x04, 0x20, 0x82, 0x08, 0x10, 0xFF, 0xFF, 0xC0,
  0x18, 0x10, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x41, 0x04, 0x20, 0x82, 0x30,
  0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 3, 5, 5, 2, -13 },
  { 10, 7, 13, 7, 0, -13 },
  { 22, 7, 15, 6, 0, -14 },
  { 36, 8, 13, 9, 1, -13 },
  { 49, 5, 13, 6, 0, -13 },
  { 58, 1, 5, 3, 2, -13 },
  { 59, 5, 16, 4, 0, -13 },
  { 69, 5, 16, 4, -1, -13 },
  { 79, 5, 5, 6, 2, -14 },
  { 83, 6, 9, 7, 1, -11 },
  { 90, 2, 4, 3, -1, -2 },
  { 91, 4, 1, 5, 0, -5 },
  { 92, 1, 1, 3, 0, -1 },
  { 93, 7, 13, 5, -1, -13 },
  { 105, 6, 13, 6, 0, -13 },
  { 115, 3, 13, 6, 2, -13 },
  { 120, 7, 13, 6, -1, -13 },
  { 132, 6, 13, 6, 0, -13 },
  { 142, 6, 13, 6, 0, -13 },
  { 152, 6, 13, 6, 0, -13 },
  { 162, 7, 13, 6, 0, -13 },
  { 174, 6, 13, 6, 1, -13 },
  { 184, 6, 13, 6, 0, -13 },
  { 194, 6, 13, 6, 0, -13 },
  { 204, 3, 10, 3, 0, -10 },
  { 208, 4, 12, 3, -1, -10 },
  { 214, 6, 7, 7, 1, -10 },
  { 220, 6, 5, 7, 1, -9 },
  { 224, 6, 7, 7, 1, -10 },
  { 230, 5, 13, 4, 0, -13 },
  { 239, 9, 15, 9, 0, -13 },
  { 256, 6, 13, 6, -1, -13 },
  { 266, 7, 13, 7, 0, -13 },
  { 278, 6, 13, 6, 1, -13 },
  { 288, 7, 13, 7, 0, -13 },
  { 300, 7, 13, 6, 0, -13 },
  { 312, 7, 13, 6, 0, -13 },
  { 324, 8, 13, 8, 1, -13 },
  { 337, 8, 13, 8, 0, -13 },
  { 350, 5, 13, 3, -1, -13 },
  { 359, 6, 16, 3, -3, -13 },
  { 371, 8, 13, 6, 0, -13 },
  { 384, 4, 13, 5, 0, -13 },
  { 391, 11, 13, 11, 0, -13 },
  { 409, 9, 13, 8, 0, -13 },
  { 424, 7, 13, 8, 1, -13 },
  { 436, 7, 13, 6, 0, -13 },
  { 448, 7, 16, 8, 1, -13 },
  { 462, 7, 13, 6, 0, -13 },
  { 474, 8, 13, 6, -1, -13 },
  { 487, 6, 13, 5, 1, -13 },
  { 497, 7, 13, 8, 1, -13 },
  { 509, 6, 13, 6, 2, -13 },
  { 519, 11, 13, 11, 1, -13 },
  { 537, 8, 13, 5, -1, -13 },
  { 550, 6, 13, 5, 1, -13 },
  { 560, 8, 13, 5, -1, -13 },
  { 573, 6, 16, 5, 0, -13 },
  { 585, 2, 13, 6, 2, -13 },
  { 589, 6, 16, 5, -1, -13 },
  { 601, 7, 6, 7, 0, -13 },
  { 607, 4, 1, 5, -1, 1 },
  { 608, 1, 3, 4, 3, -14 },
  { 609, 6, 10, 7, 1, -10 },
  { 617, 6, 14, 7, 0, -14 },
  { 628, 4, 10, 5, 1, -10 },
  { 633, 7, 14, 7, 1, -14 },
  { 646, 6, 10, 6, 0, -10 },
  { 654, 7, 18, 3, -2, -14 },
  { 670, 7, 14, 7, 0, -10 },
  { 683, 6, 14, 6, 0, -14 },
  { 694, 3, 13, 3, 0, -13 },
  { 699, 5, 17, 3, -2, -13 },
  { 710, 6, 14, 5, 0, -14 },
  { 721, 3, 14, 3, 0, -14 },
  { 727, 9, 10, 10, 0, -10 },
  { 739, 6, 10, 6, 0, -10 },
  { 747, 6, 10, 6, 0, -10 },
  { 755, 7, 14, 7, -1, -10 },
  { 768, 6, 14, 7, 1, -10 },
  { 779, 5, 10, 4, 0, -10 },
  { 786, 5, 10, 5, 0, -10 },
  { 793, 4, 12, 3, 0, -12 },
  { 799, 6, 9, 6, 0, -9 },
  { 806, 5, 9, 5, 1, -9 },
  { 812, 8, 9, 8, 1, -9 },
  { 821, 7, 9, 5, -1, -9 },
  { 829, 8, 13, 5, -2, -9 },
  { 842, 6, 9, 4, -1, -9 },
  { 849, 6, 16, 6, 1, -13 },
  { 861, 1, 18, 6, 3, -14 },
  { 864, 6, 16, 6, -1, -13 },
  { 876, 6, 1, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC18PT7B_H_
