#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x00, 0x00, 0x00, 0x82, 0x00, 0x22, 0x44, 0x89,
  0x14, 0x48, 0x91, 0x22, 0x85, 0x10, 0x00, 0x84, 0x02, 0x20, 0x10, 0x80,
  0x42, 0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x88, 0x1F, 0xFC, 0x10, 0x80,
  0x42, 0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x88, 0x04, 0x20, 0x10, 0x83,
  0xFF, 0x82, 0x10, 0x08, 0x40, 0x22, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x84, 0x02, 0x10, 0x00, 0x00, 0x40, 0x02, 0x00, 0x20, 0x0F, 0xF0, 0x88,
  0x8C, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x12, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x04, 0x80, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x04, 0x20, 0x21, 0x01, 0x10, 0xCB, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x0E, 0x04, 0x24, 0x08, 0x88, 0x22, 0x10, 0x44,
  0x21, 0x08, 0x42, 0x20, 0x88, 0x41, 0x10, 0x82, 0x41, 0x04, 0x82, 0x12,
  0x34, 0x24, 0x98, 0x52, 0x31, 0x2C, 0x64, 0x90, 0xB9, 0x21, 0x04, 0x82,
  0x09, 0x04, 0x22, 0x08, 0x44, 0x11, 0x08, 0x42, 0x10, 0x88, 0x21, 0x10,
  0x44, 0x40, 0x88, 0x81, 0xE0, 0x03, 0x80, 0xC8, 0x11, 0x04, 0x20, 0x84,
  0x10, 0x82, 0x10, 0x44, 0x08, 0x81, 0x20, 0x2C, 0x03, 0x00, 0xC0, 0x38,
  0x0C, 0x81, 0x11, 0x42, 0x28, 0x4A, 0x05, 0x40, 0xA8, 0x19, 0x03, 0x20,
  0x44, 0x14, 0x82, 0x8F, 0x90, 0x24, 0x94, 0x92, 0x90, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01,
  0x00, 0x04, 0x02, 0x32, 0x05, 0x11, 0xF0, 0xC0, 0x91, 0x84, 0x02, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x12, 0x22, 0x44, 0x88, 0xFE, 0xC0, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x8C,
  0x20, 0x84, 0x11, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x28, 0x05, 0x00,
  0xA0, 0x14, 0x07, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x02, 0x40,
  0x48, 0x11, 0x02, 0x20, 0x84, 0x10, 0x84, 0x0F, 0x00, 0x04, 0x33, 0x59,
  0x88, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x00, 0x03, 0xE0, 0x20, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x07, 0xFC, 0x00,
  0x03, 0xE0, 0x30, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x78, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x81, 0x87, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0A, 0x00, 0x48, 0x01, 0x40, 0x09, 0x00, 0x44, 0x01, 0x10, 0x08,
  0x40, 0x22, 0x01, 0x08, 0x0C, 0x20, 0x20, 0x81, 0x04, 0x04, 0x10, 0x20,
  0x41, 0x81, 0x04, 0x04, 0x3F, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x07, 0xE0, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x81,
  0x83, 0xF8, 0x00, 0x01, 0xF0, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x46, 0x05, 0x98, 0x60, 0x8C, 0x04,
  0xC0, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08,
  0x81, 0x88, 0x10, 0x42, 0x07, 0xC0, 0x3F, 0xF8, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x03, 0xE0, 0x21, 0x82, 0x04, 0x10, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x42, 0x02, 0x10, 0x10, 0x41, 0x02, 0x10, 0x0B, 0x00, 0x60, 0x04, 0x80,
  0xC6, 0x0C, 0x10, 0x40, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x10, 0x41, 0x81, 0xF8, 0x00, 0x03, 0xC0, 0x42, 0x08,
  0x10, 0x81, 0x10, 0x11, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x03, 0x20, 0x22, 0x06, 0x10, 0xA0, 0xF2, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x06, 0x0F, 0x80, 0x08,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x30, 0x03,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x00,
  0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x10, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x03,
  0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x00, 0x80, 0x00, 0x0F,
  0x84, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x78, 0x00, 0xC3,
  0x00, 0x80, 0xC0, 0x80, 0x20, 0x80, 0x10, 0x40, 0x04, 0x40, 0x02, 0x20,
  0x41, 0x20, 0xD8, 0x90, 0x88, 0x48, 0x84, 0x28, 0x42, 0x24, 0x62, 0x12,
  0x21, 0x09, 0x10, 0x85, 0x08, 0x42, 0x88, 0x42, 0x44, 0x21, 0x22, 0x10,
  0x91, 0x18, 0x88, 0x5C, 0x84, 0x39, 0x82, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x20, 0x44,
  0x08, 0x82, 0x10, 0x42, 0x08, 0x42, 0x08, 0x7F, 0x10, 0x22, 0x04, 0x40,
  0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x07, 0xE0,
  0x10, 0x40, 0x40, 0x81, 0x02, 0x04, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02,
  0x08, 0x08, 0x20, 0x61, 0x01, 0x04, 0x18, 0x1F, 0x80, 0x41, 0x01, 0x02,
  0x08, 0x08, 0x20, 0x10, 0x80, 0x42, 0x03, 0x10, 0x08, 0x40, 0x21, 0x00,
  0x84, 0x04, 0x10, 0x30, 0x81, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x04, 0x10,
  0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x10, 0xC0, 0x40, 0x81,
  0x02, 0x04, 0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x11,
  0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x31, 0x00, 0x88, 0x02, 0x20, 0x08,
  0x80, 0x42, 0x01, 0x10, 0x04, 0x40, 0x21, 0x01, 0x84, 0x04, 0x10, 0x20,
  0x83, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x1F, 0xE0, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x7F, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0x03, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x7C, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x10, 0x80, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x20, 0x20, 0x1F, 0xE0, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01,
  0x04, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04,
  0x10, 0x04, 0x10, 0x04, 0x1F, 0xFC, 0x10, 0x04, 0x20, 0x08, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x20, 0x80, 0x20, 0x80, 0x20, 0x07, 0xE0, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x1F, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x07, 0x80, 0x04, 0x02, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x41, 0x01, 0x04, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00, 0x4C,
  0x00, 0x90, 0x01, 0x60, 0x03, 0x40, 0x04, 0x80, 0x10, 0x80, 0x21, 0x00,
  0x42, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x41, 0x00, 0x80, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xFF, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x28, 0x28, 0x00, 0xA0,
  0xA0, 0x05, 0x02, 0x80, 0x14, 0x0A, 0x00, 0x90, 0x28, 0x02, 0x41, 0x10,
  0x12, 0x04, 0x40, 0x48, 0x11, 0x02, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42,
  0x08, 0x41, 0x10, 0x21, 0x08, 0x40, 0x84, 0x21, 0x02, 0x11, 0x04, 0x10,
  0x44, 0x10, 0x41, 0x20, 0x81, 0x04, 0x82, 0x04, 0x16, 0x08, 0x10, 0x50,
  0x20, 0x81, 0x40, 0x82, 0x06, 0x04, 0x00, 0x06, 0x00, 0x83, 0x00, 0x41,
  0x80, 0x20, 0xC0, 0x20, 0x50, 0x10, 0x48, 0x08, 0x24, 0x04, 0x12, 0x02,
  0x09, 0x02, 0x04, 0x81, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08, 0x20, 0x84,
  0x20, 0x82, 0x10, 0x40, 0x88, 0x20, 0x44, 0x10, 0x24, 0x08, 0x12, 0x08,
  0x09, 0x04, 0x04, 0x82, 0x01, 0x41, 0x00, 0xC0, 0x80, 0x60, 0x80, 0x30,
  0x40, 0x18, 0x00, 0x01, 0xF0, 0x08, 0x20, 0x40, 0x42, 0x01, 0x08, 0x04,
  0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x00, 0x14, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x00, 0x84, 0x04, 0x10, 0x10, 0x60, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x21, 0x81, 0x04, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20,
  0x21, 0x01, 0x08, 0x08, 0x40, 0x44, 0x04, 0x20, 0x21, 0x02, 0x08, 0x60,
  0x7C, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x20,
  0x40, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x84, 0x04,
  0x10, 0x10, 0x60, 0x80, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x07, 0xC0, 0x21, 0x81, 0x04, 0x08, 0x10, 0x40,
  0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x84, 0x04, 0x20, 0x61,
  0x06, 0x0F, 0xE0, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x82,
  0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x80, 0x84, 0x06, 0x00, 0x01,
  0xF8, 0x08, 0x10, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x80, 0x83, 0xFC, 0x00, 0x7F, 0xE0, 0x40,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x00, 0x08, 0x02, 0x10,
  0x04, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04,
  0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x04, 0x02, 0x10,
  0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x40, 0x41, 0x80, 0x7E, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88,
  0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x08, 0x40, 0x88, 0x08,
  0x80, 0x90, 0x09, 0x00, 0x90, 0x0A, 0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x05, 0x00, 0xC0, 0x28,
  0x0A, 0x02, 0x40, 0x50, 0x12, 0x02, 0x80, 0x90, 0x24, 0x08, 0x81, 0x20,
  0x44, 0x09, 0x04, 0x20, 0x88, 0x21, 0x04, 0x41, 0x08, 0x42, 0x10, 0x42,
  0x10, 0x82, 0x10, 0x88, 0x11, 0x04, 0x40, 0x88, 0x22, 0x04, 0x81, 0x20,
  0x24, 0x09, 0x01, 0x20, 0x50, 0x0A, 0x04, 0x80, 0x50, 0x24, 0x03, 0x01,
  0x40, 0x18, 0x0A, 0x00, 0xC0, 0x60, 0x04, 0x03, 0x00, 0x00, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x20, 0x02, 0x80, 0x05, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x01,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x41, 0x00, 0x80, 0x40,
  0x28, 0x05, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x41, 0x08, 0x22, 0x04,
  0x40, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x00, 0x03,
  0xFE, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0x80,
  0x01, 0xF8, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x08, 0x1F, 0x80, 0x88, 0x88, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22,
  0x22, 0x22, 0x11, 0x11, 0x11, 0x03, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x0F, 0xC0, 0x02, 0x00, 0x18, 0x01, 0x40, 0x09, 0x00,
  0x88, 0x04, 0x60, 0x41, 0x02, 0x08, 0x20, 0x23, 0x01, 0x10, 0x05, 0x80,
  0x28, 0x00, 0x80, 0xFF, 0xC0, 0xC4, 0x42, 0x10, 0x07, 0xD0, 0x85, 0x10,
  0x31, 0x03, 0x20, 0x22, 0x02, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x18, 0x81, 0x84, 0x28, 0x7C,
  0x80, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x09, 0xE0, 0xA1, 0x0C, 0x11, 0x81, 0x18, 0x11, 0x01, 0x10, 0x11,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x02, 0x20, 0x24, 0x02, 0x40, 0x44,
  0x04, 0x60, 0x8A, 0x18, 0x9F, 0x00, 0x07, 0xC2, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x07, 0xD0, 0x21, 0x41,
  0x03, 0x04, 0x0C, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x08, 0x40, 0x23,
  0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x60,
  0x81, 0x81, 0x0A, 0x07, 0xC8, 0x00, 0x07, 0x82, 0x11, 0x04, 0x81, 0x20,
  0x50, 0x14, 0x09, 0x04, 0x46, 0x3E, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x07, 0xE0, 0x00, 0x02, 0x00, 0x0D, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x01, 0xF8, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x01, 0xF4, 0x08, 0x50,
  0x40, 0xC1, 0x03, 0x08, 0x08, 0x20, 0x21, 0x00, 0x84, 0x02, 0x10, 0x08,
  0xC0, 0x42, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x18,
  0x20, 0x60, 0x42, 0x81, 0xF4, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x0C, 0x60, 0x06, 0x00, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0B, 0xE0, 0xC1,
  0x0C, 0x10, 0x81, 0x18, 0x11, 0x02, 0x10, 0x21, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84, 0x08,
  0x80, 0x80, 0x02, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x10, 0x81, 0x10, 0x12, 0x01, 0x40, 0x2E, 0x02, 0xA0, 0x32, 0x02, 0x20,
  0x22, 0x04, 0x20, 0x41, 0x04, 0x10, 0x41, 0x08, 0x10, 0x81, 0x00, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x00, 0x0B,
  0xE7, 0xC1, 0x85, 0x08, 0x20, 0x40, 0x8C, 0x08, 0x11, 0x02, 0x04, 0x20,
  0x40, 0x84, 0x08, 0x10, 0x81, 0x02, 0x20, 0x20, 0x44, 0x08, 0x10, 0x81,
  0x02, 0x10, 0x20, 0x42, 0x04, 0x08, 0x81, 0x02, 0x10, 0x20, 0x42, 0x04,
  0x08, 0x40, 0x81, 0x08, 0x10, 0x22, 0x04, 0x08, 0x00, 0x0B, 0xE0, 0xC1,
  0x0C, 0x11, 0x81, 0x18, 0x11, 0x02, 0x10, 0x21, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x42, 0x04, 0x20, 0x44, 0x04, 0x40, 0x44, 0x08, 0x40, 0x84, 0x08,
  0x80, 0x80, 0x07, 0xC1, 0x08, 0x40, 0x90, 0x12, 0x02, 0xC0, 0x50, 0x0A,
  0x01, 0x40, 0x38, 0x0E, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x24, 0x04,
  0x81, 0x08, 0x41, 0xF0, 0x00, 0x04, 0xF0, 0x28, 0x41, 0x82, 0x08, 0x10,
  0xC0, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20,
  0x11, 0x01, 0x18, 0x08, 0x80, 0xC4, 0x04, 0x30, 0x41, 0x86, 0x13, 0xE0,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x07, 0xD0, 0x85, 0x10, 0x31, 0x03, 0x20, 0x22, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88,
  0x18, 0x81, 0x84, 0x28, 0x7D, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x0B, 0xC3, 0x00, 0xC0, 0x60, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x00, 0x07, 0xE1, 0x04, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x08, 0x01, 0x10, 0x63, 0xF8, 0x00, 0x08, 0x21, 0x04,
  0x11, 0xF1, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x38, 0x10, 0x22, 0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x88,
  0x11, 0x02, 0x40, 0x48, 0x09, 0x02, 0x20, 0x48, 0x09, 0x01, 0x20, 0x44,
  0x08, 0x83, 0x10, 0xA1, 0xE4, 0x00, 0x80, 0xE0, 0x28, 0x12, 0x04, 0x81,
  0x20, 0x88, 0x22, 0x10, 0x84, 0x22, 0x08, 0x82, 0x60, 0x90, 0x24, 0x0A,
  0x02, 0x80, 0xC0, 0x30, 0x08, 0x00, 0x80, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x81, 0x82, 0x82, 0x84, 0x82, 0x84, 0x84, 0x84, 0x84, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0, 0xA0,
  0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x04, 0x08, 0x20, 0xC1,
  0x04, 0x08, 0x40, 0x22, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0A, 0x00, 0xD0, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x82,
  0x04, 0x30, 0x30, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x01, 0x02, 0x01,
  0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x90, 0x00, 0xC0, 0x00, 0x0F,
  0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x0F, 0xE0, 0x00,
  0x10, 0x0C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x07, 0x00, 0xE0,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x06, 0x00, 0xF0, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x30, 0x08, 0x00, 0x7C, 0x18, 0x33, 0x80, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 26, 7, 1, -26 },
  { 21, 7, 10, 9, 3, -26 },
  { 30, 14, 26, 13, 0, -26 },
  { 76, 13, 29, 12, 0, -27 },
  { 124, 15, 26, 19, 2, -26 },
  { 173, 11, 26, 12, 0, -26 },
  { 209, 3, 10, 5, 3, -26 },
  { 213, 10, 32, 9, 1, -26 },
  { 253, 9, 32, 9, -2, -26 },
  { 289, 9, 9, 11, 4, -27 },
  { 300, 12, 17, 14, 1, -21 },
  { 326, 4, 8, 6, -1, -3 },
  { 330, 7, 1, 9, 1, -10 },
  { 331, 1, 2, 6, 1, -2 },
  { 332, 15, 26, 11, -2, -26 },
  { 381, 11, 26, 12, 1, -26 },
  { 417, 6, 26, 12, 4, -26 },
  { 437, 13, 26, 12, -1, -26 },
  { 480, 13, 26, 12, -1, -26 },
  { 523, 14, 26, 12, -1, -26 },
  { 569, 14, 26, 12, -1, -26 },
  { 615, 12, 26, 12, 1, -26 },
  { 654, 13, 26, 12, 1, -26 },
  { 697, 13, 26, 12, 0, -26 },
  { 740, 12, 26, 12, 0, -26 },
  { 779, 5, 19, 6, 0, -19 },
  { 791, 8, 24, 6, -2, -19 },
  { 815, 12, 15, 14, 1, -20 },
  { 838, 12, 9, 14, 1, -17 },
  { 852, 12, 15, 14, 1, -20 },
  { 875, 10, 26, 9, 0, -26 },
  { 908, 17, 29, 18, 1, -26 },
  { 970, 11, 26, 12, -2, -26 },
  { 1006, 14, 26, 13, 0, -26 },
  { 1052, 14, 26, 12, 1, -26 },
  { 1098, 14, 26, 15, 0, -26 },
  { 1144, 14, 26, 12, 0, -26 },
  { 1190, 14, 26, 11, 0, -26 },
  { 1236, 16, 26, 16, 1, -26 },
  { 1288, 16, 26, 16, 0, -26 },
  { 1340, 11, 26, 6, -2, -26 },
  { 1376, 11, 32, 6, -5, -26 },
  { 1420, 15, 26, 12, 0, -26 },
  { 1469, 8, 26, 11, 0, -26 },
  { 1495, 22, 26, 21, 0, -26 },
  { 1567, 17, 26, 17, 0, -26 },
  { 1623, 14, 26, 16, 1, -26 },
  { 1669, 13, 26, 13, 0, -26 },
  { 1712, 14, 32, 16, 1, -26 },
  { 1768, 13, 26, 13, 0, -26 },
  { 1811, 14, 26, 12, -1, -26 },
  { 1857, 11, 26, 11, 2, -26 },
  { 1893, 15, 26, 15, 1, -26 },
  { 1942, 12, 26, 12, 3, -26 },
  { 1981, 21, 26, 22, 3, -26 },
  { 2050, 15, 26, 11, -2, -26 },
  { 2099, 11, 26, 10, 2, -26 },
  { 2135, 15, 26, 11, -2, -26 },
  { 2184, 13, 32, 10, -1, -26 },
  { 2236, 4, 26, 11, 4, -26 },
  { 2249, 12, 32, 10, -2, -26 },
  { 2297, 13, 13, 14, 1, -26 },
  { 2319, 10, 1, 9, -3, 3 },
  { 2321, 4, 5, 7, 5, -27 },
  { 2324, 12, 19, 14, 1, -19 },
  { 2353, 12, 27, 13, 0, -27 },
  { 2394, 10, 19, 10, 1, -19 },
  { 2418, 14, 27, 14, 1, -27 },
  { 2466, 10, 19, 12, 1, -19 },
  { 2490, 16, 37, 7, -5, -28 },
  { 2564, 14, 28, 14, -1, -19 },
  { 2613, 12, 27, 13, 0, -27 },
  { 2654, 7, 26, 6, 0, -26 },
  { 2677, 12, 35, 6, -5, -26 },
  { 2730, 12, 27, 11, 0, -27 },
  { 2771, 7, 27, 5, 0, -27 },
  { 2795, 19, 19, 20, 0, -19 },
  { 2841, 12, 19, 13, 0, -19 },
  { 2870, 11, 19, 13, 1, -19 },
  { 2897, 13, 27, 13, -1, -19 },
  { 2941, 12, 27, 14, 1, -19 },
  { 2982, 10, 19, 8, 0, -19 },
  { 3006, 11, 19, 10, -1, -19 },
  { 3033, 6, 24, 7, 1, -24 },
  { 3051, 11, 19, 13, 1, -19 },
  { 3078, 10, 19, 10, 2, -19 },
  { 3102, 16, 19, 17, 2, -19 },
  { 3140, 13, 19, 10, -2, -19 },
  { 3171, 16, 28, 11, -4, -19 },
  { 3227, 10, 19, 8, -1, -19 },
  { 3251, 12, 32, 11, 1, -26 },
  { 3299, 1, 36, 12, 6, -27 },
  { 3304, 12, 32, 11, -2, -26 },
  { 3352, 12, 3, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC36PT7B_H_
