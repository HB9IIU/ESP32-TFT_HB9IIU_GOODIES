#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_ThinItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_ThinItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_ThinItalic72pt7b.h"
