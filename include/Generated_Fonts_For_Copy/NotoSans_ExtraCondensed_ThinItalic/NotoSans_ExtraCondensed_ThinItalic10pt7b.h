#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xF0, 0x35, 0x66, 0xEC, 0xC0, 0x27, 0xA4, 0x46, 0x6C,
  0x80, 0x6D, 0xA9, 0xF2, 0xB5, 0xC0, 0x6D, 0x2F, 0x78, 0xC0, 0x29, 0x49,
  0x24, 0x80, 0x24, 0x92, 0x52, 0x80, 0x5F, 0x00, 0x44, 0xF4, 0x40, 0xC0,
  0xC0, 0x80, 0x12, 0x24, 0x88, 0x80, 0x6E, 0xDB, 0x70, 0xD6, 0xA8, 0x64,
  0x95, 0x30, 0x64, 0xB2, 0x70, 0x25, 0xDA, 0xD0, 0x6B, 0x12, 0x70, 0x74,
  0xCA, 0xAA, 0xE0, 0x71, 0x22, 0x44, 0x80, 0x75, 0x64, 0xAA, 0xE0, 0x76,
  0xD6, 0x70, 0x08, 0x40, 0xA0, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16,
  0x80, 0x64, 0xA8, 0x20, 0x3A, 0x6F, 0xBE, 0xDA, 0x1C, 0x11, 0x35, 0x75,
  0x90, 0x75, 0x5A, 0x9A, 0xE0, 0x74, 0x88, 0x88, 0xE0, 0x75, 0x59, 0x9A,
  0xE0, 0x74, 0x4A, 0x88, 0xC0, 0x74, 0x46, 0x88, 0x80, 0x7A, 0x21, 0x29,
  0x4B, 0xC0, 0x4A, 0x55, 0x69, 0x4A, 0x80, 0x24, 0xA4, 0xB0, 0x24, 0xA4,
  0x92, 0x80, 0x56, 0x4C, 0xAA, 0xA0, 0x56, 0xAC, 0x45, 0x14, 0xB5, 0xBA,
  0xAA, 0x80, 0x4A, 0x53, 0x6B, 0x4A, 0x40, 0x75, 0x99, 0x99, 0xE0, 0x75,
  0x5E, 0x88, 0x80, 0x75, 0x99, 0x99, 0xE2, 0x20, 0x75, 0x5E, 0xAA, 0xA0,
  0x78, 0x44, 0x22, 0xE0, 0xF2, 0x49, 0x20, 0x55, 0x59, 0x99, 0xE0, 0xB7,
  0x69, 0x20, 0xA6, 0xAE, 0xAA, 0xB2, 0x8A, 0x00, 0x29, 0x88, 0x46, 0x32,
  0x40, 0xBA, 0x49, 0x20, 0x72, 0x24, 0x48, 0xC0, 0x69, 0x29, 0x24, 0xC0,
  0xFE, 0x31, 0x12, 0x22, 0x22, 0xC0, 0x26, 0x90, 0xE0, 0xC0, 0x79, 0xAA,
  0xE0, 0x49, 0x3B, 0x6F, 0x72, 0x4C, 0x11, 0x35, 0x9A, 0xAE, 0x77, 0x4C,
  0x12, 0x22, 0x44, 0x44, 0x48, 0x79, 0xAA, 0xE2, 0xE0, 0x49, 0x3B, 0x6D,
  0x46, 0xA8, 0x20, 0xA4, 0x92, 0x80, 0x49, 0x3D, 0xB5, 0x55, 0xAA, 0x7D,
  0x6B, 0x5A, 0x80, 0x76, 0xDA, 0x76, 0xDE, 0x76, 0xDF, 0x20, 0x79, 0xAA,
  0xE2, 0x20, 0x72, 0x48, 0xF1, 0x2C, 0x56, 0xA8, 0x76, 0xDC, 0xEA, 0x80,
  0xDD, 0xEA, 0xC0, 0x69, 0x6C, 0x55, 0x56, 0x24, 0xC0, 0x69, 0x4C, 0x32,
  0x44, 0xC4, 0x88, 0x40, 0xFF, 0xC0, 0x31, 0x22, 0x32, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 4, 7, 4, 0, -7 },
  { 8, 4, 9, 3, 0, -8 },
  { 13, 5, 7, 5, 0, -7 },
  { 18, 3, 7, 3, 0, -7 },
  { 21, 1, 2, 1, 1, -7 },
  { 22, 3, 9, 2, 0, -7 },
  { 26, 3, 9, 2, -1, -7 },
  { 30, 3, 3, 3, 1, -8 },
  { 32, 4, 5, 4, 0, -6 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 2, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 4, 7, 3, 0, -7 },
  { 42, 3, 7, 3, 0, -7 },
  { 45, 2, 7, 3, 1, -7 },
  { 47, 3, 7, 3, 0, -7 },
  { 50, 3, 7, 3, 0, -7 },
  { 53, 3, 7, 3, 0, -7 },
  { 56, 3, 7, 3, 0, -7 },
  { 59, 4, 7, 3, 0, -7 },
  { 63, 4, 7, 3, 0, -7 },
  { 67, 4, 7, 3, 0, -7 },
  { 71, 3, 7, 3, 0, -7 },
  { 74, 1, 5, 2, 0, -5 },
  { 75, 2, 6, 2, 0, -5 },
  { 77, 4, 5, 4, 0, -6 },
  { 80, 4, 3, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -6 },
  { 85, 3, 7, 2, 0, -7 },
  { 88, 5, 8, 5, 0, -7 },
  { 93, 4, 7, 3, -1, -7 },
  { 97, 4, 7, 4, 0, -7 },
  { 101, 4, 7, 3, 0, -7 },
  { 105, 4, 7, 4, 0, -7 },
  { 109, 4, 7, 3, 0, -7 },
  { 113, 4, 7, 3, 0, -7 },
  { 117, 5, 7, 5, 0, -7 },
  { 122, 5, 7, 4, 0, -7 },
  { 127, 3, 7, 2, -1, -7 },
  { 130, 3, 9, 2, -1, -7 },
  { 134, 4, 7, 3, 0, -7 },
  { 138, 2, 7, 3, 0, -7 },
  { 140, 6, 7, 6, 0, -7 },
  { 146, 5, 7, 5, 0, -7 },
  { 151, 4, 7, 4, 0, -7 },
  { 155, 4, 7, 4, 0, -7 },
  { 159, 4, 9, 4, 0, -7 },
  { 164, 4, 7, 4, 0, -7 },
  { 168, 4, 7, 3, 0, -7 },
  { 172, 3, 7, 3, 1, -7 },
  { 175, 4, 7, 4, 0, -7 },
  { 179, 3, 7, 3, 1, -7 },
  { 182, 6, 7, 6, 1, -7 },
  { 188, 5, 7, 3, -1, -7 },
  { 193, 3, 7, 3, 1, -7 },
  { 196, 4, 7, 3, 0, -7 },
  { 200, 3, 9, 3, 0, -7 },
  { 204, 1, 7, 3, 1, -7 },
  { 205, 4, 9, 3, -1, -7 },
  { 210, 4, 3, 4, 0, -7 },
  { 212, 3, 1, 3, -1, 1 },
  { 213, 1, 2, 2, 1, -8 },
  { 214, 4, 5, 4, 0, -5 },
  { 217, 3, 8, 4, 0, -8 },
  { 220, 3, 5, 3, 0, -5 },
  { 222, 4, 8, 4, 0, -8 },
  { 226, 3, 5, 3, 0, -5 },
  { 228, 4, 10, 2, -1, -8 },
  { 233, 4, 7, 4, 0, -5 },
  { 237, 3, 8, 4, 0, -8 },
  { 240, 2, 7, 2, 0, -7 },
  { 242, 3, 9, 2, -1, -7 },
  { 246, 3, 8, 3, 0, -8 },
  { 249, 2, 8, 1, 0, -8 },
  { 251, 5, 5, 5, 0, -5 },
  { 255, 3, 5, 4, 0, -5 },
  { 257, 3, 5, 4, 0, -5 },
  { 259, 3, 7, 4, 0, -5 },
  { 262, 4, 7, 4, 0, -5 },
  { 266, 3, 5, 2, 0, -5 },
  { 268, 3, 5, 3, 0, -5 },
  { 270, 2, 7, 2, 0, -7 },
  { 272, 3, 5, 4, 0, -5 },
  { 274, 2, 5, 3, 1, -5 },
  { 276, 4, 5, 5, 1, -5 },
  { 279, 3, 5, 3, 0, -5 },
  { 281, 4, 7, 3, -1, -5 },
  { 285, 3, 5, 2, 0, -5 },
  { 287, 4, 9, 3, 0, -7 },
  { 292, 1, 10, 3, 1, -8 },
  { 294, 4, 9, 3, -1, -7 },
  { 299, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC10PT7B_H_
