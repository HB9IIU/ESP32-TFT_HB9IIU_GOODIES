#ifndef _NOTOSANS_EXTRACONDENSED_THINITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THINITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ThinItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ThinItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x88, 0x42, 0x11, 0x08, 0x42, 0x11, 0x00, 0x02,
  0x20, 0x25, 0x24, 0x92, 0x49, 0x29, 0x00, 0x02, 0x41, 0x10, 0x48, 0x12,
  0x08, 0x82, 0x43, 0xFC, 0x44, 0x11, 0x04, 0x81, 0x20, 0x88, 0xFF, 0x09,
  0x04, 0x41, 0x20, 0x48, 0x22, 0x09, 0x00, 0x02, 0x01, 0x01, 0x83, 0x52,
  0x41, 0x20, 0x90, 0x48, 0x24, 0x0C, 0x02, 0x01, 0x80, 0xA0, 0x50, 0x48,
  0x24, 0x12, 0x0B, 0x3E, 0x04, 0x02, 0x01, 0x00, 0x18, 0x24, 0x89, 0x11,
  0x22, 0x44, 0x49, 0x0A, 0x22, 0x44, 0x50, 0x8A, 0xF2, 0xA6, 0x54, 0xB4,
  0x90, 0xA2, 0x14, 0x44, 0x88, 0x91, 0x22, 0x44, 0x49, 0x0E, 0x00, 0x06,
  0x0A, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18, 0x10, 0x28, 0x49, 0x89,
  0x86, 0x86, 0x84, 0x84, 0x8A, 0xF2, 0x29, 0x24, 0xA0, 0x06, 0x10, 0x20,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x08, 0x00, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x20, 0x41, 0x04, 0x18,
  0x00, 0x10, 0x4D, 0x0B, 0x31, 0x28, 0x80, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x25, 0x28, 0xF8,
  0x70, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x00, 0x07, 0x04, 0x44, 0x22, 0x12, 0x09, 0x04, 0x82, 0x81, 0x40, 0xA0,
  0x90, 0x48, 0x24, 0x14, 0x12, 0x09, 0x04, 0x84, 0x22, 0x1E, 0x00, 0x13,
  0x59, 0x12, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x80, 0x07, 0x02, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0F, 0xE0, 0x07, 0x82, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x03, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x8F, 0xC0, 0x00, 0x40, 0x30,
  0x14, 0x05, 0x02, 0x80, 0xA0, 0x48, 0x22, 0x09, 0x04, 0x41, 0x10, 0x84,
  0x41, 0x10, 0x8F, 0xF8, 0x08, 0x02, 0x00, 0x80, 0x40, 0x07, 0xC2, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x3E, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x8F, 0xC0, 0x07, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x80, 0xBC, 0xC2, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x88, 0x70, 0x7F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x00, 0x0E, 0x08, 0x44, 0x24, 0x12, 0x09, 0x04, 0x82, 0x22, 0x16,
  0x0C, 0x09, 0x08, 0x48, 0x24, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x1F, 0x00,
  0x0E, 0x08, 0x84, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x20, 0x88,
  0xC3, 0xA0, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x3C, 0x00, 0x11, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x88, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x21, 0x08, 0x80, 0x00, 0x81, 0x81, 0x03, 0x06, 0x04, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20,
  0x00, 0x1C, 0x44, 0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x20, 0x81, 0x04,
  0x08, 0x10, 0x00, 0x00, 0x82, 0x00, 0x03, 0x80, 0x46, 0x08, 0x21, 0x01,
  0x20, 0x12, 0x01, 0x47, 0x94, 0x89, 0x89, 0x19, 0x11, 0x91, 0x29, 0x12,
  0x92, 0x29, 0x24, 0x96, 0x49, 0xD8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x7C, 0x00, 0x00, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x12, 0x09, 0x08,
  0x84, 0x42, 0x23, 0xF1, 0x09, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x60, 0x20,
  0x0F, 0x02, 0x21, 0x04, 0x41, 0x10, 0x44, 0x11, 0x08, 0x82, 0x21, 0x0F,
  0x82, 0x10, 0x84, 0x41, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x8F, 0xC0,
  0x03, 0xC3, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x07, 0xC0,
  0x0C, 0x02, 0x61, 0x04, 0x41, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48,
  0x12, 0x04, 0x81, 0x40, 0x90, 0x24, 0x11, 0x04, 0x82, 0x21, 0x0F, 0x80,
  0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0F,
  0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0F, 0xC0,
  0x0F, 0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x43, 0xE1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x00,
  0x03, 0xC1, 0x84, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x0F, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x04, 0x81, 0x08,
  0x20, 0xFC, 0x00, 0x08, 0x10, 0x81, 0x10, 0x11, 0x02, 0x10, 0x21, 0x02,
  0x10, 0x22, 0x04, 0x20, 0x43, 0xFC, 0x20, 0x44, 0x04, 0x40, 0x84, 0x08,
  0x40, 0x84, 0x08, 0x80, 0x88, 0x10, 0x81, 0x00, 0x0F, 0x02, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0xF0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x83, 0xC0, 0x08, 0x21, 0x08, 0x42, 0x08, 0x41, 0x10,
  0x24, 0x05, 0x01, 0x20, 0x28, 0x07, 0x00, 0xA0, 0x12, 0x04, 0x40, 0x88,
  0x11, 0x02, 0x10, 0x82, 0x10, 0x42, 0x08, 0x00, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x0F, 0xC0, 0x08,
  0x03, 0x08, 0x02, 0x08, 0x06, 0x18, 0x06, 0x18, 0x0A, 0x18, 0x0A, 0x18,
  0x14, 0x24, 0x14, 0x24, 0x14, 0x24, 0x24, 0x24, 0x24, 0x44, 0x48, 0x44,
  0x48, 0x44, 0x88, 0x44, 0x88, 0x45, 0x08, 0x85, 0x10, 0x86, 0x10, 0x86,
  0x10, 0x08, 0x10, 0x81, 0x18, 0x11, 0x41, 0x14, 0x11, 0x42, 0x14, 0x22,
  0x42, 0x22, 0x22, 0x22, 0x22, 0x44, 0x24, 0x42, 0x44, 0x24, 0x41, 0x84,
  0x18, 0x81, 0x88, 0x18, 0x81, 0x80, 0x07, 0x02, 0x21, 0x04, 0x81, 0x20,
  0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28,
  0x12, 0x04, 0x82, 0x20, 0x87, 0xC0, 0x0E, 0x02, 0x61, 0x08, 0x41, 0x10,
  0x44, 0x11, 0x08, 0x82, 0x20, 0x88, 0x43, 0xE1, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x00, 0x07, 0x02, 0x21, 0x04, 0x81, 0x20,
  0x50, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28,
  0x12, 0x04, 0x82, 0x20, 0x87, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x40, 0x0C,
  0x04, 0xC4, 0x22, 0x11, 0x08, 0x84, 0x42, 0x41, 0x21, 0x11, 0x8F, 0x08,
  0x84, 0x42, 0x21, 0x10, 0x88, 0x82, 0x41, 0x20, 0x80, 0x07, 0xC1, 0x04,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x43, 0xF0, 0x00,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x10, 0x22, 0x08, 0x81, 0x10,
  0x22, 0x04, 0x40, 0x90, 0x22, 0x04, 0x40, 0x88, 0x11, 0x04, 0x40, 0x88,
  0x11, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10, 0x81, 0xE0, 0x00, 0x80, 0xC0,
  0x60, 0x50, 0x28, 0x24, 0x12, 0x09, 0x08, 0x84, 0x44, 0x22, 0x12, 0x09,
  0x04, 0x82, 0x81, 0x40, 0xC0, 0x60, 0x20, 0x00, 0x81, 0x03, 0x02, 0x06,
  0x04, 0x0C, 0x18, 0x28, 0x30, 0x50, 0xA0, 0xA1, 0x42, 0x42, 0x84, 0x89,
  0x11, 0x12, 0x22, 0x44, 0x84, 0x89, 0x09, 0x12, 0x14, 0x28, 0x28, 0x50,
  0x60, 0xC0, 0xC1, 0x81, 0x83, 0x02, 0x04, 0x00, 0x04, 0x10, 0x42, 0x04,
  0x20, 0x44, 0x04, 0x40, 0x48, 0x02, 0x80, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x0A, 0x01, 0x20, 0x11, 0x02, 0x10, 0x21, 0x04, 0x10, 0xC1,
  0x00, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x50, 0x50, 0x60, 0x60,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xC0, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x0F, 0xE0, 0x0F, 0x84, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x03, 0xC0, 0x92, 0x49,
  0x22, 0x49, 0x24, 0x89, 0x24, 0x80, 0x07, 0xC0, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x0F, 0x80, 0x08,
  0x04, 0x05, 0x02, 0x82, 0x22, 0x11, 0x05, 0x02, 0x80, 0x80, 0xFE, 0xA5,
  0x1E, 0x91, 0x48, 0x48, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41, 0x21,
  0x10, 0x88, 0xC3, 0xA0, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x5C,
  0x31, 0x10, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x21,
  0x30, 0x97, 0x80, 0x1E, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x0E, 0x00, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x21,
  0xE8, 0x8C, 0x21, 0x10, 0x44, 0x12, 0x04, 0x82, 0x20, 0x88, 0x22, 0x08,
  0x84, 0x21, 0x08, 0xC1, 0xD0, 0x1C, 0x44, 0x8A, 0x14, 0x30, 0xA6, 0x70,
  0x81, 0x02, 0x04, 0x08, 0x0F, 0x00, 0x00, 0xE0, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0xE0, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x18, 0x00, 0x0F, 0x44, 0x51, 0x08, 0x82, 0x20,
  0x90, 0x24, 0x11, 0x04, 0x41, 0x10, 0x44, 0x21, 0x08, 0x46, 0x0E, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x83, 0xC0, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x5C, 0x31, 0x10, 0x90, 0x48, 0x44, 0x22, 0x12, 0x09, 0x04,
  0x84, 0x42, 0x21, 0x20, 0x90, 0x80, 0x08, 0x40, 0x00, 0x08, 0x44, 0x21,
  0x08, 0x44, 0x21, 0x08, 0x44, 0x20, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x42, 0x22, 0x22, 0x12, 0x09, 0x05, 0x03, 0x83, 0x41, 0x20,
  0x90, 0x44, 0x22, 0x21, 0x10, 0x80, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x00, 0x17, 0x78, 0xCC, 0x44, 0x22,
  0x42, 0x12, 0x10, 0x90, 0x84, 0x84, 0x28, 0x21, 0x42, 0x12, 0x10, 0x90,
  0x84, 0x84, 0x28, 0x41, 0x42, 0x10, 0x17, 0x0C, 0x44, 0x24, 0x12, 0x11,
  0x08, 0x84, 0x82, 0x42, 0x21, 0x10, 0x88, 0x48, 0x24, 0x20, 0x1C, 0x22,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x84, 0x88, 0x70,
  0x0B, 0x83, 0x10, 0x84, 0x41, 0x10, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48,
  0x22, 0x08, 0x84, 0x61, 0x17, 0x84, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02,
  0x00, 0x1E, 0x91, 0x48, 0x48, 0x24, 0x14, 0x0A, 0x09, 0x04, 0x82, 0x41,
  0x21, 0x10, 0x88, 0xC3, 0xA0, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x16, 0x30, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x00, 0x1E, 0x41, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x40,
  0x9E, 0x00, 0x10, 0x84, 0x72, 0x10, 0x84, 0x22, 0x10, 0x84, 0x22, 0x10,
  0x60, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x84,
  0x84, 0x88, 0xF8, 0x83, 0x06, 0x0C, 0x28, 0x51, 0x22, 0x48, 0x91, 0x42,
  0x85, 0x04, 0x08, 0x00, 0x84, 0x30, 0x86, 0x31, 0x46, 0x29, 0x45, 0x29,
  0x29, 0x25, 0x28, 0xA5, 0x18, 0xA3, 0x18, 0x43, 0x08, 0x41, 0x08, 0x00,
  0x10, 0x88, 0x44, 0x41, 0x40, 0xA0, 0x60, 0x20, 0x10, 0x14, 0x0A, 0x09,
  0x08, 0x84, 0x44, 0x10, 0x04, 0x10, 0x41, 0x04, 0x20, 0x42, 0x04, 0x40,
  0x44, 0x04, 0x80, 0x48, 0x05, 0x00, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x0E, 0x00, 0x1F, 0x01,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0xF8,
  0x01, 0x83, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x18, 0x04, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x30, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x80, 0xF8, 0xC3, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ThinItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 19, 5, 0, -19 },
  { 13, 6, 7, 7, 2, -19 },
  { 19, 10, 19, 10, 0, -19 },
  { 43, 9, 22, 9, 0, -20 },
  { 68, 11, 19, 14, 1, -19 },
  { 95, 8, 19, 8, 0, -19 },
  { 114, 3, 7, 4, 2, -19 },
  { 117, 7, 22, 6, 1, -18 },
  { 137, 7, 22, 6, -2, -18 },
  { 157, 6, 7, 8, 3, -20 },
  { 163, 9, 12, 10, 1, -15 },
  { 177, 3, 5, 4, -1, -2 },
  { 179, 5, 1, 7, 1, -8 },
  { 180, 2, 2, 4, 0, -2 },
  { 181, 10, 19, 8, -1, -19 },
  { 205, 9, 19, 9, 0, -19 },
  { 227, 4, 19, 9, 3, -19 },
  { 237, 10, 19, 9, -1, -19 },
  { 261, 10, 19, 9, -1, -19 },
  { 285, 10, 19, 9, -1, -19 },
  { 309, 10, 19, 9, -1, -19 },
  { 333, 8, 19, 9, 1, -19 },
  { 352, 9, 19, 9, 1, -19 },
  { 374, 9, 19, 9, 0, -19 },
  { 396, 9, 19, 9, 0, -19 },
  { 418, 4, 14, 4, 0, -14 },
  { 425, 5, 17, 4, -1, -14 },
  { 436, 9, 11, 10, 1, -15 },
  { 449, 9, 6, 10, 1, -12 },
  { 456, 9, 11, 10, 1, -15 },
  { 469, 7, 19, 6, 0, -19 },
  { 486, 12, 21, 13, 1, -19 },
  { 518, 9, 19, 8, -2, -19 },
  { 540, 10, 19, 10, 0, -19 },
  { 564, 10, 19, 9, 1, -19 },
  { 588, 10, 19, 11, 0, -19 },
  { 612, 10, 19, 9, 0, -19 },
  { 636, 10, 19, 8, 0, -19 },
  { 660, 11, 19, 12, 1, -19 },
  { 687, 12, 19, 11, 0, -19 },
  { 716, 8, 19, 4, -2, -19 },
  { 735, 9, 23, 4, -4, -19 },
  { 761, 11, 19, 9, 0, -19 },
  { 788, 6, 19, 8, 0, -19 },
  { 803, 16, 19, 15, 0, -19 },
  { 841, 12, 19, 12, 0, -19 },
  { 870, 10, 19, 12, 1, -19 },
  { 894, 10, 19, 9, 0, -19 },
  { 918, 10, 23, 12, 1, -19 },
  { 947, 9, 19, 9, 0, -19 },
  { 969, 11, 19, 9, -1, -19 },
  { 996, 8, 19, 8, 2, -19 },
  { 1015, 11, 19, 11, 1, -19 },
  { 1042, 9, 19, 9, 2, -19 },
  { 1064, 15, 19, 16, 2, -19 },
  { 1100, 12, 19, 8, -2, -19 },
  { 1129, 8, 19, 8, 2, -19 },
  { 1148, 10, 19, 8, -1, -19 },
  { 1172, 9, 23, 7, 0, -19 },
  { 1198, 3, 19, 8, 3, -19 },
  { 1206, 10, 23, 7, -2, -19 },
  { 1235, 9, 9, 10, 1, -19 },
  { 1246, 7, 1, 7, -2, 2 },
  { 1247, 2, 4, 5, 4, -20 },
  { 1248, 9, 14, 10, 1, -14 },
  { 1264, 9, 20, 10, 0, -20 },
  { 1287, 7, 14, 7, 1, -14 },
  { 1300, 10, 20, 10, 1, -20 },
  { 1325, 7, 14, 8, 1, -14 },
  { 1338, 11, 26, 5, -3, -20 },
  { 1374, 10, 20, 10, 0, -14 },
  { 1399, 9, 20, 9, 0, -20 },
  { 1422, 5, 19, 4, 0, -19 },
  { 1434, 8, 25, 4, -3, -19 },
  { 1459, 9, 20, 8, 0, -20 },
  { 1482, 5, 20, 4, 0, -20 },
  { 1495, 13, 14, 14, 0, -14 },
  { 1518, 9, 14, 9, 0, -14 },
  { 1534, 8, 14, 9, 1, -14 },
  { 1548, 10, 20, 10, -1, -14 },
  { 1573, 9, 20, 10, 1, -14 },
  { 1596, 7, 14, 6, 0, -14 },
  { 1609, 7, 14, 7, 0, -14 },
  { 1622, 5, 17, 5, 0, -17 },
  { 1633, 8, 14, 9, 1, -14 },
  { 1647, 7, 14, 7, 1, -14 },
  { 1660, 11, 14, 12, 2, -14 },
  { 1680, 9, 14, 7, -1, -14 },
  { 1696, 12, 20, 8, -3, -14 },
  { 1726, 8, 14, 6, -1, -14 },
  { 1740, 9, 23, 8, 1, -19 },
  { 1766, 1, 26, 9, 4, -20 },
  { 1770, 9, 23, 8, -2, -19 },
  { 1796, 9, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ThinItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ThinItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ThinItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_THINITALIC26PT7B_H_
