#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x5F, 0x60, 0x69, 0xC0, 0xFD, 0xB0, 0x4B, 0x70, 0x80,
  0xF8, 0xF8, 0x70, 0x74, 0xC0, 0x80, 0x80, 0x5A, 0xFF, 0xD5, 0xD7, 0xD7,
  0x7D, 0xF7, 0xFF, 0xD6, 0xDF, 0xF7, 0xA0, 0xB0, 0xD0, 0xF0, 0xF0, 0xDA,
  0xFF, 0xC6, 0x7F, 0xFF, 0xEB, 0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xF0, 0xBE,
  0xD0, 0xF0, 0xF8, 0xD3, 0x50, 0xAB, 0x99, 0xFD, 0xBE, 0xD0, 0xF6, 0xF0,
  0xFA, 0xF6, 0xF2, 0xF7, 0x50, 0xE7, 0xD5, 0xB6, 0xF0, 0xF5, 0xDB, 0x6A,
  0xD7, 0xD5, 0xDB, 0xEA, 0xC0, 0xA5, 0xF8, 0x70, 0xE0, 0x80, 0xFC, 0xAF,
  0xC0, 0xEC, 0x5F, 0xC0, 0xEC, 0x6A, 0x80, 0xFF, 0xAF, 0xC0, 0xF0, 0xF8,
  0xAF, 0xC0, 0xF8, 0xFF, 0x80, 0xFC, 0xFC, 0xFE, 0xFD, 0xE8, 0xDC, 0xF0,
  0xFC, 0xF8, 0xF6, 0x80, 0xDC, 0xD6, 0xEC, 0x59, 0x40, 0xFC, 0xD5, 0x80,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 2, 0, -5 },
  { 7, 3, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 2, 2, 2, 0, -5 },
  { 15, 2, 3, 2, 0, -4 },
  { 16, 1, 2, 1, 0, -1 },
  { 17, 1, 1, 2, 0, -2 },
  { 18, 1, 1, 1, 0, -1 },
  { 19, 2, 4, 2, 0, -4 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 2, 4, 2, 0, -4 },
  { 27, 2, 4, 2, 0, -4 },
  { 28, 2, 4, 2, 0, -4 },
  { 29, 2, 4, 2, 0, -4 },
  { 30, 1, 3, 1, 0, -3 },
  { 31, 1, 4, 1, 0, -3 },
  { 32, 2, 2, 2, 0, -3 },
  { 33, 2, 2, 2, 0, -3 },
  { 34, 2, 2, 2, 0, -3 },
  { 35, 2, 4, 2, 0, -4 },
  { 36, 3, 5, 4, 0, -4 },
  { 38, 2, 4, 2, 0, -4 },
  { 39, 2, 4, 3, 0, -4 },
  { 40, 2, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 2, 4, 2, 0, -4 },
  { 44, 2, 4, 2, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 3, 4, 3, 0, -4 },
  { 49, 1, 4, 2, 0, -4 },
  { 50, 1, 5, 1, 0, -4 },
  { 51, 3, 4, 2, 0, -4 },
  { 53, 2, 4, 2, 0, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 2, 4, 3, 0, -4 },
  { 61, 3, 5, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 2, 4, 2, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 2, 5, 2, 0, -4 },
  { 77, 2, 4, 2, 0, -4 },
  { 78, 1, 5, 2, 0, -4 },
  { 79, 2, 2, 3, 0, -4 },
  { 80, 3, 1, 2, 0, 0 },
  { 81, 1, 1, 1, 0, -5 },
  { 82, 2, 3, 2, 0, -3 },
  { 83, 2, 5, 3, 0, -5 },
  { 85, 2, 3, 2, 0, -3 },
  { 86, 2, 5, 3, 0, -5 },
  { 88, 2, 3, 2, 0, -3 },
  { 89, 2, 5, 1, 0, -5 },
  { 91, 2, 4, 3, 0, -3 },
  { 92, 2, 5, 3, 0, -5 },
  { 94, 1, 4, 1, 0, -4 },
  { 95, 1, 5, 1, 0, -4 },
  { 96, 2, 5, 2, 0, -5 },
  { 98, 1, 5, 1, 0, -5 },
  { 99, 3, 3, 4, 0, -3 },
  { 101, 2, 3, 3, 0, -3 },
  { 102, 2, 3, 3, 0, -3 },
  { 103, 2, 4, 3, 0, -3 },
  { 104, 2, 4, 3, 0, -3 },
  { 105, 2, 3, 2, 0, -3 },
  { 106, 2, 3, 2, 0, -3 },
  { 107, 1, 4, 1, 0, -4 },
  { 108, 2, 3, 3, 0, -3 },
  { 109, 2, 3, 2, 0, -3 },
  { 110, 3, 3, 3, 0, -3 },
  { 112, 2, 3, 2, 0, -3 },
  { 113, 2, 4, 2, 0, -3 },
  { 114, 2, 3, 2, 0, -3 },
  { 115, 2, 5, 2, 0, -4 },
  { 117, 1, 6, 2, 1, -5 },
  { 118, 2, 5, 2, 0, -4 },
  { 120, 2, 1, 2, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Light6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT6PT7B_H_
