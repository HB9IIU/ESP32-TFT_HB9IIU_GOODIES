#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0xDA, 0x49, 0x24, 0x92, 0x48, 0x01, 0xFF, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x10,
  0xC0, 0x84, 0x04, 0x20, 0x21, 0x1F, 0xFF, 0xFF, 0xF8, 0xC6, 0x06, 0x30,
  0x21, 0x81, 0x0C, 0x08, 0x40, 0x42, 0x1F, 0xFE, 0xFF, 0xF1, 0x84, 0x0C,
  0x60, 0x63, 0x02, 0x18, 0x10, 0xC0, 0x84, 0x04, 0x20, 0x04, 0x00, 0x80,
  0x3E, 0x1F, 0xF6, 0x44, 0x88, 0x31, 0x06, 0x20, 0xC4, 0x18, 0x81, 0x90,
  0x1A, 0x01, 0xE0, 0x0E, 0x01, 0x70, 0x23, 0x04, 0x60, 0x84, 0x10, 0x82,
  0x10, 0x47, 0x89, 0xBF, 0xE0, 0xF0, 0x04, 0x00, 0x80, 0x10, 0x00, 0x18,
  0x0C, 0x0F, 0x03, 0x06, 0x60, 0x81, 0x08, 0x60, 0x42, 0x18, 0x30, 0x84,
  0x0C, 0x23, 0x03, 0x08, 0xC0, 0xC2, 0x20, 0x30, 0x98, 0x04, 0x26, 0xF9,
  0x09, 0x22, 0x66, 0xD8, 0xCF, 0x36, 0x31, 0x89, 0x8C, 0x06, 0x63, 0x01,
  0x98, 0xC0, 0x46, 0x30, 0x31, 0x8C, 0x0C, 0x63, 0x02, 0x18, 0xC1, 0x82,
  0x20, 0x40, 0xD8, 0x30, 0x1C, 0x0E, 0x00, 0xF8, 0x0C, 0x40, 0x63, 0x02,
  0x18, 0x10, 0xC0, 0xC6, 0x06, 0x20, 0x33, 0x00, 0xD8, 0x07, 0x80, 0x38,
  0x03, 0x40, 0x33, 0x0D, 0x8C, 0x58, 0x62, 0xC1, 0xB6, 0x0D, 0xB0, 0x39,
  0x80, 0xCC, 0x0E, 0x30, 0xD9, 0xCE, 0xC7, 0xC3, 0xFF, 0xFF, 0xC0, 0x0C,
  0x61, 0x8C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x20, 0xC3,
  0x0C, 0x30, 0xC3, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x0C, 0xC1, 0x82, 0x0C,
  0x10, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC3,
  0x0C, 0x31, 0x86, 0x18, 0xC3, 0x18, 0xC0, 0x0C, 0x03, 0x00, 0xC1, 0xB7,
  0xFF, 0x83, 0x01, 0xE0, 0xCC, 0x61, 0x88, 0x40, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x33, 0x26, 0x66, 0x4C, 0xFF,
  0xFC, 0xDF, 0x80, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x0F, 0x03, 0xF0,
  0xC7, 0x18, 0x66, 0x0C, 0xC0, 0xD8, 0x1B, 0x03, 0x40, 0x68, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1A, 0x03, 0x40, 0x6C, 0x0D, 0x81, 0xB0,
  0x26, 0x0C, 0x61, 0x8F, 0xE0, 0xF8, 0x06, 0x1C, 0x79, 0xB6, 0x78, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x1E, 0x0F, 0xF1, 0x07, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0x1E, 0x0F, 0xF3, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x0E, 0x0F, 0x01, 0xF8, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xB8, 0xE3, 0xF8, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x08, 0xC1, 0x8C,
  0x10, 0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0x80, 0xCF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x7F, 0xBF, 0xEC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xE3, 0x1E,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xA0,
  0x6C, 0x73, 0xF8, 0x07, 0x87, 0xE3, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x21, 0x09, 0xF2, 0x86, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x67, 0x38, 0xFC, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x0F, 0x07, 0xF1, 0xC3, 0x30, 0x36,
  0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xC6, 0x38, 0x6E, 0x07, 0x01, 0xF0,
  0x63, 0x18, 0x33, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x3C, 0x06, 0xC0,
  0xCE, 0x70, 0xFC, 0x0E, 0x07, 0xF1, 0xC6, 0x30, 0x64, 0x0D, 0x80, 0xB0,
  0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x76, 0x0E, 0x7E, 0xC7, 0x98,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x11, 0xC3, 0xF0,
  0x5F, 0xA0, 0x00, 0x00, 0x00, 0x06, 0xFC, 0x27, 0x72, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x33, 0x36, 0x66, 0x4C, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x0C, 0x00, 0x3C, 0x7F, 0x90, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xE0, 0x30, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0x03, 0x02,
  0x00, 0xC3, 0x00, 0x23, 0x00, 0x19, 0x80, 0x04, 0x83, 0xE3, 0xC3, 0x31,
  0xE3, 0x18, 0xF1, 0x8C, 0x30, 0x86, 0x18, 0x43, 0x0C, 0x21, 0x86, 0x10,
  0xC7, 0x08, 0x63, 0x84, 0x31, 0xC3, 0x28, 0xB1, 0x94, 0xD8, 0x73, 0xCC,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x08, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x05, 0x80,
  0x36, 0x00, 0xC8, 0x03, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x84, 0x06, 0x18,
  0x18, 0x60, 0x41, 0x83, 0xFE, 0x0F, 0xFC, 0x30, 0x30, 0x80, 0xC6, 0x03,
  0x18, 0x06, 0x60, 0x19, 0x80, 0x6C, 0x01, 0xB0, 0x03, 0xFC, 0x1F, 0xE2,
  0x06, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34, 0x06, 0x80, 0xD0, 0x32, 0x0E,
  0x7F, 0x08, 0x79, 0x03, 0xA0, 0x34, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x28, 0x0D, 0x03, 0xBF, 0xE7, 0xF8, 0x07, 0xC3, 0xFC, 0xE0, 0x98, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x98, 0x7F, 0xF0, 0x0F, 0xF0, 0x83, 0x88, 0x1C, 0x80, 0xC8, 0x06,
  0x80, 0x68, 0x06, 0x80, 0x68, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x0C, 0x80, 0xC8, 0x18,
  0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x03, 0xE0, 0x3F, 0xF1, 0x80, 0x8C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00,
  0xD8, 0x03, 0x30, 0x0C, 0xE0, 0x31, 0xE3, 0xC3, 0xFE, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30, 0xC3, 0xFF, 0xE0, 0x80,
  0xD0, 0x1A, 0x06, 0x40, 0xC8, 0x31, 0x0C, 0x21, 0x84, 0x60, 0x8C, 0x13,
  0x02, 0x60, 0x5C, 0x0F, 0x81, 0x98, 0x33, 0x04, 0x30, 0x86, 0x10, 0x62,
  0x0C, 0x40, 0xC8, 0x19, 0x01, 0xA0, 0x34, 0x07, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7A, 0x00, 0x7D, 0x80, 0x3E, 0xC0, 0x17, 0x20,
  0x1B, 0x90, 0x0D, 0xCC, 0x06, 0xE6, 0x02, 0x71, 0x03, 0x38, 0xC1, 0x9C,
  0x60, 0x8E, 0x10, 0xC7, 0x0C, 0x63, 0x86, 0x21, 0xC3, 0x30, 0xE0, 0x98,
  0x70, 0x6C, 0x38, 0x34, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xA0, 0x3B, 0x03, 0x90, 0x39, 0x83, 0x98,
  0x38, 0xC3, 0x8C, 0x38, 0x63, 0x86, 0x38, 0x23, 0x83, 0x38, 0x33, 0x81,
  0xB8, 0x19, 0x80, 0xD8, 0x0D, 0x80, 0x58, 0x07, 0x80, 0x78, 0x03, 0x07,
  0x80, 0x7F, 0x83, 0x07, 0x18, 0x0C, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0x98, 0x06, 0x60, 0x30,
  0xC0, 0xC3, 0xCE, 0x03, 0xF0, 0xF0, 0x3F, 0xC8, 0x3A, 0x06, 0x80, 0xA0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1A, 0x06, 0x87, 0x3F, 0x88, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x07,
  0x80, 0x7F, 0x83, 0x07, 0x18, 0x0C, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0x98, 0x06, 0x60, 0x30,
  0xC0, 0xC3, 0xCE, 0x03, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0xF0, 0x1F, 0xE2, 0x0E, 0x40, 0xC8, 0x0D, 0x01,
  0xA0, 0x34, 0x06, 0x80, 0xD0, 0x12, 0x06, 0x41, 0xCF, 0xE1, 0xF8, 0x21,
  0x04, 0x30, 0x86, 0x10, 0x62, 0x0C, 0x40, 0xC8, 0x19, 0x01, 0xA0, 0x34,
  0x06, 0x0F, 0x87, 0xFD, 0xC1, 0x30, 0x06, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0x01, 0xBC, 0xE7, 0xF8, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x34, 0x03, 0x60, 0x36, 0x06, 0x3C, 0xE1, 0xFC, 0xC0, 0x1E,
  0x00, 0xF0, 0x06, 0xC0, 0x36, 0x01, 0x30, 0x19, 0x80, 0xC4, 0x06, 0x30,
  0x21, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x84, 0x0C, 0x60, 0x63, 0x01, 0x18,
  0x0C, 0x80, 0x64, 0x03, 0x60, 0x1B, 0x00, 0x58, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x34, 0x03, 0x80, 0xD8, 0x0E, 0x03,
  0x60, 0x38, 0x0D, 0x81, 0xA0, 0x66, 0x06, 0x81, 0x88, 0x1B, 0x06, 0x30,
  0x4C, 0x18, 0xC1, 0x30, 0x63, 0x0C, 0x43, 0x0C, 0x31, 0x0C, 0x10, 0xC6,
  0x30, 0x62, 0x18, 0xC1, 0x88, 0x62, 0x06, 0x61, 0x98, 0x09, 0x82, 0x60,
  0x36, 0x0D, 0x80, 0xD0, 0x36, 0x03, 0x40, 0xD0, 0x0F, 0x03, 0xC0, 0x1C,
  0x07, 0x00, 0x70, 0x1C, 0x01, 0x80, 0x70, 0x60, 0x36, 0x06, 0x30, 0x63,
  0x06, 0x10, 0xC1, 0x8C, 0x18, 0x80, 0x98, 0x0D, 0x80, 0xF0, 0x07, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x0D, 0x00, 0x98, 0x19, 0x81, 0x88, 0x30, 0xC3,
  0x0C, 0x30, 0x66, 0x06, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x06, 0x60, 0x66,
  0x06, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x19, 0x81, 0x98, 0x19, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xBF, 0xE0, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x08, 0x03, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x06, 0x00, 0x60, 0x0F, 0x00,
  0xF0, 0x19, 0x81, 0x98, 0x30, 0x83, 0x0C, 0x60, 0x46, 0x06, 0xC0, 0x2C,
  0x03, 0xFF, 0xFC, 0xE1, 0xC3, 0x06, 0x0C, 0x1E, 0x1F, 0xE2, 0x18, 0x02,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x1F, 0xCC, 0x36, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1F, 0x07, 0x62, 0xCF, 0xB0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x78, 0xDF, 0x9E, 0x1B, 0x81, 0x70, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0xF8, 0x36, 0xCE, 0xCF, 0x80, 0x0F, 0x8F, 0xCC, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0x60, 0x38,
  0x8F, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x71, 0x3F, 0xA6, 0x15, 0x81, 0xB0, 0x36, 0x06, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x05, 0x00, 0xA0, 0x36, 0x06, 0xC0, 0xD8, 0x29, 0xCD, 0x1F,
  0x20, 0x0F, 0x03, 0xF0, 0xC3, 0x30, 0x66, 0x04, 0xC0, 0xD0, 0x1A, 0x03,
  0xFF, 0xF8, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0xC3, 0xF8, 0x0F, 0x1D, 0x18, 0x10, 0x10, 0x10, 0x10, 0x3E, 0xFE, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x0E, 0x27, 0xF4, 0xC2, 0xB0, 0x36, 0x06, 0xC0, 0xD0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xA0, 0x14, 0x06, 0xC0, 0xD8, 0x1B,
  0x05, 0x39, 0xA3, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x1A, 0x06,
  0x7F, 0x87, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x3C, 0xDF, 0xBC, 0x7E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x33, 0x30, 0x00, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xEE, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0x18,
  0xCC, 0x33, 0x0D, 0x83, 0x70, 0xEC, 0x39, 0x8C, 0x63, 0x08, 0xC3, 0x30,
  0xCC, 0x1B, 0x06, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xCE, 0x1E, 0x6F, 0x9F, 0xB8, 0x68, 0xFC, 0x38, 0x3C, 0x0C, 0x1E, 0x06,
  0x0F, 0x03, 0x07, 0x81, 0x83, 0xC0, 0xC1, 0xE0, 0x60, 0xF0, 0x30, 0x78,
  0x18, 0x3C, 0x0C, 0x1E, 0x06, 0x0F, 0x03, 0x07, 0x81, 0x83, 0xC0, 0xC1,
  0xE0, 0x60, 0xC0, 0xCF, 0x37, 0xEF, 0x1F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x30, 0x0F, 0x01, 0xF8, 0x30, 0xC6, 0x06, 0x60, 0x66, 0x06, 0x40,
  0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x02, 0x40, 0x26, 0x06, 0x60,
  0x63, 0x0C, 0x39, 0xC1, 0xF8, 0xCF, 0x1B, 0xF3, 0xC3, 0x70, 0x6E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x1F, 0x06, 0xD9, 0xD9, 0xF3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x27, 0xF4, 0xC2, 0xB0, 0x36, 0x06,
  0xC0, 0xD0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xA0, 0x14, 0x06, 0xC0,
  0xD8, 0x1B, 0x85, 0x39, 0xA3, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0xCF, 0xBF, 0x47, 0x0E, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1E, 0x3F, 0xD8,
  0x58, 0x0C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x60, 0x18,
  0x0C, 0x07, 0x06, 0xE7, 0x3F, 0x00, 0x20, 0x82, 0x18, 0x7F, 0xF6, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x34, 0xF0, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x87, 0x73, 0x4F, 0x90, 0xC0, 0x78,
  0x0D, 0x03, 0x30, 0x66, 0x0C, 0xC1, 0x88, 0x21, 0x8C, 0x31, 0x86, 0x30,
  0x44, 0x0D, 0x81, 0xB0, 0x36, 0x02, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0xC0,
  0xC0, 0xD0, 0x30, 0x36, 0x0E, 0x0D, 0x83, 0x82, 0x61, 0xA0, 0x98, 0x68,
  0x62, 0x1B, 0x18, 0xC4, 0xC6, 0x31, 0x31, 0x0C, 0xC4, 0xC1, 0x31, 0x30,
  0x4C, 0x6C, 0x1A, 0x1A, 0x06, 0x86, 0x81, 0xE0, 0xE0, 0x38, 0x38, 0x0E,
  0x0E, 0x03, 0x03, 0x00, 0xC0, 0xF0, 0x66, 0x19, 0x8C, 0x23, 0x0C, 0x81,
  0x60, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xD8, 0x32, 0x08, 0xC6, 0x31, 0x86,
  0xC1, 0xB0, 0x30, 0xC0, 0x6C, 0x0D, 0x81, 0xB0, 0x22, 0x0C, 0x61, 0x8C,
  0x31, 0x84, 0x11, 0x82, 0x30, 0x66, 0x0C, 0x80, 0xB0, 0x16, 0x03, 0xC0,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0xF8, 0x1C, 0x00, 0xFE, 0xFE, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0x01, 0x0F, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0xE0,
  0xE0, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0xE0, 0x30, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x07, 0x0F, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x70, 0xE0,
  0x7C, 0x1C, 0x7F, 0x83, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 24, 7, 2, -24 },
  { 10, 7, 9, 11, 2, -24 },
  { 18, 13, 24, 15, 1, -24 },
  { 57, 11, 27, 14, 1, -25 },
  { 95, 18, 24, 20, 1, -24 },
  { 149, 13, 24, 14, 1, -24 },
  { 188, 2, 9, 6, 2, -24 },
  { 191, 6, 29, 9, 2, -24 },
  { 213, 6, 29, 9, 1, -24 },
  { 235, 10, 10, 12, 1, -25 },
  { 248, 12, 15, 14, 1, -19 },
  { 271, 4, 8, 7, 1, -4 },
  { 275, 7, 2, 9, 1, -10 },
  { 277, 3, 3, 7, 2, -3 },
  { 279, 10, 24, 12, 1, -24 },
  { 309, 11, 24, 14, 1, -24 },
  { 342, 7, 24, 14, 2, -24 },
  { 363, 11, 24, 14, 1, -24 },
  { 396, 11, 24, 14, 1, -24 },
  { 429, 12, 24, 14, 1, -24 },
  { 465, 10, 24, 14, 2, -24 },
  { 495, 10, 24, 14, 2, -24 },
  { 525, 11, 24, 14, 1, -24 },
  { 558, 11, 24, 14, 1, -24 },
  { 591, 11, 24, 14, 1, -24 },
  { 624, 3, 18, 7, 2, -18 },
  { 631, 4, 22, 7, 1, -18 },
  { 642, 12, 14, 14, 1, -19 },
  { 663, 12, 9, 14, 1, -16 },
  { 677, 12, 14, 14, 1, -19 },
  { 698, 9, 24, 10, 0, -24 },
  { 725, 17, 27, 21, 2, -24 },
  { 783, 14, 24, 14, 0, -24 },
  { 825, 11, 24, 15, 3, -24 },
  { 858, 11, 24, 14, 2, -24 },
  { 891, 12, 24, 16, 3, -24 },
  { 927, 8, 24, 13, 3, -24 },
  { 951, 8, 24, 12, 3, -24 },
  { 975, 14, 24, 18, 2, -24 },
  { 1017, 11, 24, 17, 3, -24 },
  { 1050, 6, 24, 8, 1, -24 },
  { 1068, 6, 30, 7, -2, -24 },
  { 1091, 11, 24, 14, 3, -24 },
  { 1124, 8, 24, 12, 3, -24 },
  { 1148, 17, 24, 23, 3, -24 },
  { 1199, 12, 24, 18, 3, -24 },
  { 1235, 14, 24, 18, 2, -24 },
  { 1277, 10, 24, 14, 3, -24 },
  { 1307, 14, 30, 18, 2, -24 },
  { 1360, 11, 24, 14, 3, -24 },
  { 1393, 11, 24, 13, 1, -24 },
  { 1426, 12, 24, 12, 0, -24 },
  { 1462, 12, 24, 17, 2, -24 },
  { 1498, 13, 24, 13, 0, -24 },
  { 1537, 22, 24, 23, 0, -24 },
  { 1603, 12, 24, 12, 0, -24 },
  { 1639, 12, 24, 12, 0, -24 },
  { 1675, 10, 24, 11, 1, -24 },
  { 1705, 6, 29, 10, 3, -24 },
  { 1727, 10, 24, 12, 1, -24 },
  { 1757, 7, 29, 10, 1, -24 },
  { 1783, 12, 12, 14, 1, -24 },
  { 1801, 14, 1, 14, 0, 3 },
  { 1803, 6, 5, 8, 1, -25 },
  { 1807, 10, 18, 13, 1, -18 },
  { 1830, 11, 25, 15, 2, -25 },
  { 1865, 9, 18, 11, 1, -18 },
  { 1886, 11, 25, 15, 1, -25 },
  { 1921, 11, 18, 13, 1, -18 },
  { 1946, 8, 25, 8, 0, -25 },
  { 1971, 11, 26, 15, 1, -18 },
  { 2007, 10, 25, 14, 2, -25 },
  { 2039, 2, 24, 6, 2, -24 },
  { 2045, 4, 32, 6, 0, -24 },
  { 2061, 10, 25, 12, 2, -25 },
  { 2093, 2, 25, 6, 2, -25 },
  { 2100, 17, 18, 21, 2, -18 },
  { 2139, 10, 18, 14, 2, -18 },
  { 2162, 12, 18, 14, 1, -18 },
  { 2189, 11, 26, 15, 2, -18 },
  { 2225, 11, 26, 15, 1, -18 },
  { 2261, 7, 18, 9, 2, -18 },
  { 2277, 9, 18, 11, 1, -18 },
  { 2298, 6, 22, 8, 1, -22 },
  { 2315, 10, 18, 14, 2, -18 },
  { 2338, 11, 18, 11, 0, -18 },
  { 2363, 18, 18, 18, 0, -18 },
  { 2404, 10, 18, 11, 1, -18 },
  { 2427, 11, 26, 11, 0, -18 },
  { 2463, 8, 18, 9, 1, -18 },
  { 2481, 8, 29, 12, 2, -24 },
  { 2510, 1, 33, 13, 6, -25 },
  { 2515, 8, 29, 12, 2, -24 },
  { 2544, 12, 3, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Light33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT33PT7B_H_
