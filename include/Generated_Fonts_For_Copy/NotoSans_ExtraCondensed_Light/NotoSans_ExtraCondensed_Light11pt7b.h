#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x52, 0xBE, 0xA5, 0x79, 0x4C, 0x7A, 0xA4, 0x33, 0xB6,
  0x20, 0x4A, 0xAB, 0x2F, 0x5C, 0xB2, 0xCB, 0x63, 0x18, 0xC6, 0xD6, 0x4D,
  0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x12, 0x4A, 0x50, 0x3E, 0x60, 0x22, 0xF2,
  0x20, 0x60, 0xE0, 0x80, 0x12, 0x22, 0x44, 0x48, 0x65, 0x99, 0x99, 0x56,
  0x75, 0x55, 0x61, 0x11, 0x22, 0x4F, 0xE1, 0x16, 0x11, 0x1E, 0x13, 0x55,
  0x9F, 0x11, 0xF2, 0x62, 0x4E, 0x72, 0x6B, 0x6F, 0xF1, 0x12, 0x22, 0x44,
  0x69, 0x96, 0x59, 0x97, 0x69, 0x99, 0x71, 0x1E, 0x84, 0x40, 0x18, 0x34,
  0xC3, 0xF0, 0xF0, 0xC3, 0x3C, 0xE4, 0x94, 0x82, 0x74, 0x6F, 0xBD, 0xEE,
  0xF0, 0x70, 0x21, 0x18, 0xA7, 0x4A, 0x51, 0xE9, 0x9E, 0xA9, 0x9E, 0x72,
  0x49, 0x23, 0xE9, 0x99, 0x99, 0x9E, 0xF2, 0x79, 0x27, 0xF2, 0x4F, 0x24,
  0x78, 0x88, 0xB9, 0x97, 0x99, 0x9F, 0x99, 0x99, 0xD5, 0x57, 0x55, 0x55,
  0x70, 0xAA, 0xCC, 0xCA, 0xAB, 0x92, 0x49, 0x27, 0x86, 0x38, 0xF3, 0xD7,
  0x5B, 0x69, 0x99, 0xDD, 0xBB, 0x99, 0x69, 0x99, 0x99, 0x9E, 0xF6, 0xDD,
  0x24, 0x69, 0x99, 0x99, 0x9E, 0x21, 0xEA, 0xAA, 0xCA, 0xA9, 0x78, 0x84,
  0x21, 0x1E, 0xF4, 0x44, 0x44, 0x44, 0x99, 0x99, 0x99, 0x9E, 0x99, 0x95,
  0x56, 0x62, 0x93, 0x26, 0x6A, 0xD6, 0xAD, 0x59, 0x12, 0x95, 0x62, 0x26,
  0x99, 0x99, 0x66, 0x44, 0x44, 0xE2, 0x22, 0x44, 0x8F, 0xEA, 0xAA, 0xB0,
  0x84, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x26, 0x59, 0xF8, 0xC0,
  0x61, 0x3D, 0x97, 0x93, 0xDB, 0x6F, 0x6A, 0x48, 0xC0, 0x11, 0x79, 0x99,
  0x97, 0x69, 0xF8, 0x87, 0x6B, 0x24, 0x92, 0x79, 0x99, 0x97, 0x11, 0x60,
  0x93, 0xDB, 0x6D, 0xBF, 0xBF, 0xE0, 0x92, 0xE9, 0xB5, 0xFF, 0xFD, 0x6B,
  0x5A, 0xD4, 0xF6, 0xDB, 0x40, 0x69, 0x99, 0x97, 0xF6, 0xDB, 0xE4, 0x80,
  0x79, 0x99, 0x97, 0x11, 0x10, 0xEA, 0xA0, 0x71, 0x13, 0xC0, 0x75, 0x54,
  0xB6, 0xDB, 0xC0, 0x9A, 0xA6, 0x64, 0x96, 0xDB, 0x5D, 0x49, 0x20, 0x96,
  0x44, 0x69, 0x99, 0x66, 0x64, 0x44, 0x80, 0xE5, 0x25, 0xC0, 0x6A, 0xAA,
  0x90, 0xFF, 0xE0, 0xC9, 0x22, 0x52, 0x58, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 5, 8, 5, 0, -8 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 6, 8, 7, 0, -8 },
  { 19, 5, 8, 5, 0, -8 },
  { 24, 1, 3, 2, 1, -8 },
  { 25, 2, 10, 3, 1, -8 },
  { 28, 3, 10, 3, 0, -8 },
  { 32, 4, 3, 4, 0, -8 },
  { 34, 4, 5, 5, 0, -6 },
  { 37, 2, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 1, -1 },
  { 40, 4, 8, 4, 0, -8 },
  { 44, 4, 8, 5, 0, -8 },
  { 48, 2, 8, 5, 1, -8 },
  { 50, 4, 8, 5, 0, -8 },
  { 54, 4, 8, 5, 0, -8 },
  { 58, 4, 8, 5, 0, -8 },
  { 62, 3, 8, 5, 1, -8 },
  { 65, 3, 8, 5, 1, -8 },
  { 68, 4, 8, 5, 0, -8 },
  { 72, 4, 8, 5, 0, -8 },
  { 76, 4, 8, 5, 0, -8 },
  { 80, 1, 6, 2, 1, -6 },
  { 81, 2, 7, 2, 0, -6 },
  { 83, 4, 4, 5, 0, -6 },
  { 85, 4, 3, 5, 0, -5 },
  { 87, 4, 4, 5, 0, -6 },
  { 89, 3, 8, 3, 0, -8 },
  { 92, 5, 9, 7, 1, -8 },
  { 98, 5, 8, 5, 0, -8 },
  { 103, 4, 8, 5, 1, -8 },
  { 107, 3, 8, 5, 1, -8 },
  { 110, 4, 8, 5, 1, -8 },
  { 114, 3, 8, 4, 1, -8 },
  { 117, 3, 8, 4, 1, -8 },
  { 120, 4, 8, 6, 1, -8 },
  { 124, 4, 8, 6, 1, -8 },
  { 128, 2, 8, 3, 0, -8 },
  { 130, 2, 10, 2, -1, -8 },
  { 133, 4, 8, 5, 1, -8 },
  { 137, 3, 8, 4, 1, -8 },
  { 140, 6, 8, 8, 1, -8 },
  { 146, 4, 8, 6, 1, -8 },
  { 150, 4, 8, 6, 1, -8 },
  { 154, 3, 8, 5, 1, -8 },
  { 157, 4, 10, 6, 1, -8 },
  { 162, 4, 8, 5, 1, -8 },
  { 166, 4, 8, 4, 0, -8 },
  { 170, 4, 8, 4, 0, -8 },
  { 174, 4, 8, 6, 1, -8 },
  { 178, 4, 8, 4, 0, -8 },
  { 182, 7, 8, 8, 0, -8 },
  { 189, 4, 8, 4, 0, -8 },
  { 193, 4, 8, 4, 0, -8 },
  { 197, 4, 8, 4, 0, -8 },
  { 201, 2, 10, 3, 1, -8 },
  { 204, 4, 8, 4, 0, -8 },
  { 208, 3, 10, 3, 0, -8 },
  { 212, 4, 4, 5, 0, -8 },
  { 214, 5, 1, 5, 0, 1 },
  { 215, 2, 1, 3, 0, -8 },
  { 216, 4, 6, 4, 0, -6 },
  { 219, 3, 8, 5, 1, -8 },
  { 222, 3, 6, 4, 0, -6 },
  { 225, 4, 8, 5, 0, -8 },
  { 229, 4, 6, 4, 0, -6 },
  { 232, 3, 8, 3, 0, -8 },
  { 235, 4, 9, 5, 0, -6 },
  { 240, 3, 8, 5, 1, -8 },
  { 243, 1, 8, 2, 1, -8 },
  { 244, 1, 11, 2, 0, -8 },
  { 246, 3, 8, 4, 1, -8 },
  { 249, 1, 8, 2, 1, -8 },
  { 250, 5, 6, 7, 1, -6 },
  { 254, 3, 6, 5, 1, -6 },
  { 257, 4, 6, 5, 0, -6 },
  { 260, 3, 9, 5, 1, -6 },
  { 264, 4, 9, 5, 0, -6 },
  { 269, 2, 6, 3, 1, -6 },
  { 271, 3, 6, 4, 0, -6 },
  { 274, 2, 7, 3, 0, -7 },
  { 276, 3, 6, 5, 1, -6 },
  { 279, 4, 6, 4, 0, -6 },
  { 282, 6, 6, 6, 0, -6 },
  { 287, 4, 6, 4, 0, -6 },
  { 290, 4, 9, 4, 0, -6 },
  { 295, 3, 6, 3, 0, -6 },
  { 298, 2, 10, 4, 1, -8 },
  { 301, 1, 11, 4, 2, -8 },
  { 303, 3, 10, 4, 0, -8 },
  { 307, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Light11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT11PT7B_H_
