#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xF2, 0x85, 0x0A, 0x7E,
  0x48, 0x91, 0x20, 0x23, 0xE9, 0x4A, 0x70, 0xC5, 0x29, 0x6C, 0xC2, 0x00,
  0x40, 0xA4, 0xA4, 0xA8, 0xA8, 0xAF, 0xB5, 0x55, 0x15, 0x25, 0x25, 0x27,
  0x30, 0x91, 0x22, 0x42, 0x86, 0x1C, 0x29, 0x8D, 0x19, 0x33, 0x90, 0xF0,
  0x6A, 0x49, 0x24, 0x92, 0x24, 0x40, 0x89, 0x22, 0x49, 0x29, 0x29, 0x00,
  0x4D, 0x66, 0x90, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0xF0, 0xF0, 0x80,
  0x08, 0x44, 0x21, 0x10, 0x84, 0x42, 0x20, 0x22, 0xA3, 0x18, 0xC6, 0x31,
  0x8C, 0x64, 0xE0, 0x3C, 0x92, 0x49, 0x24, 0x80, 0x64, 0x82, 0x10, 0x88,
  0x44, 0x22, 0x21, 0xF0, 0x64, 0x82, 0x11, 0x19, 0xC1, 0x08, 0x43, 0xE0,
  0x08, 0x21, 0x86, 0x28, 0xA4, 0x92, 0xFC, 0x20, 0x82, 0xF4, 0x21, 0x0F,
  0x0C, 0x21, 0x08, 0xBC, 0x32, 0x21, 0x08, 0x7A, 0x31, 0x8C, 0x62, 0xE0,
  0xF8, 0x44, 0x21, 0x10, 0x84, 0x42, 0x10, 0x64, 0xA3, 0x19, 0x39, 0xD1,
  0x8C, 0x63, 0xE0, 0x64, 0xA3, 0x18, 0xC6, 0x6D, 0x08, 0x85, 0xC0, 0xC0,
  0x80, 0xC1, 0xE0, 0x04, 0x66, 0x30, 0x30, 0x20, 0x40, 0xFC, 0x00, 0x3F,
  0xC0, 0xC0, 0x81, 0x19, 0x88, 0x00, 0x69, 0x11, 0x11, 0x24, 0x40, 0x04,
  0x18, 0x26, 0x41, 0x81, 0x9D, 0xA5, 0xA5, 0xA5, 0xA5, 0x9F, 0x80, 0x40,
  0x7C, 0x10, 0x60, 0xA1, 0x44, 0x89, 0x1F, 0x22, 0x45, 0x0A, 0x08, 0xFA,
  0x28, 0xA2, 0x9B, 0xE8, 0xA1, 0x86, 0x2F, 0x80, 0x19, 0x94, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x04, 0x0E, 0xFA, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x2F, 0x00, 0xFC, 0x21, 0x08, 0x7A, 0x10, 0x84, 0x3E, 0xFC, 0x21, 0x08,
  0x7A, 0x10, 0x84, 0x20, 0x18, 0xCD, 0x04, 0x08, 0x10, 0x23, 0xC1, 0x83,
  0x05, 0x09, 0xF0, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x40,
  0xD5, 0x55, 0x5C, 0x24, 0x92, 0x49, 0x24, 0x93, 0xC0, 0x8E, 0x49, 0x28,
  0xA3, 0x89, 0x24, 0x92, 0x28, 0xC0, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0xC1, 0xE0, 0xF0, 0x74, 0x5A, 0x2D, 0x16, 0x53, 0x29, 0x94, 0xCC, 0x62,
  0x20, 0xC7, 0x1A, 0x69, 0xA6, 0x59, 0x63, 0x8E, 0x18, 0x40, 0x30, 0x9A,
  0x14, 0x28, 0x30, 0x60, 0xC1, 0x83, 0x09, 0x13, 0xC0, 0xFC, 0x63, 0x18,
  0xFA, 0x10, 0x84, 0x20, 0x30, 0x9A, 0x14, 0x28, 0x30, 0x60, 0xC1, 0x83,
  0x09, 0x13, 0xC0, 0x81, 0x01, 0x00, 0xFA, 0x28, 0xA2, 0x8B, 0xC9, 0x24,
  0x8A, 0x28, 0xC0, 0x36, 0x61, 0x08, 0x60, 0xC2, 0x08, 0x47, 0xE0, 0xFC,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x17, 0x80, 0x86, 0x14, 0x51, 0x49, 0x22, 0x8A, 0x30,
  0xC1, 0x00, 0x84, 0x30, 0x85, 0x29, 0x25, 0x24, 0xA4, 0x94, 0x92, 0xA1,
  0x8C, 0x31, 0x86, 0x30, 0xC6, 0x00, 0xCD, 0x22, 0x8C, 0x30, 0xC3, 0x12,
  0x49, 0x28, 0x40, 0x8D, 0x24, 0x94, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x00,
  0x78, 0x44, 0x21, 0x10, 0x88, 0x42, 0x3E, 0xF2, 0x49, 0x24, 0x92, 0x49,
  0xC0, 0xC2, 0x10, 0x42, 0x10, 0x42, 0x10, 0x42, 0xE4, 0x92, 0x49, 0x24,
  0x93, 0xC0, 0x10, 0xA2, 0x91, 0xC4, 0xFE, 0x90, 0x69, 0x11, 0x79, 0x99,
  0xF0, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0x8C, 0x63, 0xE0, 0x3C, 0x88, 0x88,
  0x88, 0x70, 0x08, 0x42, 0xD9, 0xC6, 0x31, 0x8C, 0x62, 0xF0, 0x64, 0xA3,
  0x1F, 0xC2, 0x10, 0x70, 0x34, 0x4E, 0x44, 0x44, 0x44, 0x44, 0x6C, 0xE3,
  0x18, 0xC6, 0x31, 0x78, 0x42, 0x1F, 0x00, 0x84, 0x21, 0x6C, 0xC6, 0x31,
  0x8C, 0x63, 0x10, 0xDF, 0xF0, 0x51, 0x55, 0x55, 0x56, 0x84, 0x21, 0x19,
  0x52, 0x9C, 0xA4, 0xA5, 0x10, 0xFF, 0xF0, 0xB6, 0xD9, 0x89, 0x89, 0x89,
  0x89, 0x89, 0x89, 0x89, 0xB6, 0x63, 0x18, 0xC6, 0x31, 0x88, 0x64, 0xA3,
  0x18, 0xC6, 0x31, 0x70, 0xB6, 0x63, 0x18, 0xC6, 0x31, 0xF4, 0x21, 0x08,
  0x00, 0x6C, 0xE3, 0x18, 0xC6, 0x31, 0x78, 0x42, 0x10, 0x80, 0xBA, 0x49,
  0x24, 0x80, 0x69, 0x88, 0x42, 0x11, 0xE0, 0x44, 0xE4, 0x44, 0x44, 0x44,
  0x70, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x8C, 0x62, 0x95, 0x29, 0x44,
  0x20, 0x88, 0xC4, 0x55, 0x4A, 0xA5, 0x52, 0xA9, 0x54, 0x44, 0x22, 0x00,
  0x8A, 0x54, 0x62, 0x19, 0x49, 0x88, 0x8C, 0x52, 0x95, 0x28, 0xC6, 0x21,
  0x08, 0x4C, 0x00, 0x71, 0x12, 0x24, 0x44, 0xF0, 0x34, 0x44, 0x44, 0x84,
  0x44, 0x44, 0x21, 0xFF, 0xFF, 0xC4, 0x44, 0x42, 0x12, 0x44, 0x44, 0x48,
  0x62, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Light16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 7, 11, 7, 0, -11 },
  { 15, 5, 13, 7, 1, -12 },
  { 24, 8, 12, 10, 1, -12 },
  { 36, 7, 12, 7, 0, -12 },
  { 47, 1, 4, 3, 1, -11 },
  { 48, 3, 14, 4, 1, -11 },
  { 54, 3, 14, 4, 1, -11 },
  { 60, 4, 5, 6, 1, -12 },
  { 63, 6, 7, 7, 0, -9 },
  { 69, 1, 4, 3, 1, -2 },
  { 70, 4, 1, 4, 0, -5 },
  { 71, 1, 1, 3, 1, -1 },
  { 72, 5, 11, 6, 0, -11 },
  { 79, 5, 12, 7, 1, -12 },
  { 87, 3, 11, 7, 1, -11 },
  { 92, 5, 12, 7, 1, -12 },
  { 100, 5, 12, 7, 1, -12 },
  { 108, 6, 12, 7, 0, -12 },
  { 117, 5, 11, 7, 1, -11 },
  { 124, 5, 12, 7, 1, -12 },
  { 132, 5, 11, 7, 1, -11 },
  { 139, 5, 12, 7, 1, -12 },
  { 147, 5, 12, 7, 1, -12 },
  { 155, 1, 9, 3, 1, -9 },
  { 157, 1, 11, 3, 1, -9 },
  { 159, 6, 7, 7, 0, -9 },
  { 165, 6, 4, 7, 0, -8 },
  { 168, 6, 7, 7, 0, -9 },
  { 174, 4, 12, 5, 0, -12 },
  { 180, 8, 13, 10, 1, -12 },
  { 193, 7, 11, 7, 0, -11 },
  { 203, 6, 11, 7, 1, -11 },
  { 212, 6, 12, 7, 1, -12 },
  { 221, 6, 11, 8, 1, -11 },
  { 230, 5, 11, 6, 1, -11 },
  { 237, 5, 11, 6, 1, -11 },
  { 244, 7, 12, 9, 1, -12 },
  { 255, 6, 11, 8, 1, -11 },
  { 264, 2, 11, 4, 1, -11 },
  { 267, 3, 14, 3, -1, -11 },
  { 273, 6, 11, 7, 1, -11 },
  { 282, 4, 11, 6, 1, -11 },
  { 288, 9, 11, 11, 1, -11 },
  { 301, 6, 11, 9, 1, -11 },
  { 310, 7, 12, 9, 1, -12 },
  { 321, 5, 11, 7, 1, -11 },
  { 328, 7, 15, 9, 1, -12 },
  { 342, 6, 11, 7, 1, -11 },
  { 351, 5, 12, 6, 1, -12 },
  { 359, 6, 11, 6, 0, -11 },
  { 368, 6, 11, 8, 1, -11 },
  { 377, 6, 11, 6, 0, -11 },
  { 386, 11, 11, 11, 0, -11 },
  { 402, 6, 11, 6, 0, -11 },
  { 411, 6, 11, 6, 0, -11 },
  { 420, 5, 11, 5, 0, -11 },
  { 427, 3, 14, 5, 1, -11 },
  { 433, 5, 11, 6, 0, -11 },
  { 440, 3, 14, 5, 1, -11 },
  { 446, 6, 5, 7, 0, -11 },
  { 450, 7, 1, 7, 0, 1 },
  { 451, 2, 2, 4, 1, -12 },
  { 452, 4, 9, 6, 1, -9 },
  { 457, 5, 12, 7, 1, -12 },
  { 465, 4, 9, 5, 1, -9 },
  { 470, 5, 12, 7, 1, -12 },
  { 478, 5, 9, 6, 1, -9 },
  { 484, 4, 12, 4, 0, -12 },
  { 490, 5, 13, 7, 1, -9 },
  { 499, 5, 12, 7, 1, -12 },
  { 507, 1, 12, 3, 1, -12 },
  { 509, 2, 16, 3, 0, -12 },
  { 513, 5, 12, 6, 1, -12 },
  { 521, 1, 12, 3, 1, -12 },
  { 523, 8, 9, 10, 1, -9 },
  { 532, 5, 9, 7, 1, -9 },
  { 538, 5, 9, 7, 1, -9 },
  { 544, 5, 13, 7, 1, -9 },
  { 553, 5, 13, 7, 1, -9 },
  { 562, 3, 9, 5, 1, -9 },
  { 566, 4, 9, 5, 1, -9 },
  { 571, 4, 11, 4, 0, -11 },
  { 577, 5, 9, 7, 1, -9 },
  { 583, 5, 9, 5, 0, -9 },
  { 589, 9, 9, 9, 0, -9 },
  { 600, 5, 9, 6, 0, -9 },
  { 606, 5, 13, 5, 0, -9 },
  { 615, 4, 9, 5, 0, -9 },
  { 620, 4, 14, 6, 1, -11 },
  { 627, 1, 16, 6, 3, -12 },
  { 629, 4, 14, 6, 1, -11 },
  { 636, 6, 2, 7, 0, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Light16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT16PT7B_H_
