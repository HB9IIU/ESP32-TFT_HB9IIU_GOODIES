#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x24, 0xA2, 0x9F, 0x28, 0xA2, 0xBF, 0x49,
  0x25, 0x00, 0x27, 0xA9, 0x4A, 0x30, 0xC5, 0x2D, 0x98, 0x40, 0xC4, 0xA4,
  0xA8, 0xA8, 0xAA, 0xB6, 0xD9, 0x29, 0x29, 0x29, 0x46, 0x30, 0xA1, 0x22,
  0x83, 0x04, 0x15, 0x4A, 0x8C, 0x99, 0xD8, 0xF0, 0x2A, 0x49, 0x24, 0x92,
  0x26, 0xA5, 0x55, 0x55, 0x80, 0x4F, 0x6A, 0x10, 0x41, 0x3F, 0x10, 0x41,
  0x00, 0xF0, 0xF0, 0x80, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x20, 0x64,
  0xA5, 0x28, 0xC6, 0x31, 0x94, 0x98, 0x2E, 0x92, 0x49, 0x24, 0x80, 0xE9,
  0x11, 0x11, 0x24, 0x48, 0xF0, 0xE9, 0x11, 0x16, 0x11, 0x11, 0xF0, 0x08,
  0x61, 0x8A, 0x29, 0x24, 0xA2, 0xFC, 0x20, 0x80, 0xF4, 0x21, 0x0E, 0x48,
  0x41, 0x08, 0xB8, 0x32, 0x21, 0x0E, 0x4A, 0x31, 0x8C, 0x9C, 0xF8, 0x84,
  0x22, 0x10, 0x84, 0x42, 0x30, 0x64, 0xA3, 0x29, 0x32, 0x51, 0x8C, 0x7C,
  0x69, 0x99, 0x99, 0xF1, 0x11, 0xE0, 0x81, 0x83, 0xC0, 0x04, 0x23, 0x30,
  0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x03, 0x19, 0x88, 0x00,
  0xE1, 0x11, 0x12, 0x44, 0x00, 0x40, 0x38, 0x46, 0x82, 0x99, 0xA9, 0xA9,
  0xA9, 0xA9, 0xBE, 0x80, 0x80, 0x7C, 0x10, 0xC3, 0x0C, 0x49, 0x27, 0x92,
  0x46, 0x18, 0x40, 0xF4, 0x63, 0x18, 0xFA, 0x31, 0x8C, 0x7C, 0x3A, 0x21,
  0x08, 0x42, 0x10, 0x82, 0x1E, 0xE2, 0x68, 0xA1, 0x86, 0x18, 0x61, 0x8A,
  0x2F, 0x00, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0xF0, 0xF8, 0x88, 0x8F, 0x88,
  0x88, 0x80, 0x39, 0x18, 0x20, 0x82, 0x28, 0x61, 0x85, 0x13, 0xC0, 0x86,
  0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x40, 0xEA, 0xAA, 0xAC, 0x24,
  0x92, 0x49, 0x24, 0x93, 0x80, 0x8C, 0xA5, 0x4A, 0x72, 0x92, 0x94, 0x62,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0xC1, 0xC3, 0xC3, 0xA3, 0xA5,
  0xA5, 0x95, 0x99, 0x99, 0x89, 0x87, 0x1C, 0x69, 0xA6, 0x99, 0x65, 0x8E,
  0x38, 0x40, 0x31, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0x80, 0xE4,
  0xA3, 0x18, 0xCB, 0x90, 0x84, 0x20, 0x31, 0x28, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x17, 0x84, 0x08, 0x10, 0xE4, 0xA3, 0x18, 0xEA, 0x92, 0x94, 0x62,
  0x78, 0x88, 0x86, 0x11, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x27, 0x80, 0x86, 0x18,
  0x52, 0x49, 0x24, 0x8C, 0x30, 0xC3, 0x00, 0x84, 0x63, 0x18, 0xC5, 0x31,
  0x4C, 0x92, 0xA5, 0x29, 0x4A, 0x32, 0x8C, 0x42, 0x10, 0x8A, 0x52, 0x63,
  0x10, 0xCA, 0x4A, 0x62, 0x8C, 0x52, 0xA5, 0x18, 0x84, 0x21, 0x08, 0x78,
  0x44, 0x22, 0x10, 0x88, 0x42, 0x3E, 0xF2, 0x49, 0x24, 0x92, 0x4E, 0x82,
  0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0xD5, 0x55, 0x55, 0xC0, 0x10, 0xC2,
  0x92, 0x46, 0x10, 0xFC, 0x90, 0xE1, 0x17, 0x99, 0x9F, 0x84, 0x21, 0xE8,
  0xC6, 0x31, 0x8C, 0x7C, 0x78, 0x88, 0x88, 0x87, 0x08, 0x42, 0xD9, 0xC6,
  0x31, 0x8C, 0xDA, 0x79, 0x9F, 0x88, 0x87, 0x74, 0x4E, 0x44, 0x44, 0x44,
  0x40, 0x6C, 0xE3, 0x18, 0xC6, 0x6D, 0x08, 0x64, 0xC0, 0x88, 0x8F, 0x99,
  0x99, 0x99, 0x90, 0x9F, 0xE0, 0x41, 0x55, 0x55, 0x58, 0x88, 0x89, 0xAA,
  0xCA, 0xA9, 0x90, 0xFF, 0xE0, 0xF6, 0x99, 0x91, 0x91, 0x91, 0x91, 0x91,
  0x91, 0xF9, 0x99, 0x99, 0x99, 0x74, 0xA3, 0x18, 0xC6, 0x4E, 0xF4, 0x63,
  0x18, 0xC6, 0x3E, 0x84, 0x21, 0x00, 0x6C, 0xE3, 0x18, 0xC6, 0x6D, 0x08,
  0x42, 0x10, 0xF2, 0x49, 0x24, 0xF2, 0x62, 0x4F, 0x4B, 0xA4, 0x92, 0x4C,
  0x99, 0x99, 0x99, 0x9F, 0x8C, 0x54, 0xA5, 0x28, 0x84, 0x89, 0x99, 0x59,
  0x55, 0x56, 0x66, 0x26, 0x26, 0xCA, 0x94, 0x42, 0x29, 0x51, 0x8C, 0x52,
  0xA5, 0x28, 0x84, 0x21, 0x11, 0x00, 0x71, 0x22, 0x44, 0x4F, 0x34, 0x44,
  0x44, 0xC4, 0x44, 0x44, 0x30, 0xFF, 0xFE, 0x84, 0x44, 0x44, 0x34, 0x44,
  0x44, 0xC0, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 6, 11, 7, 0, -11 },
  { 14, 5, 12, 6, 1, -11 },
  { 22, 8, 11, 9, 1, -11 },
  { 33, 7, 11, 6, 0, -11 },
  { 43, 1, 4, 3, 1, -11 },
  { 44, 3, 13, 4, 1, -11 },
  { 49, 2, 13, 4, 1, -11 },
  { 53, 4, 4, 6, 1, -11 },
  { 55, 6, 7, 6, 0, -9 },
  { 61, 1, 4, 3, 1, -2 },
  { 62, 4, 1, 4, 0, -5 },
  { 63, 1, 1, 3, 1, -1 },
  { 64, 5, 11, 5, 0, -11 },
  { 71, 5, 11, 6, 1, -11 },
  { 78, 3, 11, 6, 1, -11 },
  { 83, 4, 11, 6, 1, -11 },
  { 89, 4, 11, 6, 1, -11 },
  { 95, 6, 11, 6, 0, -11 },
  { 104, 5, 11, 6, 1, -11 },
  { 111, 5, 11, 6, 1, -11 },
  { 118, 5, 11, 6, 1, -11 },
  { 125, 5, 11, 6, 1, -11 },
  { 132, 4, 11, 6, 1, -11 },
  { 138, 1, 8, 3, 1, -8 },
  { 139, 1, 10, 3, 1, -8 },
  { 141, 6, 7, 6, 0, -9 },
  { 147, 6, 4, 6, 0, -7 },
  { 150, 6, 7, 6, 0, -9 },
  { 156, 4, 11, 4, 0, -11 },
  { 162, 8, 12, 9, 1, -11 },
  { 174, 6, 11, 6, 0, -11 },
  { 183, 5, 11, 7, 1, -11 },
  { 190, 5, 11, 6, 1, -11 },
  { 197, 6, 11, 7, 1, -11 },
  { 206, 4, 11, 6, 1, -11 },
  { 212, 4, 11, 5, 1, -11 },
  { 218, 6, 11, 8, 1, -11 },
  { 227, 6, 11, 8, 1, -11 },
  { 236, 2, 11, 4, 1, -11 },
  { 239, 3, 14, 3, -1, -11 },
  { 245, 5, 11, 6, 1, -11 },
  { 252, 4, 11, 5, 1, -11 },
  { 258, 8, 11, 10, 1, -11 },
  { 269, 6, 11, 8, 1, -11 },
  { 278, 6, 11, 8, 1, -11 },
  { 287, 5, 11, 6, 1, -11 },
  { 294, 6, 14, 8, 1, -11 },
  { 305, 5, 11, 7, 1, -11 },
  { 312, 4, 11, 6, 1, -11 },
  { 318, 5, 11, 5, 0, -11 },
  { 325, 6, 11, 8, 1, -11 },
  { 334, 6, 11, 6, 0, -11 },
  { 343, 10, 11, 10, 0, -11 },
  { 357, 5, 11, 5, 0, -11 },
  { 364, 5, 11, 5, 0, -11 },
  { 371, 5, 11, 5, 0, -11 },
  { 378, 3, 13, 5, 1, -11 },
  { 383, 5, 11, 5, 0, -11 },
  { 390, 2, 13, 5, 1, -11 },
  { 394, 6, 6, 6, 0, -11 },
  { 399, 6, 1, 6, 0, 1 },
  { 400, 2, 2, 4, 1, -11 },
  { 401, 4, 8, 6, 1, -8 },
  { 405, 5, 11, 7, 1, -11 },
  { 412, 4, 8, 5, 1, -8 },
  { 416, 5, 11, 7, 1, -11 },
  { 423, 4, 8, 6, 1, -8 },
  { 427, 4, 11, 3, 0, -11 },
  { 433, 5, 12, 7, 1, -8 },
  { 441, 4, 11, 6, 1, -11 },
  { 447, 1, 11, 3, 1, -11 },
  { 449, 2, 15, 3, 0, -11 },
  { 453, 4, 11, 5, 1, -11 },
  { 459, 1, 11, 3, 1, -11 },
  { 461, 8, 8, 10, 1, -8 },
  { 469, 4, 8, 6, 1, -8 },
  { 473, 5, 8, 6, 1, -8 },
  { 478, 5, 12, 7, 1, -8 },
  { 486, 5, 12, 7, 1, -8 },
  { 494, 3, 8, 4, 1, -8 },
  { 497, 3, 8, 5, 1, -8 },
  { 500, 3, 10, 4, 0, -10 },
  { 504, 4, 8, 6, 1, -8 },
  { 508, 5, 8, 5, 0, -8 },
  { 513, 8, 8, 8, 0, -8 },
  { 521, 5, 8, 5, 0, -8 },
  { 526, 5, 12, 5, 0, -8 },
  { 534, 4, 8, 4, 0, -8 },
  { 538, 4, 13, 5, 1, -11 },
  { 545, 1, 15, 6, 2, -11 },
  { 547, 4, 13, 5, 1, -11 },
  { 554, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Light15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT15PT7B_H_
