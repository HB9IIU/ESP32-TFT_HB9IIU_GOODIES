#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x00, 0x27, 0xFF, 0x70, 0xE1, 0xF8, 0x7E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0D, 0x83, 0x60, 0xC0,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x83,
  0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x60, 0xE0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x18,
  0x01, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFE, 0x71, 0x86, 0x61, 0x80, 0xE1, 0x80, 0xC1, 0x80,
  0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xE1, 0x80, 0x71, 0x80,
  0x79, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xBC,
  0x01, 0x8E, 0x01, 0x87, 0x01, 0x87, 0x01, 0x83, 0x01, 0x83, 0x01, 0x83,
  0x01, 0x83, 0x01, 0x83, 0x01, 0x87, 0x81, 0x8E, 0xF1, 0xBC, 0xFF, 0xF8,
  0x3F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x1F, 0x00, 0x30, 0x0F, 0xE0, 0x1C, 0x07, 0x18, 0x06, 0x01, 0x87, 0x01,
  0x80, 0x60, 0xC0, 0xE0, 0x38, 0x30, 0x30, 0x0E, 0x0C, 0x0C, 0x03, 0x83,
  0x07, 0x00, 0xC0, 0xC1, 0x80, 0x30, 0x38, 0x60, 0x0C, 0x0E, 0x38, 0x03,
  0x03, 0x8C, 0x00, 0xC0, 0xC3, 0x00, 0x30, 0x31, 0xC2, 0x0E, 0x0C, 0x63,
  0xF3, 0x83, 0x18, 0xFC, 0x60, 0xCE, 0x61, 0x98, 0x73, 0x18, 0x67, 0x18,
  0xCE, 0x1C, 0xFE, 0x73, 0x03, 0x1F, 0x18, 0xC0, 0xC0, 0x06, 0x30, 0x30,
  0x03, 0x8C, 0x0C, 0x00, 0xC3, 0x03, 0x00, 0x30, 0xC0, 0xC0, 0x1C, 0x30,
  0x30, 0x06, 0x0C, 0x0C, 0x01, 0x83, 0x03, 0x00, 0xE0, 0xC0, 0xC0, 0x30,
  0x30, 0x30, 0x0C, 0x0E, 0x1C, 0x07, 0x01, 0x86, 0x01, 0x80, 0x61, 0x80,
  0x60, 0x0F, 0xC0, 0x38, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x71,
  0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x70, 0x60, 0x0E, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x30, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x0E, 0x38, 0x01, 0xC6,
  0x00, 0x19, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xE6, 0x00, 0x38, 0xE0, 0xE7, 0x0C, 0x1D, 0xC1, 0xC3, 0xB8, 0x1C,
  0x76, 0x03, 0x8C, 0xC0, 0x39, 0x98, 0x03, 0x73, 0x00, 0x7E, 0x60, 0x07,
  0x8C, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x07, 0xC7, 0x81, 0xDC, 0x78, 0x79,
  0xC7, 0xFE, 0x38, 0x7F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0x01,
  0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0,
  0xE0, 0x60, 0x70, 0x30, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xC3, 0x0F, 0xED, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x3B, 0x01,
  0xCE, 0x06, 0x18, 0x38, 0x78, 0x40, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x39,
  0xCE, 0x67, 0x39, 0xCC, 0x67, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x4F,
  0xFF, 0xF0, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xF8,
  0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x06,
  0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x30, 0x0E, 0x38, 0x1C, 0x38, 0x1C,
  0x1E, 0x38, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x1D,
  0xCE, 0x7F, 0x1D, 0x87, 0x21, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x1F, 0xE0, 0x7F, 0xF8, 0xF0, 0x3C, 0x60, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xE0, 0x7F, 0xF8, 0xF0, 0x3C, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x80, 0x1C, 0xE0, 0x7C, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xDC,
  0x00, 0x3B, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x06, 0x38,
  0x01, 0x87, 0x00, 0x30, 0xE0, 0x0C, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x70,
  0x0C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x00, 0xE0,
  0xE0, 0x1C, 0x18, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x70, 0x7C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E,
  0x80, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xFC, 0x07, 0xFC,
  0x0F, 0x82, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x61, 0xE0,
  0xE7, 0xF8, 0xEF, 0xFC, 0xEC, 0x1C, 0xF8, 0x0E, 0xF0, 0x0E, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07,
  0x60, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x06, 0x38, 0x0E, 0x38, 0x0E,
  0x1C, 0x1C, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x1C,
  0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07,
  0x60, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1C, 0x3C, 0x0E, 0x78,
  0x07, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x1E, 0x78, 0x3C, 0x3C, 0x38, 0x1C,
  0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x38, 0x1E,
  0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3C, 0x38, 0x70, 0x1C,
  0x70, 0x1C, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0x60, 0x0F, 0x70, 0x1F, 0x78, 0x37, 0x3F, 0xF7, 0x1F, 0xE6, 0x07, 0x86,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x40, 0xF0, 0x7F, 0xE0,
  0x7F, 0x80, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0xFF, 0x3B, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xE7, 0x3B, 0x9C, 0xE6, 0x33, 0x98, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0xE1, 0xE8, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0E,
  0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x01, 0xFE, 0x1C, 0xC0, 0xFF,
  0x87, 0x70, 0x70, 0xE0, 0xD8, 0x18, 0x38, 0x36, 0x06, 0x0C, 0x0D, 0x83,
  0x83, 0x03, 0x60, 0xC0, 0xC0, 0xD8, 0x30, 0x30, 0x36, 0x0C, 0x0C, 0x0F,
  0x83, 0x03, 0x03, 0xE0, 0xC0, 0xC0, 0xF8, 0x30, 0x30, 0x36, 0x0C, 0x1C,
  0x0D, 0x83, 0x07, 0x03, 0x60, 0xC1, 0xC1, 0xD8, 0x38, 0x50, 0x66, 0x06,
  0x36, 0x39, 0x81, 0xFD, 0xFC, 0x70, 0x3E, 0x3E, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1D, 0x80, 0x01, 0x98, 0x00, 0x19,
  0xC0, 0x03, 0x9C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xC0, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x0C, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x06, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0xFF, 0xE0, 0xFF,
  0xF8, 0xC0, 0xFC, 0xC0, 0x1E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x06, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x0C, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xC0,
  0x1E, 0xC0, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0x81,
  0xFF, 0xE1, 0xE0, 0x61, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC1, 0x81, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0C, 0x3F, 0x83, 0x00, 0xF0, 0xC0, 0x1E, 0x30,
  0x03, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00,
  0x3B, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00,
  0x3B, 0x00, 0x1C, 0xC0, 0x07, 0x30, 0x03, 0x8C, 0x01, 0xE3, 0x00, 0xF0,
  0xC3, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF,
  0xB0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xBF, 0xFD, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0x80, 0xF0, 0xE0, 0x02, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x03, 0x38,
  0x00, 0x33, 0x80, 0x03, 0x1C, 0x00, 0x31, 0xE0, 0x03, 0x0F, 0x80, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0xFF, 0xFF, 0xC7, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x7F, 0xFF, 0xE0,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x07, 0x07, 0xDE, 0xFE, 0xF8, 0xC0, 0x07, 0xC0, 0x0E,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x70, 0xC0, 0x70,
  0xC0, 0xE0, 0xC1, 0xC0, 0xC1, 0xC0, 0xC3, 0x80, 0xC3, 0x80, 0xC7, 0x00,
  0xC7, 0x00, 0xCE, 0x00, 0xDE, 0x00, 0xDF, 0x00, 0xFB, 0x00, 0xF3, 0x80,
  0xE3, 0x80, 0xC1, 0xC0, 0xC1, 0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70,
  0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF6, 0x00, 0x03, 0xFD, 0x80,
  0x00, 0xFF, 0x70, 0x00, 0x37, 0xCC, 0x00, 0x1D, 0xF3, 0x00, 0x07, 0x7C,
  0xE0, 0x01, 0x9F, 0x38, 0x00, 0x67, 0xC6, 0x00, 0x39, 0xF1, 0xC0, 0x0E,
  0x7C, 0x70, 0x03, 0x1F, 0x0C, 0x01, 0xC7, 0xC3, 0x00, 0x71, 0xF0, 0xE0,
  0x18, 0x7C, 0x18, 0x06, 0x1F, 0x06, 0x03, 0x87, 0xC1, 0xC0, 0xC1, 0xF0,
  0x70, 0x30, 0x7C, 0x0C, 0x1C, 0x1F, 0x03, 0x07, 0x07, 0xC0, 0xE1, 0x81,
  0xF0, 0x18, 0xE0, 0x7C, 0x06, 0x38, 0x1F, 0x01, 0xCC, 0x07, 0xC0, 0x73,
  0x01, 0xF0, 0x0D, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x1C, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xB0, 0x01, 0xF7,
  0x00, 0x3E, 0x60, 0x07, 0xCE, 0x00, 0xF9, 0xC0, 0x1F, 0x1C, 0x03, 0xE3,
  0x80, 0x7C, 0x30, 0x0F, 0x87, 0x01, 0xF0, 0x60, 0x3E, 0x0E, 0x07, 0xC1,
  0xC0, 0xF8, 0x1C, 0x1F, 0x03, 0x83, 0xE0, 0x30, 0x7C, 0x07, 0x0F, 0x80,
  0x61, 0xF0, 0x0E, 0x3E, 0x01, 0xC7, 0xC0, 0x1C, 0xF8, 0x03, 0x9F, 0x00,
  0x33, 0xE0, 0x07, 0x7C, 0x00, 0x6F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0x07, 0x81, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0C,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1E,
  0x38, 0x01, 0xC1, 0xC0, 0x38, 0x1F, 0x0F, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0xE3, 0x0F, 0xE6, 0x01, 0xCC, 0x01, 0xD8, 0x03,
  0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xC0, 0x3D, 0x80, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xF0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0x07, 0x81, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x60, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01,
  0xC1, 0xC0, 0x38, 0x1F, 0x0F, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0xC7,
  0xF8, 0xC0, 0x3C, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x1C, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xC1,
  0xC0, 0xC1, 0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x70, 0xC0,
  0x38, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0,
  0x0E, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C,
  0x0E, 0x78, 0x02, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x80, 0x1C, 0xF0,
  0x7C, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x0E, 0x1E, 0x0F, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x38, 0x1C, 0x03, 0x81,
  0xC0, 0x38, 0x1C, 0x03, 0x00, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x39, 0xC0, 0x03, 0x98, 0x00, 0x39,
  0x80, 0x01, 0xB8, 0x00, 0x1B, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xB0,
  0x00, 0xE0, 0x01, 0xD8, 0x00, 0x78, 0x00, 0xEE, 0x00, 0x3C, 0x00, 0x77,
  0x00, 0x1E, 0x00, 0x33, 0x80, 0x1F, 0x00, 0x38, 0xC0, 0x0D, 0x80, 0x1C,
  0x70, 0x06, 0xE0, 0x0E, 0x38, 0x03, 0x70, 0x06, 0x1C, 0x01, 0xB8, 0x03,
  0x0E, 0x01, 0xCC, 0x03, 0x83, 0x00, 0xE6, 0x01, 0xC1, 0xC0, 0x63, 0x80,
  0xE0, 0xE0, 0x31, 0xC0, 0x60, 0x70, 0x18, 0xE0, 0x70, 0x38, 0x1C, 0x30,
  0x38, 0x0C, 0x0E, 0x18, 0x1C, 0x07, 0x06, 0x0C, 0x0E, 0x03, 0x83, 0x07,
  0x06, 0x01, 0xC1, 0x83, 0x87, 0x00, 0x61, 0xC0, 0xC3, 0x80, 0x30, 0xE0,
  0x61, 0xC0, 0x1C, 0x60, 0x30, 0xE0, 0x0E, 0x30, 0x1C, 0x60, 0x07, 0x18,
  0x0E, 0x70, 0x01, 0x9C, 0x03, 0x38, 0x00, 0xCE, 0x01, 0x9C, 0x00, 0x76,
  0x00, 0xCC, 0x00, 0x3B, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x3F, 0x00, 0x06,
  0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x30, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x03, 0x80, 0xE0, 0xE0,
  0x38, 0x30, 0x06, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x0C, 0xE0, 0x03,
  0xB8, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0x60, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0xC0, 0x70, 0x38, 0x1C,
  0x0E, 0x06, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x03, 0x9C, 0x00,
  0xEE, 0x00, 0x3C, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE3,
  0x00, 0x71, 0xC0, 0x30, 0xE0, 0x38, 0x30, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E,
  0x03, 0x07, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x31, 0xC0, 0x1C, 0xC0, 0x0E,
  0x60, 0x03, 0x70, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B,
  0x00, 0x06, 0x70, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0C, 0x01, 0xC1,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x83, 0x80, 0x30, 0x70, 0x07, 0x1C, 0x00,
  0x63, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7F, 0x83,
  0xFF, 0x0C, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x07, 0xFC, 0x7F, 0xF3, 0xC1, 0xDC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0B, 0x70, 0x6D, 0xFF, 0x33, 0xF8, 0xC0, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x10, 0x1C, 0x7F, 0x0E, 0x7F, 0xC7,
  0x60, 0xF3, 0xE0, 0x39, 0xE0, 0x0C, 0xF0, 0x07, 0x78, 0x03, 0xB8, 0x00,
  0xDC, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x3B,
  0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x0E, 0x7C, 0x07, 0x3B, 0x07, 0x1C, 0xFF,
  0x8E, 0x3F, 0x00, 0x00, 0x80, 0x3F, 0xC3, 0xFE, 0x3C, 0x13, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x08, 0xFF, 0xC1, 0xFE, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x01, 0x03, 0x0F, 0xE3, 0x1F,
  0xF3, 0x3C, 0x1B, 0x38, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x60,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60,
  0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x0B, 0x3C, 0x1B, 0x1F, 0xF3, 0x0F,
  0xE3, 0x00, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xE1, 0xC3, 0x81, 0xCE, 0x01,
  0x9C, 0x03, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x01, 0x1C, 0x06,
  0x1F, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x83, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xFF, 0x8F,
  0xFC, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x0F, 0xE3, 0x1F, 0xF3, 0x3C,
  0x1B, 0x38, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x70,
  0x07, 0x70, 0x0F, 0x38, 0x0B, 0x3C, 0x1B, 0x1F, 0xF3, 0x0F, 0xE3, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x60, 0x1E, 0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x82, 0x07, 0x1F, 0x8E, 0xFF, 0x9D,
  0x87, 0xBE, 0x07, 0x78, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0x6F, 0xFE, 0x60,
  0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0x0C, 0x38, 0x78, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xDF, 0x3E, 0x70, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x07, 0xE0, 0x3B, 0x80, 0xCE, 0x07, 0x38,
  0x38, 0xE0, 0xC3, 0x87, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0E,
  0xF0, 0x3B, 0xE0, 0xF9, 0x83, 0xC7, 0x0F, 0x1C, 0x38, 0x38, 0xE0, 0xE3,
  0x81, 0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xB8, 0x07,
  0xE0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x10, 0x63, 0xF8, 0x7F, 0x3B, 0xFE,
  0x7F, 0xDD, 0x87, 0x30, 0xEF, 0x81, 0xB0, 0x3F, 0x80, 0xF0, 0x1F, 0xC0,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x0C, 0x01, 0xF0, 0x06, 0x00, 0xF8,
  0x03, 0x00, 0x7C, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0x1F, 0x00, 0x60, 0x0F,
  0x80, 0x30, 0x07, 0xC0, 0x18, 0x03, 0xE0, 0x0C, 0x01, 0xF0, 0x06, 0x00,
  0xF8, 0x03, 0x00, 0x7C, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0x1F, 0x00, 0x60,
  0x0F, 0x80, 0x30, 0x07, 0xC0, 0x18, 0x03, 0xE0, 0x0C, 0x01, 0xF0, 0x06,
  0x00, 0xF8, 0x03, 0x00, 0x60, 0x00, 0xC1, 0x8F, 0xE3, 0xBF, 0xE7, 0x60,
  0xEF, 0x81, 0xDE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38, 0x00, 0x80, 0x07, 0xF8,
  0x07, 0xFF, 0x07, 0x83, 0x83, 0x80, 0xE3, 0x80, 0x31, 0xC0, 0x1C, 0xC0,
  0x0E, 0x60, 0x07, 0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x00,
  0xCC, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x18, 0x70, 0x1C, 0x1C,
  0x1C, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x61, 0xFC, 0x39, 0xFF,
  0x1D, 0x83, 0x8F, 0x80, 0xE7, 0x80, 0x33, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0,
  0x03, 0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00,
  0xEF, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x39, 0xF0, 0x1C, 0xEC, 0x1C, 0x73,
  0xFE, 0x38, 0xFC, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x0F, 0xE3, 0x1F, 0xF3, 0x3C,
  0x1B, 0x38, 0x0F, 0x70, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x70,
  0x07, 0x70, 0x0F, 0x38, 0x0B, 0x3C, 0x1B, 0x1F, 0xF3, 0x0F, 0xE3, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0xB0, 0xFE, 0x7F, 0xB9, 0xEC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x02, 0x01, 0xFE,
  0x7F, 0xF7, 0x03, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x78, 0x07, 0xC0, 0xEF, 0xFE,
  0x7F, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x0F, 0xFF, 0xFF,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xEC, 0x02, 0xDC,
  0x0D, 0xBC, 0x33, 0x3F, 0xE6, 0x3F, 0x8C, 0xE0, 0x07, 0x60, 0x07, 0x70,
  0x06, 0x70, 0x0E, 0x70, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x38, 0x0C, 0x38,
  0x1C, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x1C, 0x38, 0x0C, 0x38, 0x0C,
  0x30, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0,
  0x0E, 0x00, 0xEC, 0x01, 0xE0, 0x1D, 0xC0, 0x3C, 0x03, 0x38, 0x07, 0x80,
  0x67, 0x01, 0xF0, 0x1C, 0x60, 0x36, 0x03, 0x8C, 0x06, 0xE0, 0x61, 0xC0,
  0xDC, 0x0C, 0x38, 0x39, 0x81, 0x83, 0x07, 0x30, 0x70, 0x60, 0xC6, 0x0E,
  0x0E, 0x18, 0xE1, 0x81, 0xC3, 0x0C, 0x30, 0x38, 0xE1, 0x8E, 0x03, 0x1C,
  0x31, 0xC0, 0x63, 0x06, 0x30, 0x0E, 0x60, 0xE6, 0x01, 0xCC, 0x0C, 0xC0,
  0x1B, 0x81, 0xB8, 0x03, 0x70, 0x37, 0x00, 0x6C, 0x06, 0xC0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0xE0, 0x39, 0xC0, 0x71, 0xC0, 0xC3, 0x83,
  0x83, 0x06, 0x07, 0x1C, 0x06, 0x30, 0x0E, 0xE0, 0x0D, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xE0, 0x18,
  0xC0, 0x71, 0xC0, 0xC3, 0x83, 0x83, 0x87, 0x07, 0x1C, 0x07, 0x38, 0x0E,
  0xE0, 0x0D, 0xC0, 0x1C, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3B, 0x00, 0x76,
  0x00, 0xCE, 0x03, 0x9C, 0x07, 0x18, 0x0E, 0x30, 0x18, 0x70, 0x70, 0xE0,
  0xE0, 0xC1, 0xC1, 0x83, 0x03, 0x8E, 0x07, 0x1C, 0x06, 0x38, 0x0C, 0x60,
  0x1C, 0xC0, 0x3B, 0x80, 0x37, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x07, 0xE0, 0x0F,
  0x80, 0x1C, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0xF8,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x0F, 0xC0, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xF0, 0x07, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x3C,
  0x07, 0xC0, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x7E, 0x07, 0xE0, 0x38, 0x00, 0x1E, 0x00,
  0x5F, 0xF0, 0x1F, 0x7E, 0x1F, 0x03, 0xFE, 0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 35, 11, 3, -35 },
  { 19, 10, 13, 16, 3, -35 },
  { 36, 20, 35, 22, 1, -35 },
  { 124, 16, 40, 20, 2, -37 },
  { 204, 26, 35, 30, 2, -35 },
  { 318, 19, 35, 21, 2, -35 },
  { 402, 3, 13, 9, 3, -35 },
  { 407, 10, 43, 14, 2, -35 },
  { 461, 9, 43, 14, 2, -35 },
  { 510, 14, 14, 18, 2, -37 },
  { 535, 18, 23, 20, 1, -29 },
  { 587, 5, 11, 10, 2, -5 },
  { 594, 11, 3, 13, 1, -15 },
  { 599, 4, 5, 10, 3, -5 },
  { 602, 15, 35, 17, 1, -35 },
  { 668, 16, 35, 20, 2, -35 },
  { 738, 10, 35, 20, 3, -35 },
  { 782, 16, 35, 20, 2, -35 },
  { 852, 16, 35, 20, 2, -35 },
  { 922, 19, 35, 20, 1, -35 },
  { 1006, 16, 35, 20, 2, -35 },
  { 1076, 16, 36, 20, 2, -35 },
  { 1148, 16, 35, 20, 2, -35 },
  { 1218, 16, 35, 20, 2, -35 },
  { 1288, 16, 35, 20, 2, -35 },
  { 1358, 4, 26, 10, 3, -26 },
  { 1371, 5, 32, 10, 2, -26 },
  { 1391, 18, 21, 20, 1, -28 },
  { 1439, 18, 13, 20, 1, -24 },
  { 1469, 18, 21, 20, 1, -28 },
  { 1517, 12, 35, 14, 1, -35 },
  { 1570, 26, 39, 31, 2, -35 },
  { 1697, 20, 35, 20, 0, -35 },
  { 1785, 16, 35, 22, 4, -35 },
  { 1855, 17, 36, 21, 3, -36 },
  { 1932, 18, 35, 24, 4, -35 },
  { 2011, 13, 35, 19, 4, -35 },
  { 2068, 13, 35, 18, 4, -35 },
  { 2125, 20, 35, 26, 3, -35 },
  { 2213, 17, 35, 25, 4, -35 },
  { 2288, 9, 35, 12, 2, -35 },
  { 2328, 8, 44, 10, -2, -35 },
  { 2372, 16, 35, 20, 4, -35 },
  { 2442, 13, 35, 17, 4, -35 },
  { 2499, 26, 35, 34, 4, -35 },
  { 2613, 19, 35, 26, 4, -35 },
  { 2697, 20, 35, 26, 3, -35 },
  { 2785, 15, 35, 21, 4, -35 },
  { 2851, 20, 43, 26, 3, -35 },
  { 2959, 16, 35, 21, 4, -35 },
  { 3029, 16, 36, 20, 2, -36 },
  { 3101, 17, 35, 18, 0, -35 },
  { 3176, 18, 35, 25, 3, -35 },
  { 3255, 20, 35, 20, 0, -35 },
  { 3343, 33, 35, 33, 0, -35 },
  { 3488, 18, 35, 18, 0, -35 },
  { 3567, 17, 35, 17, 0, -35 },
  { 3642, 15, 35, 17, 1, -35 },
  { 3708, 10, 43, 15, 4, -35 },
  { 3762, 15, 35, 17, 1, -35 },
  { 3828, 9, 43, 15, 2, -35 },
  { 3877, 19, 18, 21, 1, -35 },
  { 3920, 20, 2, 20, 0, 4 },
  { 3925, 8, 7, 12, 2, -37 },
  { 3932, 14, 27, 19, 2, -27 },
  { 3980, 17, 37, 22, 3, -37 },
  { 4059, 13, 27, 16, 2, -27 },
  { 4103, 16, 37, 22, 2, -37 },
  { 4177, 15, 27, 20, 2, -27 },
  { 4228, 13, 37, 11, 0, -37 },
  { 4289, 16, 39, 22, 2, -27 },
  { 4367, 15, 37, 21, 3, -37 },
  { 4437, 4, 36, 10, 3, -36 },
  { 4455, 7, 48, 10, 0, -36 },
  { 4497, 14, 37, 18, 3, -37 },
  { 4562, 3, 37, 9, 3, -37 },
  { 4576, 25, 27, 32, 3, -27 },
  { 4661, 15, 27, 21, 3, -27 },
  { 4712, 17, 27, 21, 2, -27 },
  { 4770, 17, 39, 22, 3, -27 },
  { 4853, 16, 39, 22, 2, -27 },
  { 4931, 10, 27, 14, 3, -27 },
  { 4965, 12, 27, 16, 2, -27 },
  { 5006, 10, 32, 11, 1, -32 },
  { 5046, 15, 26, 21, 3, -26 },
  { 5095, 16, 26, 16, 0, -26 },
  { 5147, 27, 26, 27, 0, -26 },
  { 5235, 15, 26, 17, 1, -26 },
  { 5284, 15, 38, 17, 1, -26 },
  { 5356, 12, 26, 14, 1, -26 },
  { 5395, 13, 43, 17, 2, -35 },
  { 5465, 3, 49, 19, 8, -37 },
  { 5484, 13, 43, 17, 2, -35 },
  { 5554, 18, 5, 20, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Light49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT49PT7B_H_
