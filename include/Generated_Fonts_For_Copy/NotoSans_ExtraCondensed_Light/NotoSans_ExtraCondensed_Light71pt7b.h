#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x23, 0xEF,
  0xBE, 0xFF, 0xEF, 0x88, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E,
  0x70, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0x00, 0x70, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x0F,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F,
  0xB9, 0xFC, 0x3E, 0x38, 0x18, 0x78, 0x38, 0x08, 0x78, 0x38, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xF0,
  0x38, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x38, 0x00, 0x7C, 0x38, 0x00, 0x3F,
  0x38, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3B, 0xF0, 0x00,
  0x38, 0xF8, 0x00, 0x38, 0x7C, 0x00, 0x38, 0x3E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00,
  0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1E, 0x80, 0x38, 0x3C, 0xC0, 0x38, 0x7C, 0xFC, 0x39, 0xF8, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x7F, 0xC0,
  0x01, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x78, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x38, 0x1E, 0x00, 0x0E,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x0E, 0x0F,
  0x00, 0x03, 0x80, 0x38, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x03, 0x87, 0x80, 0x00, 0xF0, 0x0E, 0x1C, 0x0F, 0x83, 0xC0, 0x38, 0x70,
  0xFF, 0x07, 0x01, 0xE3, 0xC7, 0xFE, 0x1C, 0x07, 0x0E, 0x1C, 0x3C, 0x70,
  0x1C, 0x38, 0xF0, 0x71, 0xE0, 0x71, 0xE3, 0x81, 0xE3, 0x83, 0xC7, 0x0E,
  0x03, 0x8F, 0x0E, 0x1C, 0x78, 0x0E, 0x1F, 0xF8, 0xF1, 0xC0, 0x38, 0x7F,
  0xC3, 0x87, 0x00, 0xF0, 0x7E, 0x0E, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x70,
  0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x70, 0x00,
  0x3C, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x1C, 0x00, 0x1E, 0x07, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x01,
  0xC0, 0x70, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x00,
  0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x78, 0x0E, 0x00, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x03, 0x81, 0xE0, 0x03, 0xC0, 0x0F, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x00, 0x7D, 0xE0, 0x01, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x1E, 0x1F, 0x07, 0x80,
  0xF0, 0xF0, 0x3C, 0x07, 0x8F, 0x00, 0xF0, 0x3C, 0x78, 0x03, 0x81, 0xE3,
  0xC0, 0x1E, 0x0E, 0x1C, 0x00, 0x78, 0xF1, 0xE0, 0x03, 0xC7, 0x8F, 0x00,
  0x0F, 0x3C, 0x78, 0x00, 0x7B, 0xC3, 0xC0, 0x01, 0xFE, 0x1E, 0x00, 0x07,
  0xF0, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xF8, 0x3E, 0x00, 0x7F, 0xC0, 0xF8,
  0x07, 0xCF, 0x07, 0xE0, 0x7C, 0x7C, 0x1F, 0xFF, 0xC1, 0xE0, 0x7F, 0xFC,
  0x0F, 0x81, 0xFF, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x80, 0x70, 0x1F, 0x06, 0x0F, 0xFE,
  0x67, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x3D, 0xC0, 0x03, 0x9E, 0x00, 0x78, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x78,
  0x3E, 0x03, 0xC1, 0xC0, 0x38, 0x08, 0x01, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C,
  0x71, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x11, 0xE7, 0xFF, 0xFD, 0xF7, 0x84, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7E, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x1E, 0x07,
  0x80, 0x3C, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x70, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0xE1, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0xFB,
  0xC7, 0xCF, 0x3E, 0x3D, 0xF0, 0xFF, 0x83, 0xDC, 0x0F, 0x20, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0x07, 0x80, 0x1F, 0x04, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x0F, 0x80, 0x1F, 0x0C,
  0x00, 0x1F, 0x10, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x20, 0x00, 0x7C,
  0x78, 0x03, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E,
  0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x38, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x30, 0x00, 0x7C, 0x7C,
  0x03, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xE0, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x40, 0x07,
  0x07, 0xF8, 0x0E, 0x3F, 0xFC, 0x1C, 0xFF, 0xFC, 0x7B, 0xC0, 0xF8, 0xF7,
  0x00, 0xF9, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0xF7, 0xE0, 0x01, 0xEF, 0x80,
  0x03, 0xDF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0x01,
  0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFD, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFC, 0x3F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x1E, 0x1F,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x00, 0x73, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xBC, 0x00, 0x1F, 0x78, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF0, 0x03, 0x79,
  0xF0, 0x1E, 0xE1, 0xFF, 0xF9, 0xC1, 0xFF, 0xE3, 0x81, 0xFF, 0x87, 0x00,
  0xFC, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x10, 0x0F, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x79, 0xF7, 0xFF, 0x7D, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x7D, 0xFF, 0xFF, 0x7D, 0xE1, 0x00, 0x1C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0xF1, 0xE0, 0xFC, 0x60, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0xF8, 0x03, 0xC7, 0x00, 0x3F, 0xF8, 0x0E, 0x78, 0x03, 0xFF,
  0xC0, 0x73, 0x80, 0x3E, 0x1E, 0x03, 0x9C, 0x01, 0xC0, 0xF0, 0x1E, 0xE0,
  0x1E, 0x07, 0x80, 0xFF, 0x00, 0xE0, 0x3C, 0x03, 0xF8, 0x0F, 0x01, 0xE0,
  0x1F, 0x80, 0x70, 0x0F, 0x00, 0xFC, 0x03, 0x80, 0x78, 0x07, 0xE0, 0x1C,
  0x03, 0xC0, 0x3F, 0x01, 0xE0, 0x1C, 0x01, 0xF8, 0x0F, 0x00, 0xE0, 0x0F,
  0xC0, 0x78, 0x07, 0x00, 0x7E, 0x03, 0xC0, 0x38, 0x03, 0xF0, 0x1C, 0x01,
  0xC0, 0x1F, 0x80, 0xE0, 0x0E, 0x00, 0xFC, 0x07, 0x00, 0x70, 0x07, 0xE0,
  0x3C, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x3C, 0x03, 0xF8, 0x0F, 0x01, 0xE0,
  0x1D, 0xC0, 0x38, 0x0F, 0x00, 0xEE, 0x01, 0xC0, 0x78, 0x07, 0x70, 0x0F,
  0x07, 0xE0, 0x73, 0xC0, 0x78, 0x37, 0x07, 0x9E, 0x01, 0xE3, 0x9C, 0x7C,
  0x70, 0x0F, 0xF8, 0xFF, 0xC3, 0x80, 0x3F, 0x83, 0xFC, 0x1C, 0x00, 0x78,
  0x0F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x06, 0x00,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xF0, 0x01, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0xFC,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0, 0x0F, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xE0, 0x3E, 0x00,
  0x30, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x04,
  0x07, 0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF8, 0x3C, 0x00, 0x3F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x3F,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xF0, 0x00,
  0x78, 0x1F, 0x80, 0x00, 0x40, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x3F,
  0x00, 0x03, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x03,
  0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7C, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01,
  0xE7, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x7B, 0xF8, 0x00, 0x3D, 0xDE, 0x00,
  0x1F, 0xCF, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xE1, 0xE0, 0x03, 0xE0, 0xF8,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0xBC, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x1D, 0xFD, 0xC0, 0x00, 0x00, 0x77, 0xF7, 0x00, 0x00, 0x03,
  0xDF, 0xDE, 0x00, 0x00, 0x0F, 0x7F, 0x78, 0x00, 0x00, 0x39, 0xFC, 0xE0,
  0x00, 0x01, 0xE7, 0xF3, 0xC0, 0x00, 0x07, 0x9F, 0xCF, 0x00, 0x00, 0x1C,
  0x7F, 0x1C, 0x00, 0x00, 0xF1, 0xFC, 0x70, 0x00, 0x03, 0xC7, 0xF1, 0xE0,
  0x00, 0x0E, 0x1F, 0xC7, 0x80, 0x00, 0x38, 0x7F, 0x0E, 0x00, 0x01, 0xE1,
  0xFC, 0x3C, 0x00, 0x07, 0x87, 0xF0, 0xF0, 0x00, 0x1C, 0x1F, 0xC1, 0xC0,
  0x00, 0xF0, 0x7F, 0x07, 0x80, 0x03, 0xC1, 0xFC, 0x1E, 0x00, 0x0E, 0x07,
  0xF0, 0x38, 0x00, 0x38, 0x1F, 0xC0, 0xE0, 0x01, 0xE0, 0x7F, 0x03, 0xC0,
  0x07, 0x81, 0xFC, 0x0F, 0x00, 0x1C, 0x07, 0xF0, 0x1C, 0x00, 0xF0, 0x1F,
  0xC0, 0x78, 0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x0E, 0x01, 0xFC, 0x03, 0x80,
  0x78, 0x07, 0xF0, 0x0E, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x07, 0x80, 0x7F,
  0x00, 0xF0, 0x1C, 0x01, 0xFC, 0x01, 0xC0, 0xF0, 0x07, 0xF0, 0x07, 0x83,
  0xC0, 0x1F, 0xC0, 0x1E, 0x0E, 0x00, 0x7F, 0x00, 0x38, 0x78, 0x01, 0xFC,
  0x00, 0xF1, 0xE0, 0x07, 0xF0, 0x03, 0xC7, 0x00, 0x1F, 0xC0, 0x07, 0x3C,
  0x00, 0x7F, 0x00, 0x1C, 0xF0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x07, 0xF0,
  0x01, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xF7, 0x80, 0x00, 0xFF, 0x78, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0xFF,
  0x3C, 0x00, 0x0F, 0xF1, 0xC0, 0x00, 0xFF, 0x1E, 0x00, 0x0F, 0xF1, 0xE0,
  0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0xFF, 0x07, 0x80, 0x0F,
  0xF0, 0x78, 0x00, 0xFF, 0x03, 0x80, 0x0F, 0xF0, 0x3C, 0x00, 0xFF, 0x03,
  0xC0, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0x01, 0xE0, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x00, 0xFF, 0x00, 0x78, 0x0F, 0xF0,
  0x07, 0x80, 0xFF, 0x00, 0x3C, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0x00, 0x1E,
  0x0F, 0xF0, 0x01, 0xE0, 0xFF, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0xF0, 0xFF,
  0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x78, 0xFF, 0x00, 0x07, 0x8F, 0xF0, 0x00,
  0x3C, 0xFF, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0x1E, 0xFF, 0x00, 0x01, 0xEF,
  0xF0, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x07,
  0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x01,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x0F, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0x00, 0x7F, 0x07, 0x80, 0x0F, 0xC3,
  0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x78,
  0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0x0F, 0xC3, 0xF0, 0x01, 0x87,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x30, 0x00, 0x7C,
  0x7E, 0x03, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xE0, 0x7F, 0x03, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xF0, 0x07, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0E, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x78,
  0x0E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x38, 0x00, 0x78,
  0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xE0,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x07, 0x03, 0xC0,
  0x01, 0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x80,
  0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x80,
  0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80,
  0x00, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00,
  0x00, 0x71, 0xC0, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x01, 0xCF, 0x00,
  0x00, 0x7B, 0xC0, 0x01, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x01, 0xDE, 0x00,
  0x00, 0x7B, 0x80, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x07, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0,
  0x03, 0x80, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE3, 0xC0,
  0x01, 0xE3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xE3, 0x80,
  0x01, 0xE3, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03,
  0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x3C, 0x00,
  0x1E, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xE0, 0x7C,
  0x10, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xF8, 0x0F, 0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0x77, 0x80, 0x37, 0x7C, 0x06, 0x73, 0xFB, 0xE7, 0x3F, 0xFC, 0x70, 0xFF,
  0x87, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0xFF, 0x81, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87, 0xBC,
  0x0F, 0x8F, 0x60, 0x0F, 0x9F, 0x80, 0x0F, 0x3F, 0x00, 0x1F, 0x7C, 0x00,
  0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7E, 0x00, 0x3E, 0xEC, 0x00,
  0x79, 0xDC, 0x01, 0xF3, 0x9E, 0x07, 0xC7, 0x1F, 0xFF, 0x0E, 0x1F, 0xFC,
  0x1C, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xE0, 0x60, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x0F, 0x07, 0xFF, 0x8F, 0x0F, 0xFF,
  0xCF, 0x0F, 0x81, 0xCF, 0x1F, 0x00, 0xEF, 0x3E, 0x00, 0x7F, 0x3C, 0x00,
  0x3F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x1E, 0x00, 0xEF, 0x1F, 0x81,
  0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x87, 0x03, 0xFF, 0x07, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0xF8,
  0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78,
  0x00, 0x39, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x70, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x20, 0xF8,
  0x03, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x20, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x0F, 0x07,
  0xFF, 0x8F, 0x0F, 0xFF, 0xCF, 0x0F, 0x81, 0xEF, 0x1F, 0x00, 0xEF, 0x3E,
  0x00, 0x7F, 0x3C, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x6F, 0x1E,
  0x00, 0xEF, 0x1F, 0x81, 0xCF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x8F, 0x03,
  0xFE, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x40,
  0x00, 0x78, 0x30, 0x01, 0xF8, 0x3F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0xFF, 0x07, 0x8F, 0xFE, 0x3C, 0xFF, 0xF9, 0xEF, 0x07, 0xCF, 0xF0, 0x1F,
  0x77, 0x00, 0x7B, 0xF0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3C, 0x79, 0xEF, 0xFF, 0x79, 0xE1, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xF0,
  0x3C, 0x07, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x9B,
  0xF3, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xFF,
  0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E,
  0x00, 0xF3, 0xE0, 0x0F, 0x7F, 0x00, 0xFF, 0xF0, 0x0E, 0xE7, 0x80, 0xFC,
  0x78, 0x0F, 0x83, 0x80, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F,
  0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x00, 0xFF, 0x0E, 0x3F, 0xF8, 0x3F, 0xF8, 0xE3, 0xFF, 0xC7, 0xFF,
  0xCE, 0x70, 0x7C, 0x70, 0x7E, 0xEE, 0x03, 0xEE, 0x03, 0xEE, 0xC0, 0x1E,
  0xC0, 0x1E, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0xFF, 0x87, 0x0F, 0xFE, 0x38, 0xFF, 0xF9, 0xCF, 0x07,
  0xCE, 0xE0, 0x1F, 0x76, 0x00, 0x7B, 0xB0, 0x03, 0xDF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x7C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x78,
  0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0xE0, 0xFF, 0x81, 0xC3, 0xFF, 0x83, 0x8F, 0xFF, 0x87,
  0x3C, 0x0F, 0x8E, 0x60, 0x0F, 0x9D, 0xC0, 0x0F, 0x3B, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7E, 0x00, 0x3E, 0xFC,
  0x00, 0x79, 0xEC, 0x01, 0xF3, 0xDE, 0x07, 0xC7, 0x9F, 0xFF, 0x0F, 0x1F,
  0xFC, 0x1E, 0x1F, 0xF0, 0x3C, 0x07, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x03, 0xFF, 0x8F,
  0x07, 0xFF, 0xCF, 0x0F, 0xC3, 0xCF, 0x1F, 0x00, 0xEF, 0x1E, 0x00, 0x7F,
  0x3C, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x6F, 0x1F, 0x00, 0xEF,
  0x1F, 0x81, 0xCF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x8F, 0x03, 0xFE, 0x0F,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0x03,
  0xB8, 0x0E, 0xC0, 0x3B, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x01, 0xE3, 0xC0, 0x08, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x80, 0x03, 0xD8, 0x00, 0xFB, 0xC0, 0x3E, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3F, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC1, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0x38, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0x78, 0x01, 0xBB, 0xC0, 0x19, 0xDF, 0x03, 0xCE, 0x7F, 0xFC, 0x71,
  0xFF, 0xC3, 0x87, 0xFC, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xC7, 0x00,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0xC0,
  0x1C, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x78, 0x00,
  0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07,
  0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xBC, 0x00, 0x3F, 0x00, 0x0E, 0x70, 0x00, 0xFC, 0x00, 0x79, 0xE0, 0x03,
  0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x7F, 0x80, 0x1C,
  0x38, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x07, 0x38, 0x03, 0xC3, 0xC0, 0x1C,
  0xE0, 0x0F, 0x0F, 0x00, 0xF3, 0x80, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0xE0,
  0x70, 0x0E, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x70, 0x1E, 0x07, 0x80, 0xE1,
  0xC0, 0x78, 0x1E, 0x07, 0x87, 0x01, 0xC0, 0x78, 0x1E, 0x1E, 0x07, 0x00,
  0xE0, 0x70, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0xE0, 0xF0, 0x0F, 0x07, 0x03,
  0x83, 0xC0, 0x3C, 0x3C, 0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x3C, 0x38, 0x01,
  0xC3, 0x80, 0xF1, 0xE0, 0x07, 0x8E, 0x01, 0xC7, 0x80, 0x1E, 0x38, 0x07,
  0x1C, 0x00, 0x79, 0xE0, 0x1E, 0x70, 0x00, 0xE7, 0x80, 0x79, 0xC0, 0x03,
  0x9C, 0x00, 0xEF, 0x00, 0x0F, 0x70, 0x03, 0xBC, 0x00, 0x3D, 0xC0, 0x0E,
  0xE0, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x03, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x1E, 0xE0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x1E,
  0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00,
  0x07, 0x8E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0x70, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x03, 0x80, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x06, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7E,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFA, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 52, 15, 5, -51 },
  { 40, 16, 19, 24, 4, -51 },
  { 78, 29, 51, 31, 1, -51 },
  { 263, 24, 58, 29, 3, -54 },
  { 437, 38, 52, 44, 3, -51 },
  { 684, 29, 52, 31, 2, -51 },
  { 873, 5, 19, 13, 4, -51 },
  { 885, 13, 62, 20, 4, -51 },
  { 986, 14, 62, 20, 2, -51 },
  { 1095, 20, 21, 26, 3, -54 },
  { 1148, 25, 33, 29, 2, -42 },
  { 1252, 7, 17, 14, 3, -8 },
  { 1267, 15, 4, 19, 2, -21 },
  { 1275, 6, 8, 14, 4, -7 },
  { 1281, 22, 51, 25, 2, -51 },
  { 1422, 23, 52, 29, 3, -51 },
  { 1572, 14, 51, 29, 5, -51 },
  { 1662, 23, 51, 29, 3, -51 },
  { 1809, 23, 52, 29, 3, -51 },
  { 1959, 27, 51, 29, 1, -51 },
  { 2132, 23, 52, 29, 3, -51 },
  { 2282, 23, 52, 29, 3, -51 },
  { 2432, 23, 51, 29, 3, -51 },
  { 2579, 25, 52, 29, 2, -51 },
  { 2742, 23, 52, 29, 3, -51 },
  { 2892, 6, 39, 14, 4, -38 },
  { 2922, 8, 47, 14, 3, -38 },
  { 2969, 25, 30, 29, 2, -40 },
  { 3063, 25, 18, 29, 2, -34 },
  { 3120, 25, 30, 29, 2, -40 },
  { 3214, 18, 52, 21, 1, -51 },
  { 3331, 37, 57, 45, 4, -51 },
  { 3595, 29, 51, 29, 0, -51 },
  { 3780, 24, 51, 32, 5, -51 },
  { 3933, 25, 52, 31, 4, -51 },
  { 4096, 26, 51, 35, 5, -51 },
  { 4262, 20, 51, 28, 5, -51 },
  { 4390, 20, 51, 26, 5, -51 },
  { 4518, 30, 52, 38, 4, -51 },
  { 4713, 26, 51, 36, 5, -51 },
  { 4879, 12, 51, 18, 3, -51 },
  { 4956, 12, 64, 15, -3, -51 },
  { 5052, 25, 51, 29, 5, -51 },
  { 5212, 19, 51, 25, 5, -51 },
  { 5334, 38, 51, 49, 5, -51 },
  { 5577, 28, 51, 38, 5, -51 },
  { 5756, 30, 52, 38, 4, -51 },
  { 5951, 22, 51, 30, 5, -51 },
  { 6092, 30, 63, 38, 4, -51 },
  { 6329, 25, 51, 31, 5, -51 },
  { 6489, 23, 52, 28, 3, -51 },
  { 6639, 24, 51, 25, 1, -51 },
  { 6792, 26, 52, 36, 5, -51 },
  { 6961, 29, 51, 29, 0, -51 },
  { 7146, 48, 51, 49, 0, -51 },
  { 7452, 24, 51, 26, 1, -51 },
  { 7605, 25, 51, 25, 0, -51 },
  { 7765, 21, 51, 24, 2, -51 },
  { 7899, 14, 62, 22, 6, -51 },
  { 8008, 22, 51, 25, 2, -51 },
  { 8149, 14, 62, 22, 2, -51 },
  { 8258, 28, 26, 30, 1, -51 },
  { 8349, 30, 3, 29, 0, 6 },
  { 8361, 12, 11, 17, 3, -54 },
  { 8378, 20, 39, 28, 3, -38 },
  { 8476, 23, 55, 31, 5, -54 },
  { 8635, 19, 39, 23, 3, -38 },
  { 8728, 24, 55, 31, 3, -54 },
  { 8893, 22, 39, 28, 3, -38 },
  { 9001, 17, 54, 16, 1, -54 },
  { 9116, 24, 55, 31, 3, -38 },
  { 9281, 21, 54, 31, 5, -54 },
  { 9423, 6, 52, 14, 4, -52 },
  { 9462, 11, 69, 14, -1, -52 },
  { 9557, 20, 54, 26, 5, -54 },
  { 9692, 4, 54, 13, 5, -54 },
  { 9719, 36, 38, 46, 5, -38 },
  { 9890, 21, 38, 31, 5, -38 },
  { 9990, 24, 39, 30, 3, -38 },
  { 10107, 23, 55, 31, 5, -38 },
  { 10266, 24, 55, 31, 3, -38 },
  { 10431, 14, 38, 20, 5, -38 },
  { 10498, 19, 39, 23, 2, -38 },
  { 10591, 15, 48, 17, 1, -47 },
  { 10681, 21, 39, 31, 5, -38 },
  { 10784, 23, 38, 24, 0, -38 },
  { 10894, 38, 38, 40, 1, -38 },
  { 11075, 22, 38, 24, 1, -38 },
  { 11180, 23, 55, 24, 1, -38 },
  { 11339, 16, 38, 20, 2, -38 },
  { 11415, 19, 62, 25, 3, -51 },
  { 11563, 4, 71, 28, 12, -54 },
  { 11599, 19, 62, 25, 3, -51 },
  { 11747, 25, 8, 29, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_Light71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT71PT7B_H_
