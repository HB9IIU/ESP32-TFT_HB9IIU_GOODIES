#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xF0, 0x6F, 0xBB, 0x40, 0x7B, 0x37, 0x80, 0x56, 0xAC, 0xD5,
  0xA8, 0x55, 0x7B, 0xC0, 0xC0, 0x5A, 0xA4, 0x95, 0x58, 0xE8, 0x4B, 0xA0,
  0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x56, 0xDA, 0xC0, 0xFC, 0xC4, 0xA5,
  0xC0, 0xC4, 0xB3, 0xC0, 0x2D, 0xDE, 0x40, 0x73, 0x13, 0xC0, 0x73, 0x5B,
  0xC0, 0xE4, 0xA4, 0x80, 0x55, 0xDB, 0xC0, 0x56, 0xB2, 0xC0, 0x90, 0x98,
  0x2B, 0x10, 0xFC, 0x89, 0xC0, 0xD5, 0xA0, 0x32, 0x7F, 0xBF, 0xC1, 0x80,
  0x49, 0x7B, 0x40, 0xFF, 0xF0, 0x72, 0x48, 0xC0, 0xD6, 0xDB, 0x80, 0xEB,
  0xB0, 0xEB, 0xA0, 0x78, 0x8B, 0x97, 0xFF, 0xF0, 0xD5, 0x70, 0xFE, 0xFA,
  0xF0, 0xAA, 0xB0, 0x99, 0x9B, 0xBD, 0xB6, 0xFB, 0x40, 0x69, 0x99, 0x96,
  0xBE, 0xA0, 0x69, 0x99, 0x96, 0x30, 0xBE, 0xF0, 0x72, 0x33, 0xC0, 0xE9,
  0x24, 0x80, 0xFF, 0xF0, 0xB6, 0xD4, 0x80, 0xAD, 0x6B, 0x75, 0xA8, 0xB5,
  0x2B, 0x40, 0xB7, 0x24, 0x80, 0xE9, 0x29, 0xC0, 0xFE, 0x91, 0x24, 0x40,
  0xD5, 0x5C, 0x4A, 0x80, 0xE0, 0xC0, 0x6E, 0xF0, 0xAF, 0xF0, 0xEB, 0x2E,
  0xDB, 0xC0, 0xFE, 0x70, 0xFA, 0xA0, 0xF6, 0xF3, 0xC0, 0xAF, 0xF0, 0xBC,
  0xBF, 0xBA, 0xB0, 0xFC, 0xFD, 0xDD, 0xFF, 0xF6, 0xF0, 0xFF, 0xA0, 0xF6,
  0xF2, 0x40, 0xF0, 0xE7, 0xEA, 0xC0, 0xFF, 0xBB, 0x20, 0xBB, 0x55, 0xA9,
  0x50, 0xB5, 0x25, 0x00, 0xDB, 0x57, 0x54, 0xFF, 0x95, 0x5C, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 2, 2, 3, 0, -6 },
  { 3, 3, 6, 4, 0, -6 },
  { 6, 3, 6, 3, 0, -6 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 3, 6, 3, 0, -6 },
  { 16, 1, 2, 1, 0, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 3, 2, 3, 0, -6 },
  { 22, 3, 4, 3, 0, -5 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 3, 6, 3, 0, -6 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 1, 6, 3, 1, -6 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 3, 6, 3, 0, -6 },
  { 40, 3, 6, 3, 0, -6 },
  { 43, 3, 6, 3, 0, -6 },
  { 46, 3, 6, 3, 0, -6 },
  { 49, 3, 6, 3, 0, -6 },
  { 52, 3, 6, 3, 0, -6 },
  { 55, 3, 6, 3, 0, -6 },
  { 58, 1, 4, 2, 0, -4 },
  { 59, 1, 5, 2, 0, -4 },
  { 60, 3, 4, 3, 0, -5 },
  { 62, 3, 2, 3, 0, -4 },
  { 63, 3, 4, 3, 0, -5 },
  { 65, 2, 6, 2, 0, -6 },
  { 67, 5, 7, 5, 0, -6 },
  { 72, 3, 6, 3, 0, -6 },
  { 75, 2, 6, 4, 1, -6 },
  { 77, 3, 6, 3, 0, -6 },
  { 80, 3, 6, 4, 1, -6 },
  { 83, 2, 6, 3, 1, -6 },
  { 85, 2, 6, 3, 1, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 2, 6, 4, 1, -6 },
  { 92, 2, 6, 2, 0, -6 },
  { 94, 1, 7, 2, 0, -6 },
  { 95, 2, 6, 3, 1, -6 },
  { 97, 2, 6, 3, 1, -6 },
  { 99, 4, 6, 5, 1, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 4, 6, 4, 0, -6 },
  { 108, 2, 6, 3, 1, -6 },
  { 110, 4, 7, 4, 0, -6 },
  { 114, 2, 6, 3, 1, -6 },
  { 116, 3, 6, 3, 0, -6 },
  { 119, 3, 6, 3, 0, -6 },
  { 122, 2, 6, 4, 1, -6 },
  { 124, 3, 6, 3, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 3, 6, 3, 0, -6 },
  { 134, 3, 6, 3, 0, -6 },
  { 137, 3, 6, 3, 0, -6 },
  { 140, 1, 7, 2, 1, -6 },
  { 141, 3, 6, 3, 0, -6 },
  { 144, 2, 7, 2, 0, -6 },
  { 146, 3, 3, 3, 0, -6 },
  { 148, 3, 1, 3, 0, 0 },
  { 149, 2, 1, 2, 0, -6 },
  { 150, 3, 4, 3, 0, -4 },
  { 152, 2, 6, 4, 1, -6 },
  { 154, 2, 4, 3, 0, -4 },
  { 155, 3, 6, 4, 0, -6 },
  { 158, 3, 4, 3, 0, -4 },
  { 160, 2, 6, 2, 0, -6 },
  { 162, 3, 6, 4, 0, -4 },
  { 165, 2, 6, 3, 1, -6 },
  { 167, 1, 6, 2, 0, -6 },
  { 168, 1, 8, 2, 0, -6 },
  { 169, 2, 6, 3, 1, -6 },
  { 171, 1, 6, 2, 0, -6 },
  { 172, 4, 4, 5, 1, -4 },
  { 174, 2, 4, 3, 1, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 2, 6, 4, 1, -4 },
  { 179, 3, 6, 4, 0, -4 },
  { 182, 1, 4, 2, 1, -4 },
  { 183, 2, 4, 3, 0, -4 },
  { 184, 2, 5, 2, 0, -5 },
  { 186, 2, 4, 3, 1, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 6, 3, 0, -4 },
  { 196, 2, 4, 2, 0, -4 },
  { 197, 2, 7, 3, 0, -6 },
  { 199, 1, 8, 3, 1, -6 },
  { 200, 2, 7, 3, 0, -6 },
  { 202, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Light8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT8PT7B_H_
