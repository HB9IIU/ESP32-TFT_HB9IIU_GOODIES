#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xAA, 0xAA, 0x80, 0xF0, 0x9C, 0xE7, 0x39, 0xC6, 0x20, 0x08,
  0x81, 0x10, 0x22, 0x04, 0x40, 0x98, 0xFF, 0xC4, 0x40, 0x88, 0x11, 0x02,
  0x20, 0x44, 0x7F, 0xE1, 0x10, 0x66, 0x08, 0x81, 0x10, 0x22, 0x04, 0x40,
  0x08, 0x08, 0x7F, 0x49, 0x88, 0x88, 0x88, 0xC8, 0x68, 0x38, 0x0E, 0x0B,
  0x09, 0x09, 0x09, 0x09, 0x8B, 0x7C, 0x08, 0x08, 0x70, 0x42, 0x42, 0x22,
  0x31, 0x11, 0x08, 0x88, 0x44, 0xC2, 0x24, 0x11, 0x2E, 0x8B, 0x5A, 0x56,
  0x5C, 0xA2, 0x09, 0x10, 0x48, 0x82, 0x44, 0x22, 0x21, 0x11, 0x08, 0x48,
  0x83, 0x80, 0x38, 0x19, 0x04, 0x41, 0x10, 0x44, 0x19, 0x02, 0xC0, 0xE0,
  0x30, 0x1E, 0x04, 0x8A, 0x32, 0x84, 0xA0, 0xE8, 0x32, 0x0C, 0xC7, 0x9F,
  0x30, 0xFE, 0x18, 0x8C, 0x46, 0x21, 0x08, 0xC6, 0x31, 0x8C, 0x61, 0x08,
  0x43, 0x08, 0x61, 0x0C, 0x82, 0x18, 0x43, 0x18, 0x42, 0x10, 0xC6, 0x31,
  0x8C, 0x42, 0x31, 0x88, 0xC4, 0x40, 0x10, 0x22, 0x4F, 0xF1, 0x85, 0x11,
  0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x69, 0x2D, 0x00, 0xF8, 0xE0, 0x02, 0x04, 0x10, 0x20,
  0xC1, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0x81, 0x00,
  0x3C, 0x66, 0x42, 0x43, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC3, 0x43, 0x42, 0x66, 0x3C, 0x19, 0xDF, 0xB9, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0x7C, 0xC6, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x40, 0xC0, 0xFF,
  0x7C, 0xC6, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x38, 0x1E, 0x02, 0x03,
  0x01, 0x01, 0x03, 0x03, 0x86, 0xFC, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x0D,
  0x02, 0x41, 0x90, 0x44, 0x31, 0x08, 0x46, 0x11, 0x04, 0xC1, 0x3F, 0xF0,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0xFC, 0x6E, 0x03, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x86, 0xFC, 0x1E,
  0x30, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xDC, 0xE2, 0xC3, 0xC1, 0xC1, 0xC1,
  0xC1, 0x41, 0x43, 0x62, 0x3E, 0xFF, 0x01, 0x03, 0x02, 0x02, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0x3C,
  0x62, 0xC3, 0xC1, 0xC1, 0x43, 0x62, 0x36, 0x18, 0x3C, 0x42, 0xC3, 0x81,
  0x81, 0x81, 0xC1, 0x43, 0x3E, 0x3C, 0x66, 0xC2, 0xC3, 0x83, 0x81, 0x81,
  0x83, 0xC3, 0x45, 0x7D, 0x01, 0x03, 0x02, 0x02, 0x06, 0x0C, 0x78, 0xE0,
  0x00, 0x03, 0x80, 0x68, 0x00, 0x00, 0x01, 0xB4, 0xB4, 0x01, 0x83, 0x83,
  0x06, 0x0C, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x20, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x18,
  0x38, 0x30, 0x60, 0x60, 0x20, 0x00, 0xF8, 0x98, 0x18, 0x30, 0x60, 0xC1,
  0x06, 0x08, 0x20, 0x41, 0x82, 0x00, 0x00, 0x00, 0x30, 0x60, 0x07, 0x80,
  0x61, 0x83, 0x03, 0x08, 0x04, 0x60, 0x09, 0x0F, 0x24, 0x4C, 0x93, 0x22,
  0xC8, 0x8A, 0x22, 0x38, 0x88, 0xA2, 0x22, 0xC8, 0x8B, 0x35, 0x24, 0x77,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x04, 0x03, 0xF0, 0x0C, 0x03, 0x00,
  0xE0, 0x68, 0x1A, 0x04, 0x81, 0x30, 0x4C, 0x31, 0x08, 0x43, 0xF8, 0xFE,
  0x60, 0x98, 0x24, 0x0D, 0x03, 0xC0, 0x70, 0x10, 0xFC, 0x86, 0x83, 0x83,
  0x81, 0x83, 0x83, 0x86, 0xFC, 0x86, 0x83, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x86, 0xFC, 0x0F, 0x9C, 0x48, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x38, 0x87, 0xC0, 0xF8,
  0x47, 0x20, 0xD0, 0x28, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0E, 0x05, 0x06, 0x8E, 0x7C, 0x00, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFD, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFC,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFA, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x00, 0x0F, 0xC3, 0x0C, 0xC0, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0x00, 0xE0, 0x14, 0x02, 0x80, 0x58,
  0x09, 0x01, 0x38, 0x61, 0xFC, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x40, 0x83,
  0x82, 0x86, 0x84, 0x8C, 0x88, 0x90, 0xB0, 0xB0, 0xD0, 0xD8, 0x88, 0x8C,
  0x84, 0x86, 0x82, 0x83, 0x81, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0x40, 0x7A, 0x02, 0xD0, 0x16, 0xC1, 0xB2, 0x09, 0x90, 0x4C, 0xC6, 0x62,
  0x23, 0x11, 0x18, 0xC8, 0xC2, 0xC6, 0x14, 0x30, 0xA1, 0x87, 0x0C, 0x10,
  0x40, 0xC0, 0xF0, 0x3E, 0x0E, 0x83, 0xA0, 0xE4, 0x39, 0x0E, 0x63, 0x88,
  0xE3, 0x38, 0x4E, 0x13, 0x82, 0xE0, 0xB8, 0x3E, 0x07, 0x81, 0xE0, 0x30,
  0x1F, 0x06, 0x31, 0x83, 0x30, 0x24, 0x04, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x34, 0x06, 0x80, 0xD8, 0x13, 0x06, 0x31, 0x83,
  0xE0, 0xF8, 0x8E, 0x82, 0x83, 0x83, 0x83, 0x83, 0x82, 0x86, 0xFC, 0xF8,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x06, 0x31, 0x83, 0x30,
  0x24, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x34,
  0x06, 0x80, 0xD8, 0x13, 0x06, 0x31, 0x83, 0xE0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0xF8, 0x9E, 0x82, 0x83, 0x83, 0x83, 0x83, 0x82, 0x86, 0xFC,
  0x88, 0x88, 0x8C, 0x84, 0x86, 0x82, 0x83, 0x81, 0x3E, 0x63, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x03, 0x03,
  0x86, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x82, 0x63, 0x1F, 0x00, 0xC0, 0x70, 0x34, 0x0D,
  0x02, 0x40, 0x98, 0x66, 0x18, 0x84, 0x21, 0x0C, 0x43, 0x30, 0x48, 0x12,
  0x04, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x81, 0xE0, 0x40, 0xD0,
  0x70, 0x48, 0x28, 0x24, 0x14, 0x13, 0x0A, 0x19, 0x85, 0x0C, 0x46, 0xC4,
  0x22, 0x22, 0x11, 0x11, 0x0C, 0x89, 0x82, 0x44, 0xC1, 0x63, 0x40, 0xA0,
  0xA0, 0x50, 0x50, 0x38, 0x38, 0x0C, 0x1C, 0x06, 0x0C, 0x00, 0x41, 0xB0,
  0x88, 0x44, 0x63, 0x20, 0xB0, 0x50, 0x18, 0x0C, 0x06, 0x07, 0x02, 0xC3,
  0x21, 0x10, 0x8C, 0xC2, 0x41, 0x60, 0xC0, 0xC1, 0xE0, 0x90, 0x4C, 0x66,
  0x21, 0x10, 0xD8, 0x28, 0x14, 0x0E, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x00, 0xFE, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x0C, 0x10,
  0x60, 0x81, 0x06, 0x08, 0x10, 0x60, 0x81, 0xFC, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0x81, 0x03,
  0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0x81, 0x81, 0x02,
  0x06, 0x04, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0xFC, 0x04, 0x03, 0x00, 0xA0, 0x68, 0x11, 0x0C, 0x42,
  0x19, 0x82, 0xC0, 0xC0, 0xFF, 0xC0, 0xC6, 0x21, 0x18, 0xF8, 0x18, 0x10,
  0x20, 0x47, 0xB1, 0xC3, 0x06, 0x0C, 0x3C, 0x6F, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x88, 0xBE, 0xC2, 0xC3, 0x83, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x83, 0xC2, 0xC6, 0xBC, 0x08, 0x7D, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x02, 0x06, 0x07, 0xC0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x19, 0x3D,
  0x63, 0x41, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0xC1, 0xC1, 0x43, 0x63, 0x3D,
  0x08, 0x3C, 0x42, 0x43, 0xC1, 0xC1, 0xFF, 0x80, 0x80, 0xC0, 0xC0, 0x40,
  0x61, 0x3E, 0x1C, 0xC2, 0x08, 0x20, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x18, 0x3D, 0x63, 0x41, 0xC1, 0xC1, 0xC1,
  0x81, 0x81, 0xC1, 0xC1, 0x43, 0x63, 0x3D, 0x01, 0x01, 0x01, 0x03, 0x46,
  0x7C, 0x81, 0x02, 0x04, 0x08, 0x11, 0x2F, 0x63, 0xC3, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0xC7, 0xFF, 0xC0, 0x24, 0x00, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x5E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x61,
  0x46, 0x99, 0x22, 0xC5, 0x8D, 0x13, 0x22, 0x44, 0x8D, 0x0A, 0x18, 0xFF,
  0xFF, 0xE0, 0x10, 0x4B, 0xDF, 0xC5, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x09,
  0x7B, 0x1E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40,
  0x08, 0x1F, 0x10, 0xC8, 0x2C, 0x16, 0x0A, 0x05, 0x03, 0x81, 0x60, 0xB0,
  0x48, 0x66, 0x21, 0xF0, 0x08, 0xBE, 0xC2, 0xC3, 0x83, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x83, 0xC2, 0xC6, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x08, 0x3D, 0x63, 0x41, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0xC1, 0xC1, 0x43,
  0x63, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x15, 0xF1, 0x88, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x40, 0x11, 0xFC, 0x20, 0x83, 0x06, 0x0E, 0x0C,
  0x10, 0x41, 0x8F, 0xE0, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1E,
  0x57, 0xA0, 0xC1, 0x43, 0x42, 0x42, 0x62, 0x26, 0x24, 0x24, 0x34, 0x14,
  0x1C, 0x18, 0x18, 0xC3, 0x0D, 0x0C, 0x24, 0x30, 0x91, 0xE2, 0x64, 0x98,
  0x92, 0x42, 0x49, 0x09, 0x24, 0x2C, 0xD0, 0xE1, 0xC1, 0x86, 0x06, 0x18,
  0x18, 0x60, 0x43, 0x62, 0x26, 0x34, 0x14, 0x18, 0x18, 0x1C, 0x34, 0x26,
  0x22, 0x63, 0xC1, 0xC1, 0x41, 0x43, 0x62, 0x22, 0x22, 0x26, 0x34, 0x14,
  0x14, 0x1C, 0x18, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0xE0, 0xF8, 0x46,
  0x21, 0x18, 0x8C, 0x42, 0x31, 0x0F, 0x80, 0x0E, 0x30, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x63, 0x87, 0x03, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x60,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x38, 0x71, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x83, 0x1C, 0x00, 0xF0, 0xC7, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 18, 5, 2, -18 },
  { 6, 5, 7, 8, 2, -18 },
  { 11, 11, 18, 11, 0, -18 },
  { 36, 8, 20, 10, 1, -19 },
  { 56, 13, 18, 15, 1, -18 },
  { 86, 10, 18, 11, 1, -18 },
  { 109, 1, 7, 5, 2, -18 },
  { 110, 5, 22, 7, 1, -18 },
  { 124, 5, 22, 7, 1, -18 },
  { 138, 7, 7, 9, 1, -19 },
  { 145, 9, 12, 10, 1, -15 },
  { 159, 3, 6, 5, 1, -3 },
  { 162, 5, 1, 7, 1, -7 },
  { 163, 2, 2, 5, 2, -2 },
  { 164, 7, 18, 9, 1, -18 },
  { 180, 8, 18, 10, 1, -18 },
  { 198, 5, 18, 10, 2, -18 },
  { 210, 8, 18, 10, 1, -18 },
  { 228, 8, 18, 10, 1, -18 },
  { 246, 10, 18, 10, 0, -18 },
  { 269, 8, 18, 10, 1, -18 },
  { 287, 8, 18, 10, 1, -18 },
  { 305, 8, 18, 10, 1, -18 },
  { 323, 8, 18, 10, 1, -18 },
  { 341, 8, 18, 10, 1, -18 },
  { 359, 2, 13, 5, 2, -13 },
  { 363, 3, 16, 5, 1, -13 },
  { 369, 9, 11, 10, 1, -14 },
  { 382, 9, 6, 10, 1, -12 },
  { 389, 9, 11, 10, 1, -14 },
  { 402, 7, 18, 7, 0, -18 },
  { 418, 14, 20, 16, 1, -18 },
  { 453, 10, 18, 10, 0, -18 },
  { 476, 8, 18, 11, 2, -18 },
  { 494, 9, 18, 11, 1, -18 },
  { 515, 9, 18, 12, 2, -18 },
  { 536, 7, 18, 10, 2, -18 },
  { 552, 7, 18, 9, 2, -18 },
  { 568, 11, 18, 13, 1, -18 },
  { 593, 9, 18, 13, 2, -18 },
  { 614, 4, 18, 6, 1, -18 },
  { 623, 4, 23, 5, -1, -18 },
  { 635, 8, 18, 10, 2, -18 },
  { 653, 6, 18, 9, 2, -18 },
  { 667, 13, 18, 17, 2, -18 },
  { 697, 10, 18, 13, 2, -18 },
  { 720, 11, 18, 13, 1, -18 },
  { 745, 8, 18, 10, 2, -18 },
  { 763, 11, 22, 13, 1, -18 },
  { 794, 8, 18, 11, 2, -18 },
  { 812, 8, 18, 10, 1, -18 },
  { 830, 9, 18, 9, 0, -18 },
  { 851, 9, 18, 13, 2, -18 },
  { 872, 10, 18, 10, 0, -18 },
  { 895, 17, 18, 17, 0, -18 },
  { 934, 9, 18, 9, 0, -18 },
  { 955, 9, 18, 9, 0, -18 },
  { 976, 7, 18, 9, 1, -18 },
  { 992, 5, 22, 8, 2, -18 },
  { 1006, 7, 18, 9, 1, -18 },
  { 1022, 5, 22, 8, 1, -18 },
  { 1036, 10, 9, 10, 0, -18 },
  { 1048, 10, 1, 10, 0, 2 },
  { 1050, 4, 4, 6, 1, -19 },
  { 1052, 7, 14, 10, 1, -14 },
  { 1065, 8, 19, 11, 2, -19 },
  { 1084, 7, 14, 8, 1, -14 },
  { 1097, 8, 19, 11, 1, -19 },
  { 1116, 8, 14, 10, 1, -14 },
  { 1130, 6, 19, 6, 0, -19 },
  { 1145, 8, 20, 11, 1, -14 },
  { 1165, 7, 19, 11, 2, -19 },
  { 1182, 1, 18, 5, 2, -18 },
  { 1185, 3, 24, 5, 0, -18 },
  { 1194, 7, 19, 9, 2, -19 },
  { 1211, 1, 19, 5, 2, -19 },
  { 1214, 12, 14, 16, 2, -14 },
  { 1235, 7, 14, 11, 2, -14 },
  { 1248, 9, 14, 11, 1, -14 },
  { 1264, 8, 20, 11, 2, -14 },
  { 1284, 8, 20, 11, 1, -14 },
  { 1304, 5, 14, 7, 2, -14 },
  { 1313, 6, 14, 8, 1, -14 },
  { 1324, 5, 16, 6, 0, -16 },
  { 1334, 7, 13, 11, 2, -13 },
  { 1346, 8, 13, 8, 0, -13 },
  { 1359, 14, 13, 14, 0, -13 },
  { 1382, 8, 13, 9, 0, -13 },
  { 1395, 8, 19, 9, 0, -13 },
  { 1414, 5, 13, 7, 1, -13 },
  { 1423, 7, 22, 9, 1, -18 },
  { 1443, 2, 25, 10, 4, -19 },
  { 1450, 7, 22, 9, 1, -18 },
  { 1470, 9, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Light25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT25PT7B_H_
