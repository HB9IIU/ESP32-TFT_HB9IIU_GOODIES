#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x0E, 0xEF, 0xE0, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x0C, 0x10, 0x02, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x06, 0x0C, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC, 0x18, 0x30, 0x06, 0x08, 0x03,
  0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1,
  0x83, 0xFF, 0xFE, 0xFF, 0xFF, 0x82, 0x04, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06,
  0x08, 0x03, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0x83,
  0xFF, 0xCE, 0x61, 0x38, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C,
  0x06, 0x18, 0x0C, 0x30, 0x1C, 0x60, 0x1C, 0xC0, 0x1F, 0x80, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x19, 0xC0, 0x31, 0xC0, 0x61, 0x80, 0xC3, 0x01,
  0x87, 0x03, 0x0E, 0x06, 0x18, 0x0C, 0x30, 0x18, 0xEC, 0x33, 0x9F, 0xFE,
  0x1F, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x7C, 0x01, 0x81, 0x8C, 0x06, 0x03, 0x18, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x30, 0x60, 0x30, 0x60, 0xC0, 0x60, 0xC1, 0x80, 0xC1,
  0x86, 0x01, 0x83, 0x0C, 0x03, 0x06, 0x18, 0x06, 0x0C, 0x60, 0x0C, 0x18,
  0xC0, 0x18, 0x31, 0x9F, 0x30, 0x66, 0x37, 0x60, 0xCC, 0xC6, 0x63, 0x19,
  0x86, 0xC6, 0x66, 0x0C, 0xF8, 0xCC, 0x18, 0xE3, 0x98, 0x30, 0x06, 0x30,
  0x60, 0x0C, 0x60, 0xC0, 0x38, 0xC1, 0x80, 0x61, 0x83, 0x00, 0xC3, 0x06,
  0x03, 0x06, 0x0C, 0x06, 0x0C, 0x18, 0x0C, 0x18, 0x30, 0x30, 0x18, 0x60,
  0x60, 0x31, 0x80, 0xC0, 0x37, 0x03, 0x00, 0x7C, 0x03, 0x80, 0x03, 0xF8,
  0x00, 0xC6, 0x00, 0x61, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0xC7, 0x00, 0x31, 0x80, 0x0C,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x06, 0x60,
  0x03, 0x1C, 0x19, 0xC3, 0x06, 0x60, 0x63, 0x98, 0x1C, 0xEE, 0x03, 0x33,
  0x80, 0xEC, 0xE0, 0x1F, 0x38, 0x07, 0x86, 0x00, 0xE1, 0x80, 0x78, 0x70,
  0x3F, 0x0E, 0x1C, 0xE3, 0xFE, 0x38, 0x7F, 0x07, 0xFB, 0x6D, 0xB6, 0xDB,
  0x00, 0x03, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0xC0, 0xE0, 0x60,
  0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x07,
  0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06,
  0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x08, 0x61, 0xE6, 0x7F, 0xFF, 0x0F, 0x00, 0xF0,
  0x1D, 0x81, 0x9C, 0x30, 0xC7, 0x06, 0x10, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x33, 0x77, 0x76, 0x6E, 0xCC, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x07, 0x80, 0x3F,
  0x81, 0xEE, 0x0E, 0x1C, 0x30, 0x39, 0xC0, 0xE6, 0x01, 0x98, 0x06, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0x60, 0x1D, 0x80, 0x67, 0x01, 0x9C, 0x0E, 0x30, 0x30,
  0xE1, 0xC1, 0xFE, 0x03, 0xF0, 0x03, 0x83, 0xC3, 0xE7, 0xF7, 0xBF, 0x1D,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x81, 0xFF, 0x8F, 0x9F, 0x10, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0x81, 0xFF, 0x8F, 0x9F, 0x30, 0x1E, 0x80, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x3C, 0x07, 0xC0, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x3B, 0x01, 0xCF, 0xFE, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x03,
  0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x60, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x7F, 0xF9, 0xFF, 0xE6, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x7F, 0xC3, 0xFF, 0x86, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0xC0, 0xF3, 0xFF, 0x87, 0xFC, 0x00, 0x01,
  0xF0, 0x1F, 0xE0, 0xF9, 0x87, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE1, 0x83, 0x9F, 0x8E,
  0xFF, 0x36, 0x0E, 0xF0, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x36, 0x01, 0xDC, 0x06,
  0x30, 0x18, 0xE0, 0xE1, 0xFF, 0x03, 0xF8, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0xF3, 0xC3, 0x81, 0xC6,
  0x01, 0x9C, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1C, 0xC0, 0x39, 0x80,
  0x63, 0x81, 0xC3, 0x87, 0x03, 0x9C, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0xC0,
  0x79, 0xC0, 0xC1, 0xC3, 0x01, 0xCE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x37, 0x00, 0xEE, 0x01, 0xCE, 0x07,
  0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x83, 0xCE, 0x1C, 0x1C, 0x60,
  0x3B, 0x80, 0x6E, 0x01, 0xB0, 0x06, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x2D, 0xE1, 0xF3,
  0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0xFC, 0x1F, 0xC0,
  0x5F, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x23, 0x9C, 0xE3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x39, 0xCE,
  0x63, 0x39, 0x8C, 0x60, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x1E, 0x1F, 0xF3, 0x8F, 0x40, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xC3, 0xC0, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x1E, 0x06, 0x60, 0x7F, 0x86, 0x60,
  0x63, 0x06, 0x60, 0xC3, 0x06, 0x60, 0xC3, 0x06, 0x61, 0x83, 0x06, 0xC1,
  0x83, 0x06, 0xC1, 0x83, 0x07, 0xC1, 0x83, 0x06, 0xC1, 0x83, 0x06, 0xC1,
  0x83, 0x06, 0xC1, 0x83, 0x06, 0xC1, 0x83, 0x06, 0xC1, 0x87, 0x06, 0xE1,
  0x85, 0x0E, 0x60, 0xCD, 0x8C, 0x60, 0xFC, 0xF8, 0x60, 0x78, 0xF0, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x81, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03,
  0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x83, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x1C, 0x0E, 0x07, 0x01, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x18,
  0x07, 0x0E, 0x01, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0C,
  0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xF7, 0x00, 0xEE, 0x00, 0xDC, 0x01, 0xB8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x37, 0x00, 0xEE, 0x03,
  0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0xF8, 0xE0, 0x3D, 0xC0, 0x3B, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xEE, 0x07, 0x9F, 0xFE, 0x3F, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0x07, 0xCE, 0x0E, 0x02, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x02, 0x07,
  0xFE, 0x01, 0xFE, 0xFF, 0xE0, 0xFF, 0xF0, 0xE0, 0x78, 0xE0, 0x1C, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0x9F, 0x87, 0x80,
  0x21, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01,
  0xF0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x80, 0x03,
  0x70, 0x00, 0x66, 0x00, 0x0C, 0xE0, 0x01, 0x8E, 0x00, 0x31, 0xE0, 0x06,
  0x1E, 0x01, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFE, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x9F, 0xFF,
  0x80, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x06, 0x8E, 0xFC, 0xF8, 0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xCE,
  0x07, 0x1C, 0x0C, 0x38, 0x38, 0x70, 0x60, 0xE1, 0xC1, 0xC7, 0x03, 0x8E,
  0x07, 0x38, 0x0E, 0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x80, 0xFB, 0x01,
  0xE7, 0x03, 0x86, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x18, 0x70,
  0x38, 0xE0, 0x31, 0xC0, 0x73, 0x80, 0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x01,
  0xF8, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1B, 0xF8, 0x00, 0x1B, 0xFC, 0x00, 0x1B, 0xEC, 0x00, 0x3B, 0xEC,
  0x00, 0x33, 0xEC, 0x00, 0x33, 0xEE, 0x00, 0x73, 0xE6, 0x00, 0x63, 0xE6,
  0x00, 0x63, 0xE7, 0x00, 0x63, 0xE3, 0x00, 0xC3, 0xE3, 0x00, 0xC3, 0xE3,
  0x00, 0xC3, 0xE1, 0x81, 0xC3, 0xE1, 0x81, 0x83, 0xE1, 0x81, 0x83, 0xE1,
  0xC3, 0x83, 0xE0, 0xC3, 0x03, 0xE0, 0xC3, 0x03, 0xE0, 0xE3, 0x03, 0xE0,
  0x67, 0x03, 0xE0, 0x66, 0x03, 0xE0, 0x66, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x18, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xB0, 0x07, 0xDC, 0x03, 0xE6, 0x01, 0xF3, 0x80, 0xF8, 0xC0, 0x7C, 0x60,
  0x3E, 0x38, 0x1F, 0x0C, 0x0F, 0x87, 0x07, 0xC1, 0x83, 0xE0, 0xE1, 0xF0,
  0x30, 0xF8, 0x18, 0x7C, 0x0E, 0x3E, 0x03, 0x1F, 0x01, 0xCF, 0x80, 0x67,
  0xC0, 0x3B, 0xE0, 0x0D, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0E, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3E, 0x78,
  0x0E, 0x03, 0x83, 0x80, 0x38, 0x70, 0x03, 0x0C, 0x00, 0x73, 0x80, 0x0E,
  0x70, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x3B,
  0x00, 0x06, 0x70, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC1,
  0xC0, 0x38, 0x1C, 0x1E, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF,
  0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xB8,
  0x3C, 0xFF, 0xE3, 0xFE, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x3E, 0x78, 0x0E,
  0x03, 0x83, 0x80, 0x38, 0x70, 0x03, 0x0C, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x00, 0xCC, 0x00, 0x1D, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00,
  0x06, 0x70, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC1, 0xC0,
  0x38, 0x1C, 0x1E, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x77, 0x00, 0xEE,
  0x01, 0x9C, 0x07, 0x38, 0x1C, 0x7F, 0xF0, 0xFF, 0x81, 0xC3, 0x03, 0x87,
  0x07, 0x06, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x18, 0x70, 0x38, 0xE0, 0x31,
  0xC0, 0x73, 0x80, 0x67, 0x00, 0xEE, 0x00, 0xDC, 0x01, 0xF8, 0x03, 0x80,
  0x07, 0xC0, 0x7F, 0xF3, 0xEF, 0x9C, 0x02, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x3B, 0x01, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xFC, 0x0F, 0xF0, 0xE0, 0x01, 0xF8,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18,
  0x18, 0x0E, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x1C, 0x03,
  0x87, 0x00, 0xE1, 0x80, 0x18, 0x60, 0x06, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1D, 0x80,
  0x1E, 0x00, 0x66, 0x00, 0x78, 0x01, 0x98, 0x01, 0xE0, 0x06, 0x70, 0x07,
  0x80, 0x39, 0xC0, 0x1E, 0x00, 0xE3, 0x00, 0xFC, 0x03, 0x0C, 0x03, 0x30,
  0x0C, 0x38, 0x0C, 0xC0, 0x30, 0xE0, 0x33, 0x01, 0xC1, 0x80, 0xCC, 0x07,
  0x06, 0x07, 0x38, 0x18, 0x18, 0x18, 0x60, 0x60, 0x70, 0x61, 0x83, 0x81,
  0xC1, 0x86, 0x0E, 0x03, 0x06, 0x18, 0x38, 0x0C, 0x38, 0x70, 0xC0, 0x30,
  0xC0, 0xC3, 0x00, 0xE3, 0x03, 0x1C, 0x03, 0x8C, 0x0C, 0x70, 0x06, 0x30,
  0x31, 0x80, 0x19, 0xC0, 0xE6, 0x00, 0x67, 0x01, 0x98, 0x01, 0xD8, 0x06,
  0xE0, 0x07, 0x60, 0x1B, 0x80, 0x0D, 0x80, 0x6C, 0x00, 0x36, 0x01, 0xB0,
  0x00, 0xF8, 0x02, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x38, 0x0E, 0x38, 0x0C, 0x18, 0x0C,
  0x1C, 0x1C, 0x0C, 0x18, 0x0C, 0x38, 0x0E, 0x38, 0x06, 0x30, 0x06, 0x70,
  0x07, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x30,
  0x0C, 0x38, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0C,
  0x70, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x38, 0x18, 0x38,
  0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFB, 0xFF, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFF, 0xFE, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x31, 0x80,
  0x38, 0xC0, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x06, 0x0E, 0x03, 0x06, 0x01,
  0xC7, 0x00, 0x63, 0x00, 0x3B, 0x80, 0x0D, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE1, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x80, 0x0F, 0x07, 0xFC,
  0x30, 0xE2, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x03, 0xF1, 0xFF, 0x3C, 0x37, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7E, 0x0F, 0x7F, 0xB3, 0xF3, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x87, 0x83, 0x3F, 0xC6, 0xE3, 0x8D, 0x03, 0x9E, 0x03, 0x38,
  0x07, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0xC0, 0x1B, 0x80, 0x37,
  0x00, 0xEE, 0x01, 0xDE, 0x03, 0x36, 0x0E, 0x67, 0xF8, 0xC7, 0xE0, 0x03,
  0xC0, 0xFF, 0x1E, 0x63, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x81, 0x1F, 0xE0, 0xFE, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x0F, 0x1C, 0x7F, 0x39, 0xE3, 0x73, 0x03, 0xEE,
  0x03, 0xD8, 0x07, 0xB0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3B, 0x00, 0x76, 0x01, 0xEE, 0x03, 0xCE, 0x0F, 0x9F, 0xF3, 0x1F,
  0xC6, 0x07, 0x80, 0x7F, 0x83, 0xCF, 0x0C, 0x0C, 0x70, 0x39, 0x80, 0x66,
  0x01, 0xB8, 0x06, 0xE0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x21, 0xFF, 0x83, 0xFC, 0x01, 0xC0, 0xFC, 0x3D, 0x86,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x7F, 0xCF,
  0xF8, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x3F, 0x9C, 0xF1, 0xB9,
  0x81, 0xF7, 0x01, 0xEC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x7B, 0x00, 0xF7, 0x01, 0xE7, 0x05, 0xCF,
  0xFB, 0x87, 0xE7, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x20, 0x1C, 0x7F, 0xF0, 0xFF, 0xC0, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x1E, 0x33, 0xF9, 0xB9, 0xED, 0x03, 0x78, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x71, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0xFB, 0xCC, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x1D, 0x81, 0xCC, 0x0C,
  0x60, 0xE3, 0x06, 0x18, 0x70, 0xC7, 0x06, 0x30, 0x33, 0x81, 0x9C, 0x0D,
  0xF0, 0x79, 0x83, 0xCC, 0x1C, 0x70, 0xC1, 0x86, 0x0E, 0x30, 0x31, 0x81,
  0x8C, 0x0E, 0x60, 0x33, 0x01, 0xD8, 0x06, 0xC0, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x81, 0xE3, 0x3F, 0x8F, 0xED,
  0xCE, 0x73, 0xB4, 0x1F, 0x07, 0xE0, 0x38, 0x0F, 0x80, 0xE0, 0x3E, 0x03,
  0x80, 0xF8, 0x0E, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0,
  0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0x03, 0x86, 0x7F, 0x37, 0x3D, 0xA0, 0x7F, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x07, 0xC0, 0x3F, 0xC0, 0xF1, 0xC1, 0x81, 0xC7, 0x01,
  0xCC, 0x03, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0D, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0D, 0xC0,
  0x19, 0x80, 0x33, 0x00, 0xE7, 0x01, 0x87, 0x07, 0x07, 0xFC, 0x07, 0xF0,
  0x03, 0xC1, 0x9F, 0xE3, 0x71, 0xC6, 0x81, 0xCF, 0x01, 0x9C, 0x03, 0xB8,
  0x03, 0x70, 0x06, 0xE0, 0x0D, 0x80, 0x1B, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x77,
  0x00, 0xED, 0x01, 0x9B, 0x07, 0x33, 0xFC, 0x63, 0xF0, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x07, 0x80, 0x3F, 0x9C, 0xF3, 0xB9, 0xC1, 0xF7,
  0x01, 0xEC, 0x03, 0xD8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1D, 0x80, 0x3B, 0x00, 0xF7, 0x01, 0xE7, 0x05, 0xCF, 0xFB, 0x87,
  0xE7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x03, 0xE7, 0xF3, 0xFB,
  0x0D, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x1F,
  0x87, 0xFD, 0xC3, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0x03, 0xBF, 0xE7, 0xF8, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x83, 0xFF, 0xFF, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x03, 0xF1, 0xF8, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0xF7, 0x0D, 0xBF, 0xCC, 0xFC, 0x60, 0xE0, 0x0D, 0x80, 0x36, 0x01,
  0xDC, 0x06, 0x70, 0x18, 0xC0, 0x63, 0x03, 0x8C, 0x0C, 0x38, 0x30, 0x60,
  0xC1, 0x87, 0x06, 0x18, 0x1C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0E,
  0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x1C, 0x03, 0x60, 0x1C, 0x07, 0x60, 0x3C, 0x07, 0x70, 0x34, 0x06,
  0x30, 0x36, 0x06, 0x30, 0x36, 0x06, 0x30, 0x36, 0x0E, 0x30, 0x66, 0x0C,
  0x38, 0x67, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0x63, 0x1C,
  0x1C, 0xC3, 0x18, 0x1C, 0xC3, 0x98, 0x0C, 0xC1, 0x98, 0x0C, 0xC1, 0xB8,
  0x0C, 0xC1, 0xB0, 0x0F, 0x81, 0xB0, 0x07, 0x81, 0xB0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0xE0, 0x3B, 0x01,
  0x9C, 0x1C, 0x60, 0xC3, 0x86, 0x0C, 0x70, 0x73, 0x01, 0xB8, 0x0D, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x06, 0xC0, 0x37, 0x03, 0x98, 0x18,
  0xE1, 0xC3, 0x0C, 0x18, 0xE0, 0xE6, 0x03, 0x70, 0x1F, 0x00, 0x60, 0xC0,
  0x1F, 0x00, 0x6E, 0x01, 0x98, 0x0E, 0x60, 0x39, 0x80, 0xC7, 0x03, 0x0C,
  0x1C, 0x30, 0x70, 0xC1, 0x83, 0x86, 0x06, 0x38, 0x18, 0xE0, 0x63, 0x01,
  0xCC, 0x03, 0x30, 0x0D, 0xC0, 0x36, 0x00, 0xD8, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x7F,
  0xDF, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x10, 0x1F, 0x03, 0xF0, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x3C, 0x0F, 0x00, 0xF8, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x80,
  0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0x80,
  0xF0, 0x00, 0x1E, 0x01, 0x7F, 0x81, 0xE3, 0xE7, 0x80, 0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 31, 9, 3, -31 },
  { 17, 9, 11, 15, 3, -31 },
  { 30, 18, 31, 19, 1, -31 },
  { 100, 15, 36, 18, 2, -33 },
  { 168, 23, 32, 27, 2, -32 },
  { 260, 18, 32, 19, 1, -32 },
  { 332, 3, 11, 8, 3, -31 },
  { 337, 9, 39, 12, 2, -32 },
  { 381, 8, 39, 12, 2, -32 },
  { 420, 12, 13, 16, 2, -33 },
  { 440, 16, 21, 18, 1, -26 },
  { 482, 4, 11, 9, 2, -5 },
  { 488, 10, 2, 12, 1, -13 },
  { 491, 3, 4, 9, 3, -4 },
  { 493, 14, 32, 15, 1, -32 },
  { 549, 14, 32, 18, 2, -32 },
  { 605, 9, 31, 18, 3, -31 },
  { 640, 14, 32, 18, 2, -32 },
  { 696, 14, 32, 18, 2, -32 },
  { 752, 17, 32, 18, 1, -32 },
  { 820, 14, 31, 18, 2, -31 },
  { 875, 14, 33, 18, 2, -32 },
  { 933, 14, 31, 18, 2, -31 },
  { 988, 15, 32, 18, 2, -32 },
  { 1048, 14, 32, 18, 2, -32 },
  { 1104, 3, 24, 9, 3, -24 },
  { 1113, 5, 30, 9, 2, -24 },
  { 1132, 16, 19, 18, 1, -25 },
  { 1170, 16, 11, 18, 1, -21 },
  { 1192, 16, 19, 18, 1, -25 },
  { 1230, 11, 32, 13, 1, -32 },
  { 1274, 24, 36, 28, 2, -32 },
  { 1382, 18, 31, 18, 0, -31 },
  { 1452, 15, 31, 20, 3, -31 },
  { 1511, 16, 32, 19, 2, -32 },
  { 1575, 16, 31, 22, 3, -31 },
  { 1637, 12, 31, 17, 3, -31 },
  { 1684, 12, 31, 16, 3, -31 },
  { 1731, 19, 32, 23, 2, -32 },
  { 1807, 16, 31, 22, 3, -31 },
  { 1869, 7, 31, 11, 2, -31 },
  { 1897, 8, 39, 9, -2, -31 },
  { 1936, 15, 31, 18, 3, -31 },
  { 1995, 12, 31, 16, 3, -31 },
  { 2042, 24, 31, 30, 3, -31 },
  { 2135, 17, 31, 24, 3, -31 },
  { 2201, 19, 32, 23, 2, -32 },
  { 2277, 14, 31, 18, 3, -31 },
  { 2332, 19, 39, 23, 2, -32 },
  { 2425, 15, 31, 19, 3, -31 },
  { 2484, 14, 32, 18, 2, -32 },
  { 2540, 15, 31, 16, 0, -31 },
  { 2599, 16, 31, 22, 3, -31 },
  { 2661, 18, 31, 18, 0, -31 },
  { 2731, 30, 31, 30, 0, -31 },
  { 2848, 16, 31, 16, 0, -31 },
  { 2910, 16, 31, 16, 0, -31 },
  { 2972, 13, 31, 15, 1, -31 },
  { 3023, 9, 39, 14, 3, -32 },
  { 3067, 14, 32, 15, 1, -32 },
  { 3123, 9, 39, 14, 1, -32 },
  { 3167, 17, 16, 18, 1, -31 },
  { 3201, 18, 2, 18, 0, 4 },
  { 3206, 7, 7, 11, 2, -34 },
  { 3213, 12, 24, 17, 2, -24 },
  { 3249, 15, 33, 19, 3, -33 },
  { 3311, 12, 24, 15, 2, -24 },
  { 3347, 15, 33, 19, 2, -33 },
  { 3409, 14, 24, 18, 2, -24 },
  { 3451, 11, 34, 10, 0, -34 },
  { 3498, 15, 35, 19, 2, -24 },
  { 3564, 13, 33, 19, 3, -33 },
  { 3618, 3, 32, 9, 3, -32 },
  { 3630, 6, 43, 9, 0, -32 },
  { 3663, 13, 33, 16, 3, -33 },
  { 3717, 2, 33, 8, 3, -33 },
  { 3726, 22, 24, 28, 3, -24 },
  { 3792, 13, 24, 19, 3, -24 },
  { 3831, 15, 24, 19, 2, -24 },
  { 3876, 15, 34, 19, 3, -24 },
  { 3940, 15, 34, 19, 2, -24 },
  { 4004, 9, 24, 12, 3, -24 },
  { 4031, 11, 24, 14, 2, -24 },
  { 4064, 9, 29, 10, 1, -29 },
  { 4097, 13, 23, 19, 3, -23 },
  { 4135, 14, 23, 15, 0, -23 },
  { 4176, 24, 23, 25, 0, -23 },
  { 4245, 13, 23, 15, 1, -23 },
  { 4283, 14, 34, 15, 1, -23 },
  { 4343, 10, 23, 12, 1, -23 },
  { 4372, 12, 39, 16, 2, -32 },
  { 4431, 2, 45, 17, 8, -34 },
  { 4443, 12, 39, 16, 2, -32 },
  { 4502, 16, 5, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Light44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT44PT7B_H_
