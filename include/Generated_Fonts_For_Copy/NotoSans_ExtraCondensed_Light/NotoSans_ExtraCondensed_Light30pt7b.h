#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFD, 0x54, 0x0F, 0xC0, 0xCF, 0x3C, 0xF1, 0xC7, 0x18,
  0x40, 0x08, 0xC0, 0x8C, 0x08, 0xC1, 0x88, 0x18, 0x81, 0x08, 0xFF, 0xF1,
  0x08, 0x10, 0x81, 0x18, 0x11, 0x83, 0x18, 0x31, 0x0F, 0xFE, 0x21, 0x02,
  0x10, 0x21, 0x02, 0x30, 0x23, 0x02, 0x30, 0x62, 0x00, 0x04, 0x01, 0x01,
  0xF0, 0xFF, 0x64, 0xB1, 0x0C, 0x43, 0x10, 0xC4, 0x11, 0x07, 0x40, 0xF0,
  0x0F, 0x01, 0xE0, 0x4C, 0x11, 0x04, 0x41, 0x10, 0x46, 0x13, 0xFF, 0x8F,
  0x80, 0x40, 0x10, 0x04, 0x00, 0x10, 0x08, 0x7C, 0x10, 0x44, 0x10, 0x44,
  0x30, 0xC6, 0x20, 0xC6, 0x20, 0xC6, 0x60, 0xC6, 0x40, 0xC6, 0x40, 0xC6,
  0xDE, 0x44, 0x92, 0x45, 0xB3, 0x7D, 0xA1, 0x19, 0x21, 0x03, 0x21, 0x03,
  0x21, 0x02, 0x21, 0x06, 0x21, 0x06, 0x21, 0x04, 0x33, 0x0C, 0x12, 0x0C,
  0x1E, 0x0C, 0x03, 0xE0, 0x23, 0x02, 0x30, 0x23, 0x02, 0x30, 0x23, 0x03,
  0x20, 0x36, 0x01, 0xC0, 0x18, 0x03, 0xC0, 0x64, 0x24, 0x62, 0xC2, 0x6C,
  0x36, 0xC1, 0xCC, 0x1C, 0xC0, 0xCC, 0x1C, 0x63, 0x63, 0xE3, 0xFF, 0xFC,
  0x04, 0x31, 0x84, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x04, 0x10,
  0x41, 0x06, 0x18, 0x60, 0x83, 0x04, 0x18, 0x20, 0x40, 0xC1, 0x06, 0x08,
  0x30, 0x41, 0x86, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x86,
  0x18, 0x43, 0x0C, 0x61, 0x0C, 0x00, 0x08, 0x04, 0x02, 0x1D, 0x37, 0xF0,
  0xE0, 0x58, 0x44, 0x63, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x6D, 0xB5, 0xB0, 0xFF, 0xF0, 0xFC, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x40, 0x60, 0x30, 0x10, 0x18, 0x08, 0x00, 0x0E, 0x07, 0xC3, 0x19, 0x86,
  0x60, 0x90, 0x34, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0D, 0x03, 0x40, 0xD8, 0x26, 0x08, 0x86, 0x33, 0x07, 0x80, 0x0C,
  0x77, 0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x1C, 0x3F, 0xC4, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x0C, 0x1F, 0xCC, 0x18, 0x06,
  0x00, 0x80, 0x30, 0x08, 0x02, 0x01, 0x80, 0xC3, 0xE0, 0xFC, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0xC3, 0xBF, 0x80, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x08,
  0xC1, 0x8C, 0x10, 0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0x60, 0xC4, 0x0C, 0xFF,
  0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x7F, 0x98, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x7E, 0x1F, 0xE0, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1B, 0x0C, 0x7E, 0x00, 0x03,
  0x03, 0xE1, 0x80, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x17, 0xCD,
  0x1B, 0x82, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD0, 0x36, 0x0D, 0x82,
  0x31, 0x87, 0xC0, 0xFF, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x0F, 0xC6, 0x19, 0x03, 0x40,
  0xD0, 0x34, 0x0D, 0x82, 0x21, 0x8E, 0xC0, 0xE0, 0x78, 0x33, 0x98, 0x6C,
  0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x0D, 0x03, 0x71, 0x8F, 0xC0, 0x0C, 0x0F,
  0xC6, 0x19, 0x06, 0xC0, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x34, 0x0D,
  0x87, 0x3E, 0xC7, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x46,
  0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x6D, 0x80, 0x00, 0x00, 0x00, 0xDB,
  0x6B, 0x60, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x02, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x08, 0x00,
  0x18, 0xFE, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x0C, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x10, 0x38, 0x38, 0x01, 0x00,
  0x1F, 0xC0, 0x60, 0x61, 0x80, 0x46, 0x00, 0xC8, 0x00, 0x90, 0x61, 0xE1,
  0xF1, 0x84, 0x63, 0x18, 0xC6, 0x31, 0x0C, 0x42, 0x18, 0x84, 0x31, 0x08,
  0x62, 0x10, 0xC6, 0x61, 0x8C, 0xA7, 0x0F, 0x7B, 0x0C, 0x46, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x08, 0x0F, 0xF0, 0x07, 0x00, 0x06, 0x00, 0x70,
  0x0F, 0x00, 0xD0, 0x09, 0x00, 0x98, 0x19, 0x81, 0x88, 0x18, 0x81, 0x0C,
  0x10, 0xC3, 0x0C, 0x3F, 0xC3, 0x06, 0x20, 0x66, 0x06, 0x60, 0x26, 0x03,
  0x40, 0x3C, 0x03, 0xC0, 0x10, 0xFF, 0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x02, 0xC1, 0xBF, 0x8F, 0xFB, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x1E, 0xFF, 0x00, 0x07, 0x87, 0xF3, 0x05,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x38, 0x43, 0xF0,
  0xFF, 0x18, 0x73, 0x03, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x58,
  0x1B, 0x06, 0x7F, 0x8F, 0xE0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03,
  0xC1, 0xFF, 0x38, 0x16, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x1F, 0x81, 0xF8, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x14, 0x01, 0x60, 0x13, 0x01, 0x3C, 0x70, 0xFF, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x06, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x6F, 0x80, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0x90, 0xC0, 0xF0, 0x6C, 0x1B,
  0x0C, 0xC2, 0x31, 0x8C, 0xC3, 0x30, 0xD8, 0x36, 0x0F, 0x83, 0xB0, 0xC4,
  0x31, 0x8C, 0x23, 0x0C, 0xC1, 0x30, 0x6C, 0x1B, 0x03, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x05, 0xD0, 0x0D, 0xD0, 0x0D, 0xD8, 0x09, 0xD8, 0x09,
  0xC8, 0x19, 0xCC, 0x19, 0xCC, 0x11, 0xC4, 0x31, 0xC4, 0x31, 0xC6, 0x21,
  0xC2, 0x61, 0xC2, 0x61, 0xC3, 0x41, 0xC3, 0x41, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0x81, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xD0, 0x3D, 0x83, 0xC8,
  0x3C, 0xC3, 0xCC, 0x3C, 0x63, 0xC6, 0x3C, 0x23, 0xC3, 0x3C, 0x13, 0xC1,
  0xBC, 0x0B, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x30, 0x06, 0x03,
  0xF8, 0x30, 0xC6, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x60, 0x66, 0x06, 0x39, 0xC1, 0xF8, 0xFE, 0x30, 0xEC, 0x1B, 0x02,
  0xC0, 0xF0, 0x3C, 0x0F, 0x02, 0xC1, 0xB0, 0x6C, 0x73, 0xF8, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03,
  0xF8, 0x30, 0xC6, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x60, 0x66, 0x06, 0x39, 0xC1, 0xF8, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0xFF, 0x30, 0xEC, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F,
  0x02, 0xC1, 0xB0, 0xEF, 0xF3, 0xF0, 0xC6, 0x31, 0x8C, 0x33, 0x0C, 0xC1,
  0x30, 0x6C, 0x0B, 0x03, 0xC0, 0xC0, 0x0F, 0x0F, 0xF6, 0x09, 0x80, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0xE3, 0xBF, 0x80, 0xFF, 0xC1,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0D, 0x83, 0x38, 0xE3, 0xF8, 0xC0, 0x3C, 0x03, 0x40, 0x26, 0x06,
  0x60, 0x66, 0x06, 0x20, 0x43, 0x04, 0x30, 0xC3, 0x0C, 0x10, 0xC1, 0x08,
  0x19, 0x81, 0x98, 0x09, 0x80, 0x90, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x60, 0x34, 0x06, 0x03, 0x40, 0x70, 0x36, 0x07, 0x03,
  0x60, 0xD0, 0x26, 0x0D, 0x06, 0x20, 0xD0, 0x62, 0x09, 0x86, 0x30, 0x98,
  0x63, 0x18, 0x84, 0x31, 0x88, 0xC1, 0x18, 0x8C, 0x11, 0x0C, 0xC1, 0x90,
  0xC8, 0x1B, 0x0C, 0x81, 0xB0, 0x58, 0x0B, 0x05, 0x80, 0xA0, 0x58, 0x0E,
  0x07, 0x00, 0xE0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x64, 0x18, 0xC3, 0x18,
  0xC1, 0x18, 0x32, 0x02, 0xC0, 0x58, 0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xB0, 0x36, 0x04, 0x41, 0x8C, 0x31, 0x84, 0x11, 0x83, 0x30, 0x6C, 0x06,
  0xC0, 0x68, 0x19, 0x83, 0x30, 0x42, 0x18, 0x63, 0x0C, 0x40, 0x98, 0x1B,
  0x03, 0x40, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0x00, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x1F, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xFF, 0xC0, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x18, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x0C,
  0x01, 0xC0, 0x68, 0x0D, 0x83, 0x10, 0x63, 0x18, 0x23, 0x06, 0xC0, 0x58,
  0x0C, 0xFF, 0xF8, 0xC3, 0x0C, 0x20, 0x80, 0x3E, 0x31, 0x80, 0x40, 0x30,
  0x18, 0x0C, 0x06, 0x7F, 0x61, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1D, 0x8E,
  0xFB, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x7C, 0xF3,
  0xB8, 0x6C, 0x0B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x02, 0xE1, 0xBC, 0xE9, 0xF0, 0x1F, 0x31, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x31, 0x1F, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x79, 0x33, 0x58, 0x36, 0x0D,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x0D, 0x83, 0x60,
  0xCC, 0x53, 0xE4, 0x1F, 0x0C, 0xC6, 0x19, 0x82, 0x40, 0xB0, 0x3C, 0x0F,
  0xFF, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x08, 0x7E, 0x0F,
  0x1E, 0x10, 0x30, 0x30, 0x30, 0x30, 0xFC, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1E, 0x4C,
  0x56, 0x0D, 0x83, 0x40, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x05,
  0x03, 0x60, 0xD8, 0x33, 0x34, 0x79, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xD8, 0xE7, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xBE,
  0xF3, 0x70, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x33,
  0x30, 0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x36, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x86, 0xC2,
  0x63, 0x31, 0x19, 0x8D, 0x86, 0xC3, 0xA1, 0xD8, 0xCC, 0x62, 0x31, 0x98,
  0x4C, 0x36, 0x1B, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x9E, 0x3D,
  0x46, 0x8E, 0x86, 0x1E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0,
  0xC1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30,
  0x70, 0x60, 0xE0, 0xC1, 0x9F, 0x59, 0xA8, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x1F, 0x0C,
  0x66, 0x09, 0x83, 0x40, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x05,
  0x03, 0x60, 0xD8, 0x33, 0x18, 0x7C, 0x9F, 0x2C, 0xEA, 0x1B, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xB8, 0x6F,
  0x3B, 0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1E,
  0x4C, 0xD6, 0x0D, 0x83, 0x40, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x05, 0x03, 0x60, 0xD8, 0x33, 0x14, 0x79, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x9E, 0xDA, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x3F, 0x62, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x38,
  0x1C, 0x06, 0x03, 0x03, 0x03, 0x03, 0xC6, 0xFC, 0x21, 0x86, 0x18, 0xFD,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x0F, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x15, 0x9A, 0xF9, 0xC0, 0xD0, 0x24, 0x09, 0x86, 0x61, 0x98,
  0x42, 0x10, 0xCC, 0x33, 0x0C, 0x81, 0x20, 0x58, 0x1E, 0x07, 0x00, 0xC0,
  0x30, 0xC1, 0x81, 0x41, 0xC1, 0x41, 0x43, 0x61, 0x43, 0x61, 0x43, 0x63,
  0x42, 0x23, 0x62, 0x22, 0x66, 0x32, 0x26, 0x32, 0x24, 0x16, 0x34, 0x16,
  0x3C, 0x14, 0x3C, 0x1C, 0x1C, 0x1C, 0x18, 0x0C, 0x18, 0x60, 0xD8, 0x63,
  0x18, 0xCC, 0x13, 0x06, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x81, 0xA0, 0x4C,
  0x31, 0x08, 0x66, 0x1B, 0x03, 0xC0, 0xD0, 0x36, 0x09, 0x82, 0x21, 0x88,
  0x63, 0x10, 0xC4, 0x13, 0x04, 0xC1, 0xA0, 0x68, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x2C, 0x0F, 0x00, 0xFE, 0x0C,
  0x30, 0x60, 0x83, 0x06, 0x08, 0x30, 0x61, 0x83, 0x04, 0x18, 0x30, 0x7F,
  0x07, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30,
  0xE0, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C,
  0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x18,
  0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x07, 0x0E,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0xF0, 0xC0,
  0x78, 0x39, 0xFE, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 6, 7, 10, 2, -21 },
  { 13, 12, 21, 13, 1, -21 },
  { 45, 10, 25, 12, 1, -23 },
  { 77, 16, 22, 19, 1, -22 },
  { 121, 12, 22, 13, 1, -22 },
  { 154, 2, 7, 6, 2, -21 },
  { 156, 6, 27, 8, 1, -22 },
  { 177, 6, 27, 8, 1, -22 },
  { 198, 9, 9, 11, 1, -23 },
  { 209, 11, 14, 12, 1, -18 },
  { 229, 3, 7, 6, 1, -3 },
  { 232, 6, 2, 8, 1, -9 },
  { 234, 2, 3, 6, 2, -3 },
  { 235, 9, 21, 11, 1, -21 },
  { 259, 10, 22, 12, 1, -22 },
  { 287, 6, 21, 12, 2, -21 },
  { 303, 10, 22, 12, 1, -22 },
  { 331, 10, 22, 12, 1, -22 },
  { 359, 12, 22, 12, 0, -22 },
  { 392, 10, 21, 12, 1, -21 },
  { 419, 10, 22, 12, 1, -22 },
  { 447, 10, 21, 12, 1, -21 },
  { 474, 10, 22, 12, 1, -22 },
  { 502, 10, 22, 12, 1, -22 },
  { 530, 2, 16, 6, 2, -16 },
  { 534, 3, 20, 6, 1, -16 },
  { 542, 11, 13, 12, 1, -17 },
  { 560, 11, 7, 12, 1, -14 },
  { 570, 11, 13, 12, 1, -17 },
  { 588, 8, 22, 9, 0, -22 },
  { 610, 15, 25, 19, 2, -22 },
  { 657, 12, 21, 12, 0, -21 },
  { 689, 10, 21, 14, 2, -21 },
  { 716, 10, 22, 13, 2, -22 },
  { 744, 11, 21, 15, 2, -21 },
  { 773, 8, 21, 12, 2, -21 },
  { 794, 8, 21, 11, 2, -21 },
  { 815, 12, 22, 16, 2, -22 },
  { 848, 11, 21, 15, 2, -21 },
  { 877, 5, 21, 8, 1, -21 },
  { 891, 5, 27, 6, -1, -21 },
  { 908, 10, 21, 12, 2, -21 },
  { 935, 8, 21, 11, 2, -21 },
  { 956, 16, 21, 21, 2, -21 },
  { 998, 12, 21, 16, 2, -21 },
  { 1030, 12, 22, 16, 2, -22 },
  { 1063, 10, 21, 13, 2, -21 },
  { 1090, 12, 27, 16, 2, -22 },
  { 1131, 10, 21, 13, 2, -21 },
  { 1158, 10, 22, 12, 1, -22 },
  { 1186, 10, 21, 11, 0, -21 },
  { 1213, 11, 21, 15, 2, -21 },
  { 1242, 12, 21, 12, 0, -21 },
  { 1274, 20, 21, 20, 0, -21 },
  { 1327, 11, 21, 11, 0, -21 },
  { 1356, 11, 21, 11, 0, -21 },
  { 1385, 9, 21, 10, 1, -21 },
  { 1409, 6, 27, 9, 2, -22 },
  { 1430, 9, 21, 10, 1, -21 },
  { 1454, 6, 27, 9, 1, -22 },
  { 1475, 11, 10, 13, 1, -21 },
  { 1489, 13, 1, 12, 0, 3 },
  { 1491, 5, 5, 7, 1, -23 },
  { 1495, 9, 16, 12, 1, -16 },
  { 1513, 10, 23, 13, 2, -23 },
  { 1542, 8, 16, 10, 1, -16 },
  { 1558, 10, 23, 13, 1, -23 },
  { 1587, 10, 16, 12, 1, -16 },
  { 1607, 8, 23, 7, 0, -23 },
  { 1630, 10, 23, 13, 1, -16 },
  { 1659, 9, 23, 13, 2, -23 },
  { 1685, 2, 22, 6, 2, -22 },
  { 1691, 4, 29, 6, 0, -22 },
  { 1706, 9, 23, 11, 2, -23 },
  { 1732, 2, 23, 6, 2, -23 },
  { 1738, 15, 16, 19, 2, -16 },
  { 1768, 9, 16, 13, 2, -16 },
  { 1786, 10, 16, 13, 1, -16 },
  { 1806, 10, 23, 13, 2, -16 },
  { 1835, 10, 23, 13, 1, -16 },
  { 1864, 6, 16, 8, 2, -16 },
  { 1876, 8, 16, 10, 1, -16 },
  { 1892, 6, 20, 7, 1, -20 },
  { 1907, 9, 16, 13, 2, -16 },
  { 1925, 10, 16, 10, 0, -16 },
  { 1945, 16, 16, 17, 0, -16 },
  { 1977, 10, 16, 10, 0, -16 },
  { 1997, 10, 23, 10, 0, -16 },
  { 2026, 7, 16, 8, 1, -16 },
  { 2040, 8, 26, 11, 1, -21 },
  { 2066, 2, 30, 12, 5, -23 },
  { 2074, 8, 26, 11, 1, -21 },
  { 2100, 11, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Light30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT30PT7B_H_
