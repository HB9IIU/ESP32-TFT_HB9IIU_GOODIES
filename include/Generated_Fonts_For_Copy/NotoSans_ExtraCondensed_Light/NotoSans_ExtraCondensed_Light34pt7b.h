#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x92, 0x48, 0x00, 0xFF, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC2, 0x0C, 0x20, 0x61, 0x03, 0x08, 0x18,
  0xC0, 0x86, 0x04, 0x30, 0x21, 0x9F, 0xFF, 0x18, 0x40, 0xC2, 0x06, 0x10,
  0x31, 0x81, 0x0C, 0x08, 0x60, 0x43, 0x1F, 0xFF, 0x10, 0x81, 0x84, 0x0C,
  0x20, 0x61, 0x03, 0x18, 0x10, 0xC0, 0x86, 0x04, 0x30, 0x04, 0x00, 0x40,
  0x06, 0x03, 0xFE, 0x74, 0x66, 0x40, 0xC4, 0x0C, 0x40, 0xC4, 0x0C, 0x40,
  0x64, 0x07, 0x40, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x4E, 0x04, 0x60, 0x43,
  0x04, 0x30, 0x43, 0x04, 0x30, 0x46, 0xC4, 0xEF, 0xFC, 0x1E, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x10, 0x00, 0x07, 0x80, 0x81, 0x98, 0x30, 0x21, 0x04,
  0x04, 0x20, 0x80, 0x86, 0x30, 0x30, 0xC4, 0x06, 0x18, 0x80, 0xC3, 0x30,
  0x08, 0x64, 0x01, 0x0C, 0x8C, 0x21, 0x33, 0xC4, 0x24, 0xCC, 0xCD, 0x90,
  0x8F, 0x32, 0x10, 0x44, 0xC2, 0x01, 0x98, 0x60, 0x33, 0x0C, 0x04, 0x61,
  0x81, 0x8C, 0x30, 0x31, 0x84, 0x04, 0x10, 0x81, 0x82, 0x30, 0x30, 0x66,
  0x04, 0x07, 0x80, 0x04, 0x00, 0x7C, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x6C, 0x01, 0xB0, 0x03, 0x80,
  0x1C, 0x00, 0xD8, 0x06, 0x61, 0x98, 0xC6, 0xC1, 0x9B, 0x06, 0x4C, 0x0F,
  0x30, 0x3C, 0xC0, 0x63, 0x03, 0xC6, 0x0F, 0x1C, 0xE6, 0x3F, 0x1C, 0xFF,
  0xFF, 0xC0, 0x0C, 0x61, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x30, 0xC1, 0x06, 0x0C,
  0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x60, 0xC3,
  0x0E, 0x00, 0x0C, 0x03, 0x00, 0x41, 0x11, 0xFF, 0xC3, 0x80, 0xE0, 0x6C,
  0x31, 0x18, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x33, 0x36, 0x66, 0x4C, 0xFF, 0xFC, 0xFF, 0x80, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0x02, 0x03, 0xF0, 0xE7, 0x18, 0x66, 0x06,
  0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x50, 0x0A, 0x01, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0x60, 0x8C,
  0x30, 0xFC, 0x0F, 0x00, 0x06, 0x1C, 0x7B, 0xBE, 0x68, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0C, 0x07, 0xF1, 0x87, 0x20, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0xFF, 0xFF, 0xE0,
  0x0C, 0x0F, 0xF3, 0x87, 0x20, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x07, 0x03, 0x81, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x37, 0x9E, 0x7F, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x05, 0x80, 0x6C, 0x03, 0x60, 0x33, 0x01, 0x98,
  0x08, 0xC0, 0xC6, 0x04, 0x30, 0x61, 0x82, 0x0C, 0x30, 0x61, 0x03, 0x18,
  0x18, 0x80, 0xC7, 0xFF, 0xC0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x7F, 0x88, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1B, 0x83, 0xFC, 0x41, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x02,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0D, 0x03, 0x39, 0xC7, 0xF0, 0x03,
  0x03, 0xF0, 0xE1, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x7C, 0x5F, 0xCA, 0x1D, 0x81, 0xB0, 0x36, 0x02, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x2C, 0x0D, 0x81, 0x98, 0x33, 0x9C, 0x3F, 0x00, 0xFF, 0xF0,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x06, 0x01,
  0xF8, 0x30, 0xC6, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x63,
  0x0C, 0x19, 0x80, 0xF0, 0x0F, 0x01, 0xB8, 0x30, 0xC6, 0x06, 0x60, 0x6C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x60, 0x63, 0x9C, 0x1F, 0x80,
  0x06, 0x03, 0xF0, 0xC7, 0x30, 0x66, 0x04, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xB0, 0x36, 0x06, 0xE1, 0xCF, 0xD8, 0xF3, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x62, 0x38, 0x7E, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0x36, 0x66, 0x4C, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x10,
  0xFE, 0x86, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x30, 0x30, 0x30,
  0x07, 0xF8, 0x03, 0x83, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18,
  0x00, 0x66, 0x0E, 0x19, 0x07, 0xC2, 0xC3, 0x10, 0xB1, 0x84, 0x3C, 0x63,
  0x0E, 0x18, 0xC3, 0x84, 0x30, 0xE1, 0x0C, 0x38, 0x43, 0x0E, 0x10, 0xC2,
  0x86, 0x30, 0xB1, 0x8C, 0x6C, 0x35, 0xB3, 0x0F, 0x3C, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x08, 0x03, 0xDE, 0x00, 0x3E,
  0x00, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x04, 0x80, 0x33, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0x40, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60,
  0x40, 0xC3, 0xFF, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x46, 0x01, 0x98, 0x06,
  0x60, 0x19, 0x80, 0x2C, 0x00, 0xF0, 0x03, 0xFF, 0x10, 0xF2, 0x03, 0x40,
  0x68, 0x07, 0x00, 0xE0, 0x1C, 0x06, 0x80, 0xD0, 0x3B, 0xFE, 0x7F, 0x88,
  0x1D, 0x01, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xBF, 0xE7, 0xF8, 0x01, 0x80, 0xFF, 0x1C, 0x23, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xE7, 0x0F, 0xE0, 0xFF, 0x08, 0xF8, 0x81, 0xC8, 0x0E,
  0x80, 0x68, 0x06, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x06, 0x80, 0x68, 0x06,
  0x80, 0xC8, 0x1C, 0xFF, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xDF, 0xE8, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xEF, 0xF4,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x00, 0xC0, 0x3F, 0xE1, 0xC1, 0xCE, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x03, 0x60,
  0x0C, 0xC0, 0x33, 0x80, 0xC7, 0xCF, 0x07, 0xF8, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x3F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC3, 0xFF,
  0xE0, 0x80, 0xF0, 0x1A, 0x06, 0x40, 0xC8, 0x31, 0x0C, 0x21, 0x84, 0x60,
  0x8C, 0x13, 0x02, 0x60, 0x5C, 0x0E, 0xC1, 0x98, 0x31, 0x84, 0x30, 0x83,
  0x10, 0x62, 0x0E, 0x40, 0xC8, 0x19, 0x01, 0xA0, 0x34, 0x03, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x80, 0x0F, 0xB0, 0x02, 0xEC, 0x01, 0xB9,
  0x00, 0x6E, 0x60, 0x13, 0x98, 0x0C, 0xE6, 0x03, 0x38, 0x80, 0xCE, 0x30,
  0x23, 0x8C, 0x18, 0xE1, 0x06, 0x38, 0x61, 0x0E, 0x18, 0xC3, 0x86, 0x30,
  0xE0, 0xCC, 0x38, 0x36, 0x0E, 0x0D, 0x83, 0x81, 0x60, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x40, 0x3B, 0x01,
  0xC8, 0x0E, 0x60, 0x73, 0x03, 0x8C, 0x1C, 0x60, 0xE1, 0x87, 0x0C, 0x38,
  0x21, 0xC1, 0x8E, 0x0C, 0x70, 0x33, 0x81, 0x9C, 0x06, 0xE0, 0x37, 0x00,
  0xB8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x03, 0x00, 0x7F, 0x83, 0x87,
  0x0C, 0x0C, 0x60, 0x19, 0x80, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x03, 0x60, 0x19, 0x80, 0x63, 0x03, 0x07,
  0x38, 0x0F, 0xC0, 0xFE, 0x23, 0xE8, 0x1A, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x1E, 0x06, 0xFF, 0x3F, 0x88, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0x00, 0x7F,
  0x83, 0x87, 0x0C, 0x0C, 0x60, 0x19, 0x80, 0x6C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x03, 0x60, 0x19, 0x80, 0x63,
  0x03, 0x07, 0x38, 0x0F, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0xFE, 0x11, 0xF2, 0x06, 0x40, 0x68, 0x0D, 0x01,
  0xA0, 0x34, 0x06, 0x80, 0xD0, 0x1A, 0x06, 0x41, 0xCF, 0xE1, 0x18, 0x21,
  0x84, 0x30, 0x83, 0x10, 0x62, 0x06, 0x40, 0xC8, 0x0D, 0x01, 0xA0, 0x34,
  0x03, 0x06, 0x03, 0xFC, 0xE1, 0xB0, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x37, 0xFE, 0x7F, 0x00,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x36, 0x03, 0x38, 0x18,
  0xF3, 0x83, 0xF8, 0xC0, 0x0F, 0x00, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19,
  0x80, 0xC2, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x81, 0x06, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0xD8,
  0x01, 0x60, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0, 0xC0, 0x18, 0x06,
  0x80, 0x70, 0x0D, 0x80, 0xE0, 0x1B, 0x01, 0x40, 0x66, 0x02, 0x80, 0xCC,
  0x05, 0x81, 0x88, 0x1B, 0x03, 0x18, 0x36, 0x04, 0x30, 0x64, 0x18, 0x60,
  0x88, 0x30, 0xC1, 0x18, 0x60, 0x86, 0x30, 0xC1, 0x8C, 0x63, 0x03, 0x18,
  0x46, 0x06, 0x20, 0x8C, 0x0C, 0x41, 0x98, 0x0D, 0x83, 0x30, 0x1B, 0x06,
  0xC0, 0x36, 0x05, 0x80, 0x68, 0x0B, 0x00, 0x50, 0x16, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0x60, 0x60, 0x33, 0x06, 0x30, 0x63, 0x06,
  0x18, 0xC1, 0x8C, 0x08, 0x80, 0xD8, 0x0D, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x50, 0x0D, 0x80, 0xD8, 0x18, 0x81, 0x8C, 0x10, 0xC3, 0x06,
  0x30, 0x66, 0x06, 0x60, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x60, 0x66, 0x06,
  0x30, 0x43, 0x0C, 0x30, 0xC1, 0x88, 0x19, 0x81, 0x98, 0x09, 0x00, 0xF0,
  0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0F, 0xFF, 0xFF,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1B,
  0x01, 0x98, 0x0C, 0x60, 0xC3, 0x06, 0x0C, 0x60, 0x63, 0x01, 0xB0, 0x0D,
  0x80, 0x30, 0xFF, 0xFC, 0xE1, 0x83, 0x06, 0x0C, 0x7F, 0x8C, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0F, 0x1F, 0xDC, 0x36, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0D, 0x87, 0x63, 0x4F, 0x90, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x8D, 0x9C, 0xE0, 0xEE,
  0x06, 0xE0, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x02, 0xC0, 0x6E, 0x06, 0xE0, 0x6F, 0x0C, 0xD9, 0xCC, 0xF8, 0x1F, 0xB8,
  0x98, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x71, 0x1F, 0x80, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x1F, 0x33, 0x9B, 0x30, 0x76,
  0x07, 0x60, 0x36, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x73, 0x07, 0x39, 0xB1, 0xF3, 0x3F, 0x1C,
  0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x81, 0x71, 0x87, 0xE0, 0x0F, 0x8F, 0x86,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0xFE, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1F, 0xB3, 0x8B, 0x30, 0x76, 0x07, 0x60, 0x36, 0x03,
  0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34, 0x03, 0x60, 0x36, 0x07,
  0x60, 0x73, 0x07, 0x39, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x64, 0x06, 0x7F, 0xC3, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xCF, 0xB6, 0x7E, 0x0F, 0x83, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x10, 0xDF, 0x00, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xC0, 0x11, 0xCC, 0x00, 0x00, 0x06, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xDE, 0xE0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0xF0, 0x6C, 0x33,
  0x0C, 0xC6, 0x33, 0x0C, 0xC3, 0x70, 0xDC, 0x39, 0x8E, 0x63, 0x08, 0xC3,
  0x30, 0xCC, 0x1B, 0x06, 0xC0, 0xF0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xDF, 0x1F, 0x34, 0xEC, 0xEE, 0x0A, 0x1B, 0x83, 0x03, 0xC0,
  0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F,
  0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x30, 0xCF, 0xB6, 0x7E, 0x0F, 0x83,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x10, 0x1F, 0x83, 0x8C, 0x30, 0x66, 0x06,
  0x60, 0x26, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34, 0x03,
  0x60, 0x36, 0x02, 0x60, 0x63, 0x06, 0x39, 0xC1, 0xF8, 0xCF, 0x8D, 0x9C,
  0xF0, 0x6E, 0x06, 0xE0, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x6E, 0x06, 0xE0, 0x6F, 0x0C, 0xD9, 0xCC, 0xF8,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x1F, 0x33, 0x9B, 0x30, 0x76, 0x07, 0x60, 0x36, 0x03, 0x40, 0x34, 0x03,
  0xC0, 0x3C, 0x03, 0x40, 0x34, 0x03, 0x60, 0x36, 0x03, 0x60, 0x73, 0x07,
  0x39, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0xCF, 0xBF, 0xC7, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x3F, 0xB8, 0xB0, 0x18, 0x0C,
  0x06, 0x01, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x07,
  0x03, 0xE7, 0x3F, 0x00, 0x20, 0x82, 0x18, 0xFD, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x34, 0xF0, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0D, 0x85, 0x73, 0x4F, 0x90, 0xC0, 0x68, 0x0D, 0x81,
  0xB0, 0x66, 0x0C, 0x41, 0x8C, 0x31, 0x8C, 0x31, 0x82, 0x30, 0x46, 0x0C,
  0x81, 0xB0, 0x36, 0x02, 0xC0, 0x50, 0x0E, 0x01, 0xC0, 0xC0, 0xE0, 0x68,
  0x1C, 0x09, 0x83, 0x83, 0x30, 0x50, 0x66, 0x0B, 0x0C, 0x43, 0x61, 0x0C,
  0x6C, 0x61, 0x8C, 0x8C, 0x31, 0x11, 0x86, 0x63, 0x30, 0x4C, 0x64, 0x0D,
  0x8D, 0x81, 0xB0, 0xB0, 0x34, 0x16, 0x02, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0x80, 0xC0, 0xC0, 0xD8, 0x66, 0x19, 0x8C, 0x33, 0x0C, 0x81,
  0xE0, 0x78, 0x0C, 0x07, 0x01, 0xE0, 0x58, 0x33, 0x08, 0xC6, 0x19, 0x86,
  0xC0, 0xF0, 0x30, 0xC0, 0x6C, 0x0D, 0x81, 0xB0, 0x32, 0x0C, 0x61, 0x8C,
  0x31, 0x86, 0x11, 0x83, 0x30, 0x66, 0x0C, 0x80, 0x90, 0x1E, 0x03, 0xC0,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0xF8, 0x1E, 0x00, 0xFF, 0xFF, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0x07, 0x0E, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xC0,
  0x70, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x70, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0E, 0x03, 0x0E, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0xE0, 0x38, 0x1F, 0xE1, 0x87, 0xF8, 0x0C,
};

const GFXglyph NotoSans_ExtraCondensed_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 24, 7, 2, -24 },
  { 10, 7, 9, 11, 2, -24 },
  { 18, 13, 24, 15, 1, -24 },
  { 57, 12, 28, 14, 1, -26 },
  { 99, 19, 25, 21, 1, -25 },
  { 159, 14, 25, 15, 1, -25 },
  { 203, 2, 9, 6, 2, -24 },
  { 206, 6, 29, 9, 2, -24 },
  { 228, 7, 29, 9, 1, -24 },
  { 254, 10, 10, 13, 1, -26 },
  { 267, 12, 16, 14, 1, -20 },
  { 291, 4, 8, 7, 1, -4 },
  { 295, 7, 2, 9, 1, -10 },
  { 297, 3, 3, 7, 2, -3 },
  { 299, 10, 24, 12, 1, -24 },
  { 329, 11, 25, 14, 1, -25 },
  { 364, 7, 24, 14, 2, -24 },
  { 385, 11, 25, 14, 1, -25 },
  { 420, 11, 25, 14, 1, -25 },
  { 455, 13, 24, 14, 1, -24 },
  { 494, 11, 24, 14, 2, -24 },
  { 527, 11, 25, 14, 2, -25 },
  { 562, 12, 24, 14, 1, -24 },
  { 598, 12, 25, 14, 1, -25 },
  { 636, 11, 25, 14, 1, -25 },
  { 671, 3, 18, 7, 2, -18 },
  { 678, 4, 22, 7, 1, -18 },
  { 689, 12, 14, 14, 1, -19 },
  { 710, 12, 8, 14, 1, -16 },
  { 722, 12, 14, 14, 1, -19 },
  { 743, 8, 25, 10, 1, -25 },
  { 768, 18, 27, 21, 2, -24 },
  { 829, 14, 24, 14, 0, -24 },
  { 871, 11, 24, 15, 3, -24 },
  { 904, 12, 25, 15, 2, -25 },
  { 942, 12, 24, 17, 3, -24 },
  { 978, 9, 24, 13, 3, -24 },
  { 1005, 9, 24, 12, 3, -24 },
  { 1032, 14, 25, 18, 2, -25 },
  { 1076, 12, 24, 17, 3, -24 },
  { 1112, 6, 24, 9, 1, -24 },
  { 1130, 6, 30, 7, -2, -24 },
  { 1153, 11, 24, 14, 3, -24 },
  { 1186, 8, 24, 12, 3, -24 },
  { 1210, 18, 24, 23, 3, -24 },
  { 1264, 13, 24, 18, 3, -24 },
  { 1303, 14, 25, 18, 2, -25 },
  { 1347, 10, 24, 14, 3, -24 },
  { 1377, 14, 31, 18, 2, -25 },
  { 1432, 11, 24, 15, 3, -24 },
  { 1465, 11, 25, 14, 1, -25 },
  { 1500, 12, 24, 12, 0, -24 },
  { 1536, 13, 24, 17, 2, -24 },
  { 1575, 14, 24, 14, 0, -24 },
  { 1617, 23, 24, 23, 0, -24 },
  { 1686, 12, 24, 12, 0, -24 },
  { 1722, 12, 24, 12, 0, -24 },
  { 1758, 10, 24, 12, 1, -24 },
  { 1788, 6, 29, 11, 3, -24 },
  { 1810, 10, 24, 12, 1, -24 },
  { 1840, 7, 29, 11, 1, -24 },
  { 1866, 13, 12, 14, 1, -24 },
  { 1886, 14, 1, 14, 0, 3 },
  { 1888, 6, 5, 8, 1, -26 },
  { 1892, 10, 18, 13, 1, -18 },
  { 1915, 12, 26, 15, 2, -26 },
  { 1954, 9, 18, 11, 2, -18 },
  { 1975, 12, 26, 15, 1, -26 },
  { 2014, 10, 18, 14, 2, -18 },
  { 2037, 9, 26, 8, 0, -26 },
  { 2067, 12, 26, 15, 1, -18 },
  { 2106, 10, 26, 15, 2, -26 },
  { 2139, 3, 25, 7, 2, -25 },
  { 2149, 5, 33, 7, 0, -25 },
  { 2170, 10, 26, 12, 2, -26 },
  { 2203, 2, 26, 6, 2, -26 },
  { 2210, 18, 18, 22, 2, -18 },
  { 2251, 10, 18, 15, 2, -18 },
  { 2274, 12, 18, 14, 1, -18 },
  { 2301, 12, 26, 15, 2, -18 },
  { 2340, 12, 26, 15, 1, -18 },
  { 2379, 7, 18, 10, 2, -18 },
  { 2395, 9, 18, 11, 1, -18 },
  { 2416, 6, 22, 8, 1, -22 },
  { 2433, 10, 18, 15, 2, -18 },
  { 2456, 11, 18, 11, 0, -18 },
  { 2481, 19, 18, 19, 0, -18 },
  { 2524, 10, 18, 12, 1, -18 },
  { 2547, 11, 26, 12, 0, -18 },
  { 2583, 8, 18, 10, 1, -18 },
  { 2601, 8, 29, 12, 2, -24 },
  { 2630, 2, 34, 13, 6, -26 },
  { 2639, 8, 29, 12, 2, -24 },
  { 2668, 12, 4, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Light34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT34PT7B_H_
