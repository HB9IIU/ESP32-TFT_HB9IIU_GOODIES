#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x76, 0x66, 0x66, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x60, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x03,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xF9, 0xF1,
  0xC7, 0x04, 0x70, 0xE0, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x00, 0xE3, 0x80, 0x1F, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1C, 0xF0, 0x03, 0x8F, 0x00,
  0x70, 0xF0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x18, 0x07, 0x03, 0x00,
  0xE0, 0x60, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xF8, 0x0E, 0x1D, 0xE1,
  0xCF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x07,
  0x00, 0x3F, 0x80, 0x0C, 0x00, 0xE3, 0x80, 0x38, 0x01, 0x83, 0x00, 0x70,
  0x07, 0x07, 0x00, 0xC0, 0x0E, 0x0E, 0x03, 0x80, 0x1C, 0x0C, 0x07, 0x00,
  0x30, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x38, 0x00, 0xC0, 0x60, 0x70, 0x03,
  0x80, 0xE0, 0xC0, 0x07, 0x01, 0xC3, 0x80, 0x0E, 0x03, 0x87, 0x00, 0x1C,
  0x07, 0x0C, 0x00, 0x38, 0x0E, 0x38, 0x00, 0x30, 0x18, 0x70, 0x00, 0x60,
  0x30, 0xC1, 0xE0, 0xC0, 0x63, 0x8F, 0xE1, 0xC0, 0xC7, 0x1C, 0xE3, 0x83,
  0x8C, 0x70, 0xC7, 0x07, 0x38, 0xC1, 0xC6, 0x0C, 0x73, 0x83, 0x8E, 0x38,
  0xC7, 0x03, 0x0F, 0xE3, 0x8E, 0x06, 0x0F, 0x87, 0x18, 0x0E, 0x00, 0x0C,
  0x30, 0x1C, 0x00, 0x38, 0x60, 0x38, 0x00, 0x70, 0xC0, 0x70, 0x00, 0xC1,
  0x80, 0xE0, 0x03, 0x83, 0x01, 0xC0, 0x07, 0x06, 0x03, 0x80, 0x0C, 0x0C,
  0x07, 0x00, 0x38, 0x18, 0x0E, 0x00, 0x70, 0x38, 0x1C, 0x00, 0xC0, 0x70,
  0x30, 0x03, 0x80, 0xE0, 0x60, 0x07, 0x00, 0xC1, 0xC0, 0x0C, 0x01, 0xC3,
  0x80, 0x38, 0x03, 0x8E, 0x00, 0x70, 0x03, 0xFC, 0x01, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x70, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07,
  0x9C, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x38,
  0x1C, 0x70, 0x38, 0x38, 0xE0, 0x70, 0x73, 0x80, 0x70, 0xE7, 0x00, 0xE1,
  0xCE, 0x00, 0xE7, 0x1C, 0x01, 0xEE, 0x38, 0x01, 0xDC, 0x70, 0x01, 0xF0,
  0xE0, 0x03, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07,
  0x00, 0x77, 0x0F, 0x01, 0xEF, 0x0F, 0x9F, 0x8E, 0x0F, 0xFE, 0x1E, 0x0F,
  0xF0, 0x1E, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x03, 0x0E, 0x19, 0xF3, 0x7D, 0xFF, 0xFF, 0x07, 0xF0,
  0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xF0,
  0x78, 0x30, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x71, 0xCF, 0x38,
  0xE3, 0x8E, 0x71, 0xC7, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x70, 0x78, 0x38, 0x0E, 0x0E, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1E, 0x70, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x07,
  0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x0F,
  0x83, 0xF0, 0xFE, 0x3D, 0xCF, 0x3B, 0xC7, 0xF0, 0xEC, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xFC,
  0x3C, 0x07, 0x82, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x78, 0x07, 0x86, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x79, 0x80,
  0x1F, 0x3E, 0x0F, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80,
  0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE1, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xC0,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x20, 0x07, 0x8F, 0x0F, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE3, 0xF8, 0x39, 0xFF, 0x8E, 0xFF, 0xF3, 0xF0, 0x3C,
  0xF8, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x0E,
  0x38, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1E,
  0x03, 0xC3, 0x80, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80, 0x1C, 0x70,
  0x07, 0x8F, 0x00, 0xE0, 0xF0, 0x3C, 0x0F, 0x0F, 0x00, 0xF7, 0xC0, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0x7C, 0x03, 0x83, 0xC0, 0xE0,
  0x3C, 0x38, 0x03, 0x8F, 0x00, 0x39, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1C, 0x78, 0x07, 0x8F, 0xC3,
  0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xF8, 0x1E, 0x07, 0x83, 0x80, 0x70, 0xF0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xF0, 0x01,
  0xEE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x01, 0xF7, 0x80, 0x3E, 0x78, 0x0D,
  0x8F, 0x87, 0x70, 0xFF, 0xEE, 0x0F, 0xF1, 0xC0, 0x78, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x0C, 0x3F, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xE0, 0x00,
  0x4F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xCF, 0x3C, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71,
  0xCF, 0x3C, 0xF3, 0x8E, 0x39, 0xC7, 0x1C, 0x63, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xC3, 0xFF, 0xCF, 0xFF, 0x90, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x20, 0x0E, 0x30, 0x07, 0xF8, 0x39,
  0xC0, 0x7F, 0xE0, 0x67, 0x01, 0xC3, 0x81, 0xD8, 0x0E, 0x0E, 0x07, 0x60,
  0x30, 0x38, 0x1F, 0x81, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0x81, 0xF8, 0x18,
  0x0E, 0x07, 0xE0, 0x60, 0x38, 0x1F, 0x83, 0x80, 0xE0, 0x7E, 0x0E, 0x03,
  0x81, 0xF8, 0x38, 0x0E, 0x07, 0xE0, 0xE0, 0x30, 0x1F, 0x83, 0x81, 0xC0,
  0x7E, 0x0E, 0x07, 0x01, 0xF8, 0x38, 0x1C, 0x06, 0xE0, 0x60, 0x70, 0x1B,
  0x81, 0xC1, 0x60, 0xEE, 0x07, 0x0D, 0x83, 0xB8, 0x0E, 0x37, 0x1C, 0x60,
  0x3F, 0x8F, 0xE1, 0xC0, 0x7E, 0x3F, 0x07, 0x00, 0x40, 0x10, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC7, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x83,
  0x80, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0E, 0x00, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x01,
  0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0,
  0x03, 0x8E, 0x00, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0E,
  0x00, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00,
  0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x02,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x01, 0x03, 0xF1, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xC0, 0x7E, 0x0E, 0x00, 0x78,
  0x70, 0x01, 0xE3, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0xE0, 0x00, 0xF7, 0x00,
  0x07, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1E, 0xE0,
  0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x79, 0xC0, 0x07, 0x8E, 0x00, 0x78,
  0x70, 0x0F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x0E, 0x0F, 0x80, 0x02, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x78, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x3C, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x07, 0xC0,
  0x07, 0x03, 0xF8, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0xFF, 0xFF, 0xF3, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0xEF,
  0x9F, 0xF3, 0xFC, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE,
  0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0,
  0xE0, 0x1C, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0x70,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x38,
  0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xEF, 0xC0, 0x0E, 0xDC, 0x00, 0xF9,
  0xE0, 0x0F, 0x8E, 0x00, 0xF0, 0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x78, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0,
  0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x3B, 0xF7, 0x00, 0x00, 0x77, 0xEE,
  0x00, 0x00, 0xEF, 0xCE, 0x00, 0x01, 0x9F, 0x9C, 0x00, 0x07, 0x3F, 0x38,
  0x00, 0x0E, 0x7E, 0x30, 0x00, 0x1C, 0xFC, 0x70, 0x00, 0x71, 0xF8, 0xE0,
  0x00, 0xE3, 0xF1, 0xC0, 0x01, 0xC7, 0xE1, 0xC0, 0x07, 0x0F, 0xC3, 0x80,
  0x0E, 0x1F, 0x87, 0x00, 0x1C, 0x3F, 0x06, 0x00, 0x30, 0x7E, 0x0E, 0x00,
  0xE0, 0xFC, 0x1C, 0x01, 0xC1, 0xF8, 0x38, 0x03, 0x83, 0xF0, 0x38, 0x0E,
  0x07, 0xE0, 0x70, 0x1C, 0x0F, 0xC0, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x60,
  0x3F, 0x01, 0xC1, 0xC0, 0x7E, 0x03, 0x83, 0x80, 0xFC, 0x03, 0x07, 0x01,
  0xF8, 0x07, 0x1C, 0x03, 0xF0, 0x0E, 0x38, 0x07, 0xE0, 0x1C, 0x70, 0x0F,
  0xC0, 0x1D, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x77, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7E,
  0xE0, 0x01, 0xFB, 0x80, 0x07, 0xE7, 0x00, 0x1F, 0x9C, 0x00, 0x7E, 0x78,
  0x01, 0xF8, 0xE0, 0x07, 0xE3, 0x80, 0x1F, 0x87, 0x00, 0x7E, 0x1C, 0x01,
  0xF8, 0x38, 0x07, 0xE0, 0xE0, 0x1F, 0x83, 0xC0, 0x7E, 0x07, 0x01, 0xF8,
  0x1C, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x01, 0xC1, 0xF8, 0x07,
  0x07, 0xE0, 0x1E, 0x1F, 0x80, 0x38, 0x7E, 0x00, 0xF1, 0xF8, 0x01, 0xC7,
  0xE0, 0x07, 0x1F, 0x80, 0x0E, 0x7E, 0x00, 0x39, 0xF8, 0x00, 0xF7, 0xE0,
  0x01, 0xDF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0xF0,
  0x1E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE3, 0x80, 0xFC, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00,
  0x7B, 0x80, 0x1E, 0xE0, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xE3, 0xF0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0E, 0x03, 0xF0, 0xE0, 0x0F,
  0x0E, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8E,
  0x01, 0xF0, 0xE0, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x1C,
  0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x00, 0xC3, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x79, 0x80,
  0x1F, 0x3F, 0x9F, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x01, 0xE7,
  0x80, 0x0E, 0x1E, 0x00, 0xF0, 0x7E, 0x3F, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0x7B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9E, 0x00, 0x0F,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xF0, 0x01, 0xE0,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x3C,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xE0, 0x00, 0xE7, 0x00, 0x07,
  0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x80, 0x07, 0x8E, 0x00, 0x1B, 0x00, 0x0E,
  0x1C, 0x00, 0x36, 0x00, 0x1C, 0x38, 0x00, 0xEE, 0x00, 0x38, 0x70, 0x01,
  0xDC, 0x00, 0x70, 0xF0, 0x03, 0xB8, 0x01, 0xE0, 0xE0, 0x07, 0x70, 0x03,
  0x81, 0xC0, 0x0C, 0x60, 0x07, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x07, 0x00,
  0x71, 0xC0, 0x1C, 0x0F, 0x00, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0x00,
  0xE0, 0x1C, 0x03, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x70,
  0x38, 0x01, 0xC0, 0xC0, 0x60, 0x70, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x07,
  0x07, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x07,
  0x0E, 0x00, 0x1C, 0x30, 0x06, 0x1C, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x1C, 0xF0, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x01, 0xCC, 0x00, 0x67, 0x00, 0x03, 0xB8, 0x00, 0xCE, 0x00,
  0x07, 0x70, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xEE, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x38, 0x07,
  0x07, 0x00, 0xE0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x71, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xB8, 0x00, 0x73, 0x80,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xF0, 0xE0, 0x0E, 0x1C, 0x01, 0xC7,
  0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x78, 0x00,
  0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0xC0, 0x1C, 0x1C, 0x03, 0x81, 0xC0,
  0x38, 0x1E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x83, 0x03, 0xC1, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFC,
  0x1F, 0xFE, 0x3F, 0xE7, 0x3E, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xDC, 0x03, 0xEE, 0x03, 0x77, 0xC3, 0xB9, 0xFF, 0x9C, 0x7F, 0x8E,
  0x04, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x0F, 0x81, 0xC7, 0xF8, 0x39,
  0xFF, 0xC7, 0x70, 0x78, 0xFC, 0x07, 0x9F, 0x00, 0x73, 0xC0, 0x0F, 0x78,
  0x00, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80,
  0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0x3E, 0x00, 0xE7, 0x60,
  0x3C, 0xEF, 0x1F, 0x1C, 0xFF, 0xC3, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0x01,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xF0, 0x23, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x03, 0xE1, 0xC3, 0xFE, 0x71, 0xFF, 0xDC, 0xF0, 0x37, 0x38,
  0x07, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xDC, 0x00,
  0xF7, 0x80, 0x6C, 0xE0, 0x1B, 0x3E, 0x1C, 0xC7, 0xFE, 0x30, 0xFF, 0x0C,
  0x02, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC3, 0x80,
  0xE3, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x21, 0xF0, 0x70, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0xC0, 0x00, 0x60,
  0x0F, 0xF0, 0x7F, 0x83, 0xC2, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x0F, 0xFE,
  0x3F, 0xF8, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x31, 0xFF, 0xCC, 0xF0, 0x33,
  0x38, 0x06, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xDC,
  0x00, 0xF7, 0x80, 0x7C, 0xE0, 0x3F, 0x3E, 0x1D, 0xC7, 0xFE, 0x70, 0xFF,
  0x1C, 0x02, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x40, 0x07, 0x9C,
  0x07, 0xC7, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x1F,
  0x07, 0x1F, 0xE3, 0x9F, 0xF9, 0xDC, 0x3E, 0xFC, 0x07, 0x7C, 0x03, 0xBC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x6E, 0xFF, 0xE4, 0x00, 0x00, 0x00, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0x06, 0x0E, 0x0F, 0x0F, 0x0E, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x9C, 0xFC, 0xF8, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0xC0, 0xE3, 0x80, 0xE7, 0x80,
  0xE7, 0x80, 0xEF, 0xC0, 0xFD, 0xC0, 0xF9, 0xC0, 0xF8, 0xE0, 0xF0, 0xE0,
  0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x3C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0x86, 0x3F, 0xC1, 0xFE,
  0x33, 0xFF, 0x1F, 0xF9, 0x98, 0x3C, 0xC1, 0xEF, 0x80, 0xEC, 0x07, 0x78,
  0x07, 0x40, 0x3F, 0xC0, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xE0, 0x07,
  0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00,
  0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC,
  0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01,
  0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80,
  0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F,
  0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00,
  0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xF0,
  0x61, 0xFE, 0x31, 0xFF, 0x99, 0xC1, 0xEF, 0xC0, 0x77, 0xC0, 0x3B, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0E, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1E,
  0x07, 0x83, 0x80, 0x78, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x0E, 0xE0,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xE0, 0x1E, 0x1E, 0x03, 0x81, 0xE1,
  0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x18, 0x7F,
  0x83, 0x1F, 0xF8, 0x67, 0x07, 0x8E, 0xC0, 0x79, 0xF0, 0x07, 0x3C, 0x00,
  0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x03, 0xDF, 0x00, 0x73, 0xE0, 0x0E,
  0x76, 0x03, 0xCE, 0xF1, 0xF1, 0xCF, 0xFC, 0x38, 0xFF, 0x07, 0x02, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x31, 0xFF, 0xCC,
  0xF8, 0x73, 0x38, 0x06, 0xDE, 0x00, 0xB7, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x03, 0xDC, 0x00, 0xF7, 0x80, 0x7C, 0xF0, 0x3F, 0x3E, 0x1D, 0xC7, 0xFE,
  0x70, 0xFF, 0x1C, 0x02, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x01, 0xFC, 0x3E, 0xC7,
  0xEC, 0xF2, 0xEC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xFC, 0xFF,
  0xF3, 0xC0, 0x67, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x76, 0x01, 0xEF,
  0x0F, 0x9F, 0xFE, 0x1F, 0xF8, 0x01, 0x00, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x07, 0xFF, 0xFF, 0xE3, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x87, 0xF0, 0x7E, 0x03, 0x00,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xDC, 0x06, 0xEF, 0x8F, 0x73,
  0xFF, 0x38, 0xFF, 0x1C, 0x18, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x60, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0C, 0x00, 0xC3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x06, 0x70, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x1E,
  0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xF0, 0x06, 0x70, 0x0F, 0xC0,
  0x39, 0xC0, 0x3F, 0x00, 0xE7, 0x00, 0xEC, 0x03, 0x9C, 0x03, 0x30, 0x0E,
  0x70, 0x1C, 0xE0, 0x70, 0xE0, 0x73, 0x81, 0xC3, 0x81, 0xCE, 0x07, 0x0E,
  0x07, 0x38, 0x1C, 0x38, 0x18, 0x60, 0x60, 0x70, 0xE1, 0xC3, 0x81, 0xC3,
  0x87, 0x0E, 0x07, 0x0E, 0x1C, 0x38, 0x1C, 0x38, 0x70, 0xE0, 0x70, 0xC0,
  0xC3, 0x00, 0xE7, 0x03, 0x9C, 0x03, 0x9C, 0x0E, 0x70, 0x0E, 0x70, 0x39,
  0xC0, 0x39, 0x80, 0xE7, 0x00, 0x66, 0x01, 0x98, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x9E, 0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x77, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x87,
  0x01, 0xC1, 0xC0, 0x70, 0x38, 0x3C, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x71,
  0xC0, 0x1E, 0x70, 0x03, 0xB8, 0x00, 0xF0, 0xE0, 0x01, 0xF8, 0x00, 0x77,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x70, 0xE0,
  0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x9E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0,
  0x7C, 0x0F, 0xFF, 0x80, 0x3F, 0xE8, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 41, 12, 4, -41 },
  { 22, 12, 15, 19, 4, -41 },
  { 45, 23, 41, 25, 1, -41 },
  { 163, 19, 46, 23, 2, -43 },
  { 273, 31, 42, 35, 2, -41 },
  { 436, 23, 42, 25, 2, -41 },
  { 557, 3, 15, 11, 4, -41 },
  { 563, 11, 50, 16, 3, -41 },
  { 632, 11, 50, 16, 2, -41 },
  { 701, 17, 16, 21, 2, -43 },
  { 735, 20, 26, 24, 2, -33 },
  { 800, 6, 13, 11, 2, -6 },
  { 810, 12, 3, 15, 2, -17 },
  { 815, 4, 5, 12, 4, -5 },
  { 818, 18, 41, 20, 1, -41 },
  { 911, 18, 41, 23, 3, -41 },
  { 1004, 11, 41, 23, 4, -41 },
  { 1061, 19, 41, 23, 2, -41 },
  { 1159, 19, 42, 23, 2, -41 },
  { 1259, 22, 41, 23, 1, -41 },
  { 1372, 18, 42, 23, 3, -41 },
  { 1467, 18, 42, 23, 3, -41 },
  { 1562, 19, 41, 23, 2, -41 },
  { 1660, 19, 42, 23, 2, -41 },
  { 1760, 19, 42, 23, 2, -41 },
  { 1860, 4, 31, 12, 4, -31 },
  { 1876, 6, 38, 12, 2, -31 },
  { 1905, 20, 24, 24, 2, -32 },
  { 1965, 20, 15, 24, 2, -28 },
  { 2003, 20, 24, 24, 2, -32 },
  { 2063, 14, 41, 17, 1, -41 },
  { 2135, 30, 46, 36, 3, -41 },
  { 2308, 24, 41, 24, 0, -41 },
  { 2431, 20, 41, 26, 4, -41 },
  { 2534, 20, 42, 25, 3, -41 },
  { 2639, 21, 41, 28, 4, -41 },
  { 2747, 16, 41, 22, 4, -41 },
  { 2829, 16, 41, 21, 4, -41 },
  { 2911, 24, 42, 30, 3, -41 },
  { 3037, 21, 41, 29, 4, -41 },
  { 3145, 10, 41, 14, 2, -41 },
  { 3197, 11, 51, 12, -3, -41 },
  { 3268, 20, 41, 24, 4, -41 },
  { 3371, 15, 41, 20, 4, -41 },
  { 3448, 31, 41, 39, 4, -41 },
  { 3607, 22, 41, 31, 4, -41 },
  { 3720, 24, 42, 30, 3, -41 },
  { 3846, 18, 41, 24, 4, -41 },
  { 3939, 24, 51, 30, 3, -41 },
  { 4092, 20, 41, 25, 4, -41 },
  { 4195, 19, 42, 23, 2, -41 },
  { 4295, 19, 41, 20, 1, -41 },
  { 4393, 21, 42, 29, 4, -41 },
  { 4504, 23, 41, 23, 0, -41 },
  { 4622, 39, 41, 39, 0, -41 },
  { 4822, 19, 41, 21, 1, -41 },
  { 4920, 20, 41, 20, 0, -41 },
  { 5023, 16, 41, 20, 2, -41 },
  { 5105, 12, 50, 18, 4, -41 },
  { 5180, 18, 41, 20, 1, -41 },
  { 5273, 11, 50, 18, 2, -41 },
  { 5342, 22, 21, 24, 1, -41 },
  { 5400, 24, 2, 24, 0, 5 },
  { 5406, 10, 9, 14, 2, -44 },
  { 5418, 17, 32, 22, 2, -31 },
  { 5486, 19, 44, 25, 4, -43 },
  { 5591, 15, 32, 19, 3, -31 },
  { 5651, 18, 44, 25, 3, -43 },
  { 5750, 17, 32, 23, 3, -31 },
  { 5818, 14, 44, 13, 1, -44 },
  { 5895, 18, 45, 25, 3, -31 },
  { 5997, 17, 43, 25, 4, -43 },
  { 6089, 4, 42, 11, 4, -42 },
  { 6110, 8, 56, 11, 0, -42 },
  { 6166, 16, 43, 21, 4, -43 },
  { 6252, 3, 43, 11, 4, -43 },
  { 6269, 29, 31, 37, 4, -31 },
  { 6382, 17, 31, 25, 4, -31 },
  { 6448, 19, 32, 24, 3, -31 },
  { 6524, 19, 44, 25, 4, -31 },
  { 6629, 18, 44, 25, 3, -31 },
  { 6728, 12, 31, 16, 4, -31 },
  { 6775, 15, 32, 19, 2, -31 },
  { 6835, 11, 38, 13, 1, -37 },
  { 6888, 17, 31, 25, 4, -30 },
  { 6954, 19, 30, 19, 0, -30 },
  { 7026, 30, 30, 32, 1, -30 },
  { 7139, 18, 30, 20, 1, -30 },
  { 7207, 18, 44, 20, 1, -30 },
  { 7306, 13, 30, 16, 2, -30 },
  { 7355, 15, 50, 20, 3, -41 },
  { 7449, 3, 57, 22, 10, -43 },
  { 7471, 15, 50, 20, 3, -41 },
  { 7565, 20, 6, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Light57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT57PT7B_H_
