#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xED, 0xA4, 0x80, 0x03, 0xFF,
  0xC0, 0xC3, 0xE1, 0xF0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x61,
  0xB0, 0xC0, 0x03, 0x0C, 0x01, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60,
  0xC0, 0x30, 0x60, 0x18, 0x20, 0x0C, 0x10, 0x06, 0x18, 0x3F, 0xFF, 0xDF,
  0xFF, 0xE1, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x20,
  0x0C, 0x30, 0x06, 0x18, 0x02, 0x0C, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x20, 0x0C, 0x30, 0x06, 0x18, 0x02,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x03,
  0xF8, 0x3F, 0xF9, 0xC8, 0xCE, 0x20, 0x30, 0x80, 0xC2, 0x03, 0x08, 0x0C,
  0x20, 0x30, 0x80, 0xC2, 0x03, 0x88, 0x07, 0x20, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x2F, 0x00, 0x8E, 0x02, 0x18, 0x08, 0x70, 0x20, 0xC0, 0x83,
  0x02, 0x0C, 0x08, 0x70, 0x21, 0xA0, 0x8E, 0xFF, 0xF1, 0xFF, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3E, 0x01, 0x81, 0xD8, 0x06, 0x06,
  0x30, 0x30, 0x30, 0xC0, 0xC0, 0xC3, 0x02, 0x03, 0x06, 0x18, 0x0C, 0x18,
  0x60, 0x30, 0x61, 0x00, 0xC1, 0x8C, 0x03, 0x06, 0x30, 0x0C, 0x18, 0x80,
  0x30, 0x66, 0x00, 0xC1, 0x99, 0xF3, 0x0C, 0x46, 0xEC, 0x33, 0x31, 0x98,
  0xCC, 0xC3, 0x76, 0x62, 0x0C, 0xF1, 0x98, 0x30, 0x06, 0x60, 0xC0, 0x31,
  0x83, 0x00, 0xC6, 0x0C, 0x03, 0x18, 0x30, 0x18, 0x60, 0xC0, 0x61, 0x83,
  0x01, 0x86, 0x0C, 0x0C, 0x08, 0x30, 0x30, 0x30, 0xC0, 0xC0, 0xC6, 0x06,
  0x01, 0xB8, 0x18, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60,
  0x0C, 0x30, 0x07, 0x38, 0x01, 0x98, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x39, 0x83, 0x18, 0xE1, 0x98, 0x30, 0xCC, 0x1C, 0x6E,
  0x06, 0x77, 0x01, 0xB3, 0x80, 0xF9, 0xC0, 0x3C, 0xE0, 0x1C, 0x30, 0x0E,
  0x18, 0x0F, 0x8E, 0x0E, 0xE3, 0xFE, 0x30, 0xFE, 0x1C, 0xFF, 0xFF, 0xFC,
  0x03, 0x06, 0x0E, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x06,
  0x03, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xC6, 0x6F, 0xFF, 0x1F, 0x00, 0xE0, 0x1B, 0x03, 0x98, 0x31, 0xC6,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x37, 0x77, 0x66, 0x6C, 0xCC, 0xFF, 0xFF, 0xFF, 0xE0,
  0xDF, 0xF0, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x18, 0x60, 0xE7, 0x03, 0x30,
  0x19, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x60, 0x33, 0x81, 0x8C, 0x1C, 0x70,
  0xC1, 0xFE, 0x07, 0xE0, 0x03, 0x07, 0x0F, 0x1B, 0x73, 0xE3, 0xC3, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x3F, 0xC7,
  0xFF, 0x38, 0x3C, 0x80, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xC7, 0xFF, 0x30, 0x1D, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x0F, 0xC0, 0x7C, 0x03,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0D, 0x01, 0xEF, 0xFE, 0x7F, 0xC0,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xB0, 0x01, 0xB0,
  0x01, 0xB0, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x18, 0x30, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x30,
  0x60, 0x30, 0xE0, 0x30, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x7F, 0xF3, 0xFF, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0xF8, 0x7F, 0xF1, 0x03,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1D, 0x01, 0xCF, 0xFE, 0x3F,
  0xC0, 0x03, 0xF0, 0x3F, 0xC1, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0xC0, 0xCF, 0xE3,
  0x77, 0xCD, 0x03, 0x38, 0x0E, 0xE0, 0x1B, 0x80, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x1F, 0x00, 0x6E, 0x01, 0xB8, 0x06, 0x60, 0x19, 0x80, 0xE7, 0x03,
  0x0E, 0x1C, 0x1F, 0xE0, 0x3F, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0xE0, 0xE1, 0x80, 0xE7, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30, 0x06,
  0x70, 0x0C, 0x60, 0x38, 0xE0, 0x60, 0xE1, 0x80, 0xEF, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0x70, 0x1C, 0x70, 0x70, 0x71, 0xC0, 0x73, 0x00, 0x66, 0x00,
  0xEC, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0x60, 0x0E, 0xC0, 0x19, 0xC0, 0x71,
  0xC0, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0x81, 0xFF, 0x1C, 0x18, 0xC0,
  0xEE, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0xEC, 0x0F, 0x7D, 0xD9, 0xFC, 0xC3,
  0x86, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x87, 0xF8, 0x3F, 0x80, 0x5F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x6F, 0xF8, 0x27, 0x77, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x37, 0x77, 0x66, 0x6C, 0xCC, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x7F,
  0x3F, 0xE8, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x3C, 0x0E,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x18,
  0x1C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x70,
  0x3E, 0x19, 0x81, 0xFC, 0x36, 0x0C, 0x30, 0xD8, 0x70, 0xC3, 0x61, 0x87,
  0x0F, 0x06, 0x1C, 0x3C, 0x18, 0x60, 0xF0, 0xC1, 0x83, 0xC3, 0x06, 0x0F,
  0x0C, 0x18, 0x3C, 0x30, 0x60, 0xF0, 0xC1, 0x83, 0xC1, 0x86, 0x0F, 0x06,
  0x38, 0x3C, 0x18, 0xF1, 0x98, 0x3E, 0x7E, 0x60, 0xF1, 0xF1, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x08, 0x01, 0xC0, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x0C, 0xC0, 0x0E, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8E, 0x01, 0xC3,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0F,
  0xFE, 0x07, 0xFF, 0x83, 0x01, 0xC3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x1C,
  0x60, 0x0E, 0x70, 0x03, 0x38, 0x01, 0x98, 0x00, 0xEC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0C, 0xFF, 0xC3, 0xFF, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x1B,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xB8, 0x0E,
  0xE0, 0x73, 0xFF, 0x8F, 0xFC, 0x38, 0x3C, 0xE0, 0x3B, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x03, 0xB8, 0x1E, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xFC,
  0x38, 0x10, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x10, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0xE0, 0xF0, 0xE0,
  0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF,
  0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0xF0, 0x18, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x3E, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x37, 0x00, 0x0C,
  0xC0, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x31, 0xC0, 0x0C, 0x3C, 0x03, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xC0, 0xFF, 0xF8, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x8F, 0xFF, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x06, 0x06, 0x06, 0xDE, 0xFC, 0x70, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xB8,
  0x1C, 0xE0, 0x63, 0x83, 0x8E, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x8E, 0x0E,
  0x70, 0x39, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x03,
  0x8C, 0x0E, 0x38, 0x38, 0x60, 0xE1, 0xC3, 0x83, 0x0E, 0x0E, 0x38, 0x18,
  0xE0, 0x73, 0x80, 0xCE, 0x03, 0xB8, 0x06, 0xE0, 0x1F, 0x80, 0x30, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xFD, 0x80, 0x03, 0xFB, 0x00, 0x07, 0xF6, 0x00,
  0x1B, 0xE6, 0x00, 0x37, 0xCC, 0x00, 0x6F, 0x98, 0x01, 0xDF, 0x38, 0x03,
  0x3E, 0x30, 0x06, 0x7C, 0x60, 0x0C, 0xF8, 0xC0, 0x31, 0xF0, 0xC0, 0x63,
  0xE1, 0x80, 0xC7, 0xC3, 0x03, 0x8F, 0x83, 0x06, 0x1F, 0x06, 0x0C, 0x3E,
  0x0C, 0x18, 0x7C, 0x1C, 0x60, 0xF8, 0x18, 0xC1, 0xF0, 0x31, 0x83, 0xE0,
  0x66, 0x07, 0xC0, 0x6C, 0x0F, 0x80, 0xD8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x7C, 0x03, 0x80, 0xF8, 0x07, 0x01, 0xC0, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03,
  0xCE, 0x03, 0xC6, 0x03, 0xC7, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0xC3, 0xC0, 0xC3, 0xC0, 0xE3, 0xC0, 0x63, 0xC0, 0x63,
  0xC0, 0x33, 0xC0, 0x33, 0xC0, 0x3B, 0xC0, 0x1B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x07, 0xF8, 0x03, 0xFF,
  0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x1C, 0x00, 0xE7, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x19,
  0xC0, 0x06, 0x30, 0x03, 0x8E, 0x00, 0xC1, 0x80, 0x70, 0x70, 0x38, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1B, 0x81, 0xDC, 0x7C, 0xFF, 0xC7, 0xF0, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xE0,
  0xE0, 0x1C, 0x38, 0x03, 0x1C, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x06, 0x30,
  0x03, 0x8E, 0x00, 0xC1, 0x80, 0x70, 0x70, 0x38, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0xFF, 0x03, 0xFF, 0x8E, 0x1F, 0x38, 0x1C,
  0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x1B, 0x80, 0x6E, 0x01,
  0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x0E, 0x3F, 0xF0, 0xFF, 0x03, 0x8E,
  0x0E, 0x18, 0x38, 0x70, 0xE0, 0xC3, 0x83, 0x8E, 0x06, 0x38, 0x1C, 0xE0,
  0x73, 0x80, 0xCE, 0x03, 0xB8, 0x06, 0xE0, 0x1F, 0x80, 0x30, 0x1F, 0xF1,
  0xFF, 0xDE, 0x04, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x1D, 0x01, 0xEF, 0xFE, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x33, 0xC0,
  0xE3, 0xFF, 0x81, 0xFE, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x33, 0x80, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x1C, 0x07, 0x0E, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x70,
  0x70, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x8E, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x3B, 0x00, 0x38, 0x01, 0x98, 0x01, 0xC0, 0x0C, 0xC0, 0x0E, 0x00, 0xE6,
  0x00, 0xF0, 0x07, 0x38, 0x06, 0xC0, 0x30, 0xC0, 0x36, 0x01, 0x86, 0x01,
  0xB0, 0x0C, 0x30, 0x0D, 0x80, 0xE1, 0xC0, 0xCC, 0x07, 0x0E, 0x06, 0x70,
  0x30, 0x30, 0x31, 0x81, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x0C, 0x60, 0xE0,
  0x70, 0xC3, 0x06, 0x03, 0x86, 0x1C, 0x30, 0x0C, 0x30, 0x61, 0x80, 0x61,
  0x83, 0x1C, 0x03, 0x0C, 0x18, 0xE0, 0x1C, 0xC0, 0xC6, 0x00, 0x66, 0x06,
  0x30, 0x03, 0x30, 0x19, 0x80, 0x19, 0x80, 0xDC, 0x00, 0xCC, 0x06, 0xE0,
  0x07, 0xC0, 0x36, 0x00, 0x1E, 0x01, 0xB0, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E,
  0x60, 0x18, 0xE0, 0x30, 0xC0, 0xE1, 0x81, 0x83, 0x87, 0x03, 0x0C, 0x06,
  0x18, 0x0E, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x60, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x19, 0x80, 0x33, 0x00,
  0xC7, 0x01, 0x86, 0x07, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x70, 0x30, 0xC0,
  0x73, 0x80, 0x66, 0x00, 0xDC, 0x01, 0xC0, 0xE0, 0x0E, 0xC0, 0x19, 0x80,
  0x33, 0x80, 0xE3, 0x01, 0x86, 0x03, 0x0E, 0x0E, 0x0C, 0x18, 0x18, 0x30,
  0x38, 0xE0, 0x31, 0x80, 0x63, 0x00, 0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFF, 0xF8, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x1C, 0x30, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x80,
  0x0F, 0x07, 0xFC, 0x71, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0F, 0xF3, 0xFF, 0x70, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xE0, 0xB7, 0xBB, 0x3F, 0x30, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x0E, 0x0C, 0xFE, 0x37, 0x3C, 0xD0, 0x33, 0x80, 0xEE,
  0x01, 0xB8, 0x06, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x6E, 0x01, 0xB8, 0x06,
  0xF0, 0x3B, 0x41, 0xCD, 0xFE, 0x33, 0xF0, 0x07, 0x83, 0xFC, 0xF1, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x7F, 0xC3, 0xF8, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x1C, 0x31, 0xFC, 0xCE, 0x3B,
  0x70, 0x2D, 0x80, 0xF6, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xD8, 0x07, 0x60, 0x3D, 0xC1, 0xB3, 0xFC, 0xC7, 0xE3, 0x07,
  0x00, 0xFE, 0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x30, 0x1B, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x81, 0x0F, 0xF8, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x83, 0xFE, 0x7F, 0xC1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x7F,
  0x33, 0xCE, 0xDC, 0x0B, 0x60, 0x3D, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x76, 0x01, 0xD8, 0x0B, 0x70, 0x6C, 0xFF, 0x31,
  0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE6, 0x07, 0x1F, 0xF8, 0x3F, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x38, 0xCF, 0xED,
  0xCE, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xDF, 0xE0, 0x00, 0x1B, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x18, 0x71, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63,
  0xBC, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC1, 0xCC, 0x18, 0xC3,
  0x8C, 0x30, 0xC6, 0x0C, 0xE0, 0xCC, 0x0D, 0xE0, 0xD6, 0x0F, 0x70, 0xE3,
  0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC1, 0xCC, 0x0C, 0xC0, 0xEC, 0x06, 0xC0,
  0x6C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x01,
  0xC6, 0x7E, 0x3F, 0xB6, 0x7B, 0x9D, 0xE0, 0xD0, 0x7E, 0x07, 0x81, 0xF0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x30, 0x1E, 0x01, 0x80,
  0xF0, 0x0C, 0x07, 0x80, 0x60, 0x3C, 0x03, 0x01, 0xE0, 0x18, 0x0F, 0x00,
  0xC0, 0x78, 0x06, 0x03, 0xC0, 0x30, 0x1E, 0x01, 0x80, 0xF0, 0x0C, 0x07,
  0x80, 0x60, 0x3C, 0x03, 0x01, 0xE0, 0x18, 0x0F, 0x00, 0xC0, 0x60, 0x03,
  0x8C, 0xFE, 0xDC, 0xEF, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x07, 0x80,
  0x7F, 0x83, 0xCF, 0x1C, 0x0C, 0x60, 0x39, 0x80, 0x6E, 0x01, 0xB0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x66, 0x01, 0x9C, 0x0E, 0x30, 0x70, 0xFF,
  0x80, 0xFC, 0x00, 0x03, 0x83, 0x3F, 0x8D, 0x8F, 0x34, 0x0C, 0xE0, 0x3B,
  0x80, 0x6E, 0x01, 0xB0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1B, 0x80, 0x6E, 0x01,
  0xBC, 0x0E, 0xD0, 0x73, 0x7F, 0x8C, 0xFC, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x7F, 0x33, 0xCE, 0xDC, 0x0B, 0x60, 0x3D, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x76, 0x01, 0xDC, 0x0B,
  0x70, 0x6C, 0xFF, 0x31, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x07,
  0xE7, 0xB7, 0xDA, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x07, 0x07, 0xFC, 0xE3, 0xB0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x3C, 0x0F, 0xFF, 0x9F, 0xE0, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38, 0x3F,
  0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x76, 0x0F, 0x7F, 0xB3, 0xF3, 0xE0, 0x1D,
  0x80, 0x66, 0x01, 0x98, 0x06, 0x70, 0x38, 0xC0, 0xC3, 0x03, 0x0C, 0x0C,
  0x38, 0x70, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0xE0, 0x33, 0x00, 0xCC,
  0x03, 0x30, 0x0C, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0C,
  0x00, 0xE0, 0x38, 0x06, 0xC0, 0x70, 0x1D, 0x80, 0xF0, 0x33, 0x01, 0xE0,
  0x67, 0x02, 0xC0, 0xC6, 0x0D, 0x81, 0x8C, 0x1B, 0x07, 0x18, 0x33, 0x0C,
  0x38, 0x66, 0x18, 0x31, 0x8C, 0x30, 0x63, 0x18, 0x60, 0xC6, 0x19, 0x81,
  0x8C, 0x33, 0x03, 0x98, 0x66, 0x03, 0x60, 0xCC, 0x06, 0xC1, 0x98, 0x0D,
  0x81, 0xE0, 0x1B, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x3B, 0x03, 0x9C, 0x18, 0x60, 0xC3,
  0x8C, 0x0C, 0x60, 0x66, 0x01, 0xB0, 0x0F, 0x80, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x06, 0xC0, 0x66, 0x03, 0x18, 0x38, 0xC1, 0x87, 0x1C, 0x18,
  0xC0, 0xEE, 0x03, 0x60, 0x1C, 0x60, 0x0D, 0x80, 0x77, 0x01, 0x8C, 0x06,
  0x30, 0x18, 0xC0, 0xE3, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC1, 0xC6,
  0x03, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xEC, 0x01, 0xB0, 0x06, 0xC0, 0x1B,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x0F, 0xC0, 0x3E,
  0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06,
  0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x7C, 0x1C, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x1F, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x1E, 0x01, 0xF0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x7C, 0x07, 0x81, 0xC0, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0xF0, 0x7C, 0x0C, 0x00, 0x3E, 0x02,
  0xFF, 0x07, 0x0F, 0xFC, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 30, 9, 3, -30 },
  { 13, 9, 11, 14, 3, -30 },
  { 26, 17, 30, 19, 1, -30 },
  { 90, 14, 34, 17, 2, -32 },
  { 150, 22, 30, 26, 2, -30 },
  { 233, 17, 30, 18, 1, -30 },
  { 297, 2, 11, 8, 3, -30 },
  { 300, 8, 37, 12, 2, -30 },
  { 337, 9, 37, 12, 1, -30 },
  { 379, 12, 12, 15, 2, -32 },
  { 397, 15, 20, 17, 1, -25 },
  { 435, 4, 10, 8, 2, -5 },
  { 440, 9, 3, 11, 1, -13 },
  { 444, 3, 4, 9, 3, -4 },
  { 446, 13, 30, 15, 1, -30 },
  { 495, 13, 30, 17, 2, -30 },
  { 544, 8, 30, 17, 3, -30 },
  { 574, 13, 30, 17, 2, -30 },
  { 623, 13, 30, 17, 2, -30 },
  { 672, 16, 30, 17, 1, -30 },
  { 732, 13, 30, 17, 2, -30 },
  { 781, 14, 31, 17, 2, -30 },
  { 836, 13, 30, 17, 2, -30 },
  { 885, 15, 30, 17, 1, -30 },
  { 942, 13, 30, 17, 2, -30 },
  { 991, 3, 23, 9, 3, -23 },
  { 1000, 4, 28, 9, 2, -23 },
  { 1014, 15, 18, 17, 1, -24 },
  { 1048, 15, 11, 17, 1, -20 },
  { 1069, 15, 18, 17, 1, -24 },
  { 1103, 10, 30, 12, 1, -30 },
  { 1141, 22, 34, 26, 2, -30 },
  { 1235, 17, 30, 17, 0, -30 },
  { 1299, 14, 30, 19, 3, -30 },
  { 1352, 15, 30, 18, 2, -30 },
  { 1409, 16, 30, 21, 3, -30 },
  { 1469, 11, 30, 16, 3, -30 },
  { 1511, 12, 30, 15, 3, -30 },
  { 1556, 18, 30, 22, 2, -30 },
  { 1624, 15, 30, 21, 3, -30 },
  { 1681, 7, 30, 11, 2, -30 },
  { 1708, 8, 38, 9, -2, -30 },
  { 1746, 14, 30, 17, 3, -30 },
  { 1799, 11, 30, 15, 3, -30 },
  { 1841, 23, 30, 29, 3, -30 },
  { 1928, 16, 30, 23, 3, -30 },
  { 1988, 18, 30, 22, 2, -30 },
  { 2056, 13, 30, 18, 3, -30 },
  { 2105, 18, 37, 22, 2, -30 },
  { 2189, 14, 30, 18, 3, -30 },
  { 2242, 13, 30, 17, 2, -30 },
  { 2291, 15, 30, 15, 0, -30 },
  { 2348, 15, 30, 21, 3, -30 },
  { 2405, 17, 30, 17, 0, -30 },
  { 2469, 29, 30, 29, 0, -30 },
  { 2578, 15, 30, 15, 0, -30 },
  { 2635, 15, 30, 15, 0, -30 },
  { 2692, 13, 30, 14, 1, -30 },
  { 2741, 9, 37, 13, 3, -30 },
  { 2783, 13, 30, 15, 1, -30 },
  { 2832, 9, 37, 13, 1, -30 },
  { 2874, 16, 15, 18, 1, -30 },
  { 2904, 18, 2, 17, 0, 4 },
  { 2909, 7, 7, 10, 2, -32 },
  { 2916, 12, 23, 16, 2, -23 },
  { 2951, 14, 32, 19, 3, -32 },
  { 3007, 11, 23, 14, 2, -23 },
  { 3039, 14, 32, 19, 2, -32 },
  { 3095, 13, 23, 17, 2, -23 },
  { 3133, 11, 32, 10, 0, -32 },
  { 3177, 14, 33, 19, 2, -23 },
  { 3235, 12, 32, 18, 3, -32 },
  { 3283, 3, 31, 8, 3, -31 },
  { 3295, 6, 41, 8, 0, -31 },
  { 3326, 12, 32, 15, 3, -32 },
  { 3374, 2, 32, 8, 3, -32 },
  { 3382, 21, 23, 27, 3, -23 },
  { 3443, 12, 23, 18, 3, -23 },
  { 3478, 14, 23, 18, 2, -23 },
  { 3519, 14, 33, 19, 3, -23 },
  { 3577, 14, 33, 19, 2, -23 },
  { 3635, 9, 23, 12, 3, -23 },
  { 3661, 11, 23, 14, 1, -23 },
  { 3693, 8, 28, 10, 1, -28 },
  { 3721, 12, 22, 18, 3, -22 },
  { 3754, 14, 22, 14, 0, -22 },
  { 3793, 23, 22, 23, 0, -22 },
  { 3857, 13, 22, 14, 1, -22 },
  { 3893, 14, 32, 14, 0, -22 },
  { 3949, 10, 22, 12, 1, -22 },
  { 3977, 11, 37, 15, 2, -30 },
  { 4028, 2, 42, 16, 7, -32 },
  { 4039, 11, 37, 15, 2, -30 },
  { 4090, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Light42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT42PT7B_H_
