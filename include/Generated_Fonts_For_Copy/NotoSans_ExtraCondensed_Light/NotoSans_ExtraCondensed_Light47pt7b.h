#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x60, 0x00, 0x00, 0xFF, 0xF7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x70, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC1, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0xC1, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83,
  0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0E,
  0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x1F, 0xF8, 0x3F, 0xFE, 0x71, 0x0C, 0x61, 0x00,
  0xE1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00,
  0xE1, 0x00, 0x71, 0x00, 0x39, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x01, 0x3C, 0x01, 0x0E, 0x01, 0x06, 0x01, 0x07, 0x01, 0x07,
  0x01, 0x07, 0x01, 0x07, 0x01, 0x06, 0x01, 0x06, 0x81, 0x0E, 0xE1, 0x3C,
  0xFF, 0xF8, 0x3F, 0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x1E, 0x00, 0x60, 0x1F, 0x80, 0x30, 0x1C, 0xE0, 0x38, 0x0C,
  0x30, 0x18, 0x06, 0x18, 0x0C, 0x07, 0x0E, 0x0E, 0x03, 0x03, 0x06, 0x01,
  0x81, 0x83, 0x00, 0xC0, 0xC3, 0x80, 0x60, 0x61, 0x80, 0x30, 0x30, 0xC0,
  0x18, 0x18, 0xE0, 0x0C, 0x0C, 0x60, 0x06, 0x06, 0x30, 0xC3, 0x03, 0x39,
  0xF9, 0xC3, 0x98, 0xCE, 0x61, 0x8C, 0xC3, 0x30, 0xCE, 0x61, 0x9C, 0xE6,
  0x70, 0xE7, 0xE3, 0x30, 0x31, 0xE3, 0x18, 0x18, 0x01, 0x8C, 0x0C, 0x00,
  0xC6, 0x06, 0x00, 0xC3, 0x03, 0x00, 0x61, 0x81, 0x80, 0x30, 0xC0, 0xC0,
  0x30, 0x60, 0x60, 0x18, 0x30, 0x30, 0x0C, 0x1C, 0x18, 0x0C, 0x06, 0x1C,
  0x06, 0x03, 0x0C, 0x03, 0x01, 0x86, 0x03, 0x00, 0x7E, 0x01, 0x80, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x39, 0xC0, 0x0E, 0x1C, 0x01, 0xC3,
  0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x06, 0x18, 0x00, 0xE7, 0x00, 0x0D, 0xC0, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x77, 0x00, 0x1C, 0x70,
  0x63, 0x06, 0x0C, 0xE0, 0xE3, 0x98, 0x0C, 0x73, 0x01, 0xCE, 0xE0, 0x19,
  0x9C, 0x03, 0xF3, 0x80, 0x3E, 0x30, 0x03, 0x86, 0x00, 0x70, 0xE0, 0x1F,
  0x1C, 0x07, 0xE1, 0xC1, 0xCE, 0x1F, 0xF0, 0xC1, 0xFC, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEC, 0x01, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x03,
  0x80, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E,
  0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xE0,
  0x00, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x08, 0x30, 0xF9, 0x9F, 0xFF,
  0xE1, 0xF8, 0x07, 0x80, 0x6C, 0x07, 0x30, 0x71, 0xC7, 0x07, 0x18, 0x10,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x39,
  0xCC, 0x67, 0x39, 0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xFE,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x7B, 0xC1, 0xC1, 0xC3,
  0x81, 0x8E, 0x03, 0x9C, 0x03, 0x38, 0x06, 0x60, 0x0E, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0E, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0x67, 0x01, 0xC6, 0x03,
  0x8E, 0x0E, 0x0E, 0x3C, 0x1F, 0xF0, 0x0F, 0xC0, 0x01, 0xC0, 0xF0, 0x7C,
  0x3F, 0x1D, 0xCE, 0x77, 0x1F, 0x87, 0x41, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x0F, 0xC0, 0x7F, 0xE3, 0xE3, 0xE3, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x01, 0xC4, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F,
  0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xA0, 0x07, 0x60, 0x3C, 0xFF, 0xF0, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0D, 0xC0, 0x03, 0x70, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x31, 0xC0,
  0x0C, 0x70, 0x07, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x1C,
  0x1C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x70, 0x70, 0x1C, 0x18, 0x07,
  0x0E, 0x01, 0xC3, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0x78,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0xA0, 0x0F, 0x60, 0x3C, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xF8,
  0x3E, 0x30, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x7C, 0x39, 0xFC,
  0x77, 0xBC, 0xF8, 0x1D, 0xE0, 0x1B, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00,
  0x77, 0x00, 0xE6, 0x01, 0x8E, 0x07, 0x0E, 0x1C, 0x1F, 0xF8, 0x1F, 0xE0,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x3C, 0x78,
  0x70, 0x1C, 0x70, 0x0C, 0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0x60, 0x0E, 0x60, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1E, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x1C, 0x70, 0x38, 0x38, 0x70, 0x1C,
  0x60, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x3C, 0x3F, 0xF8,
  0x0F, 0xF0, 0x07, 0xC0, 0x3F, 0xC0, 0xF3, 0xC3, 0x81, 0xC7, 0x01, 0x8C,
  0x03, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x60, 0x1E, 0xE0, 0x3C,
  0xE1, 0xF9, 0xFF, 0x71, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xEF, 0xFE, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x73, 0xDE, 0xF2, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0xEE, 0x73, 0x98,
  0xCE, 0x63, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x0F, 0xFC,
  0xF3, 0xC8, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x70, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x07, 0xF0, 0xCE, 0x07,
  0x78, 0x76, 0x07, 0x1C, 0x1B, 0x07, 0x0E, 0x0D, 0x83, 0x07, 0x06, 0xC1,
  0x83, 0x83, 0x60, 0xC1, 0xC1, 0xF0, 0xE0, 0xE0, 0xF8, 0x70, 0x60, 0x7C,
  0x38, 0x30, 0x3E, 0x1C, 0x18, 0x1F, 0x0E, 0x0C, 0x0F, 0x87, 0x06, 0x07,
  0xC1, 0x83, 0x07, 0x60, 0xC3, 0x83, 0x30, 0x61, 0x61, 0x98, 0x1D, 0xBB,
  0x8C, 0x0F, 0x8F, 0xC7, 0x01, 0x81, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x18, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03,
  0x70, 0x00, 0x6E, 0x00, 0x1C, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x80, 0x0C,
  0x70, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x80, 0x70,
  0x70, 0x0E, 0x06, 0x01, 0xC0, 0xC0, 0x30, 0x1C, 0x0E, 0x03, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x06, 0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00,
  0x30, 0xE0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0x9C, 0x00,
  0x3B, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0C, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xC0, 0x3C, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x1C,
  0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xF1, 0xE1, 0xE0,
  0x21, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x03,
  0x03, 0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x18,
  0x0F, 0x0C, 0x01, 0xC6, 0x00, 0xF3, 0x00, 0x39, 0x80, 0x0C, 0xC0, 0x07,
  0x60, 0x03, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03,
  0xB0, 0x01, 0xD8, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0xE3, 0x00, 0xE1, 0x83,
  0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xF3, 0xF0, 0xF0, 0x02, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x0F, 0xF6,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x03,
  0x70, 0x00, 0x33, 0x00, 0x03, 0x38, 0x00, 0x33, 0x80, 0x03, 0x1C, 0x00,
  0x31, 0xE0, 0x03, 0x0F, 0x00, 0x30, 0x78, 0x07, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x0F, 0xFE,
  0xFC, 0x70, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x38,
  0xC0, 0x70, 0xC0, 0x70, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1, 0xC0, 0xC3, 0x80,
  0xC3, 0x80, 0xC7, 0x00, 0xC7, 0x00, 0xCE, 0x00, 0xCE, 0x00, 0xDE, 0x00,
  0xFF, 0x00, 0xF7, 0x00, 0xE3, 0x80, 0xE3, 0x80, 0xC1, 0xC0, 0xC1, 0xC0,
  0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38,
  0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0F, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x60, 0x00, 0x7F, 0xB0,
  0x00, 0x37, 0xDC, 0x00, 0x1B, 0xE6, 0x00, 0x1D, 0xF3, 0x00, 0x0C, 0xF9,
  0xC0, 0x06, 0x7C, 0xE0, 0x07, 0x3E, 0x30, 0x03, 0x1F, 0x18, 0x01, 0x8F,
  0x8E, 0x01, 0xC7, 0xC3, 0x00, 0xE3, 0xE1, 0x80, 0x61, 0xF0, 0xE0, 0x30,
  0xF8, 0x30, 0x38, 0x7C, 0x18, 0x18, 0x3E, 0x0C, 0x0C, 0x1F, 0x07, 0x0E,
  0x0F, 0x81, 0x87, 0x07, 0xC0, 0xC3, 0x03, 0xE0, 0x71, 0x81, 0xF0, 0x19,
  0xC0, 0xF8, 0x0C, 0xC0, 0x7C, 0x07, 0x60, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x0E, 0x01, 0xC0,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7D, 0x80, 0x1F, 0x70, 0x07, 0xCC, 0x01, 0xF3, 0x80, 0x7C, 0xE0,
  0x1F, 0x18, 0x07, 0xC7, 0x01, 0xF0, 0xC0, 0x7C, 0x38, 0x1F, 0x06, 0x07,
  0xC1, 0xC1, 0xF0, 0x30, 0x7C, 0x0E, 0x1F, 0x03, 0x87, 0xC0, 0x61, 0xF0,
  0x1C, 0x7C, 0x03, 0x1F, 0x00, 0xE7, 0xC0, 0x19, 0xF0, 0x07, 0x7C, 0x01,
  0xDF, 0x00, 0x37, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xF3,
  0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86,
  0x00, 0x0C, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xC0, 0x00,
  0xE6, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0D, 0xC0, 0x00, 0x66, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x8C, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFC,
  0x03, 0xFF, 0x0F, 0xFF, 0x30, 0x1E, 0xC0, 0x3B, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0E, 0xC0, 0x7B, 0x03, 0xCF, 0xFE, 0x3F, 0xE0, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xF3, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x1C,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x30, 0x00, 0x1B,
  0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xC0, 0x78, 0xC0, 0x38,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0xC3, 0x80, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x38,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0F, 0x07, 0xF0,
  0x3F, 0xFC, 0xFD, 0xF3, 0xC0, 0x27, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xA0, 0x0F, 0x70, 0x3C, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x1C, 0xE0, 0x1C, 0x78, 0x1C, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0x67, 0x00, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x71, 0x80, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0xE0, 0x01, 0xC0, 0x07, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06,
  0x70, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x0E, 0x30, 0x03, 0xC0, 0x0E,
  0x30, 0x07, 0xE0, 0x0C, 0x38, 0x06, 0x60, 0x0C, 0x38, 0x06, 0x60, 0x1C,
  0x38, 0x06, 0x60, 0x1C, 0x18, 0x06, 0x60, 0x1C, 0x18, 0x0E, 0x70, 0x18,
  0x1C, 0x0E, 0x30, 0x18, 0x1C, 0x0C, 0x30, 0x38, 0x1C, 0x0C, 0x30, 0x38,
  0x0C, 0x0C, 0x30, 0x38, 0x0C, 0x1C, 0x38, 0x30, 0x0E, 0x1C, 0x18, 0x70,
  0x0E, 0x18, 0x18, 0x70, 0x0E, 0x18, 0x18, 0x70, 0x06, 0x18, 0x18, 0x60,
  0x06, 0x38, 0x1C, 0x60, 0x07, 0x38, 0x0C, 0xE0, 0x07, 0x30, 0x0C, 0xE0,
  0x07, 0x30, 0x0C, 0xE0, 0x03, 0x30, 0x0C, 0xC0, 0x03, 0x70, 0x0E, 0xC0,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0x80,
  0x70, 0x03, 0x98, 0x03, 0x8E, 0x01, 0xC3, 0x00, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x30, 0x30, 0x1C, 0x38, 0x0E, 0x1C, 0x03, 0x0C, 0x01, 0xCE, 0x00,
  0x66, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x37, 0x00, 0x39, 0x80, 0x1C,
  0xE0, 0x0C, 0x70, 0x0E, 0x18, 0x06, 0x0E, 0x07, 0x07, 0x03, 0x81, 0x81,
  0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0xF0, 0x01, 0x98, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x61,
  0x80, 0x70, 0xE0, 0x38, 0x70, 0x18, 0x18, 0x1C, 0x0E, 0x0E, 0x07, 0x06,
  0x01, 0x87, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x19, 0xC0, 0x0E, 0xE0, 0x03,
  0x60, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF,
  0x80, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xCC, 0x00, 0x73, 0x80, 0x18, 0x60, 0x0E, 0x1C,
  0x03, 0x03, 0x01, 0xC0, 0xE0, 0x60, 0x18, 0x38, 0x07, 0x0C, 0x00, 0xC7,
  0x00, 0x39, 0x80, 0x0E, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x1F, 0xE3, 0xFF, 0x88,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x7E, 0x1F, 0xF3, 0xE1, 0xBC, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3D, 0xC1, 0x6F, 0xFB, 0x3F,
  0x98, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE7,
  0xF0, 0xEF, 0xF8, 0xEC, 0x1C, 0xF8, 0x1C, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0,
  0x06, 0xF0, 0x0E, 0xF0, 0x0E, 0xF8, 0x1C, 0xFC, 0x3C, 0xCF, 0xF8, 0xC7,
  0xF0, 0x07, 0xF8, 0xFF, 0x87, 0x04, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x23, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x0F, 0xE7, 0x1F, 0xF7, 0x3C, 0x37, 0x38, 0x1F,
  0x70, 0x0F, 0x70, 0x0F, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x0F, 0x70, 0x0F, 0x30, 0x1F,
  0x38, 0x37, 0x1F, 0xF3, 0x0F, 0xE3, 0x0F, 0xE0, 0x3F, 0xE0, 0xE0, 0xE1,
  0x80, 0xC7, 0x01, 0xCC, 0x01, 0x98, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x03, 0x0F, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x7F, 0x0F, 0x20, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x07, 0xFC, 0xFF,
  0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xE3, 0x1F, 0xF7, 0x3C, 0x37, 0x38, 0x1F, 0x70, 0x0F, 0x70, 0x0F, 0x60,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x07, 0x60, 0x0F, 0x70, 0x0F, 0x30, 0x1F, 0x38, 0x37, 0x1F, 0xF7, 0x0F,
  0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x40, 0x1C, 0x60, 0x3C, 0x7F, 0xF8, 0x3F, 0xE0, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x39, 0xFC, 0xEF, 0xFB, 0xF0, 0xEF,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xFF, 0xB0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1C, 0x71, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xBE,
  0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x0E, 0xE0, 0x33,
  0x81, 0xCE, 0x0E, 0x38, 0x30, 0xE1, 0xC3, 0x86, 0x0E, 0x38, 0x39, 0xC0,
  0xE6, 0x03, 0xBC, 0x0E, 0xF0, 0x3E, 0xE0, 0xF3, 0x83, 0xC6, 0x0E, 0x1C,
  0x38, 0x30, 0xE0, 0xE3, 0x83, 0x8E, 0x06, 0x38, 0x1C, 0xE0, 0x33, 0x80,
  0xEE, 0x03, 0xB8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0xE1, 0xFC, 0xCF, 0xF1, 0xFE,
  0xD8, 0x73, 0x0E, 0xD0, 0x3E, 0x07, 0xF0, 0x1C, 0x07, 0xE0, 0x1C, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xC7, 0xF3, 0x3F,
  0xED, 0xC3, 0xB6, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0C, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x30,
  0x1C, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x38,
  0x1C, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0xC7, 0xF0, 0xCF, 0xF8, 0xCC,
  0x1C, 0xD8, 0x1C, 0xD0, 0x0E, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF8, 0x1C, 0xEC, 0x3C, 0xEF, 0xF8, 0xE7, 0xF0, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xE3, 0x1F, 0xF7, 0x3C,
  0x37, 0x38, 0x1F, 0x70, 0x0F, 0x70, 0x0F, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x70,
  0x0F, 0x38, 0x1F, 0x3C, 0x37, 0x1F, 0xF7, 0x0F, 0xC7, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xC7, 0xF3, 0xFC, 0xC7, 0x60,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x3F, 0xE7, 0xFF, 0x70, 0x2E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x06,
  0xC0, 0xEF, 0xFC, 0x7F, 0x80, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC1,
  0xFF, 0xFF, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x01, 0x80, 0xFC, 0x3E, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xC0, 0xB7, 0x06, 0xCF, 0xF3, 0x1F, 0x8C,
  0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0x77, 0x00, 0xC6, 0x03, 0x8C,
  0x07, 0x1C, 0x0E, 0x38, 0x18, 0x30, 0x30, 0x60, 0xE0, 0xC1, 0xC1, 0xC3,
  0x01, 0x86, 0x03, 0x1C, 0x06, 0x38, 0x0E, 0x60, 0x0C, 0xC0, 0x1B, 0x80,
  0x37, 0x00, 0x6C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0xE0,
  0x0E, 0x01, 0xD8, 0x03, 0x80, 0x67, 0x01, 0xE0, 0x19, 0xC0, 0x78, 0x06,
  0x70, 0x1F, 0x03, 0x8C, 0x06, 0xC0, 0xE3, 0x03, 0xB0, 0x30, 0xE0, 0xCC,
  0x0C, 0x38, 0x33, 0x03, 0x06, 0x0C, 0xE1, 0xC1, 0x83, 0x18, 0x70, 0x61,
  0xC6, 0x18, 0x1C, 0x61, 0x86, 0x07, 0x18, 0x63, 0x80, 0xC6, 0x1C, 0xE0,
  0x31, 0x83, 0x30, 0x0C, 0xE0, 0xCC, 0x03, 0xB0, 0x33, 0x00, 0x6C, 0x0D,
  0xC0, 0x1B, 0x03, 0xF0, 0x06, 0xC0, 0x78, 0x01, 0xB0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1D, 0xC0,
  0x77, 0x03, 0x8C, 0x0E, 0x38, 0x30, 0x61, 0xC1, 0xC6, 0x03, 0x38, 0x0E,
  0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03,
  0xB0, 0x0C, 0xE0, 0x73, 0x81, 0x87, 0x0E, 0x1C, 0x30, 0x31, 0xC0, 0xE7,
  0x01, 0xB8, 0x07, 0xE0, 0x0C, 0xC0, 0x0F, 0xC0, 0x1B, 0x80, 0x33, 0x00,
  0xE6, 0x01, 0xCE, 0x03, 0x1C, 0x06, 0x18, 0x1C, 0x30, 0x38, 0x70, 0x60,
  0xE0, 0xC0, 0xC3, 0x81, 0x87, 0x03, 0x8C, 0x07, 0x18, 0x06, 0x70, 0x0C,
  0xE0, 0x19, 0x80, 0x3B, 0x00, 0x36, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x10, 0x1F, 0x03, 0xF0, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3F,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0xBF, 0xE0, 0x78, 0x7D, 0xF8, 0x0F,
  0xE8, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 34, 10, 3, -34 },
  { 18, 10, 13, 16, 3, -34 },
  { 35, 19, 34, 21, 1, -34 },
  { 116, 16, 39, 19, 2, -36 },
  { 194, 25, 34, 29, 2, -34 },
  { 301, 19, 34, 20, 1, -34 },
  { 382, 3, 13, 9, 3, -34 },
  { 387, 9, 41, 13, 2, -34 },
  { 434, 9, 41, 13, 2, -34 },
  { 481, 13, 14, 17, 2, -36 },
  { 504, 17, 22, 20, 1, -28 },
  { 551, 5, 11, 9, 2, -5 },
  { 558, 10, 3, 13, 1, -14 },
  { 562, 4, 4, 10, 3, -4 },
  { 564, 15, 34, 16, 1, -34 },
  { 628, 15, 34, 19, 2, -34 },
  { 692, 10, 34, 19, 3, -34 },
  { 735, 15, 34, 19, 2, -34 },
  { 799, 15, 34, 19, 2, -34 },
  { 863, 18, 34, 19, 1, -34 },
  { 940, 15, 34, 19, 2, -34 },
  { 1004, 15, 35, 19, 2, -34 },
  { 1070, 15, 34, 19, 2, -34 },
  { 1134, 16, 34, 19, 2, -34 },
  { 1202, 15, 34, 19, 2, -34 },
  { 1266, 4, 25, 10, 3, -25 },
  { 1279, 5, 31, 10, 2, -25 },
  { 1299, 17, 20, 20, 1, -27 },
  { 1342, 17, 13, 20, 1, -23 },
  { 1370, 17, 20, 20, 1, -27 },
  { 1413, 12, 34, 14, 1, -34 },
  { 1464, 25, 38, 29, 2, -34 },
  { 1583, 19, 34, 19, 0, -34 },
  { 1664, 16, 34, 21, 4, -34 },
  { 1732, 17, 34, 20, 2, -34 },
  { 1805, 17, 34, 23, 4, -34 },
  { 1878, 12, 34, 18, 4, -34 },
  { 1929, 12, 34, 17, 4, -34 },
  { 1980, 20, 34, 25, 2, -34 },
  { 2065, 16, 34, 24, 4, -34 },
  { 2133, 8, 34, 12, 2, -34 },
  { 2167, 8, 43, 10, -2, -34 },
  { 2210, 16, 34, 19, 4, -34 },
  { 2278, 12, 34, 17, 4, -34 },
  { 2329, 25, 34, 32, 4, -34 },
  { 2436, 18, 34, 25, 4, -34 },
  { 2513, 21, 34, 25, 2, -34 },
  { 2603, 14, 34, 20, 4, -34 },
  { 2663, 21, 42, 25, 2, -34 },
  { 2774, 16, 34, 20, 4, -34 },
  { 2842, 15, 34, 19, 2, -34 },
  { 2906, 16, 34, 17, 0, -34 },
  { 2974, 17, 34, 24, 3, -34 },
  { 3047, 19, 34, 19, 0, -34 },
  { 3128, 32, 34, 32, 0, -34 },
  { 3264, 17, 34, 17, 0, -34 },
  { 3337, 17, 34, 17, 0, -34 },
  { 3410, 14, 34, 16, 1, -34 },
  { 3470, 9, 41, 15, 4, -34 },
  { 3517, 15, 34, 16, 1, -34 },
  { 3581, 9, 41, 15, 2, -34 },
  { 3628, 18, 17, 20, 1, -34 },
  { 3667, 20, 2, 20, 0, 4 },
  { 3672, 8, 8, 12, 2, -36 },
  { 3680, 13, 25, 18, 2, -25 },
  { 3721, 16, 36, 21, 3, -36 },
  { 3793, 13, 25, 16, 2, -25 },
  { 3834, 16, 36, 21, 2, -36 },
  { 3906, 15, 25, 19, 2, -25 },
  { 3953, 12, 36, 11, 0, -36 },
  { 4007, 16, 36, 21, 2, -25 },
  { 4079, 14, 36, 20, 3, -36 },
  { 4142, 3, 34, 9, 3, -34 },
  { 4155, 6, 45, 9, 0, -34 },
  { 4189, 14, 36, 17, 3, -36 },
  { 4252, 3, 36, 9, 3, -36 },
  { 4266, 24, 25, 30, 3, -25 },
  { 4341, 14, 25, 20, 3, -25 },
  { 4385, 16, 25, 20, 2, -25 },
  { 4435, 16, 36, 21, 3, -25 },
  { 4507, 16, 36, 21, 2, -25 },
  { 4579, 10, 25, 13, 3, -25 },
  { 4611, 12, 25, 15, 2, -25 },
  { 4649, 9, 31, 11, 1, -31 },
  { 4684, 14, 25, 20, 3, -25 },
  { 4728, 15, 25, 16, 0, -25 },
  { 4775, 26, 25, 26, 0, -25 },
  { 4857, 14, 25, 16, 1, -25 },
  { 4901, 15, 36, 16, 1, -25 },
  { 4969, 11, 25, 13, 1, -25 },
  { 5004, 12, 41, 17, 2, -34 },
  { 5066, 2, 47, 18, 8, -36 },
  { 5078, 12, 41, 17, 2, -34 },
  { 5140, 17, 5, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Light47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT47PT7B_H_
