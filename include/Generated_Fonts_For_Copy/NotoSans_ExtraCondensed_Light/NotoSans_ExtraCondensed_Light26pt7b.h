#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xAA, 0xA0, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x81, 0x10, 0x22, 0x04, 0x40, 0x88, 0x11, 0x1F, 0xF8, 0xCC, 0x11, 0x82,
  0x20, 0x44, 0x08, 0x8F, 0xFC, 0x22, 0x04, 0x41, 0x88, 0x23, 0x04, 0x40,
  0x88, 0x00, 0x08, 0x04, 0x0F, 0x8D, 0x6C, 0x84, 0x42, 0x21, 0x10, 0xC8,
  0x34, 0x07, 0x01, 0xC0, 0xB0, 0x4C, 0x22, 0x13, 0x09, 0x65, 0x9F, 0x01,
  0x00, 0x80, 0x40, 0x30, 0x21, 0x61, 0x0C, 0x84, 0x22, 0x10, 0x8C, 0x82,
  0x32, 0x08, 0xC8, 0x23, 0x40, 0x89, 0x79, 0x2D, 0x25, 0xA4, 0x4C, 0xB1,
  0x06, 0xC4, 0x13, 0x10, 0x4C, 0x43, 0x11, 0x08, 0x4C, 0x21, 0x21, 0x83,
  0x80, 0x18, 0x09, 0x06, 0x61, 0x98, 0x66, 0x19, 0x82, 0x40, 0xB0, 0x38,
  0x0E, 0x06, 0x83, 0x33, 0x84, 0xA1, 0xA8, 0x3A, 0x04, 0xC3, 0xB1, 0xA7,
  0xCC, 0xFE, 0x08, 0xC4, 0x42, 0x31, 0x08, 0x46, 0x31, 0x8C, 0x63, 0x08,
  0x43, 0x18, 0x43, 0x08, 0x20, 0x82, 0x18, 0x43, 0x18, 0x42, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x10, 0x8C, 0x46, 0x23, 0x00, 0x18, 0x10, 0x11, 0xFF,
  0x18, 0x28, 0x64, 0x46, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x6D, 0x2D, 0x00, 0xFF, 0xC0, 0xF0,
  0x03, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x1C, 0x1B, 0x18, 0x88, 0x64,
  0x16, 0x0B, 0x05, 0x82, 0xC1, 0xE0, 0xF0, 0x78, 0x2C, 0x16, 0x0B, 0x04,
  0x82, 0x63, 0x13, 0x0F, 0x00, 0x08, 0xCB, 0x98, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x3C, 0xFE, 0x83, 0x03, 0x01, 0x01, 0x03,
  0x03, 0x02, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x40, 0xC0, 0xFF,
  0x3C, 0xEE, 0x83, 0x01, 0x01, 0x01, 0x03, 0x02, 0x0C, 0x3C, 0x06, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x86, 0xFC, 0x01, 0x00, 0xC0, 0x30, 0x14,
  0x05, 0x02, 0x40, 0x90, 0x64, 0x11, 0x0C, 0x42, 0x11, 0x84, 0x41, 0x3F,
  0xFF, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7F, 0x3F, 0x90, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xFE, 0x21, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x04,
  0x02, 0x03, 0x43, 0x3F, 0x00, 0x07, 0x0F, 0x8C, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x98, 0xFE, 0x71, 0xB0, 0x58, 0x2C, 0x1E, 0x0F, 0x06, 0x82, 0x41,
  0x31, 0x8F, 0x80, 0xFF, 0xFF, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08,
  0x00, 0x1C, 0x3B, 0x10, 0xD8, 0x2C, 0x16, 0x09, 0x0C, 0xC4, 0x3C, 0x0E,
  0x09, 0x88, 0x6C, 0x14, 0x0E, 0x07, 0x03, 0xC1, 0x31, 0x8F, 0x80, 0x1C,
  0x7E, 0x42, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0xC1, 0x43, 0x67, 0x3D, 0x01,
  0x01, 0x03, 0x02, 0x06, 0x0C, 0x78, 0xB8, 0x00, 0x00, 0xF0, 0x6D, 0x00,
  0x00, 0x00, 0x36, 0x96, 0x80, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x06, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x60, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x0C, 0x1C, 0x38,
  0x30, 0x20, 0x00, 0x39, 0xD8, 0x18, 0x10, 0x20, 0xC1, 0x82, 0x0C, 0x30,
  0x40, 0x83, 0x06, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x03, 0x80, 0x3B, 0x81,
  0x83, 0x0C, 0x06, 0x20, 0x09, 0x84, 0x24, 0x3C, 0x51, 0x11, 0xCC, 0x47,
  0x31, 0x1C, 0x8C, 0x72, 0x31, 0xC8, 0xC7, 0x33, 0x34, 0x4C, 0x91, 0xCE,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x08, 0x0F, 0xC0, 0x0C, 0x01, 0xC0,
  0x28, 0x05, 0x01, 0xA0, 0x34, 0x04, 0xC0, 0x88, 0x11, 0x06, 0x20, 0x86,
  0x1F, 0xC2, 0x08, 0xC1, 0x18, 0x32, 0x06, 0x40, 0x58, 0x0B, 0x01, 0x80,
  0xF0, 0x7F, 0x20, 0xD0, 0x28, 0x14, 0x0A, 0x05, 0x06, 0x86, 0x7F, 0x20,
  0xD0, 0x28, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x43, 0xBF, 0x00, 0x07, 0x87,
  0x73, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x30, 0x06, 0x20, 0xF8, 0xF0, 0x3F,
  0x88, 0x32, 0x04, 0x81, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x38, 0x0E,
  0x02, 0x80, 0xA0, 0x28, 0x1A, 0x06, 0x83, 0x21, 0x8F, 0xC0, 0xFF, 0xFE,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x03, 0xF8, 0xFF, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFF,
  0xFC, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x07, 0x83, 0xFC, 0xC0,
  0x90, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xE0,
  0x14, 0x02, 0x80, 0x58, 0x0B, 0x01, 0x30, 0x23, 0x04, 0x3F, 0x80, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0xFB, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFC, 0x81, 0xC1, 0xA0,
  0x90, 0xC8, 0x44, 0x62, 0x61, 0x20, 0xB0, 0x58, 0x36, 0x19, 0x08, 0xC4,
  0x22, 0x19, 0x04, 0x83, 0x40, 0xA0, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8,
  0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xE8, 0x05, 0xA0, 0x1E, 0xC0, 0xF9, 0x02,
  0xE4, 0x0B, 0x90, 0x6E, 0x61, 0x38, 0x84, 0xE2, 0x13, 0x8C, 0xCE, 0x12,
  0x38, 0x48, 0xE1, 0x63, 0x87, 0x0E, 0x0C, 0x38, 0x30, 0xC0, 0xC0, 0x70,
  0x1E, 0x06, 0x81, 0xA0, 0x6C, 0x19, 0x06, 0x61, 0x88, 0x63, 0x18, 0x46,
  0x19, 0x86, 0x60, 0x98, 0x36, 0x05, 0x81, 0xE0, 0x38, 0x0C, 0x0F, 0x03,
  0xF0, 0xC3, 0x30, 0x24, 0x06, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x14, 0x02, 0x80, 0x50, 0x1B, 0x03, 0x20, 0x46, 0x18, 0x7E,
  0x00, 0xE0, 0xFE, 0x82, 0x83, 0x81, 0x81, 0x81, 0x83, 0x83, 0x86, 0xFC,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x03, 0xF0, 0xC3,
  0x30, 0x24, 0x06, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x14, 0x02, 0x80, 0x50, 0x1B, 0x03, 0x20, 0x46, 0x18, 0x7C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0xF0, 0x7F, 0x20, 0x90, 0x68, 0x14, 0x0A, 0x05,
  0x06, 0x82, 0x47, 0x3E, 0x11, 0x08, 0xC4, 0x22, 0x19, 0x04, 0x83, 0x40,
  0xA0, 0x60, 0x1E, 0x7F, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x70, 0x1C,
  0x06, 0x03, 0x01, 0x01, 0x01, 0x01, 0x03, 0x86, 0xFC, 0xFF, 0xFF, 0xC2,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xC1, 0xB1, 0x8F, 0x80, 0xC0, 0x78, 0x0B, 0x01, 0x20, 0x64, 0x0C,
  0xC1, 0x18, 0x21, 0x0C, 0x21, 0x86, 0x20, 0xC4, 0x09, 0x81, 0x30, 0x24,
  0x06, 0x80, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x00, 0xC0, 0xC0, 0xF0, 0x30,
  0x24, 0x0C, 0x09, 0x03, 0x02, 0x41, 0xC1, 0x98, 0x58, 0x66, 0x16, 0x10,
  0x84, 0x84, 0x21, 0x23, 0x08, 0xC8, 0xC3, 0x23, 0x30, 0xC8, 0xC8, 0x12,
  0x12, 0x04, 0x85, 0x81, 0x61, 0x60, 0x78, 0x50, 0x0C, 0x1C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x40, 0xB0, 0xC8, 0x44, 0x23, 0x30, 0x90, 0x58, 0x38,
  0x0C, 0x06, 0x03, 0x03, 0xC1, 0x21, 0x90, 0x8C, 0x42, 0x61, 0x20, 0xF0,
  0x20, 0xC0, 0xE0, 0xD0, 0x6C, 0x26, 0x31, 0x10, 0x88, 0x6C, 0x14, 0x0A,
  0x07, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFF,
  0xFC, 0x18, 0x30, 0x41, 0x82, 0x04, 0x18, 0x20, 0xC1, 0x82, 0x0C, 0x10,
  0x20, 0xC1, 0x03, 0xF8, 0xFF, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x80, 0xC0, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06,
  0x02, 0x03, 0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x01, 0x00, 0xA0, 0x28, 0x11, 0x04,
  0x42, 0x18, 0x82, 0x60, 0xF0, 0x10, 0xFF, 0xE0, 0xC6, 0x21, 0x7C, 0x8C,
  0x08, 0x10, 0x20, 0x4F, 0xB1, 0xC3, 0x06, 0x0C, 0x1C, 0x6F, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xA6, 0xC3, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC3, 0xA2, 0xBE, 0x1E, 0x65, 0x82, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x02, 0x06, 0x27, 0xC0, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0xF6, 0xC7, 0x41, 0xA0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xA0, 0xD8, 0xA7, 0x90, 0x3C, 0x62, 0x43, 0x41, 0xC1,
  0xC1, 0xFF, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x61, 0x3F, 0x1E, 0x64, 0xC1,
  0x02, 0x04, 0x3F, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x00, 0x3C, 0xB1, 0x50, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x68, 0x36, 0x39, 0xEC, 0x06, 0x03, 0x01, 0x80, 0x90,
  0xCF, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xA6, 0xC2, 0xC2,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xB0, 0x2A,
  0xAA, 0xAA, 0xA8, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4B,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x21, 0xC2, 0x8D, 0x32, 0x45, 0x8B,
  0x1B, 0x22, 0x44, 0x8D, 0x0A, 0x1C, 0x10, 0xFF, 0xFF, 0xF0, 0xBC, 0xF5,
  0x3C, 0xF1, 0xC7, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x04, 0xBC, 0xA6, 0xC2,
  0x82, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x3E,
  0x31, 0x90, 0x48, 0x2C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x68,
  0x26, 0x31, 0xF0, 0x9C, 0xA6, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC1, 0xC3, 0xA6, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3C,
  0xB1, 0x50, 0x68, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x68,
  0x36, 0x39, 0xEC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x9D, 0xF1,
  0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x7F, 0x8A, 0x04, 0x0C, 0x08,
  0x1C, 0x0C, 0x0C, 0x0C, 0x18, 0x38, 0xDF, 0x00, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C, 0x3C, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x3C, 0x6F, 0x40, 0xC1, 0xE0,
  0x90, 0x48, 0x66, 0x23, 0x10, 0x88, 0x4C, 0x24, 0x1A, 0x05, 0x03, 0x81,
  0x80, 0xC0, 0xC3, 0x05, 0x0C, 0x14, 0x38, 0xD0, 0xA3, 0x62, 0x89, 0x9A,
  0x22, 0x48, 0x89, 0x36, 0x24, 0x50, 0xD1, 0x41, 0xC5, 0x06, 0x14, 0x18,
  0x70, 0x60, 0x80, 0x41, 0x31, 0x88, 0x86, 0xC1, 0x40, 0xA0, 0x30, 0x38,
  0x14, 0x1B, 0x08, 0x84, 0x46, 0x36, 0x0C, 0xC1, 0xA0, 0x90, 0x4C, 0x26,
  0x31, 0x10, 0x88, 0x64, 0x36, 0x0A, 0x05, 0x02, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x18, 0x08, 0x0C, 0x1C, 0x00, 0xFC, 0x30, 0x86, 0x10, 0x43, 0x08,
  0x61, 0x84, 0x30, 0x83, 0xF0, 0x02, 0x1C, 0x60, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0xC7, 0x07, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xE0, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x70, 0xC3, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x06, 0x38, 0x00, 0x20, 0x7C, 0x63, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 11, 19, 11, 0, -19 },
  { 38, 9, 22, 11, 1, -20 },
  { 63, 14, 19, 16, 1, -19 },
  { 97, 10, 19, 11, 1, -19 },
  { 121, 1, 7, 5, 2, -19 },
  { 122, 5, 23, 7, 1, -19 },
  { 137, 5, 23, 7, 1, -19 },
  { 152, 8, 8, 10, 1, -20 },
  { 160, 9, 12, 11, 1, -15 },
  { 174, 3, 6, 5, 1, -3 },
  { 177, 5, 2, 7, 1, -8 },
  { 179, 2, 2, 5, 2, -2 },
  { 180, 8, 19, 9, 1, -19 },
  { 199, 9, 19, 11, 1, -19 },
  { 221, 5, 19, 11, 2, -19 },
  { 233, 8, 19, 11, 1, -19 },
  { 252, 8, 19, 11, 1, -19 },
  { 271, 10, 19, 11, 0, -19 },
  { 295, 9, 19, 11, 1, -19 },
  { 317, 9, 19, 11, 1, -19 },
  { 339, 9, 19, 11, 1, -19 },
  { 361, 9, 19, 11, 1, -19 },
  { 383, 8, 19, 11, 1, -19 },
  { 402, 2, 14, 5, 2, -14 },
  { 406, 3, 17, 5, 1, -14 },
  { 413, 9, 11, 11, 1, -15 },
  { 426, 9, 7, 11, 1, -13 },
  { 434, 9, 11, 11, 1, -15 },
  { 447, 7, 19, 8, 0, -19 },
  { 464, 14, 21, 16, 1, -19 },
  { 501, 11, 19, 11, 0, -19 },
  { 528, 9, 19, 12, 2, -19 },
  { 550, 10, 19, 11, 1, -19 },
  { 574, 10, 19, 13, 2, -19 },
  { 598, 7, 19, 10, 2, -19 },
  { 615, 7, 19, 10, 2, -19 },
  { 632, 11, 19, 14, 1, -19 },
  { 659, 9, 19, 13, 2, -19 },
  { 681, 5, 19, 7, 1, -19 },
  { 693, 4, 24, 5, -1, -19 },
  { 705, 9, 19, 11, 2, -19 },
  { 727, 7, 19, 9, 2, -19 },
  { 744, 14, 19, 18, 2, -19 },
  { 778, 10, 19, 14, 2, -19 },
  { 802, 11, 19, 14, 1, -19 },
  { 829, 8, 19, 11, 2, -19 },
  { 848, 11, 23, 14, 1, -19 },
  { 880, 9, 19, 11, 2, -19 },
  { 902, 8, 19, 10, 1, -19 },
  { 921, 9, 19, 9, 0, -19 },
  { 943, 9, 19, 13, 2, -19 },
  { 965, 11, 19, 11, 0, -19 },
  { 992, 18, 19, 18, 0, -19 },
  { 1035, 9, 19, 10, 0, -19 },
  { 1057, 9, 19, 9, 0, -19 },
  { 1079, 7, 19, 9, 1, -19 },
  { 1096, 5, 23, 8, 2, -19 },
  { 1111, 8, 19, 9, 1, -19 },
  { 1130, 5, 23, 8, 1, -19 },
  { 1145, 10, 10, 11, 0, -19 },
  { 1158, 11, 1, 11, 0, 2 },
  { 1160, 4, 4, 6, 1, -20 },
  { 1162, 7, 14, 10, 1, -14 },
  { 1175, 8, 20, 12, 2, -20 },
  { 1195, 7, 14, 9, 1, -14 },
  { 1208, 9, 20, 12, 1, -20 },
  { 1231, 8, 14, 10, 1, -14 },
  { 1245, 7, 20, 6, 0, -20 },
  { 1263, 9, 20, 11, 1, -14 },
  { 1286, 8, 20, 11, 2, -20 },
  { 1306, 2, 19, 5, 2, -19 },
  { 1311, 3, 25, 5, 0, -19 },
  { 1321, 7, 20, 9, 2, -20 },
  { 1339, 1, 20, 5, 2, -20 },
  { 1342, 13, 14, 17, 2, -14 },
  { 1365, 8, 14, 11, 2, -14 },
  { 1379, 9, 14, 11, 1, -14 },
  { 1395, 8, 20, 12, 2, -14 },
  { 1415, 9, 20, 11, 1, -14 },
  { 1438, 5, 14, 7, 2, -14 },
  { 1447, 7, 14, 8, 1, -14 },
  { 1460, 6, 17, 6, 0, -17 },
  { 1473, 7, 14, 11, 2, -14 },
  { 1486, 9, 14, 9, 0, -14 },
  { 1502, 14, 14, 15, 0, -14 },
  { 1527, 9, 14, 9, 0, -14 },
  { 1543, 9, 20, 9, 0, -14 },
  { 1566, 6, 14, 7, 1, -14 },
  { 1577, 7, 23, 9, 1, -19 },
  { 1598, 2, 26, 10, 4, -20 },
  { 1605, 7, 23, 9, 1, -19 },
  { 1626, 9, 3, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Light26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT26PT7B_H_
