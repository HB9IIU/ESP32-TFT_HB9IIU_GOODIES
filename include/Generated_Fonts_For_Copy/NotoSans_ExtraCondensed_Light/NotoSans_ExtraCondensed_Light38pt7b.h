#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x02, 0xFF, 0x00,
  0xE3, 0xE3, 0xE3, 0x63, 0x63, 0x63, 0x43, 0x43, 0x43, 0x43, 0x06, 0x18,
  0x0C, 0x30, 0x10, 0x40, 0x20, 0x80, 0x41, 0x01, 0x86, 0x03, 0x0C, 0x06,
  0x18, 0x7F, 0xFE, 0x18, 0x60, 0x30, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x04,
  0x06, 0x18, 0x0C, 0x30, 0x18, 0x61, 0xFF, 0xF8, 0x61, 0x80, 0xC3, 0x01,
  0x04, 0x02, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0xC3, 0xFF, 0x39, 0x09, 0x88,
  0x08, 0x40, 0xC2, 0x06, 0x10, 0x30, 0x80, 0xC4, 0x07, 0x20, 0x1D, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x13, 0x80, 0x8E, 0x04, 0x30, 0x21, 0x81,
  0x0C, 0x08, 0x60, 0x43, 0x82, 0x37, 0x97, 0x9F, 0xF8, 0x1C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x10, 0x00, 0x07, 0xC0, 0x60, 0x66, 0x06, 0x0C,
  0x60, 0x40, 0xC2, 0x0C, 0x0C, 0x20, 0xC0, 0x83, 0x08, 0x08, 0x31, 0x80,
  0x83, 0x18, 0x08, 0x31, 0x00, 0x83, 0x30, 0x08, 0x33, 0x18, 0xC2, 0x27,
  0xCC, 0x26, 0x66, 0xC6, 0x6C, 0x66, 0x6C, 0xC3, 0x7C, 0xCC, 0x31, 0x0C,
  0xC3, 0x01, 0x8C, 0x30, 0x18, 0xC3, 0x01, 0x8C, 0x30, 0x30, 0xC3, 0x03,
  0x0C, 0x30, 0x30, 0xC3, 0x06, 0x0C, 0x20, 0x60, 0x46, 0x06, 0x06, 0xE0,
  0xC0, 0x3C, 0x02, 0x00, 0x1F, 0x00, 0x67, 0x00, 0xC6, 0x03, 0x0C, 0x06,
  0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x31, 0x80, 0x66, 0x00, 0x6C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x19, 0x80, 0x73, 0x8E, 0xC3, 0x19,
  0x83, 0x36, 0x06, 0x6C, 0x06, 0xD8, 0x0F, 0x30, 0x0E, 0x70, 0x1C, 0x60,
  0x78, 0xE1, 0xD8, 0xFF, 0x38, 0xFC, 0x30, 0xFF, 0xB6, 0xDA, 0x48, 0x06,
  0x18, 0x60, 0xC3, 0x86, 0x0C, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC0, 0xC1, 0x83,
  0x83, 0x03, 0x06, 0x06, 0xE0, 0x60, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C,
  0x0E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60,
  0xE0, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xED, 0xFF, 0xE0, 0xC0, 0x78, 0x33,
  0x18, 0x66, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x39, 0x8C, 0x67,
  0x31, 0x8C, 0xC0, 0xFF, 0xFF, 0x5F, 0xB0, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x00,
  0x04, 0x01, 0xF8, 0x3F, 0xC7, 0x0C, 0x60, 0x66, 0x06, 0xE0, 0x6C, 0x06,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x06, 0xE0, 0x66, 0x06,
  0x60, 0xE7, 0x0C, 0x3F, 0xC1, 0xF8, 0x06, 0x1C, 0x7B, 0xBE, 0x78, 0xE1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x02, 0x01, 0xFE, 0x1F, 0x78, 0xC0,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x02, 0x01, 0xFE, 0x3E, 0x78, 0x80, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x1C, 0x0F, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x34, 0x03, 0x9E, 0xF8,
  0xFF, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0x60, 0x0D,
  0x80, 0x26, 0x01, 0x98, 0x04, 0x60, 0x31, 0x80, 0x86, 0x06, 0x18, 0x18,
  0x60, 0xC1, 0x83, 0x06, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x06, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xF8, 0xF7, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x0E, 0x81, 0xCF, 0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xE6, 0x38, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x0D,
  0xFC, 0xF0, 0xEE, 0x06, 0xE0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x60, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0xFE, 0x0F,
  0x38, 0x60, 0x66, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x39, 0x81,
  0x8C, 0x1C, 0x31, 0xC0, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0x9C, 0x30, 0x73,
  0x81, 0x98, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x6C, 0x03, 0x60,
  0x3B, 0x81, 0x8F, 0xF8, 0x3F, 0x80, 0x02, 0x00, 0xFE, 0x0F, 0x78, 0x60,
  0xC6, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x17, 0x00, 0xD8, 0x06,
  0xC0, 0x76, 0x03, 0xB0, 0x1D, 0xC1, 0xE7, 0x1B, 0x1F, 0x98, 0x79, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x0E,
  0x0F, 0xE0, 0x7E, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x5F, 0xB0,
  0x33, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0x8C,
  0x67, 0x31, 0x8C, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x04, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x18, 0x7F,
  0x39, 0xD0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x1C, 0x0E, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x78, 0xF0, 0x0C,
  0x03, 0x81, 0x80, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x06, 0x20, 0x00, 0x66,
  0x07, 0x86, 0x60, 0xFC, 0x24, 0x18, 0xC3, 0xC3, 0x0C, 0x3C, 0x30, 0xC3,
  0xC3, 0x0C, 0x3C, 0x20, 0xC3, 0xC2, 0x0C, 0x3C, 0x20, 0xC3, 0xC2, 0x0C,
  0x3C, 0x20, 0xC3, 0xC3, 0x1C, 0x3C, 0x31, 0x46, 0xC3, 0x34, 0x6C, 0x1E,
  0x7C, 0x60, 0x43, 0x86, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x20, 0x0F, 0x1C, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x0C, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x30, 0x18,
  0x30, 0x18, 0x18, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0x18, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x06, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x30, 0x39, 0x80, 0xEC, 0x03, 0x60,
  0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x19, 0x81, 0x8F, 0xF8,
  0x7F, 0xE3, 0x01, 0x98, 0x06, 0xC0, 0x36, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xD8, 0x0E, 0xC0, 0xE7, 0xFF, 0x3F, 0xE0, 0x00,
  0x80, 0x3F, 0xC3, 0xCE, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x43, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFF,
  0x0C, 0x0E, 0x30, 0x1C, 0xC0, 0x33, 0x00, 0xEC, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC,
  0x03, 0x30, 0x1C, 0xC1, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x03, 0xFE, 0x0F, 0x9F, 0x1C,
  0x02, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x70, 0x03, 0x30, 0x03, 0x38, 0x03, 0x1C, 0x03, 0x0F, 0xFF, 0x03,
  0xFE, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xC0, 0xFE, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x7B,
  0xF8, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x86, 0xFD, 0xF0, 0xC0, 0x36, 0x03, 0x30, 0x19,
  0x81, 0x8C, 0x1C, 0x60, 0xC3, 0x0E, 0x18, 0x60, 0xC6, 0x06, 0x30, 0x33,
  0x01, 0xB8, 0x0D, 0xC0, 0x7E, 0x03, 0x98, 0x1C, 0xC0, 0xC7, 0x06, 0x18,
  0x30, 0xE1, 0x83, 0x0C, 0x1C, 0x60, 0x63, 0x03, 0x98, 0x0C, 0xC0, 0x76,
  0x01, 0xB0, 0x0E, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF,
  0xFC, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFD, 0x80, 0x1B, 0xD8, 0x01, 0xBD, 0x80, 0x1B, 0xD8, 0x01, 0xBC,
  0xC0, 0x33, 0xCC, 0x03, 0x3C, 0xC0, 0x33, 0xC6, 0x06, 0x3C, 0x60, 0x63,
  0xC6, 0x06, 0x3C, 0x20, 0x43, 0xC3, 0x0C, 0x3C, 0x30, 0xC3, 0xC3, 0x0C,
  0x3C, 0x19, 0x83, 0xC1, 0x98, 0x3C, 0x19, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x03, 0xC0, 0x60, 0x30, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7B, 0x00, 0xF6, 0x01, 0xE6, 0x03,
  0xCC, 0x07, 0x8C, 0x0F, 0x18, 0x1E, 0x30, 0x3C, 0x30, 0x78, 0x60, 0xF0,
  0x61, 0xE0, 0xC3, 0xC0, 0xC7, 0x81, 0x8F, 0x03, 0x9E, 0x03, 0x3C, 0x06,
  0x78, 0x06, 0xF0, 0x0D, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x38,
  0x00, 0x80, 0x0F, 0xF0, 0x1F, 0x78, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0E,
  0x30, 0x0C, 0x18, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0x0F, 0xFC, 0xC1,
  0xEC, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x6C, 0x06, 0xC0, 0xEC, 0x1C, 0xFF, 0x8F, 0xE0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x0F, 0xF0, 0x1F, 0x78, 0x38, 0x1C, 0x30, 0x0C, 0x70,
  0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0x70,
  0x0E, 0x30, 0x0C, 0x18, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0xFF, 0x07, 0xFE,
  0x30, 0x79, 0x80, 0xCC, 0x06, 0x60, 0x3B, 0x00, 0xD8, 0x06, 0xC0, 0x36,
  0x03, 0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x7F, 0xC3, 0xFC, 0x18, 0xE0, 0xC3,
  0x06, 0x1C, 0x30, 0x61, 0x83, 0x0C, 0x0C, 0x60, 0x63, 0x03, 0x98, 0x0C,
  0xC0, 0x76, 0x01, 0xB0, 0x0E, 0x02, 0x01, 0xFE, 0x7D, 0xE6, 0x02, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x68, 0x0C, 0xFF, 0xCF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB8,
  0x0E, 0x70, 0x30, 0xFF, 0xC1, 0xFC, 0x00, 0xC0, 0x07, 0xC0, 0x0D, 0x80,
  0x1B, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x18,
  0x60, 0x30, 0xE0, 0x60, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x07, 0x0C, 0x06,
  0x18, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x6C, 0x00, 0xD8,
  0x01, 0xB0, 0x01, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xD8, 0x03, 0x00, 0x66, 0x01, 0xE0, 0x19, 0x80, 0x78, 0x06, 0x60,
  0x1E, 0x01, 0x98, 0x07, 0x80, 0xE3, 0x01, 0xE0, 0x30, 0xC0, 0xC8, 0x0C,
  0x30, 0x33, 0x03, 0x0C, 0x0C, 0xC0, 0xC3, 0x83, 0x30, 0x70, 0x60, 0xCC,
  0x18, 0x18, 0x61, 0x06, 0x06, 0x18, 0x61, 0x81, 0x86, 0x18, 0x60, 0x71,
  0x86, 0x38, 0x0C, 0x61, 0x8C, 0x03, 0x30, 0x23, 0x00, 0xCC, 0x0C, 0xC0,
  0x33, 0x03, 0x30, 0x06, 0xC0, 0xD8, 0x01, 0xB0, 0x36, 0x00, 0x68, 0x05,
  0x80, 0x1E, 0x01, 0x60, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x70, 0x18, 0xC0, 0x63, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x61,
  0x80, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x1B, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x06,
  0x18, 0x18, 0x60, 0x61, 0xC3, 0x03, 0x0C, 0x0C, 0x70, 0x39, 0x80, 0x6E,
  0x01, 0xC0, 0xC0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x63, 0x03, 0x18, 0x38,
  0xC1, 0x83, 0x0C, 0x18, 0xE0, 0xC6, 0x03, 0x30, 0x1B, 0x00, 0xD8, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0xFF, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x00, 0x0E, 0x00, 0x78,
  0x01, 0xA0, 0x0C, 0xC0, 0x33, 0x01, 0x86, 0x06, 0x18, 0x30, 0x30, 0xC0,
  0xC6, 0x01, 0x98, 0x06, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0x87, 0x0C, 0x18, 0x30, 0x03, 0x07, 0xF8, 0xC3, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xFC, 0x7F, 0x9C, 0x36, 0x06, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x6C, 0x0D, 0x82, 0xB9, 0xD3, 0xF2, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC6, 0x0D,
  0xFC, 0xF9, 0xCE, 0x06, 0xE0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7E,
  0x06, 0xE0, 0xE9, 0xFC, 0x8F, 0x80, 0x02, 0x07, 0xF3, 0x89, 0xC0, 0x60,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xF7, 0x1F, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x06, 0x33, 0xFB,
  0x39, 0xB6, 0x07, 0x60, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x07,
  0x60, 0x73, 0xB9, 0x1F, 0x10, 0x04, 0x01, 0xF8, 0x39, 0xC6, 0x0C, 0x60,
  0x6C, 0x06, 0xC0, 0x6C, 0x02, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x23, 0xDE, 0x1F,
  0xC0, 0x07, 0xC3, 0xE1, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x3F, 0xCF, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x04, 0x03, 0xF9, 0x39, 0xF6, 0x07, 0x60, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x07, 0x60, 0xF3, 0xBB, 0x1F, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x68, 0x0E, 0xFF, 0xC7, 0xF8, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC6, 0x1B,
  0xF3, 0xE7, 0x70, 0x6E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x06, 0x7F, 0xA0, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB0, 0x19, 0xCE, 0x20, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xCD,
  0xEE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x3B, 0x06, 0x61, 0x8C, 0x31, 0x8C, 0x33, 0x86, 0x60,
  0xD8, 0x1B, 0x83, 0xF0, 0x73, 0x0C, 0x61, 0x8C, 0x30, 0xC6, 0x18, 0xC1,
  0x98, 0x33, 0x07, 0x60, 0x6C, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x04, 0x03, 0x13, 0xF1, 0xF2, 0xC6, 0x67, 0x50, 0x78, 0x7C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x06, 0x03, 0xC0, 0xC0, 0x78,
  0x18, 0x0F, 0x03, 0x01, 0xE0, 0x60, 0x3C, 0x0C, 0x07, 0x81, 0x80, 0xF0,
  0x30, 0x1E, 0x06, 0x03, 0xC0, 0xC0, 0x78, 0x18, 0x0F, 0x03, 0x01, 0xE0,
  0x60, 0x3C, 0x0C, 0x06, 0x06, 0x13, 0xF2, 0xE7, 0x50, 0x6E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0x06, 0x01, 0xFC,
  0x38, 0xC6, 0x06, 0x60, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06,
  0x70, 0x63, 0xFC, 0x1F, 0x80, 0x06, 0x09, 0xF8, 0x99, 0xCA, 0x06, 0xA0,
  0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7E, 0x06, 0xF0, 0xED, 0xFC, 0xCF,
  0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x04, 0x01, 0xF9, 0x39, 0xB6, 0x07, 0x60, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x07, 0x70, 0xF3, 0xFB, 0x1F, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x07,
  0x3E, 0x7D, 0x8A, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x04, 0x0F, 0xF7, 0x0D, 0x80, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x1F, 0xFE, 0x7F, 0x00, 0x30, 0x60, 0xC1,
  0x83, 0x1F, 0xFF, 0x98, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1D, 0x1E, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x2D, 0xFD, 0xBF, 0x30, 0xC0,
  0x36, 0x03, 0x60, 0x36, 0x07, 0x60, 0x63, 0x06, 0x30, 0x63, 0x06, 0x30,
  0xC1, 0x0C, 0x18, 0xC1, 0x8C, 0x19, 0x80, 0x98, 0x0D, 0x80, 0xD8, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x70, 0x1B, 0x03, 0x80, 0x98, 0x1C,
  0x0C, 0xC0, 0xF0, 0x66, 0x05, 0x83, 0x18, 0x6C, 0x18, 0xC3, 0x61, 0x86,
  0x19, 0x0C, 0x30, 0xCC, 0x61, 0x8C, 0x63, 0x06, 0x63, 0x18, 0x33, 0x19,
  0x81, 0x98, 0x4C, 0x0C, 0x83, 0x60, 0x2C, 0x1B, 0x01, 0xE0, 0xD0, 0x0F,
  0x07, 0x80, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0xC0, 0x66,
  0x0E, 0x60, 0xC3, 0x1C, 0x31, 0x81, 0x98, 0x1B, 0x01, 0xB0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xF0, 0x1B, 0x01, 0xB8, 0x31, 0x83, 0x18, 0x60, 0xC6,
  0x0C, 0xC0, 0x6C, 0x07, 0x60, 0x1B, 0x01, 0x98, 0x0C, 0xE0, 0x63, 0x03,
  0x18, 0x30, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC6, 0x06, 0x30, 0x11, 0x80,
  0xCC, 0x06, 0xC0, 0x36, 0x00, 0xB0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70,
  0x3F, 0xFF, 0xF0, 0x03, 0xC1, 0xF0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x83, 0xE0, 0xE0,
  0x1E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3E, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x1E, 0x01, 0xC1, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x83, 0xE0, 0xE0,
  0x00, 0x7E, 0x07, 0xBE, 0x78, 0x1F, 0x80, 0x08,
};

const GFXglyph NotoSans_ExtraCondensed_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 27, 8, 3, -27 },
  { 12, 8, 10, 13, 2, -27 },
  { 22, 15, 27, 17, 1, -27 },
  { 73, 13, 31, 16, 1, -29 },
  { 124, 20, 28, 23, 2, -28 },
  { 194, 15, 28, 16, 1, -28 },
  { 247, 3, 10, 7, 2, -27 },
  { 251, 7, 33, 11, 2, -27 },
  { 280, 8, 33, 11, 1, -27 },
  { 313, 10, 11, 14, 2, -29 },
  { 327, 14, 17, 16, 1, -22 },
  { 357, 5, 9, 8, 1, -4 },
  { 363, 8, 2, 10, 1, -11 },
  { 365, 3, 4, 8, 2, -4 },
  { 367, 12, 27, 13, 1, -27 },
  { 408, 12, 28, 16, 2, -28 },
  { 450, 7, 27, 16, 3, -27 },
  { 474, 13, 28, 16, 1, -28 },
  { 520, 13, 28, 16, 1, -28 },
  { 566, 14, 27, 16, 1, -27 },
  { 614, 12, 27, 16, 2, -27 },
  { 655, 12, 27, 16, 2, -27 },
  { 696, 13, 27, 16, 1, -27 },
  { 740, 13, 28, 16, 1, -28 },
  { 786, 13, 28, 16, 1, -28 },
  { 832, 3, 20, 8, 2, -20 },
  { 840, 5, 25, 8, 1, -20 },
  { 856, 14, 17, 16, 1, -22 },
  { 886, 14, 10, 16, 1, -18 },
  { 904, 14, 17, 16, 1, -22 },
  { 934, 9, 28, 11, 1, -28 },
  { 966, 20, 30, 24, 2, -27 },
  { 1041, 16, 27, 16, 0, -27 },
  { 1095, 13, 27, 17, 3, -27 },
  { 1139, 13, 28, 16, 2, -28 },
  { 1185, 14, 27, 19, 3, -27 },
  { 1233, 10, 27, 15, 3, -27 },
  { 1267, 10, 27, 14, 3, -27 },
  { 1301, 16, 28, 20, 2, -28 },
  { 1357, 14, 27, 19, 3, -27 },
  { 1405, 7, 27, 10, 1, -27 },
  { 1429, 7, 34, 8, -2, -27 },
  { 1459, 13, 27, 16, 3, -27 },
  { 1503, 10, 27, 14, 3, -27 },
  { 1537, 20, 27, 26, 3, -27 },
  { 1605, 15, 27, 20, 3, -27 },
  { 1656, 16, 28, 20, 2, -28 },
  { 1712, 12, 27, 16, 3, -27 },
  { 1753, 16, 34, 20, 2, -28 },
  { 1821, 13, 27, 16, 3, -27 },
  { 1865, 12, 28, 15, 2, -28 },
  { 1907, 13, 27, 14, 0, -27 },
  { 1951, 14, 27, 19, 3, -27 },
  { 1999, 15, 27, 15, 0, -27 },
  { 2050, 26, 27, 26, 0, -27 },
  { 2138, 14, 27, 14, 0, -27 },
  { 2186, 13, 27, 13, 0, -27 },
  { 2230, 11, 27, 13, 1, -27 },
  { 2268, 7, 33, 12, 3, -27 },
  { 2297, 12, 27, 13, 1, -27 },
  { 2338, 8, 33, 12, 1, -27 },
  { 2371, 14, 14, 16, 1, -27 },
  { 2396, 16, 2, 16, 0, 3 },
  { 2400, 6, 6, 9, 2, -29 },
  { 2405, 11, 21, 15, 1, -21 },
  { 2434, 12, 29, 17, 3, -29 },
  { 2478, 10, 21, 13, 2, -21 },
  { 2505, 12, 29, 17, 2, -29 },
  { 2549, 12, 21, 15, 2, -21 },
  { 2581, 10, 29, 9, 0, -29 },
  { 2618, 12, 30, 17, 2, -21 },
  { 2663, 11, 29, 16, 3, -29 },
  { 2703, 3, 28, 7, 2, -28 },
  { 2714, 5, 37, 7, 0, -28 },
  { 2738, 11, 29, 14, 3, -29 },
  { 2778, 2, 29, 7, 3, -29 },
  { 2786, 19, 21, 25, 3, -21 },
  { 2836, 11, 21, 16, 3, -21 },
  { 2865, 12, 21, 16, 2, -21 },
  { 2897, 12, 30, 17, 3, -21 },
  { 2942, 12, 30, 17, 2, -21 },
  { 2987, 7, 21, 11, 3, -21 },
  { 3006, 10, 21, 12, 1, -21 },
  { 3033, 7, 25, 9, 1, -25 },
  { 3055, 11, 20, 16, 3, -20 },
  { 3083, 12, 20, 13, 0, -20 },
  { 3113, 21, 20, 21, 0, -20 },
  { 3166, 12, 20, 13, 1, -20 },
  { 3196, 13, 29, 13, 0, -20 },
  { 3244, 9, 20, 11, 1, -20 },
  { 3267, 10, 33, 13, 2, -27 },
  { 3309, 2, 38, 15, 6, -29 },
  { 3319, 10, 33, 13, 2, -27 },
  { 3361, 14, 4, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Light38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT38PT7B_H_
