#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0xEF, 0xFF, 0xF0, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0x70, 0x77, 0x07, 0x70, 0x76, 0x07, 0x60, 0x76, 0x07,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x18,
  0x00, 0xE0, 0x60, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x30, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x01, 0xC0,
  0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x81, 0x81, 0x80, 0x0E,
  0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0E,
  0x00, 0x30, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00,
  0x70, 0x30, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xEC, 0xF9, 0xE3, 0x04,
  0x70, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0xE0, 0xC0, 0x38,
  0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0x70, 0xC0, 0x1E, 0x30, 0x03, 0xCC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xCF, 0x00, 0x30, 0xE0, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0x78, 0x0C,
  0x3B, 0x83, 0x1E, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0xFC, 0x00, 0x60, 0x0E, 0x70, 0x07, 0x00, 0x61, 0xC0, 0x30, 0x07,
  0x0E, 0x01, 0x80, 0x30, 0x30, 0x1C, 0x01, 0x81, 0x80, 0xC0, 0x0C, 0x0E,
  0x06, 0x00, 0xE0, 0x70, 0x70, 0x07, 0x03, 0x83, 0x00, 0x38, 0x1C, 0x18,
  0x01, 0xC0, 0xE1, 0xC0, 0x0E, 0x07, 0x0C, 0x00, 0x70, 0x38, 0x60, 0x03,
  0x81, 0xC7, 0x00, 0x1C, 0x0E, 0x30, 0x70, 0x60, 0x71, 0x8F, 0xC3, 0x03,
  0x1C, 0x77, 0x18, 0x18, 0xC7, 0x1C, 0xE1, 0xC6, 0x30, 0x63, 0x0E, 0x73,
  0x83, 0x1C, 0xE3, 0x1C, 0x1C, 0x7E, 0x38, 0xC0, 0xE1, 0xE1, 0xC6, 0x07,
  0x00, 0x0C, 0x30, 0x38, 0x00, 0xE1, 0x80, 0xC0, 0x07, 0x0C, 0x06, 0x00,
  0x30, 0x60, 0x30, 0x03, 0x83, 0x01, 0x80, 0x1C, 0x18, 0x1C, 0x00, 0xC0,
  0xC0, 0xE0, 0x0E, 0x06, 0x07, 0x00, 0x70, 0x30, 0x38, 0x03, 0x01, 0xC1,
  0xC0, 0x38, 0x0E, 0x0C, 0x01, 0xC0, 0x30, 0xE0, 0x0C, 0x01, 0xC7, 0x00,
  0xE0, 0x07, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0xDE, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0x60,
  0x70, 0x03, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xCE,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1E, 0x70, 0x01, 0xE3, 0x81, 0xCE, 0x0E, 0x0E, 0xE0, 0x38,
  0x77, 0x01, 0xC3, 0xB8, 0x07, 0x19, 0xC0, 0x39, 0xCE, 0x00, 0xEE, 0x70,
  0x07, 0x63, 0x80, 0x1F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3E,
  0x3C, 0x03, 0xB8, 0xE0, 0x3D, 0xC7, 0xC3, 0xC7, 0x1F, 0xFC, 0x38, 0x7F,
  0x80, 0xE0, 0x20, 0x00, 0xFF, 0xFF, 0x77, 0x76, 0x66, 0x66, 0x66, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x61, 0x86, 0xFD,
  0xBF, 0x7F, 0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70, 0x1C,
  0x38, 0x1C, 0x38, 0x38, 0x1C, 0x10, 0x10, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3,
  0x9C, 0x71, 0xC6, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x1C, 0x0F,
  0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x38, 0xE0,
  0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x78, 0x38, 0x0F, 0x3E,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x70, 0x3C, 0x1F, 0x0E, 0xCF,
  0x37, 0x9F, 0xC7, 0xE1, 0xD0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0xE1, 0xC0, 0x78, 0x20, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xC0, 0x7C, 0x40, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x72, 0x00, 0x3C, 0xF0, 0x3E, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0x8E, 0x00,
  0x1C, 0x70, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x07,
  0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x18, 0x0E, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0xE0, 0x1C, 0x06, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38,
  0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3E, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x90, 0x07, 0xCE, 0x07, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x81, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xE0, 0xE7, 0xF8, 0x67, 0xFE,
  0x37, 0x07, 0x9B, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03,
  0xC7, 0x01, 0xC3, 0xC3, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C,
  0x38, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01, 0xDC,
  0x00, 0x67, 0x00, 0x39, 0xC0, 0x0E, 0x78, 0x03, 0x8E, 0x01, 0xC1, 0xC0,
  0xF0, 0x78, 0x78, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x0F, 0x7C, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0xE0, 0x1C, 0x70, 0x03, 0x9C,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x39, 0xE0, 0x1E,
  0x3E, 0x0F, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0x00, 0x03, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x78, 0x38, 0x0E, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xDC,
  0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1E, 0x38, 0x0D, 0x8F, 0x8F, 0x61, 0xFF,
  0xB8, 0x3F, 0xCE, 0x00, 0x83, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x20, 0xF8, 0x0F, 0xFC, 0x03, 0xFC,
  0x00, 0x10, 0x00, 0x73, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xFF, 0xF7, 0x00, 0x38, 0xF3,
  0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x8E,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0x83, 0xFF, 0x8F, 0xFF, 0x10, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE7, 0x00, 0x7E, 0x06, 0x70, 0x1F, 0xF0, 0x66, 0x03, 0xC7, 0x07, 0x60,
  0x70, 0x70, 0x7E, 0x07, 0x07, 0x07, 0xE0, 0x60, 0x70, 0x3E, 0x0E, 0x07,
  0x03, 0xE0, 0xE0, 0x60, 0x3C, 0x0E, 0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C,
  0x0C, 0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x0E, 0x03, 0xC0, 0xC0,
  0xE0, 0x3C, 0x0C, 0x0E, 0x07, 0xC0, 0xC0, 0xE0, 0x7E, 0x0E, 0x0E, 0x06,
  0xE0, 0xE1, 0xA0, 0x6E, 0x06, 0x1B, 0x0E, 0xE0, 0x7B, 0xBF, 0xC6, 0x03,
  0xF1, 0xF8, 0x60, 0x1E, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x30, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB0,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0x60, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x30, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x18,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1E,
  0x38, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x70,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x3F,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xE0, 0x1F, 0x38, 0x01, 0xEE, 0x00, 0x3B,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xEE, 0x00, 0x7B, 0x80, 0x3C, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xC0, 0x20, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x10, 0x7E, 0x1C, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x40, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0E, 0x07, 0xE0, 0xE0, 0x0F, 0x0E,
  0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x78,
  0xE0, 0x0F, 0x0E, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3E, 0x00, 0xE0, 0xF0, 0x00, 0x43, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x7C, 0x00,
  0x70, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x02, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0xFF, 0xFF, 0xF7,
  0xF0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xEF, 0xFB, 0xFC, 0x7C, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x0F, 0x38,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x00,
  0xE7, 0x80, 0x39, 0xC0, 0x0E, 0xF8, 0x03, 0xBE, 0x00, 0xFF, 0xC0, 0x3E,
  0x70, 0x0F, 0x1E, 0x03, 0xC3, 0x80, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xB8,
  0x00, 0xFE, 0x00, 0x1C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFD, 0x80, 0x00, 0x37, 0xEE, 0x00, 0x03, 0xBF, 0x70, 0x00,
  0x1D, 0xF9, 0x80, 0x00, 0xCF, 0xCE, 0x00, 0x0E, 0x7E, 0x70, 0x00, 0x73,
  0xF3, 0x80, 0x03, 0x9F, 0x8C, 0x00, 0x38, 0xFC, 0x70, 0x01, 0xC7, 0xE3,
  0x80, 0x0E, 0x3F, 0x0C, 0x00, 0x61, 0xF8, 0x70, 0x07, 0x0F, 0xC3, 0x80,
  0x38, 0x7E, 0x0C, 0x01, 0x83, 0xF0, 0x70, 0x1C, 0x1F, 0x83, 0x80, 0xE0,
  0xFC, 0x1C, 0x07, 0x07, 0xE0, 0x60, 0x30, 0x3F, 0x03, 0x83, 0x81, 0xF8,
  0x1C, 0x1C, 0x0F, 0xC0, 0x60, 0xC0, 0x7E, 0x03, 0x8E, 0x03, 0xF0, 0x1C,
  0x70, 0x1F, 0x80, 0xE3, 0x80, 0xFC, 0x03, 0x38, 0x07, 0xE0, 0x1D, 0xC0,
  0x3F, 0x00, 0xEE, 0x01, 0xF8, 0x03, 0x60, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFD, 0xC0, 0x07, 0xEE, 0x00, 0x3F, 0x38,
  0x01, 0xF9, 0xC0, 0x0F, 0xC6, 0x00, 0x7E, 0x38, 0x03, 0xF1, 0xC0, 0x1F,
  0x87, 0x00, 0xFC, 0x38, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x1C,
  0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x1C, 0x1F, 0x80, 0xE0, 0xFC,
  0x03, 0x87, 0xE0, 0x1C, 0x3F, 0x00, 0x71, 0xF8, 0x03, 0x8F, 0xC0, 0x1C,
  0x7E, 0x00, 0x73, 0xF0, 0x03, 0x9F, 0x80, 0x0E, 0xFC, 0x00, 0x77, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x0E, 0x0E,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x77, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x77,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x78, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xF8,
  0x0F, 0x00, 0xFC, 0x7E, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0C,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1C, 0x0F, 0xCE, 0x01, 0xE7,
  0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC, 0x03, 0xCE, 0x3F, 0xC7, 0xFF, 0xC3,
  0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01,
  0xE0, 0x0F, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x70,
  0x00, 0x3C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEE, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x9C, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x78,
  0x00, 0xE0, 0x70, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xFC, 0x7E, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0B, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC3, 0x81, 0xF8, 0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1E,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCE, 0x01,
  0xE3, 0x83, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0E, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1C, 0x03, 0xFC,
  0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8, 0x0C, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x73, 0x00, 0x3C, 0xFC, 0x7E, 0x3F, 0xFF, 0x07,
  0xFF, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x07,
  0x1E, 0x01, 0xE3, 0xF0, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x06, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xE3, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0x00, 0x1C, 0xE0, 0x01, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x07, 0x38,
  0x00, 0x7C, 0x00, 0x38, 0xE0, 0x03, 0x60, 0x03, 0x87, 0x00, 0x1B, 0x00,
  0x1C, 0x38, 0x01, 0xD8, 0x00, 0xE1, 0xC0, 0x0E, 0xE0, 0x07, 0x0E, 0x00,
  0x77, 0x00, 0x38, 0x38, 0x03, 0x38, 0x03, 0x81, 0xC0, 0x18, 0xC0, 0x1C,
  0x0E, 0x01, 0xC6, 0x00, 0xE0, 0x70, 0x0E, 0x38, 0x07, 0x03, 0x80, 0x71,
  0xC0, 0x70, 0x0E, 0x03, 0x0E, 0x03, 0x80, 0x70, 0x18, 0x30, 0x1C, 0x03,
  0x81, 0xC1, 0x80, 0xE0, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x70,
  0x70, 0x03, 0x83, 0x83, 0x83, 0x80, 0x1C, 0x18, 0x0C, 0x1C, 0x00, 0xE1,
  0xC0, 0x60, 0xE0, 0x07, 0x0E, 0x03, 0x87, 0x00, 0x18, 0x70, 0x1C, 0x70,
  0x00, 0xE3, 0x80, 0xE3, 0x80, 0x07, 0x18, 0x03, 0x1C, 0x00, 0x39, 0xC0,
  0x18, 0xE0, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x06, 0x70, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x3B, 0x80, 0x01, 0xD8, 0x00, 0xDC, 0x00, 0x0E, 0xC0, 0x06,
  0xE0, 0x00, 0x7E, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x01, 0xB0, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x3C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0x38, 0x00, 0x77,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0x60, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0xE0, 0x00,
  0xFC, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x03, 0x1C, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x06, 0x30,
  0x00, 0x71, 0xC0, 0x03, 0x06, 0x00, 0x38, 0x38, 0x01, 0x81, 0xC0, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x1C,
  0x38, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x1C, 0x07, 0x0F, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C, 0x10, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFF, 0x1F, 0xC7, 0x3C, 0x07, 0x78, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0x70, 0x17, 0x78, 0x37, 0x3F, 0xE7, 0x1F, 0xC7,
  0x02, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE3, 0xF8, 0x39, 0xFF, 0x0E, 0xF3, 0xE3,
  0xE0, 0x3C, 0xF8, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0xC0, 0x1C, 0xF0,
  0x07, 0x36, 0x03, 0xCC, 0xE1, 0xE3, 0x3F, 0xF0, 0xC3, 0xF8, 0x00, 0x10,
  0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x3E, 0x70, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x7C, 0x18, 0x7F, 0xF0, 0x7F, 0xC0, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x03, 0xF1, 0xC3, 0xFE, 0x71, 0xF1, 0xDC, 0x70, 0x1F, 0x38, 0x06,
  0xCE, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x1D, 0xE0, 0x0F, 0x38, 0x02, 0xCF, 0x01, 0xB1,
  0xE0, 0xCC, 0x3F, 0xE3, 0x07, 0xF0, 0xC0, 0x20, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xCF, 0x83, 0x81, 0xC3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x0C,
  0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x87, 0xC1, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x01,
  0x00, 0x03, 0xF8, 0x3F, 0x83, 0xC4, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xFC, 0x7F, 0xE3,
  0xFF, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x03, 0xF0, 0xC3, 0xFE,
  0x31, 0xF3, 0xCC, 0x70, 0x1B, 0x38, 0x02, 0xCE, 0x00, 0xF7, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x76, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D,
  0xE0, 0x0F, 0x38, 0x03, 0xCF, 0x01, 0xF1, 0xE1, 0xDC, 0x3F, 0xE7, 0x07,
  0xF1, 0xC0, 0x30, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE3, 0x00, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF0, 0xE7, 0xFC, 0xEF,
  0x7C, 0xFC, 0x1E, 0xD8, 0x0E, 0xF0, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x27, 0xFF, 0x70, 0x00, 0x00, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x04, 0x1C, 0x78, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x3B, 0xF7, 0xCF, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x01,
  0xFC, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC1, 0xC3, 0x83, 0x87,
  0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xEF, 0x01, 0x9F,
  0x03, 0x6E, 0x07, 0xCE, 0x0F, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70,
  0xE0, 0x71, 0xC0, 0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0xB8,
  0x07, 0x70, 0x07, 0xE0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC3, 0xF0, 0x3F,
  0x19, 0xFF, 0x0F, 0xF3, 0x39, 0xE3, 0x9F, 0x6C, 0x0E, 0xC0, 0xED, 0x01,
  0xD0, 0x0F, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0xC0, 0x3F, 0x00, 0x70, 0x07,
  0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07,
  0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F,
  0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38,
  0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8,
  0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0,
  0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0E, 0xC3,
  0xF0, 0xC7, 0xFC, 0xCE, 0x7C, 0xD8, 0x1E, 0xD8, 0x0E, 0xF0, 0x0E, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7C, 0xFC, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x70, 0x07, 0x1C,
  0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x70,
  0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xDC, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x83, 0x80, 0xE0, 0x78,
  0x3C, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0xC3, 0xF8, 0x31,
  0xFF, 0x0C, 0xE3, 0xE3, 0x70, 0x3C, 0xD8, 0x07, 0x3C, 0x01, 0xCF, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x1C, 0xD8, 0x07, 0x3E, 0x03, 0xCE, 0xE1, 0xE3, 0x9F, 0xF0,
  0xE3, 0xF8, 0x38, 0x10, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0xC3, 0xFE,
  0x31, 0xF3, 0xCC, 0x70, 0x3B, 0x38, 0x06, 0xCE, 0x00, 0xF7, 0x00, 0x3D,
  0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x76, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D,
  0xE0, 0x0F, 0x38, 0x02, 0xCF, 0x01, 0xF1, 0xE1, 0xDC, 0x3F, 0xE7, 0x07,
  0xF1, 0xC0, 0x20, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0xC3, 0xF8, 0xFF, 0x3F, 0x66,
  0x0D, 0x81, 0xA0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0F,
  0xF0, 0xFF, 0xF7, 0xC7, 0x9C, 0x02, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3A, 0x00, 0xEF, 0x0F, 0xBF, 0xFC,
  0x7F, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1E, 0x21, 0xFC, 0x3F, 0x80, 0xC0, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x37, 0x78, 0x77,
  0x3F, 0xE7, 0x1F, 0xC7, 0x02, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0x8C, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C,
  0x38, 0x07, 0x06, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x00, 0xC1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0x63,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xC0, 0x07, 0x00, 0x3F, 0x00, 0x78, 0x01, 0xB8, 0x03, 0xC0, 0x1D, 0xC0,
  0x1E, 0x00, 0xEE, 0x00, 0xF8, 0x07, 0x38, 0x0F, 0xC0, 0x39, 0xC0, 0x76,
  0x01, 0x8E, 0x03, 0xB0, 0x1C, 0x70, 0x19, 0xC0, 0xE1, 0x80, 0xCE, 0x07,
  0x0E, 0x0E, 0x70, 0x30, 0x70, 0x71, 0x83, 0x83, 0x83, 0x8C, 0x1C, 0x1C,
  0x18, 0x70, 0xE0, 0x60, 0xC3, 0x87, 0x03, 0x8E, 0x1C, 0x30, 0x1C, 0x70,
  0x63, 0x80, 0xE3, 0x83, 0x1C, 0x03, 0x18, 0x1C, 0xE0, 0x18, 0xC0, 0xE6,
  0x00, 0xEE, 0x07, 0x30, 0x07, 0x70, 0x1B, 0x80, 0x3B, 0x00, 0xDC, 0x00,
  0xD8, 0x06, 0xE0, 0x06, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x07,
  0xB8, 0x03, 0x9C, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x38, 0x01, 0xDC, 0x00, 0xEC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xC6, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0x70, 0x70,
  0x38, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x78,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x1C, 0x60, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x83,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x18, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x00, 0xC6, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x7E, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x40, 0x00, 0x3E, 0x00, 0x2F,
  0xF0, 0x07, 0xFF, 0x83, 0xE0, 0x7F, 0xF8, 0x03, 0xFD, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 39, 12, 4, -39 },
  { 21, 12, 14, 18, 3, -39 },
  { 42, 22, 39, 24, 1, -39 },
  { 150, 18, 44, 22, 2, -41 },
  { 249, 29, 39, 33, 2, -39 },
  { 391, 21, 40, 23, 2, -39 },
  { 496, 4, 14, 10, 3, -39 },
  { 503, 10, 48, 15, 3, -39 },
  { 563, 10, 48, 15, 2, -39 },
  { 623, 16, 16, 20, 2, -41 },
  { 655, 19, 25, 22, 2, -32 },
  { 715, 6, 13, 11, 2, -6 },
  { 725, 12, 3, 15, 1, -16 },
  { 730, 5, 5, 11, 3, -5 },
  { 734, 17, 39, 19, 1, -39 },
  { 817, 18, 39, 22, 2, -39 },
  { 905, 10, 39, 22, 4, -39 },
  { 954, 18, 39, 22, 2, -39 },
  { 1042, 18, 40, 22, 2, -39 },
  { 1132, 21, 39, 22, 1, -39 },
  { 1235, 17, 39, 22, 3, -39 },
  { 1318, 17, 40, 22, 3, -39 },
  { 1403, 18, 39, 22, 2, -39 },
  { 1491, 18, 40, 22, 2, -39 },
  { 1581, 18, 40, 22, 2, -39 },
  { 1671, 5, 29, 11, 3, -29 },
  { 1690, 6, 36, 11, 2, -29 },
  { 1717, 19, 23, 22, 2, -31 },
  { 1772, 19, 14, 22, 2, -26 },
  { 1806, 19, 23, 22, 2, -31 },
  { 1861, 14, 39, 16, 1, -39 },
  { 1930, 28, 44, 34, 3, -39 },
  { 2084, 22, 39, 22, 0, -39 },
  { 2192, 18, 39, 25, 4, -39 },
  { 2280, 19, 40, 23, 3, -39 },
  { 2375, 20, 39, 27, 4, -39 },
  { 2473, 15, 39, 21, 4, -39 },
  { 2547, 15, 39, 20, 4, -39 },
  { 2621, 23, 40, 29, 3, -39 },
  { 2736, 19, 39, 28, 4, -39 },
  { 2829, 10, 39, 14, 2, -39 },
  { 2878, 10, 49, 11, -3, -39 },
  { 2940, 18, 39, 22, 4, -39 },
  { 3028, 14, 39, 19, 4, -39 },
  { 3097, 29, 39, 37, 4, -39 },
  { 3239, 21, 39, 29, 4, -39 },
  { 3342, 23, 40, 29, 3, -39 },
  { 3457, 17, 39, 23, 4, -39 },
  { 3540, 23, 48, 29, 3, -39 },
  { 3678, 18, 39, 23, 4, -39 },
  { 3766, 18, 40, 22, 2, -39 },
  { 3856, 19, 39, 19, 0, -39 },
  { 3949, 19, 40, 27, 4, -39 },
  { 4044, 22, 39, 22, 0, -39 },
  { 4152, 37, 39, 37, 0, -39 },
  { 4333, 19, 39, 20, 0, -39 },
  { 4426, 19, 39, 19, 0, -39 },
  { 4519, 16, 39, 18, 1, -39 },
  { 4597, 11, 48, 17, 4, -39 },
  { 4663, 17, 39, 19, 1, -39 },
  { 4746, 10, 48, 17, 2, -39 },
  { 4806, 21, 20, 23, 1, -39 },
  { 4859, 23, 2, 22, 0, 5 },
  { 4865, 9, 8, 13, 2, -41 },
  { 4874, 16, 30, 21, 2, -29 },
  { 4934, 18, 42, 24, 4, -41 },
  { 5029, 15, 30, 18, 2, -29 },
  { 5086, 18, 42, 24, 2, -41 },
  { 5181, 17, 30, 22, 2, -29 },
  { 5245, 13, 41, 13, 1, -41 },
  { 5312, 18, 42, 24, 2, -29 },
  { 5407, 16, 41, 23, 4, -41 },
  { 5489, 4, 40, 10, 3, -40 },
  { 5509, 7, 53, 10, 0, -40 },
  { 5556, 15, 41, 20, 4, -41 },
  { 5633, 3, 41, 10, 4, -41 },
  { 5649, 27, 29, 35, 4, -29 },
  { 5747, 16, 29, 23, 4, -29 },
  { 5805, 19, 30, 23, 2, -29 },
  { 5877, 18, 42, 24, 4, -29 },
  { 5972, 18, 42, 24, 2, -29 },
  { 6067, 11, 29, 15, 4, -29 },
  { 6107, 14, 30, 18, 2, -29 },
  { 6160, 11, 36, 13, 1, -35 },
  { 6210, 16, 30, 23, 4, -29 },
  { 6270, 18, 29, 18, 0, -29 },
  { 6336, 29, 29, 30, 1, -29 },
  { 6442, 17, 29, 19, 1, -29 },
  { 6504, 17, 42, 19, 1, -29 },
  { 6594, 13, 29, 15, 1, -29 },
  { 6642, 14, 48, 19, 3, -39 },
  { 6726, 3, 54, 21, 9, -41 },
  { 6747, 15, 48, 19, 2, -39 },
  { 6837, 19, 6, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Light54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT54PT7B_H_
