#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x49, 0x24, 0x92, 0x00, 0x6F, 0x80, 0xC7, 0x8B,
  0x16, 0x2C, 0x58, 0xB1, 0x62, 0x08, 0x40, 0x84, 0x08, 0x40, 0x8C, 0x18,
  0xC1, 0x8C, 0xFF, 0xFF, 0xFF, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11,
  0x83, 0x18, 0xFF, 0xE3, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x23,
  0x06, 0x30, 0x04, 0x00, 0x80, 0x10, 0x1F, 0xE6, 0x4C, 0x88, 0x31, 0x06,
  0x20, 0xC4, 0x18, 0x81, 0x90, 0x1A, 0x01, 0xE0, 0x0E, 0x01, 0x70, 0x26,
  0x04, 0x60, 0x8C, 0x11, 0x82, 0x28, 0x4D, 0xFF, 0x0F, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x3C, 0x18, 0x32, 0x08, 0x11, 0x84, 0x08, 0xC6, 0x0C, 0x62,
  0x06, 0x31, 0x03, 0x19, 0x81, 0x8C, 0x80, 0xC6, 0x44, 0x23, 0x6F, 0x91,
  0x24, 0x4C, 0x92, 0x23, 0xDB, 0x18, 0x09, 0x8C, 0x04, 0xC6, 0x06, 0x63,
  0x02, 0x31, 0x81, 0x18, 0xC1, 0x8C, 0x60, 0x82, 0x20, 0x41, 0xB0, 0x60,
  0x70, 0x1E, 0x03, 0x30, 0x23, 0x02, 0x10, 0x21, 0x02, 0x10, 0x33, 0x03,
  0x30, 0x16, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x66, 0x3C, 0x23, 0xC3, 0x2C,
  0x16, 0xC1, 0xEC, 0x0C, 0xC0, 0xCC, 0x1E, 0x63, 0x33, 0xE3, 0xFF, 0xFF,
  0x1C, 0x43, 0x08, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x60, 0xC0, 0xC1, 0x82, 0x0C,
  0x10, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x0C, 0x21, 0x8C, 0x00, 0x0C, 0x06, 0x02, 0x09, 0x1F, 0xF8,
  0x60, 0x50, 0x64, 0x63, 0x11, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x3F, 0xFF, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x36, 0x66, 0x44, 0xC0, 0xFE, 0xFC, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x80, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x00, 0x1F, 0x0C, 0x62,
  0x19, 0x83, 0x60, 0xD0, 0x34, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x05, 0x03, 0x40, 0xD8, 0x36, 0x0C, 0xC6, 0x3B, 0x87,
  0xC0, 0x0C, 0x73, 0x59, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x38, 0xE0, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0x38,
  0xE4, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x81, 0xC3, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0xC3,
  0xBF, 0xC0, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x04,
  0xC0, 0xCC, 0x08, 0xC1, 0x8C, 0x10, 0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0x60,
  0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xFF,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x7F, 0x20, 0xC0,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x6C, 0x77, 0xE0,
  0x0F, 0x87, 0x13, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x00, 0x4E, 0x17,
  0xEF, 0x0F, 0x83, 0xC0, 0xF0, 0x1C, 0x05, 0x01, 0x40, 0x58, 0x16, 0x0C,
  0x83, 0x31, 0x87, 0xC0, 0xFF, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60,
  0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00, 0x3F, 0x0E, 0x31, 0x83,
  0x20, 0x64, 0x04, 0x81, 0x98, 0x33, 0x06, 0x31, 0x83, 0xE0, 0x38, 0x1D,
  0x87, 0x18, 0xC1, 0xB0, 0x16, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x30, 0x67,
  0x18, 0x7E, 0x00, 0x3F, 0x1C, 0xE6, 0x19, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x36, 0x0D, 0x87, 0x3F, 0xC3, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x0C, 0x47, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x27, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x36, 0x66, 0x44, 0xC0, 0x00,
  0x20, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C, 0x01,
  0x00, 0x00, 0xFE, 0x47, 0x03, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x06,
  0x0C, 0x08, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x18, 0x38, 0x38,
  0x07, 0xE0, 0x1C, 0x38, 0x10, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02,
  0xC3, 0xE2, 0xC6, 0x23, 0x84, 0x63, 0x84, 0x63, 0x8C, 0x63, 0x8C, 0x63,
  0x8C, 0x63, 0x8C, 0x63, 0x8C, 0x63, 0x8C, 0x62, 0x84, 0xA6, 0xC7, 0xBC,
  0xC1, 0x08, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x10, 0x1F, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00, 0xD8, 0x06, 0xC0,
  0x26, 0x03, 0x10, 0x18, 0xC0, 0xC6, 0x04, 0x30, 0x20, 0x83, 0x06, 0x1F,
  0xF0, 0xC1, 0x84, 0x04, 0x60, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x6C, 0x01,
  0x60, 0x0C, 0xFF, 0x18, 0x73, 0x03, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x16,
  0x06, 0xC0, 0xD8, 0x73, 0xFC, 0x60, 0xCC, 0x0D, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0x60, 0x6F, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0x08,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0xC4, 0x1F, 0x80, 0xFF, 0x0C, 0x78, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C,
  0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x1C, 0xFF, 0x8F,
  0xE0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3F, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xFF, 0xFC, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x1F, 0xEC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x00, 0x0F, 0xF8, 0xE1, 0x8C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x00, 0xD8, 0x06, 0x60, 0x31,
  0xC3, 0x87, 0xF8, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x40, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x33, 0xF0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFD, 0xC0, 0xC0, 0xF8, 0x1B,
  0x06, 0x60, 0x8C, 0x31, 0x8C, 0x31, 0x86, 0x60, 0xCC, 0x1B, 0x03, 0x60,
  0x76, 0x0E, 0xC1, 0x8C, 0x31, 0x86, 0x18, 0xC3, 0x18, 0x33, 0x06, 0x60,
  0x6C, 0x0D, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFD, 0x00,
  0x7E, 0x80, 0x2F, 0x60, 0x37, 0xB0, 0x1B, 0xC8, 0x09, 0xE6, 0x04, 0xF3,
  0x06, 0x78, 0x83, 0x3C, 0x61, 0x1E, 0x31, 0x8F, 0x08, 0xC7, 0x84, 0x43,
  0xC3, 0x21, 0xE1, 0xB0, 0xF0, 0x58, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x06,
  0x0C, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xD0, 0x1D, 0x81, 0xC8, 0x1C,
  0xC1, 0xCC, 0x1C, 0x61, 0xC6, 0x1C, 0x21, 0xC3, 0x1C, 0x11, 0xC1, 0x9C,
  0x19, 0xC0, 0xDC, 0x0D, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0x1F, 0x81,
  0xC6, 0x18, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0B, 0x00, 0x58, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02,
  0xC0, 0x36, 0x01, 0x98, 0x0C, 0xE0, 0xC3, 0x8C, 0x0F, 0xC0, 0xFE, 0x31,
  0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B,
  0xFC, 0xFE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x00, 0x1F, 0x81, 0xC7, 0x18, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0B,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x02, 0xC0, 0x32, 0x01, 0x98, 0x0C, 0xE0, 0xC3, 0x8C,
  0x0F, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0xFE, 0x19,
  0xF3, 0x06, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x33,
  0x0E, 0x7F, 0x0C, 0x61, 0x8C, 0x30, 0xC6, 0x18, 0xC1, 0x18, 0x33, 0x06,
  0x60, 0x6C, 0x0D, 0x80, 0xC0, 0x1F, 0xCC, 0x36, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0xE3, 0xBF, 0xC0, 0xFF, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x05, 0x01, 0xB0, 0x33, 0x9C, 0x3F, 0x00, 0xC0,
  0x1E, 0x01, 0x90, 0x0C, 0xC0, 0x66, 0x02, 0x30, 0x30, 0x81, 0x86, 0x0C,
  0x30, 0x41, 0x82, 0x0C, 0x30, 0x21, 0x81, 0x8C, 0x0C, 0x40, 0x66, 0x01,
  0x30, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0xC0,
  0x30, 0x1E, 0x03, 0x80, 0xD0, 0x1C, 0x04, 0xC0, 0xA0, 0x26, 0x05, 0x03,
  0x30, 0x2C, 0x18, 0x83, 0x60, 0xC4, 0x1B, 0x04, 0x30, 0xC8, 0x61, 0x84,
  0x43, 0x0C, 0x23, 0x18, 0x23, 0x18, 0xC1, 0x18, 0xC4, 0x0C, 0xC2, 0x60,
  0x64, 0x13, 0x03, 0x20, 0x98, 0x0B, 0x06, 0xC0, 0x58, 0x34, 0x03, 0xC0,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x01, 0x80, 0x60, 0x64, 0x08,
  0xC3, 0x18, 0x61, 0x18, 0x33, 0x06, 0x40, 0x58, 0x0F, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xF0, 0x16, 0x06, 0x40, 0xCC, 0x31, 0x86, 0x10, 0x83, 0x30,
  0x66, 0x07, 0x80, 0xC0, 0xC0, 0x68, 0x09, 0x83, 0x30, 0x62, 0x08, 0x63,
  0x0C, 0x60, 0x88, 0x1B, 0x03, 0x60, 0x28, 0x07, 0x00, 0xE0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0F, 0xFF, 0xFC,
  0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02,
  0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x04, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xFF, 0xC0, 0x04, 0x00,
  0xE0, 0x0A, 0x01, 0xB0, 0x11, 0x03, 0x18, 0x20, 0x86, 0x0C, 0x40, 0x4C,
  0x06, 0x80, 0x30, 0xFF, 0xF8, 0xC3, 0x0C, 0x20, 0x80, 0x1E, 0x3F, 0x90,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x0F, 0x3F, 0xB0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x06, 0xC5, 0x3C, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x38, 0xDF, 0xB8, 0x6E, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF8, 0x2F, 0x3B, 0x7C, 0x0F,
  0x8F, 0x8C, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08,
  0x04, 0x03, 0x01, 0x80, 0x71, 0x1F, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x63, 0x3F, 0x66, 0x3D, 0x83, 0xB0, 0x34,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x36, 0x0E,
  0xC1, 0xCC, 0x58, 0xF3, 0x0E, 0x0F, 0xC2, 0x19, 0x82, 0x40, 0xD0, 0x3C,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0xE2,
  0x1F, 0x80, 0x06, 0x1F, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0xFE, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x0E, 0x07, 0xEC, 0xC3, 0xB0, 0x76, 0x06, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x34, 0x06, 0xC1, 0xD8, 0x39, 0x8B,
  0x1E, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x90, 0x63, 0xF8, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x9C, 0xDF, 0x70, 0xF8, 0x78,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x13, 0x30, 0x00, 0x03,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC3, 0x61, 0x31, 0x99,
  0x8C, 0xC6, 0xC3, 0x61, 0xD8, 0xEC, 0x62, 0x31, 0x98, 0xCC, 0x36, 0x1B,
  0x05, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x9F, 0x3E,
  0xE3, 0x43, 0xC1, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0x0E, 0x4F, 0xB8, 0x7C, 0x3C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0x80, 0x0E, 0x07, 0xF0, 0xC3, 0x30, 0x66, 0x04, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x34, 0x04, 0xC1, 0x98, 0x31, 0x8C,
  0x1F, 0x00, 0x0E, 0x27, 0xEE, 0x1B, 0x83, 0xC0, 0xF0, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3E, 0x0B, 0xC6, 0xDF, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0E, 0x07, 0xEC, 0xC7,
  0xB0, 0x76, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x34, 0x06, 0xC1, 0xD8, 0x39, 0x8B, 0x1E, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0x3B, 0xC7, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x1E, 0x7F, 0xC1, 0xC0,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x03, 0x03, 0x03, 0xC6,
  0xFC, 0x21, 0x86, 0x18, 0xFD, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x4F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0D, 0x9A, 0x79, 0xC0, 0xD0,
  0x36, 0x09, 0x86, 0x61, 0x88, 0x62, 0x10, 0xC4, 0x33, 0x04, 0xC1, 0x20,
  0x68, 0x1E, 0x03, 0x80, 0xC0, 0x30, 0xC0, 0xC1, 0xA0, 0xE0, 0xD8, 0x70,
  0x4C, 0x28, 0x26, 0x16, 0x31, 0x0B, 0x18, 0x8C, 0x88, 0x66, 0x44, 0x32,
  0x36, 0x19, 0x1B, 0x05, 0x8D, 0x82, 0xC2, 0x81, 0xE1, 0x40, 0xE0, 0xA0,
  0x30, 0x70, 0x18, 0x38, 0x60, 0xC8, 0x63, 0x18, 0x44, 0x1B, 0x02, 0x80,
  0xE0, 0x30, 0x0E, 0x06, 0x81, 0xB0, 0x4C, 0x31, 0x88, 0x66, 0x0F, 0x83,
  0xC0, 0xD8, 0x36, 0x0D, 0x82, 0x21, 0x8C, 0x63, 0x18, 0xC4, 0x11, 0x06,
  0xC1, 0xB0, 0x68, 0x0A, 0x03, 0x80, 0xE0, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x06, 0x0F, 0x00, 0xFE, 0x0C, 0x30, 0x60, 0x83, 0x06, 0x08,
  0x30, 0x61, 0x83, 0x04, 0x18, 0x30, 0x7F, 0x07, 0x87, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x03, 0x07, 0x00, 0xE0,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x07,
  0x80, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1C,
  0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80,
  0x60, 0x1C, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x18, 0x3C, 0x38, 0x00, 0x20, 0x1F, 0x86, 0x1F, 0xC0, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 22, 7, 2, -22 },
  { 10, 7, 8, 10, 2, -22 },
  { 17, 12, 22, 14, 1, -22 },
  { 50, 11, 26, 13, 1, -24 },
  { 86, 17, 22, 19, 1, -22 },
  { 133, 12, 22, 13, 1, -22 },
  { 166, 2, 8, 6, 2, -22 },
  { 168, 6, 27, 9, 2, -22 },
  { 189, 6, 27, 9, 1, -22 },
  { 210, 9, 10, 11, 1, -24 },
  { 222, 11, 14, 13, 1, -18 },
  { 242, 4, 7, 6, 1, -3 },
  { 246, 7, 1, 8, 1, -9 },
  { 247, 2, 3, 6, 2, -3 },
  { 248, 9, 22, 11, 1, -22 },
  { 273, 10, 22, 13, 1, -22 },
  { 301, 6, 22, 13, 2, -22 },
  { 318, 10, 22, 13, 1, -22 },
  { 346, 10, 22, 13, 1, -22 },
  { 374, 12, 22, 13, 0, -22 },
  { 407, 9, 22, 13, 2, -22 },
  { 432, 10, 22, 13, 1, -22 },
  { 460, 10, 22, 13, 1, -22 },
  { 488, 11, 22, 13, 1, -22 },
  { 519, 10, 22, 13, 1, -22 },
  { 547, 2, 17, 6, 2, -17 },
  { 552, 4, 21, 6, 1, -17 },
  { 563, 11, 14, 13, 1, -18 },
  { 583, 11, 8, 13, 1, -15 },
  { 594, 11, 14, 13, 1, -18 },
  { 614, 8, 22, 9, 0, -22 },
  { 636, 16, 25, 19, 2, -22 },
  { 686, 13, 22, 13, 0, -22 },
  { 722, 11, 22, 14, 2, -22 },
  { 753, 11, 22, 13, 2, -22 },
  { 784, 12, 22, 15, 2, -22 },
  { 817, 9, 22, 12, 2, -22 },
  { 842, 9, 22, 11, 2, -22 },
  { 867, 13, 22, 17, 2, -22 },
  { 903, 11, 22, 16, 2, -22 },
  { 934, 6, 22, 8, 1, -22 },
  { 951, 5, 28, 6, -1, -22 },
  { 969, 11, 22, 13, 2, -22 },
  { 1000, 8, 22, 11, 2, -22 },
  { 1022, 17, 22, 21, 2, -22 },
  { 1069, 12, 22, 17, 2, -22 },
  { 1102, 13, 22, 16, 2, -22 },
  { 1138, 10, 22, 13, 2, -22 },
  { 1166, 13, 27, 16, 2, -22 },
  { 1210, 11, 22, 13, 2, -22 },
  { 1241, 10, 22, 12, 1, -22 },
  { 1269, 11, 22, 11, 0, -22 },
  { 1300, 11, 22, 16, 2, -22 },
  { 1331, 13, 22, 13, 0, -22 },
  { 1367, 21, 22, 21, 0, -22 },
  { 1425, 11, 22, 11, 0, -22 },
  { 1456, 11, 22, 11, 0, -22 },
  { 1487, 9, 22, 11, 1, -22 },
  { 1512, 7, 27, 10, 2, -22 },
  { 1536, 9, 22, 11, 1, -22 },
  { 1561, 6, 27, 10, 1, -22 },
  { 1582, 12, 11, 13, 1, -22 },
  { 1599, 13, 1, 13, 0, 3 },
  { 1601, 5, 5, 8, 1, -24 },
  { 1605, 9, 17, 12, 1, -17 },
  { 1625, 10, 24, 14, 2, -24 },
  { 1655, 9, 17, 10, 1, -17 },
  { 1675, 11, 24, 14, 1, -24 },
  { 1708, 10, 17, 12, 1, -17 },
  { 1730, 8, 24, 7, 0, -24 },
  { 1754, 11, 24, 14, 1, -17 },
  { 1787, 9, 24, 13, 2, -24 },
  { 1814, 2, 23, 6, 2, -23 },
  { 1820, 4, 30, 6, 0, -23 },
  { 1835, 9, 24, 11, 2, -24 },
  { 1862, 2, 24, 6, 2, -24 },
  { 1868, 16, 17, 20, 2, -17 },
  { 1902, 9, 17, 13, 2, -17 },
  { 1922, 11, 17, 13, 1, -17 },
  { 1946, 10, 24, 14, 2, -17 },
  { 1976, 11, 24, 14, 1, -17 },
  { 2009, 7, 17, 9, 2, -17 },
  { 2024, 8, 17, 10, 1, -17 },
  { 2041, 6, 20, 7, 1, -20 },
  { 2056, 9, 16, 13, 2, -16 },
  { 2074, 10, 16, 10, 0, -16 },
  { 2094, 17, 16, 17, 0, -16 },
  { 2128, 10, 16, 11, 0, -16 },
  { 2148, 10, 23, 11, 0, -16 },
  { 2177, 7, 16, 9, 1, -16 },
  { 2191, 9, 27, 11, 1, -22 },
  { 2222, 2, 31, 12, 5, -24 },
  { 2230, 9, 27, 11, 1, -22 },
  { 2261, 11, 4, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Light31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT31PT7B_H_
