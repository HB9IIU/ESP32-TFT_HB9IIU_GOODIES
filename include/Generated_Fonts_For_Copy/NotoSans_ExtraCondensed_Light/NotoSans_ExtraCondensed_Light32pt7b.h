#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x92, 0x40, 0x0D, 0xF8, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x0C, 0x60, 0x42, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x04, 0x20, 0x63, 0x1F, 0xFF, 0x18, 0xC0, 0x86, 0x04, 0x20, 0x21,
  0x01, 0x08, 0x08, 0x43, 0xFF, 0xDF, 0xFE, 0x31, 0x81, 0x8C, 0x08, 0x40,
  0x42, 0x02, 0x10, 0x10, 0x81, 0x84, 0x00, 0x04, 0x00, 0x80, 0x7E, 0x3E,
  0xE6, 0x41, 0x88, 0x31, 0x06, 0x20, 0xC4, 0x08, 0x81, 0xD0, 0x1E, 0x00,
  0xF0, 0x0F, 0x01, 0x30, 0x23, 0x04, 0x60, 0x8C, 0x11, 0x82, 0x38, 0x4D,
  0xFF, 0x0F, 0x80, 0x20, 0x04, 0x00, 0x80, 0x3C, 0x08, 0x32, 0x04, 0x11,
  0x86, 0x08, 0xC2, 0x0C, 0x21, 0x06, 0x11, 0x83, 0x08, 0x81, 0x84, 0x40,
  0xC2, 0x60, 0x61, 0x27, 0x91, 0x92, 0x48, 0xDB, 0x36, 0xC9, 0x09, 0xEC,
  0x84, 0x06, 0x42, 0x02, 0x21, 0x03, 0x10, 0x81, 0x88, 0x40, 0x84, 0x20,
  0xC2, 0x10, 0x61, 0x98, 0x20, 0x4C, 0x30, 0x3C, 0x1E, 0x01, 0x98, 0x0C,
  0x40, 0x42, 0x02, 0x18, 0x10, 0x80, 0xC4, 0x06, 0x60, 0x13, 0x00, 0xF0,
  0x03, 0x00, 0x78, 0x03, 0x60, 0x33, 0x1B, 0x0C, 0xD8, 0x66, 0xC1, 0xA6,
  0x07, 0x30, 0x39, 0x81, 0xC6, 0x1E, 0x39, 0x98, 0xF8, 0x60, 0xFF, 0xFF,
  0x0C, 0x61, 0x0C, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x0C, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xC1, 0x83, 0xC1, 0x82, 0x0C,
  0x10, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x43, 0x0C, 0x30, 0xC3,
  0x08, 0x61, 0x84, 0x30, 0x86, 0x30, 0x0C, 0x06, 0x23, 0x3F, 0xF3, 0xE0,
  0xE0, 0x48, 0x66, 0x61, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x36, 0x66, 0x64, 0xC0, 0xFF, 0xFC, 0xDF, 0x00, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x00, 0x1F, 0x07, 0x70, 0xC6, 0x30, 0x66, 0x0C, 0xC1, 0x90,
  0x12, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1A,
  0x03, 0x40, 0x4C, 0x09, 0x83, 0x30, 0x63, 0x08, 0x77, 0x07, 0xC0, 0x06,
  0x1C, 0x7B, 0xBE, 0x68, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x3F, 0x1F, 0xF1, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0x1E, 0xF1, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x7C, 0x0F, 0x80, 0x38, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0D, 0xC7, 0x3F, 0xC0,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x07, 0x80, 0x58, 0x0D, 0x80, 0x98,
  0x19, 0x81, 0x18, 0x31, 0x82, 0x18, 0x61, 0x84, 0x18, 0xC1, 0x88, 0x18,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFF,
  0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x2F, 0x0F,
  0xF0, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x03, 0xB1, 0xCF, 0xE0, 0x07, 0xC3, 0xD8, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x09, 0xF1, 0x6E, 0x30, 0x6E, 0x05, 0x80, 0xD0,
  0x1A, 0x03, 0x40, 0x6C, 0x0D, 0x81, 0xB0, 0x23, 0x0C, 0x73, 0x07, 0xC0,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x1F, 0x07, 0x71, 0x83,
  0x30, 0x24, 0x06, 0x80, 0xD8, 0x13, 0x06, 0x30, 0xC7, 0x70, 0x38, 0x0F,
  0x83, 0x38, 0xC1, 0x98, 0x36, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x36,
  0x0C, 0xE3, 0x87, 0xE0, 0x1F, 0x07, 0x71, 0x86, 0x30, 0x6C, 0x0D, 0x80,
  0xB0, 0x16, 0x02, 0xC0, 0x78, 0x0D, 0x03, 0xB0, 0x77, 0x14, 0x7C, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x8E, 0x1F, 0x80,
  0xDF, 0x00, 0x00, 0x00, 0x00, 0x37, 0xC0, 0x67, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x36, 0x66, 0x64, 0xC0, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x83,
  0xC0, 0xE0, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02,
  0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x18, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x30, 0x0C, 0x01, 0x00, 0x00, 0x7E, 0x7B, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x60, 0x03,
  0xE0, 0x07, 0x1C, 0x06, 0x03, 0x06, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x19,
  0x03, 0x0D, 0x87, 0xC2, 0xC6, 0x21, 0x43, 0x10, 0xA1, 0x08, 0x71, 0x84,
  0x38, 0xC2, 0x1C, 0x61, 0x0A, 0x31, 0x85, 0x18, 0xC2, 0x84, 0x63, 0x43,
  0x39, 0xB0, 0xE7, 0x98, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x20, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x01, 0x40,
  0x0B, 0x00, 0xD8, 0x06, 0xC0, 0x32, 0x01, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x10, 0x30, 0x81, 0x06, 0x1F, 0xF0, 0xFF, 0x86, 0x04, 0x20, 0x33, 0x01,
  0x98, 0x0C, 0xC0, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x60, 0xFF, 0x1F, 0xF3,
  0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0xFE,
  0x7F, 0xCC, 0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0D, 0xFF, 0xBF, 0xC0, 0x0F, 0xC3, 0xDC, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x38, 0xC3,
  0xF8, 0xFE, 0x0F, 0xF8, 0xC1, 0xCC, 0x0E, 0xC0, 0x6C, 0x02, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCF, 0xF8, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xFF, 0xFC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x1F, 0xFF, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x07, 0xF0, 0xFB, 0xCE, 0x02, 0xE0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x01, 0xF8,
  0x0F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x58, 0x02, 0xC0,
  0x13, 0x00, 0x8F, 0x1C, 0x3F, 0xC0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFE, 0xF0, 0xC0, 0x78, 0x1B,
  0x03, 0x60, 0xCC, 0x11, 0x86, 0x31, 0x86, 0x30, 0xCC, 0x19, 0x83, 0x60,
  0x6E, 0x0E, 0xC1, 0xCC, 0x31, 0x86, 0x18, 0xC3, 0x18, 0x33, 0x06, 0x60,
  0x6C, 0x0D, 0x80, 0xF0, 0x18, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xD0, 0x02, 0xF6, 0x01, 0xBD, 0x80, 0x6F, 0x20,
  0x13, 0xC8, 0x04, 0xF3, 0x03, 0x3C, 0xC0, 0xCF, 0x10, 0x23, 0xC6, 0x18,
  0xF1, 0x86, 0x3C, 0x21, 0x0F, 0x08, 0xC3, 0xC3, 0x30, 0xF0, 0xCC, 0x3C,
  0x12, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x30, 0x3C, 0x0C, 0x0C, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3D, 0x01, 0xEC, 0x0F, 0x20, 0x79, 0x83,
  0xCC, 0x1E, 0x30, 0xF1, 0x87, 0x84, 0x3C, 0x31, 0xE0, 0x8F, 0x06, 0x78,
  0x33, 0xC0, 0xDE, 0x06, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xE0, 0x0F, 0x81, 0xEF, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x60, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD8, 0x0C, 0xC0, 0x63, 0x07, 0x1E,
  0x70, 0x7F, 0x00, 0xFE, 0x3F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x06, 0xFF, 0x3E, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0x81, 0xEF, 0x0C,
  0x18, 0xC0, 0x66, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xD8, 0x0C, 0xC0, 0x63, 0x06, 0x1E, 0x70, 0x7E, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0xFE, 0x1F, 0xF3, 0x06, 0x60, 0x6C,
  0x0D, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0xD8, 0x1B, 0x06, 0x67, 0xCF, 0xE1,
  0x8C, 0x30, 0x86, 0x18, 0xC3, 0x18, 0x33, 0x06, 0x60, 0x6C, 0x0D, 0x80,
  0xF0, 0x18, 0x1F, 0xC7, 0xF9, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0D, 0xE7, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x02,
  0x60, 0x63, 0x9C, 0x1F, 0x80, 0xC0, 0x1E, 0x00, 0xD0, 0x04, 0xC0, 0x66,
  0x03, 0x30, 0x19, 0x80, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x10, 0x21,
  0x81, 0x8C, 0x0C, 0x60, 0x63, 0x01, 0x10, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x24, 0x03, 0x01, 0x98, 0x1C, 0x06, 0x60, 0x78, 0x19, 0x81, 0xE0, 0x66,
  0x05, 0x81, 0x08, 0x12, 0x0C, 0x30, 0xC8, 0x30, 0xC3, 0x30, 0xC3, 0x0C,
  0xC3, 0x04, 0x23, 0x08, 0x18, 0x84, 0x60, 0x66, 0x11, 0x81, 0x98, 0x66,
  0x06, 0x61, 0x90, 0x09, 0x06, 0xC0, 0x34, 0x0B, 0x00, 0xF0, 0x2C, 0x03,
  0xC0, 0xB0, 0x0F, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x6C, 0x0C, 0xC1, 0x18, 0x61, 0x0C, 0x31, 0x06, 0x60, 0x4C, 0x0F, 0x01,
  0xE0, 0x18, 0x03, 0x00, 0x70, 0x1E, 0x02, 0x40, 0xCC, 0x19, 0x86, 0x10,
  0xC3, 0x10, 0x66, 0x06, 0xC0, 0xF0, 0x18, 0xC0, 0x78, 0x0D, 0x81, 0xB0,
  0x66, 0x0C, 0x61, 0x8C, 0x60, 0x8C, 0x19, 0x03, 0x60, 0x2C, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x08, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0xF0, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0xFF,
  0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xB0, 0x19, 0x01, 0x18, 0x30, 0x82, 0x0C, 0x60, 0x44, 0x06, 0xC0,
  0x28, 0x03, 0xFF, 0xF8, 0xE0, 0xC3, 0x06, 0x0C, 0x7F, 0x11, 0xC0, 0x60,
  0x10, 0x08, 0x04, 0x02, 0x1F, 0x38, 0xB0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x06, 0xC5, 0x3C, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0xF8, 0xD1, 0x9C, 0x1B, 0x83, 0x60, 0x2C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x2E, 0x0D, 0xC1, 0xB4, 0x66,
  0xF8, 0x1F, 0x9C, 0x4C, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x08, 0x06, 0x03, 0x01, 0xC0, 0x71, 0x1F, 0x80, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0xFB, 0x39, 0xEC, 0x1D, 0x81,
  0xB0, 0x34, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0xB0,
  0x36, 0x06, 0xC1, 0xCE, 0x68, 0xF9, 0x1F, 0x0C, 0x66, 0x0D, 0x83, 0x60,
  0x50, 0x1C, 0x07, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xE3, 0x1F, 0x80, 0x0F, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0xFE,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x1F, 0x26, 0x3D, 0x83, 0xB0, 0x36, 0x06, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x34, 0x06, 0xC0, 0xD8,
  0x39, 0xCF, 0x1F, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x90, 0x33,
  0xFC, 0x1E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x7C, 0xD1, 0xB8, 0x6E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xF4, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x33, 0x10, 0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x83, 0xC3, 0x61, 0x31, 0x99, 0x8C, 0xC6, 0xC3, 0x61,
  0xD8, 0xE4, 0x63, 0x31, 0x98, 0x6C, 0x36, 0x0B, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x3E, 0x79, 0x93, 0xB8, 0x70, 0xD8, 0x38,
  0x2C, 0x18, 0x1E, 0x04, 0x0F, 0x02, 0x07, 0x81, 0x03, 0xC0, 0x81, 0xE0,
  0x40, 0xF0, 0x20, 0x78, 0x10, 0x3C, 0x08, 0x1E, 0x04, 0x0F, 0x02, 0x07,
  0x81, 0x03, 0xC0, 0x81, 0x80, 0xDF, 0x3C, 0x6E, 0x1B, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xC0, 0x1F, 0x87, 0x39, 0x83, 0x30, 0x36, 0x06, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x36, 0x06, 0xC0, 0xD8, 0x31,
  0xCE, 0x1F, 0x80, 0xDF, 0x1A, 0x33, 0x83, 0x70, 0x6C, 0x05, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x05, 0xC1, 0xB8, 0x36,
  0x8C, 0xDF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x00, 0x1F, 0x27, 0x3D, 0x83, 0xB0, 0x36, 0x06, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x36, 0x06, 0xC0, 0xD8, 0x39, 0xCF,
  0x1F, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0xDF, 0xB7, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0x3F, 0x63, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x38,
  0x1C, 0x06, 0x03, 0x03, 0x01, 0x01, 0x83, 0xC7, 0xFE, 0x20, 0x86, 0x18,
  0xFD, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x1D,
  0x3C, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1D, 0x8B, 0x3C, 0xC0, 0xC0,
  0x50, 0x36, 0x0D, 0x83, 0x60, 0x88, 0x62, 0x18, 0xC6, 0x31, 0x0C, 0xC1,
  0x30, 0x6C, 0x1A, 0x06, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0xC0, 0xC0, 0xD0,
  0x30, 0x26, 0x0C, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x88, 0x48, 0x42, 0x12,
  0x10, 0xCC, 0xCC, 0x33, 0x33, 0x0C, 0xCC, 0x81, 0x21, 0x20, 0x48, 0x58,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x00,
  0xC1, 0x90, 0x66, 0x31, 0x8C, 0x32, 0x0D, 0x81, 0x40, 0x70, 0x1C, 0x07,
  0x03, 0x60, 0xD8, 0x22, 0x18, 0xC4, 0x13, 0x06, 0xC1, 0xC0, 0xC0, 0x6C,
  0x09, 0x83, 0x30, 0x62, 0x0C, 0x61, 0x0C, 0x61, 0x8C, 0x11, 0x83, 0x20,
  0x6C, 0x0D, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x70, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x07, 0x80, 0xE0, 0x00, 0xFE, 0x0C, 0x18,
  0x60, 0xC1, 0x86, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x7F, 0xFE,
  0x03, 0x83, 0xC3, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x87, 0x83, 0xC0, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x3C, 0x1E, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x1E, 0x1E, 0x00,
  0x78, 0x3F, 0xC6, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 23, 7, 2, -23 },
  { 10, 7, 8, 11, 2, -23 },
  { 17, 13, 23, 14, 1, -23 },
  { 55, 11, 26, 13, 1, -24 },
  { 91, 17, 23, 20, 1, -23 },
  { 140, 13, 23, 14, 1, -23 },
  { 178, 2, 8, 6, 2, -23 },
  { 180, 6, 28, 9, 2, -23 },
  { 201, 6, 28, 9, 1, -23 },
  { 222, 9, 9, 12, 1, -24 },
  { 233, 11, 15, 13, 1, -19 },
  { 254, 4, 7, 6, 1, -3 },
  { 258, 7, 2, 9, 1, -10 },
  { 260, 3, 3, 7, 2, -3 },
  { 262, 10, 23, 11, 1, -23 },
  { 291, 11, 23, 13, 1, -23 },
  { 323, 7, 23, 13, 2, -23 },
  { 344, 11, 23, 13, 1, -23 },
  { 376, 11, 23, 13, 1, -23 },
  { 408, 12, 23, 13, 1, -23 },
  { 443, 10, 23, 13, 2, -23 },
  { 472, 11, 23, 13, 1, -23 },
  { 504, 11, 23, 13, 1, -23 },
  { 536, 11, 23, 13, 1, -23 },
  { 568, 11, 23, 13, 1, -23 },
  { 600, 3, 17, 7, 2, -17 },
  { 607, 4, 21, 7, 1, -17 },
  { 618, 11, 14, 13, 1, -18 },
  { 638, 11, 8, 13, 1, -15 },
  { 649, 11, 14, 13, 1, -18 },
  { 669, 9, 23, 9, 0, -23 },
  { 695, 17, 26, 20, 2, -23 },
  { 751, 13, 23, 13, 0, -23 },
  { 789, 11, 23, 15, 2, -23 },
  { 821, 11, 23, 14, 2, -23 },
  { 853, 12, 23, 16, 2, -23 },
  { 888, 9, 23, 13, 2, -23 },
  { 914, 9, 23, 12, 2, -23 },
  { 940, 13, 23, 17, 2, -23 },
  { 978, 12, 23, 16, 2, -23 },
  { 1013, 6, 23, 8, 1, -23 },
  { 1031, 6, 29, 7, -2, -23 },
  { 1053, 11, 23, 13, 2, -23 },
  { 1085, 9, 23, 11, 2, -23 },
  { 1111, 18, 23, 22, 2, -23 },
  { 1163, 13, 23, 17, 2, -23 },
  { 1201, 13, 23, 17, 2, -23 },
  { 1239, 10, 23, 13, 2, -23 },
  { 1268, 13, 28, 17, 2, -23 },
  { 1314, 11, 23, 14, 2, -23 },
  { 1346, 11, 23, 13, 1, -23 },
  { 1378, 11, 23, 11, 0, -23 },
  { 1410, 12, 23, 16, 2, -23 },
  { 1445, 13, 23, 13, 0, -23 },
  { 1483, 22, 23, 22, 0, -23 },
  { 1547, 11, 23, 12, 0, -23 },
  { 1579, 11, 23, 11, 0, -23 },
  { 1611, 9, 23, 11, 1, -23 },
  { 1637, 7, 28, 10, 2, -23 },
  { 1662, 10, 23, 11, 1, -23 },
  { 1691, 6, 28, 10, 1, -23 },
  { 1712, 12, 12, 13, 1, -23 },
  { 1730, 13, 1, 13, 0, 3 },
  { 1732, 6, 5, 8, 1, -24 },
  { 1736, 9, 17, 13, 1, -17 },
  { 1756, 11, 24, 14, 2, -24 },
  { 1789, 9, 17, 11, 1, -17 },
  { 1809, 11, 24, 14, 1, -24 },
  { 1842, 10, 17, 13, 1, -17 },
  { 1864, 8, 24, 7, 0, -24 },
  { 1888, 11, 25, 14, 1, -17 },
  { 1923, 10, 24, 14, 2, -24 },
  { 1953, 2, 23, 6, 2, -23 },
  { 1959, 4, 31, 6, 0, -23 },
  { 1975, 9, 24, 12, 2, -24 },
  { 2002, 2, 24, 6, 2, -24 },
  { 2008, 17, 17, 21, 2, -17 },
  { 2045, 10, 17, 14, 2, -17 },
  { 2067, 11, 17, 14, 1, -17 },
  { 2091, 11, 25, 14, 2, -17 },
  { 2126, 11, 25, 14, 1, -17 },
  { 2161, 7, 17, 9, 2, -17 },
  { 2176, 8, 17, 10, 1, -17 },
  { 2193, 6, 21, 7, 1, -21 },
  { 2209, 10, 17, 14, 2, -17 },
  { 2231, 10, 17, 11, 0, -17 },
  { 2253, 18, 17, 18, 0, -17 },
  { 2292, 10, 17, 11, 1, -17 },
  { 2314, 11, 25, 11, 0, -17 },
  { 2349, 7, 17, 9, 1, -17 },
  { 2364, 9, 28, 11, 1, -23 },
  { 2396, 2, 32, 13, 5, -24 },
  { 2404, 9, 28, 11, 1, -23 },
  { 2436, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Light32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT32PT7B_H_
