#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x76, 0x60, 0x00, 0x02, 0x7F, 0xF7, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE0, 0xDC, 0x19, 0x83, 0x30, 0x66,
  0x0C, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x70, 0x70,
  0x07, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0xFF, 0xC1, 0xFF, 0xF9, 0xE6, 0x18, 0xE3, 0x00,
  0xE1, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x03, 0x86, 0x00, 0xC3, 0x00, 0x71, 0x80, 0x1E, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x06, 0x78, 0x03, 0x1E, 0x01, 0x87,
  0x00, 0xC1, 0xC0, 0x60, 0xE0, 0x30, 0x70, 0x18, 0x38, 0x0C, 0x1C, 0x06,
  0x0C, 0x03, 0x0E, 0x81, 0x8E, 0x7C, 0xDF, 0x3F, 0xFE, 0x03, 0xFC, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0x00, 0x38, 0x07, 0xF0, 0x06, 0x00, 0xC6, 0x00, 0xC0, 0x30, 0xE0, 0x38,
  0x06, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0xC0, 0x38, 0x38, 0x38, 0x07, 0x07,
  0x06, 0x00, 0xE0, 0xE0, 0xC0, 0x18, 0x1C, 0x38, 0x03, 0x03, 0x86, 0x00,
  0x60, 0x70, 0xC0, 0x0C, 0x0E, 0x30, 0x01, 0xC1, 0xC6, 0x00, 0x38, 0x38,
  0xC3, 0x87, 0x06, 0x31, 0xFC, 0x60, 0xC6, 0x31, 0x8C, 0x18, 0xCE, 0x39,
  0x87, 0x31, 0x83, 0x18, 0xC6, 0x30, 0x63, 0xF9, 0xCE, 0x0C, 0x3E, 0x31,
  0xC1, 0xC0, 0x06, 0x38, 0x38, 0x01, 0xC6, 0x07, 0x00, 0x30, 0xC0, 0xE0,
  0x06, 0x18, 0x1C, 0x01, 0xC3, 0x03, 0x80, 0x30, 0x60, 0x70, 0x06, 0x0E,
  0x0E, 0x01, 0xC1, 0xC1, 0xC0, 0x30, 0x18, 0x30, 0x06, 0x03, 0x06, 0x01,
  0xC0, 0x60, 0xC0, 0x30, 0x0E, 0x30, 0x06, 0x00, 0xFE, 0x01, 0xC0, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1C, 0x70, 0x01, 0x83, 0x00, 0x38,
  0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03,
  0x83, 0x80, 0x18, 0x30, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x00, 0xC6, 0x00,
  0x0E, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0x9C, 0x00, 0x71, 0xC0, 0xC7, 0x0E, 0x0C, 0xE0, 0x60, 0xCE, 0x07,
  0x1C, 0xC0, 0x39, 0xCC, 0x03, 0x9C, 0xC0, 0x1D, 0x8C, 0x00, 0xF8, 0xC0,
  0x0F, 0x0C, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x01, 0xF8, 0x70, 0x1D, 0xC7,
  0x87, 0x9C, 0x3F, 0xF0, 0xE1, 0xFC, 0x0F, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFD, 0xB6, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0xE0, 0x30,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x83, 0x07, 0xCC, 0x7F, 0xFF,
  0xC7, 0xF8, 0x07, 0x80, 0x1B, 0x00, 0xCE, 0x07, 0x18, 0x38, 0x70, 0xC0,
  0xE1, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x39, 0xCE, 0x73, 0x39, 0xCC,
  0x67, 0x31, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x2F, 0xFF, 0xF0, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x0F, 0xF8, 0x1F, 0x78, 0x1C, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x70,
  0x0E, 0x70, 0x06, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x60, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x3C, 0x1C, 0x1E, 0x3C, 0x0F, 0xF8, 0x07, 0xF0, 0x00,
  0xC0, 0x70, 0x3C, 0x1F, 0x0E, 0xCF, 0x37, 0x8F, 0xC3, 0x20, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xE0, 0x3F, 0xF8,
  0xFC, 0xFC, 0x60, 0x1C, 0x40, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8,
  0xF8, 0x7C, 0xE0, 0x1C, 0x40, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x78, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x80, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8, 0x7F, 0xE0, 0x02, 0x00, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1B, 0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38,
  0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0x83, 0x80, 0x30, 0x70,
  0x0C, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xE0,
  0x60, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0E, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x61, 0x80, 0x7F, 0xF0, 0x7F, 0xFC, 0x20, 0x3C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x80, 0x1C, 0xE0, 0x7C, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0xFE, 0x03, 0xFE, 0x07, 0xC6, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x63, 0xF0, 0x67, 0xFC, 0xEE, 0x3C, 0xF8, 0x0E,
  0xF8, 0x0E, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x07, 0x70, 0x07,
  0x30, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x1C, 0x1C, 0x0F, 0xFC, 0x07, 0xF0,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0x8F, 0x07, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x39, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0x70, 0xF0, 0x1E, 0xF0,
  0x07, 0xE0, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xCF, 0x03, 0x81, 0xC3, 0xC0,
  0x71, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D, 0xE0, 0x0E, 0x70, 0x0F,
  0x1E, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x1F,
  0xF0, 0x3E, 0x78, 0x38, 0x1C, 0x70, 0x0C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x70, 0x1F, 0x38,
  0x3F, 0x3F, 0xF7, 0x0F, 0xE7, 0x01, 0x87, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x40, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x04, 0x00, 0x6F,
  0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF,
  0x70, 0x33, 0xDE, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE7, 0x39, 0xCC, 0xE7, 0x31, 0x9C, 0xC6, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x8F, 0xFC, 0xF1, 0xE4, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x1C, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0xF8, 0x19, 0x80,
  0xFF, 0x06, 0x60, 0x70, 0xC1, 0xB8, 0x38, 0x30, 0x7C, 0x0E, 0x1C, 0x1F,
  0x03, 0x07, 0x03, 0xC1, 0xC1, 0xC0, 0xF0, 0x70, 0x70, 0x3C, 0x18, 0x1C,
  0x0F, 0x06, 0x07, 0x03, 0xC1, 0x81, 0xC0, 0xF0, 0x60, 0x70, 0x3C, 0x18,
  0x1C, 0x1F, 0x06, 0x07, 0x07, 0xC1, 0xC1, 0xC1, 0xB0, 0x70, 0xF0, 0x6C,
  0x0C, 0x3C, 0x3B, 0x03, 0x9B, 0x0C, 0xE0, 0xFE, 0x7F, 0x38, 0x1F, 0x0F,
  0x86, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x18, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xEC,
  0x00, 0x07, 0x70, 0x00, 0x33, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00,
  0xE3, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x83, 0x00, 0x1C, 0x18,
  0x00, 0xE0, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x18, 0x03, 0x80, 0xC0, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0x80, 0x38,
  0x1C, 0x01, 0xC0, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1C, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x67,
  0x00, 0x73, 0x80, 0x79, 0xC0, 0x78, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x1E, 0x70, 0x7E, 0x3F, 0xFE, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC3, 0xF1, 0xE1, 0xC0, 0x11, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x01, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0x80, 0xF0, 0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0x73,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x3C, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFC, 0xFE, 0x1E,
  0x00, 0x61, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x00,
  0xE3, 0x80, 0x07, 0x0F, 0x00, 0x38, 0x7E, 0x07, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x3F, 0xFF, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0xA3, 0xDF, 0xCF, 0xC0, 0xE0, 0x07,
  0x70, 0x03, 0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC3, 0x80,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x70, 0x1C, 0x38, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0x70, 0x0F, 0x38, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x07, 0x0E, 0x03, 0x87,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xB0, 0x00, 0x0F, 0xF7, 0x00,
  0x01, 0xBE, 0xE0, 0x00, 0x77, 0xCC, 0x00, 0x0E, 0xF9, 0x80, 0x01, 0x9F,
  0x38, 0x00, 0x33, 0xE3, 0x00, 0x0E, 0x7C, 0x60, 0x01, 0x8F, 0x8E, 0x00,
  0x31, 0xF1, 0xC0, 0x0E, 0x3E, 0x18, 0x01, 0xC7, 0xC3, 0x00, 0x30, 0xF8,
  0x70, 0x0E, 0x1F, 0x06, 0x01, 0xC3, 0xE0, 0xC0, 0x30, 0x7C, 0x1C, 0x06,
  0x0F, 0x83, 0x81, 0xC1, 0xF0, 0x30, 0x38, 0x3E, 0x07, 0x06, 0x07, 0xC0,
  0xE1, 0xC0, 0xF8, 0x0C, 0x38, 0x1F, 0x01, 0x86, 0x03, 0xE0, 0x39, 0xC0,
  0x7C, 0x07, 0x38, 0x0F, 0x80, 0x66, 0x01, 0xF0, 0x0E, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x07, 0x00, 0x70, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xB0, 0x01, 0xF7, 0x00, 0x3E, 0x60, 0x07, 0xCE,
  0x00, 0xF9, 0xC0, 0x1F, 0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x30, 0x0F, 0x87,
  0x01, 0xF0, 0x60, 0x3E, 0x0E, 0x07, 0xC1, 0xC0, 0xF8, 0x1C, 0x1F, 0x03,
  0x83, 0xE0, 0x30, 0x7C, 0x07, 0x0F, 0x80, 0x61, 0xF0, 0x0E, 0x3E, 0x01,
  0xC7, 0xC0, 0x1C, 0xF8, 0x03, 0x9F, 0x00, 0x3B, 0xE0, 0x07, 0x7C, 0x00,
  0x67, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xE3, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x03,
  0x8E, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x1C, 0x03, 0xC0, 0x78, 0x3C, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xE7, 0x03, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x7B, 0x83, 0xE7, 0xFF, 0x8F, 0xFC, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xE0,
  0x3C, 0x07, 0x83, 0xC0, 0x1C, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x0E, 0x70, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x38, 0x1C, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1C, 0x0F, 0x8E,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x06, 0x70, 0x03,
  0x38, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x38, 0xE0, 0x3C, 0x70, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0E, 0x1C, 0x07,
  0x0E, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x0C,
  0x1C, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x70, 0x07, 0xF8, 0x1F, 0xFF,
  0x3F, 0x3E, 0x38, 0x02, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x80, 0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0x7F, 0xE0, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x03, 0x9C, 0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x03, 0x83, 0xC1, 0xF0,
  0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x60, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0x80,
  0x1C, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xC0, 0x38, 0x0E,
  0x03, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x38, 0xC0,
  0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x77, 0x00, 0x1E,
  0x00, 0x19, 0xC0, 0x07, 0x80, 0x0E, 0x70, 0x01, 0xE0, 0x03, 0x9C, 0x00,
  0x78, 0x00, 0xE3, 0x00, 0x3F, 0x00, 0x38, 0xE0, 0x0F, 0xC0, 0x0C, 0x38,
  0x03, 0xB0, 0x07, 0x0E, 0x00, 0xCC, 0x01, 0xC3, 0x80, 0x33, 0x00, 0x70,
  0x60, 0x0C, 0xE0, 0x1C, 0x1C, 0x07, 0x38, 0x06, 0x07, 0x01, 0xC6, 0x03,
  0x81, 0xC0, 0x61, 0x80, 0xE0, 0x70, 0x18, 0x60, 0x38, 0x0C, 0x06, 0x1C,
  0x0E, 0x03, 0x83, 0x87, 0x03, 0x00, 0xE0, 0xE0, 0xC1, 0xC0, 0x38, 0x30,
  0x30, 0x70, 0x0E, 0x0C, 0x0C, 0x1C, 0x01, 0x83, 0x03, 0x86, 0x00, 0x71,
  0xC0, 0xE3, 0x80, 0x1C, 0x70, 0x18, 0xE0, 0x07, 0x18, 0x06, 0x38, 0x00,
  0xC6, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x73, 0x00, 0x0E, 0xE0, 0x1D, 0xC0,
  0x03, 0xB8, 0x03, 0x70, 0x00, 0xEC, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x37,
  0x00, 0x06, 0xC0, 0x0D, 0x80, 0x01, 0xB0, 0x03, 0x60, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x70, 0x01,
  0xCE, 0x00, 0xE3, 0x80, 0x38, 0x60, 0x0C, 0x1C, 0x07, 0x07, 0x01, 0xC0,
  0xE0, 0x60, 0x38, 0x38, 0x06, 0x0E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x0C,
  0x60, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x1C, 0x60, 0x07, 0x1C, 0x01, 0x87, 0x00, 0xE0, 0xC0, 0x38,
  0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x03,
  0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x01, 0x86, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x03, 0x30, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1B, 0x80, 0x07, 0x70, 0x00, 0xC6, 0x00, 0x38, 0xE0, 0x06, 0x0C, 0x01,
  0xC1, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x81, 0x80, 0x30, 0x70, 0x07, 0x0C,
  0x00, 0x63, 0x80, 0x0E, 0x60, 0x00, 0xDC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x03, 0x0F, 0xE0, 0xFF, 0xC3, 0xC7, 0x88, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0x0F, 0xFC,
  0x7E, 0x33, 0x80, 0xDC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0B, 0x70, 0x6D, 0xFF, 0x33, 0xF8,
  0xC1, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x3E, 0x0E, 0x7F, 0xC7, 0x79, 0xF3, 0xB0, 0x39, 0xF0, 0x0E,
  0xF0, 0x07, 0x78, 0x03, 0xBC, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x06, 0xF0, 0x07,
  0x7C, 0x03, 0xBE, 0x03, 0x9D, 0xC3, 0xCE, 0x7F, 0xC7, 0x1F, 0xC0, 0x01,
  0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xF1, 0x87, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x08, 0x3F, 0xE0, 0x7F,
  0x80, 0x20, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0xFC, 0x70, 0xFF, 0x38, 0xF1, 0xDC, 0xE0, 0x3E, 0x70, 0x1F,
  0x70, 0x07, 0xB8, 0x03, 0xDC, 0x00, 0xEC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x0F, 0x70, 0x07,
  0xB8, 0x03, 0xCE, 0x03, 0xE7, 0x83, 0x71, 0xFF, 0x18, 0x7F, 0x0C, 0x04,
  0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x1E, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x70,
  0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x02, 0x1E, 0x06, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0xC0, 0x03, 0xF8, 0x3F,
  0x81, 0xC4, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3F, 0xCF, 0xFE, 0x7F, 0xF0, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x07,
  0xE1, 0x87, 0xF9, 0xC7, 0x8E, 0xE7, 0x01, 0xF3, 0x80, 0x7B, 0x80, 0x3D,
  0xC0, 0x1E, 0xE0, 0x07, 0x60, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E,
  0x70, 0x1F, 0x3C, 0x1B, 0x8F, 0xF9, 0xC3, 0xF8, 0xE0, 0x20, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC8, 0x03, 0xC7, 0xEF, 0xC3, 0xFF, 0xC0, 0x3F, 0x80, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x1F, 0x8E, 0x7F, 0x9D, 0xEF,
  0xBB, 0x07, 0x7C, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xC0, 0x4F, 0xFF,
  0x60, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x0C, 0x38, 0x78, 0xF0, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xBE, 0x7C, 0xF0,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xEE, 0x01,
  0xDC, 0x07, 0x38, 0x0C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0x83, 0x87, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x77, 0xC0, 0xFD, 0x81, 0xF3,
  0x83, 0xC7, 0x07, 0x86, 0x0E, 0x0E, 0x1C, 0x0C, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0x39, 0xC0, 0x73, 0x80, 0x67, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE3, 0xE0, 0x7E, 0x39, 0xFE, 0x3F, 0xCE, 0xE7, 0x9C,
  0xFB, 0xE0, 0x76, 0x0E, 0xF0, 0x1F, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x00,
  0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x7E,
  0x00, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03, 0x80,
  0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8, 0x03,
  0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01, 0xF8,
  0x03, 0x80, 0x7E, 0x00, 0xE0, 0x1F, 0x80, 0x38, 0x07, 0xE0, 0x0E, 0x01,
  0xF8, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x1C, 0xE3, 0xF1, 0xCF, 0xF3, 0xB8,
  0xF7, 0x60, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x18, 0x03, 0xF0,
  0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC3, 0x80, 0x63, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x06, 0x60, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xD8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x33, 0x80, 0x38, 0xC0, 0x1C, 0x70,
  0x1C, 0x1C, 0x1E, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x10, 0x00, 0xE1, 0xF0,
  0x73, 0xFE, 0x3B, 0x8F, 0x1D, 0x81, 0xCF, 0x80, 0x77, 0x80, 0x3B, 0xC0,
  0x1D, 0xE0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x77, 0x80, 0x3B, 0xE0, 0x1D, 0xD0,
  0x1C, 0xEE, 0x1E, 0x73, 0xFE, 0x38, 0xFE, 0x1C, 0x08, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE1, 0x87,
  0xF9, 0xC7, 0x8E, 0xE7, 0x81, 0xF3, 0x80, 0xFB, 0x80, 0x3D, 0xC0, 0x1E,
  0xE0, 0x07, 0x60, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xEC, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0x70, 0x1F,
  0x3C, 0x1B, 0x8F, 0xF9, 0xC3, 0xF8, 0xE0, 0x20, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0xE3, 0xFC, 0xFF, 0xBF,
  0x76, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x0F, 0xE1,
  0xFF, 0xDE, 0x1D, 0xE0, 0x2E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xD0,
  0x0E, 0xC0, 0xF7, 0xFF, 0x1F, 0xF0, 0x08, 0x00, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xCE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x7F,
  0x0F, 0xC0, 0x80, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEC, 0x01, 0xDC, 0x07, 0xB8, 0x1B,
  0x78, 0x76, 0x7F, 0xCC, 0x7F, 0x18, 0x10, 0x00, 0xE0, 0x03, 0x60, 0x07,
  0x60, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E, 0x30, 0x0E, 0x38, 0x0E,
  0x38, 0x0C, 0x38, 0x1C, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x1C, 0x18,
  0x0C, 0x38, 0x0C, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x06, 0x70, 0x06, 0x70,
  0x07, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0x6C, 0x01, 0xE0, 0x0D, 0xC0, 0x3C, 0x03,
  0xB8, 0x07, 0x80, 0x77, 0x00, 0xF0, 0x0E, 0x60, 0x3F, 0x01, 0x8C, 0x07,
  0x60, 0x31, 0xC0, 0xCC, 0x0E, 0x38, 0x19, 0x81, 0xC7, 0x03, 0x30, 0x30,
  0x60, 0xE7, 0x06, 0x0E, 0x1C, 0xE1, 0xC1, 0xC3, 0x0C, 0x38, 0x38, 0x61,
  0x87, 0x03, 0x0C, 0x30, 0xC0, 0x63, 0x87, 0x18, 0x0E, 0x70, 0xE7, 0x01,
  0xCC, 0x0C, 0xE0, 0x39, 0x81, 0x98, 0x03, 0x30, 0x33, 0x00, 0x6E, 0x07,
  0x60, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x0E,
  0xE0, 0x1D, 0xC0, 0x71, 0x80, 0xE3, 0x81, 0x83, 0x07, 0x07, 0x0C, 0x0E,
  0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x1B, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xF0, 0x03, 0xE0, 0x06, 0xE0, 0x1D, 0xC0, 0x31, 0xC0, 0xE3, 0x81,
  0xC3, 0x07, 0x07, 0x0E, 0x06, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x1F, 0x80,
  0x38, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0E, 0x70,
  0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18,
  0x38, 0x18, 0x38, 0x1C, 0x30, 0x1C, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x0E,
  0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0xBC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x7E, 0x03,
  0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x7C, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x3F, 0x01, 0xE0,
  0x00, 0x3F, 0x80, 0x5F, 0xF0, 0x1E, 0x1F, 0xBF, 0x01, 0xFE, 0x80, 0x1F,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 36, 11, 3, -36 },
  { 19, 11, 13, 17, 3, -36 },
  { 37, 20, 36, 22, 1, -36 },
  { 127, 17, 41, 21, 2, -38 },
  { 215, 27, 36, 31, 2, -36 },
  { 337, 20, 37, 22, 2, -36 },
  { 430, 3, 13, 9, 3, -36 },
  { 435, 10, 44, 14, 2, -36 },
  { 490, 9, 44, 14, 2, -36 },
  { 540, 14, 15, 18, 2, -38 },
  { 567, 18, 23, 21, 1, -29 },
  { 619, 5, 12, 10, 2, -5 },
  { 627, 11, 3, 13, 1, -15 },
  { 632, 4, 5, 10, 3, -5 },
  { 635, 16, 36, 18, 1, -36 },
  { 707, 16, 36, 21, 2, -36 },
  { 779, 10, 36, 21, 3, -36 },
  { 824, 16, 36, 21, 2, -36 },
  { 896, 16, 37, 21, 2, -36 },
  { 970, 19, 36, 21, 1, -36 },
  { 1056, 16, 36, 21, 2, -36 },
  { 1128, 16, 37, 21, 2, -36 },
  { 1202, 16, 36, 21, 2, -36 },
  { 1274, 17, 37, 21, 2, -36 },
  { 1353, 16, 37, 21, 2, -36 },
  { 1427, 4, 27, 10, 3, -27 },
  { 1441, 5, 34, 10, 2, -27 },
  { 1463, 18, 21, 21, 1, -28 },
  { 1511, 18, 13, 21, 1, -24 },
  { 1541, 18, 21, 21, 1, -28 },
  { 1589, 12, 36, 15, 1, -36 },
  { 1643, 26, 40, 31, 3, -36 },
  { 1773, 21, 36, 21, 0, -36 },
  { 1868, 17, 36, 23, 4, -36 },
  { 1945, 17, 37, 22, 3, -36 },
  { 2024, 18, 36, 25, 4, -36 },
  { 2105, 13, 36, 20, 4, -36 },
  { 2164, 13, 36, 18, 4, -36 },
  { 2223, 21, 37, 27, 3, -36 },
  { 2321, 18, 36, 26, 4, -36 },
  { 2402, 9, 36, 13, 2, -36 },
  { 2443, 9, 45, 10, -2, -36 },
  { 2494, 17, 36, 21, 4, -36 },
  { 2571, 13, 36, 18, 4, -36 },
  { 2630, 27, 36, 34, 4, -36 },
  { 2752, 19, 36, 27, 4, -36 },
  { 2838, 21, 37, 27, 3, -36 },
  { 2936, 15, 36, 21, 4, -36 },
  { 3004, 21, 45, 27, 3, -36 },
  { 3123, 17, 36, 22, 4, -36 },
  { 3200, 16, 37, 20, 2, -36 },
  { 3274, 17, 36, 18, 0, -36 },
  { 3351, 19, 37, 25, 3, -36 },
  { 3439, 20, 36, 20, 0, -36 },
  { 3529, 34, 36, 34, 0, -36 },
  { 3682, 18, 36, 18, 0, -36 },
  { 3763, 18, 36, 18, 0, -36 },
  { 3844, 15, 36, 17, 1, -36 },
  { 3912, 10, 44, 15, 4, -36 },
  { 3967, 16, 36, 17, 1, -36 },
  { 4039, 10, 44, 15, 2, -36 },
  { 4094, 19, 18, 21, 1, -36 },
  { 4137, 21, 3, 21, 0, 4 },
  { 4145, 8, 8, 12, 2, -38 },
  { 4153, 14, 28, 20, 2, -27 },
  { 4202, 17, 39, 22, 3, -38 },
  { 4285, 14, 28, 17, 2, -27 },
  { 4334, 17, 39, 22, 2, -38 },
  { 4417, 16, 28, 20, 2, -27 },
  { 4473, 13, 38, 12, 0, -38 },
  { 4535, 17, 39, 22, 2, -27 },
  { 4618, 15, 38, 22, 3, -38 },
  { 4690, 4, 37, 10, 3, -37 },
  { 4709, 7, 49, 10, 0, -37 },
  { 4752, 15, 38, 18, 3, -38 },
  { 4824, 3, 38, 9, 3, -38 },
  { 4839, 26, 27, 32, 3, -27 },
  { 4927, 15, 27, 22, 3, -27 },
  { 4978, 17, 28, 21, 2, -27 },
  { 5038, 17, 39, 22, 3, -27 },
  { 5121, 17, 39, 22, 2, -27 },
  { 5204, 11, 27, 14, 3, -27 },
  { 5242, 13, 28, 16, 2, -27 },
  { 5288, 10, 34, 12, 1, -33 },
  { 5331, 15, 28, 22, 3, -27 },
  { 5384, 16, 27, 17, 0, -27 },
  { 5438, 27, 27, 28, 0, -27 },
  { 5530, 15, 27, 17, 1, -27 },
  { 5581, 16, 39, 17, 1, -27 },
  { 5659, 12, 27, 14, 1, -27 },
  { 5700, 13, 44, 18, 2, -36 },
  { 5772, 2, 50, 20, 9, -38 },
  { 5785, 13, 44, 18, 2, -36 },
  { 5857, 18, 5, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Light50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT50PT7B_H_
