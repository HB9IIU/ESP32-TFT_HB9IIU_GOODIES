#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light66pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xBF, 0xFD, 0xF7,
  0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x1D,
  0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x06,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x01, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E, 0x38, 0x38,
  0x78, 0x70, 0x11, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1E,
  0x07, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x87,
  0x00, 0x07, 0xCE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x3E,
  0x00, 0x0E, 0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x78, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0,
  0x0E, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x7B, 0x00,
  0xE1, 0xE7, 0x81, 0xC7, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x1C,
  0x78, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0x1C, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x70, 0x0E,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0x38,
  0x07, 0x07, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x1C, 0x1C, 0x00,
  0x1C, 0x03, 0x87, 0x00, 0x03, 0x80, 0x70, 0xE0, 0x00, 0x70, 0x0E, 0x1C,
  0x1E, 0x0E, 0x01, 0xC7, 0x0F, 0xF1, 0xC0, 0x70, 0xE3, 0xFE, 0x18, 0x0E,
  0x1C, 0x70, 0xE3, 0x81, 0xC7, 0x1C, 0x1E, 0x70, 0x38, 0xE3, 0x81, 0xCF,
  0x0E, 0x1C, 0x70, 0x38, 0xE3, 0xC7, 0x0E, 0x07, 0x0F, 0xF0, 0xE3, 0x80,
  0x71, 0xFC, 0x3C, 0x70, 0x0E, 0x0F, 0x07, 0x0E, 0x01, 0xC0, 0x00, 0xE1,
  0xC0, 0x38, 0x00, 0x38, 0x38, 0x07, 0x00, 0x07, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0xE0, 0x1C, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x07, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x38, 0x07, 0x01, 0xE0, 0x07, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0x00, 0x3F, 0xC0,
  0x07, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0E, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0xF0,
  0x1C, 0x0F, 0x1E, 0x03, 0xC1, 0xE3, 0x80, 0x3C, 0x38, 0xF0, 0x07, 0x87,
  0x1E, 0x00, 0x78, 0xE3, 0xC0, 0x07, 0x3C, 0x78, 0x00, 0xF7, 0x0F, 0x00,
  0x0F, 0xE1, 0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0xC1, 0xE0, 0x07, 0xF8, 0x3E, 0x01,
  0xF7, 0x83, 0xE0, 0x7C, 0x70, 0x3F, 0xFF, 0x0F, 0x03, 0xFF, 0xC0, 0xF0,
  0x3F, 0xE0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x77, 0x77, 0x77, 0x70, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x38, 0x30, 0x77, 0xE6, 0x7E, 0xFF, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x03, 0xC7, 0x00, 0xF0, 0xF0,
  0x1C, 0x0F, 0x07, 0x80, 0xF0, 0x60, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xF0, 0x7C, 0x0F, 0x01,
  0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x3C, 0x00,
  0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F,
  0x80, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07,
  0xF0, 0x7F, 0x87, 0xBC, 0xF9, 0xEF, 0x8F, 0xF8, 0x7F, 0x83, 0xD8, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3C, 0x03,
  0xE0, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xF7, 0xF8, 0xFC, 0x03,
  0xE1, 0xC0, 0x07, 0xC2, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x10, 0x00, 0x7C,
  0x70, 0x03, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C,
  0x00, 0x07, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70,
  0x3C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x1C,
  0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07,
  0x00, 0x3C, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x18, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xC0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x20, 0x00, 0xF9, 0xC0, 0x1F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE1, 0xFE, 0x0F, 0x1F, 0xF8, 0x79, 0xFF, 0xE3, 0xDC, 0x0F, 0x9F,
  0xC0, 0x3C, 0xFC, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x03, 0xC1, 0xF0, 0x3E, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7E, 0x3F, 0x01,
  0xF0, 0x1F, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xC7, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1C, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x3C, 0x7C,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0x9F, 0x00, 0x3E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x07,
  0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00,
  0x79, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xF0, 0x1F, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xE0, 0x7C, 0x1E, 0x01,
  0xE1, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x1F,
  0x78, 0x01, 0xF9, 0xE0, 0x1F, 0xCF, 0x83, 0xDE, 0x3F, 0xFC, 0xF0, 0xFF,
  0xC7, 0x83, 0xFC, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xBC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xDE, 0x1E, 0x3E, 0x3F, 0x3F, 0x1E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xDF, 0xC6, 0x01, 0xE2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x03, 0x8F, 0x00, 0x3F, 0xC0, 0x71, 0xC0, 0x1F, 0xFC, 0x0E, 0x38,
  0x07, 0xC7, 0x81, 0xC7, 0x00, 0xE0, 0xF0, 0x1D, 0xC0, 0x38, 0x1E, 0x03,
  0xB8, 0x07, 0x03, 0xC0, 0x77, 0x01, 0xC0, 0x78, 0x0E, 0xE0, 0x38, 0x0F,
  0x01, 0xDC, 0x07, 0x01, 0xC0, 0x3B, 0x81, 0xE0, 0x38, 0x07, 0xF0, 0x38,
  0x07, 0x00, 0xFE, 0x07, 0x00, 0xE0, 0x1F, 0xC0, 0xE0, 0x1C, 0x03, 0xF0,
  0x1C, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x70, 0x0F, 0xC0, 0x70, 0x0E, 0x01,
  0xF8, 0x0E, 0x01, 0xC0, 0x3F, 0x81, 0xC0, 0x38, 0x07, 0xF0, 0x38, 0x0F,
  0x00, 0xEE, 0x07, 0x81, 0xE0, 0x39, 0xC0, 0x70, 0x3C, 0x07, 0x38, 0x0E,
  0x0F, 0xC0, 0xE7, 0x01, 0xE1, 0x98, 0x38, 0xE0, 0x1E, 0x73, 0xDF, 0x1C,
  0x03, 0xFC, 0x7F, 0xC3, 0xC0, 0x3F, 0x07, 0xF0, 0x38, 0x00, 0x80, 0x30,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x10, 0x00, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x78, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x01, 0xF8,
  0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00,
  0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0xF8, 0xF0, 0x0F, 0xC3, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xF0, 0x07, 0xE3, 0xC0, 0x07,
  0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x3C,
  0x01, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xF0, 0x06, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x06, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xF0,
  0x1F, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80,
  0x1E, 0x01, 0xF0, 0x00, 0x30, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xE0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3F, 0xEF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xEC,
  0x7C, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x7E, 0x00, 0x3F, 0xF8, 0x00,
  0xFE, 0xF0, 0x03, 0xF3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDC, 0x00, 0x00, 0x1F, 0xFB, 0x80,
  0x00, 0x03, 0xBF, 0x70, 0x00, 0x00, 0x77, 0xEF, 0x00, 0x00, 0x1E, 0xFC,
  0xE0, 0x00, 0x03, 0xDF, 0x9C, 0x00, 0x00, 0x73, 0xF3, 0xC0, 0x00, 0x0E,
  0x7F, 0x38, 0x00, 0x03, 0xCF, 0xE7, 0x00, 0x00, 0x71, 0xFC, 0xE0, 0x00,
  0x0E, 0x3F, 0x9E, 0x00, 0x03, 0xC7, 0xF1, 0xC0, 0x00, 0x70, 0xFE, 0x38,
  0x00, 0x0E, 0x1F, 0xC7, 0x80, 0x01, 0xC3, 0xF8, 0x70, 0x00, 0x78, 0x7F,
  0x0E, 0x00, 0x0E, 0x0F, 0xE1, 0xE0, 0x01, 0xC1, 0xFC, 0x1C, 0x00, 0x78,
  0x3F, 0x83, 0x80, 0x0E, 0x07, 0xF0, 0x70, 0x01, 0xC0, 0xFE, 0x0F, 0x00,
  0x78, 0x1F, 0xC0, 0xE0, 0x0F, 0x03, 0xF8, 0x1C, 0x01, 0xC0, 0x7F, 0x03,
  0xC0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0x01, 0xFC, 0x07, 0x01, 0xC0, 0x3F,
  0x80, 0xF0, 0x38, 0x07, 0xF0, 0x1E, 0x0F, 0x00, 0xFE, 0x01, 0xC1, 0xC0,
  0x1F, 0xC0, 0x38, 0x38, 0x03, 0xF8, 0x07, 0x8F, 0x00, 0x7F, 0x00, 0x71,
  0xE0, 0x0F, 0xE0, 0x0E, 0x38, 0x01, 0xFC, 0x01, 0xE7, 0x00, 0x3F, 0x80,
  0x1D, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x38, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xB8, 0x00, 0x0F, 0xDE, 0x00, 0x07, 0xE7,
  0x00, 0x03, 0xF3, 0xC0, 0x01, 0xF9, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x7E,
  0x3C, 0x00, 0x3F, 0x8E, 0x00, 0x1F, 0xC7, 0x80, 0x0F, 0xE1, 0xC0, 0x07,
  0xF0, 0xF0, 0x03, 0xF8, 0x78, 0x01, 0xFC, 0x1C, 0x00, 0xFE, 0x0F, 0x00,
  0x7F, 0x03, 0x80, 0x3F, 0x81, 0xE0, 0x1F, 0xC0, 0x70, 0x0F, 0xE0, 0x3C,
  0x07, 0xF0, 0x1E, 0x03, 0xF8, 0x07, 0x81, 0xFC, 0x03, 0xC0, 0xFE, 0x00,
  0xE0, 0x7F, 0x00, 0x78, 0x3F, 0x80, 0x1C, 0x1F, 0xC0, 0x0F, 0x0F, 0xE0,
  0x07, 0x87, 0xF0, 0x01, 0xE3, 0xF8, 0x00, 0xF1, 0xFC, 0x00, 0x38, 0xFE,
  0x00, 0x1E, 0x7F, 0x00, 0x07, 0x3F, 0x80, 0x03, 0xDF, 0xC0, 0x01, 0xEF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03, 0xE0, 0x01,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xE0, 0x3F, 0x8F, 0x00, 0x7E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x9E,
  0x01, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x70, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3C, 0x07, 0xF0,
  0xF0, 0x07, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0x73,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x0F, 0x0F, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x06,
  0x1E, 0x00, 0x11, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x79, 0x00, 0x07, 0xCF, 0x00, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x3C,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0x87, 0x80, 0x03, 0xB8, 0x00, 0x1C, 0x3C, 0x00, 0x1D, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xEE, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x70, 0x00, 0x78, 0x38,
  0x00, 0x7B, 0xC0, 0x03, 0x81, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0x0F, 0x00,
  0x1C, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xE3, 0x80, 0x0F, 0x01, 0xC0, 0x07,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0x80, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x07, 0x00, 0x70, 0x03, 0x80, 0x78, 0x3C, 0x03,
  0x80, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x00,
  0xF0, 0x78, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x00, 0x3C,
  0x1C, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x0E, 0x0F, 0x00, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x00, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x00, 0x0F, 0x1C, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x03,
  0x8F, 0x00, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0xE7,
  0x80, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x03, 0xDC, 0x00, 0x1D, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x3C, 0x70, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC1, 0xC0, 0x07,
  0x83, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0,
  0x0E, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x78, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xEF, 0x00, 0x01,
  0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x38, 0xE0,
  0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07, 0x80,
  0x1C, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x3C, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x73, 0xC0,
  0x01, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x0E, 0x00,
  0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x70, 0x03, 0xC1, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x3C, 0x00,
  0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x81, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xC7, 0xE0, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0x83, 0x8F, 0x80, 0x73, 0xC0, 0x0E, 0xF0, 0x01, 0xDE,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1E, 0xE0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x3C,
  0x06, 0xE7, 0xE3, 0xCC, 0x7F, 0xF1, 0x87, 0xFC, 0x30, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0xE0, 0xF1, 0xFF, 0xC3, 0xCF, 0x9F,
  0x8F, 0x70, 0x1F, 0x3D, 0x80, 0x3C, 0xFC, 0x00, 0x7B, 0xF0, 0x01, 0xEF,
  0x80, 0x03, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xEF, 0x80, 0x07, 0xBF, 0x00, 0x1E,
  0xFC, 0x00, 0x7B, 0xD8, 0x03, 0xCF, 0x70, 0x1E, 0x3C, 0xFF, 0xF8, 0xF1,
  0xFF, 0xC3, 0x83, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFC, 0xF1, 0xF0, 0x08, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0xFF, 0x8F, 0x0F,
  0xFF, 0x3C, 0x7F, 0x3E, 0xF1, 0xE0, 0x3B, 0xCF, 0x00, 0x7F, 0x3C, 0x00,
  0xFD, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x70, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x01, 0xF7, 0x80,
  0x07, 0xDE, 0x00, 0x1F, 0x3C, 0x00, 0xDC, 0xF0, 0x07, 0x71, 0xE0, 0x39,
  0xC7, 0xF7, 0xC7, 0x0F, 0xFF, 0x1C, 0x0F, 0xF0, 0x70, 0x06, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x1F, 0x01, 0xE0,
  0x3C, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xF3,
  0x80, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x00,
  0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x02,
  0x1F, 0x00, 0x60, 0x7F, 0xBF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x70,
  0xFF, 0xF1, 0xC7, 0xF7, 0xE7, 0x1E, 0x03, 0x9C, 0xF0, 0x03, 0xF3, 0xC0,
  0x0F, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xC0, 0x00, 0xF7, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x00, 0x7F, 0x1E, 0x03,
  0xBC, 0x7F, 0xFC, 0xF0, 0xFF, 0xE3, 0xC0, 0xFF, 0x0F, 0x00, 0x60, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC4, 0x00, 0x0F, 0x1C, 0x00, 0xF8, 0x7E, 0x1F, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x0F, 0xF0, 0xF1, 0xFF, 0xCF,
  0x3E, 0xFC, 0xF7, 0x03, 0xEF, 0xE0, 0x1E, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x77, 0xFF,
  0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xEB,
  0xE7, 0xF3, 0xF1, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF7, 0xE0, 0x0F, 0x7F, 0x00,
  0xFE, 0x70, 0x0F, 0xE7, 0x80, 0xFC, 0x78, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x01, 0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0x8F, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x78, 0x38, 0x7F, 0xC0, 0xFF, 0x8E, 0x3F, 0xF8, 0x7F, 0xF3, 0x9F,
  0x7E, 0x3E, 0xFE, 0xF6, 0x03, 0xCC, 0x07, 0xBF, 0x00, 0xF6, 0x01, 0xEF,
  0xC0, 0x1D, 0x80, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x03, 0x80,
  0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0E,
  0x00, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x1F,
  0xC0, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00,
  0x7F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x03,
  0x80, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00,
  0x0E, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x0E, 0x0F, 0xF8,
  0xE3, 0xFF, 0xCE, 0x3E, 0xFC, 0xF7, 0x03, 0xEF, 0xE0, 0x1E, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xF0,
  0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xF7, 0x00, 0x03, 0x9E, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xC3,
  0xC0, 0x0F, 0x0F, 0x80, 0x3C, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x03, 0x83, 0xFE,
  0x0E, 0x1F, 0xFC, 0x38, 0xF9, 0xF8, 0xF7, 0x01, 0xF3, 0xD8, 0x03, 0xCF,
  0xC0, 0x07, 0xBF, 0x00, 0x1E, 0xF8, 0x00, 0x3B, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0E,
  0xF8, 0x00, 0x7B, 0xF0, 0x01, 0xEF, 0xC0, 0x0F, 0x3D, 0x80, 0x3C, 0xF7,
  0x01, 0xE3, 0xCF, 0xFF, 0x8F, 0x1F, 0xFC, 0x3C, 0x3F, 0xE0, 0xF0, 0x3C,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x70,
  0xFF, 0xF1, 0xC3, 0xFF, 0xE7, 0x1F, 0x03, 0x9C, 0xF8, 0x07, 0x73, 0xC0,
  0x0F, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x80, 0x7F, 0x1F, 0x03,
  0xBC, 0x7F, 0xFC, 0xF0, 0xFF, 0xE3, 0xC0, 0xFF, 0x0F, 0x00, 0x60, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3B, 0x83, 0xFE, 0x1F, 0xF8, 0xFF,
  0xF7, 0x83, 0xDC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xFF,
  0x87, 0xFF, 0xE7, 0xF1, 0xF7, 0xC0, 0x13, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFF,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFE, 0x01, 0xC0, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00,
  0x1F, 0x78, 0x01, 0xF7, 0x80, 0x37, 0x78, 0x03, 0x73, 0xC0, 0xF7, 0x3F,
  0xFE, 0x71, 0xFF, 0xC7, 0x0F, 0xF8, 0x70, 0x1C, 0x00, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE3, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xF8,
  0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x00, 0x1C, 0xE0, 0x07, 0x70, 0x03,
  0x9E, 0x00, 0xEE, 0x00, 0xF3, 0xC0, 0x1D, 0xC0, 0x1E, 0x38, 0x03, 0xB8,
  0x03, 0x87, 0x00, 0x77, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x0E, 0x1E, 0x03,
  0x8E, 0x03, 0xC3, 0xC0, 0x71, 0xC0, 0x70, 0x38, 0x0E, 0x38, 0x0E, 0x07,
  0x03, 0xC7, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x78, 0x1E, 0x0E, 0x0E, 0x0F,
  0x03, 0xC1, 0xC1, 0xC1, 0xC0, 0x38, 0x38, 0x38, 0x38, 0x07, 0x0F, 0x07,
  0x87, 0x00, 0xF1, 0xC0, 0x71, 0xE0, 0x1E, 0x38, 0x0E, 0x38, 0x01, 0xC7,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x38, 0xE0, 0x07, 0x3C, 0x07, 0x9C, 0x00,
  0xF7, 0x00, 0x77, 0x80, 0x1E, 0xE0, 0x0E, 0xE0, 0x01, 0xDC, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x3B, 0x80, 0x07, 0x70, 0x07, 0x70, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0F, 0x01, 0xE0,
  0x38, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x07, 0x1C, 0x00, 0x3D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8,
  0x00, 0x1D, 0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x78, 0x00, 0xF1, 0xC0, 0x07,
  0x0F, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0x80,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00,
  0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81,
  0xE0, 0x1C, 0x0F, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0F, 0x03,
  0x80, 0x78, 0x3C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x03,
  0xC7, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0xF0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x13, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0xE0, 0x0F,
  0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF,
  0xE0, 0x1F, 0xC7, 0xF0, 0x7E, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xA0, 0x00,
  0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 47, 14, 4, -47 },
  { 37, 14, 17, 22, 4, -47 },
  { 67, 27, 47, 29, 1, -47 },
  { 226, 23, 54, 27, 2, -50 },
  { 382, 35, 49, 41, 3, -48 },
  { 597, 27, 49, 28, 2, -48 },
  { 763, 4, 17, 12, 4, -47 },
  { 772, 13, 57, 18, 3, -47 },
  { 865, 13, 57, 18, 2, -47 },
  { 958, 19, 19, 24, 3, -50 },
  { 1004, 23, 31, 27, 2, -39 },
  { 1094, 8, 16, 13, 2, -7 },
  { 1110, 14, 4, 18, 2, -20 },
  { 1117, 5, 6, 13, 4, -6 },
  { 1121, 21, 47, 23, 1, -47 },
  { 1245, 21, 49, 27, 3, -48 },
  { 1374, 13, 47, 27, 5, -47 },
  { 1451, 22, 48, 27, 2, -48 },
  { 1583, 22, 49, 27, 2, -48 },
  { 1718, 25, 47, 27, 1, -47 },
  { 1865, 21, 48, 27, 3, -47 },
  { 1991, 21, 49, 27, 3, -48 },
  { 2120, 21, 47, 27, 3, -47 },
  { 2244, 23, 49, 27, 2, -48 },
  { 2385, 21, 49, 27, 3, -48 },
  { 2514, 5, 35, 13, 4, -35 },
  { 2536, 8, 44, 13, 2, -35 },
  { 2580, 23, 28, 27, 2, -37 },
  { 2661, 23, 17, 27, 2, -32 },
  { 2710, 23, 28, 27, 2, -37 },
  { 2791, 17, 48, 19, 1, -48 },
  { 2893, 35, 54, 41, 3, -48 },
  { 3130, 27, 47, 27, 0, -47 },
  { 3289, 22, 47, 30, 5, -47 },
  { 3419, 24, 49, 28, 3, -48 },
  { 3566, 24, 47, 33, 5, -47 },
  { 3707, 18, 47, 26, 5, -47 },
  { 3813, 18, 47, 24, 5, -47 },
  { 3919, 29, 49, 35, 3, -48 },
  { 4097, 24, 47, 34, 5, -47 },
  { 4238, 12, 47, 17, 2, -47 },
  { 4309, 12, 59, 14, -3, -47 },
  { 4398, 22, 47, 27, 5, -47 },
  { 4528, 17, 47, 24, 5, -47 },
  { 4628, 35, 47, 45, 5, -47 },
  { 4834, 25, 47, 35, 5, -47 },
  { 4981, 29, 49, 35, 3, -48 },
  { 5159, 21, 47, 28, 5, -47 },
  { 5283, 29, 59, 35, 3, -48 },
  { 5497, 22, 47, 29, 5, -47 },
  { 5627, 21, 49, 26, 3, -48 },
  { 5756, 22, 47, 24, 1, -47 },
  { 5886, 24, 48, 33, 5, -47 },
  { 6030, 27, 47, 27, 0, -47 },
  { 6189, 45, 47, 45, 0, -47 },
  { 6454, 23, 47, 24, 1, -47 },
  { 6590, 23, 47, 23, 0, -47 },
  { 6726, 19, 47, 23, 2, -47 },
  { 6838, 13, 58, 20, 5, -47 },
  { 6933, 21, 47, 23, 1, -47 },
  { 7057, 13, 58, 20, 2, -47 },
  { 7152, 26, 24, 28, 1, -47 },
  { 7230, 28, 3, 27, 0, 6 },
  { 7241, 11, 10, 16, 3, -50 },
  { 7255, 19, 37, 26, 2, -36 },
  { 7343, 22, 51, 29, 4, -50 },
  { 7484, 17, 37, 22, 3, -36 },
  { 7563, 22, 51, 29, 3, -50 },
  { 7704, 21, 37, 26, 3, -36 },
  { 7802, 16, 50, 15, 1, -50 },
  { 7902, 22, 52, 29, 3, -36 },
  { 8045, 20, 50, 29, 4, -50 },
  { 8170, 5, 48, 13, 4, -48 },
  { 8200, 9, 64, 13, 0, -48 },
  { 8272, 20, 50, 24, 4, -50 },
  { 8397, 4, 50, 12, 4, -50 },
  { 8422, 34, 36, 43, 4, -36 },
  { 8575, 20, 36, 29, 4, -36 },
  { 8665, 22, 37, 28, 3, -36 },
  { 8767, 22, 52, 29, 4, -36 },
  { 8910, 22, 52, 29, 3, -36 },
  { 9053, 14, 36, 19, 4, -36 },
  { 9116, 17, 37, 22, 2, -36 },
  { 9195, 13, 44, 15, 1, -43 },
  { 9267, 20, 36, 29, 4, -35 },
  { 9357, 22, 35, 22, 0, -35 },
  { 9454, 35, 35, 37, 1, -35 },
  { 9608, 21, 35, 23, 1, -35 },
  { 9700, 21, 51, 23, 1, -35 },
  { 9834, 15, 35, 19, 2, -35 },
  { 9900, 17, 58, 23, 3, -47 },
  { 10024, 4, 66, 26, 11, -50 },
  { 10057, 17, 58, 23, 3, -47 },
  { 10181, 23, 7, 27, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Light66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT66PT7B_H_
