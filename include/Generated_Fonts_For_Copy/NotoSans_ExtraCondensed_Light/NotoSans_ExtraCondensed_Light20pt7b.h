#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x55, 0x50, 0xF0, 0xDC, 0xA5, 0x29, 0x00, 0x12, 0x12, 0x12,
  0x12, 0x7F, 0x22, 0x22, 0x24, 0x24, 0xFF, 0x24, 0x24, 0x24, 0x24, 0x10,
  0xF3, 0x54, 0x89, 0x12, 0x34, 0x18, 0x18, 0x28, 0x48, 0x91, 0x5F, 0x04,
  0x08, 0xE1, 0x12, 0x42, 0x48, 0x49, 0x09, 0x41, 0x2B, 0x25, 0x57, 0x52,
  0x0A, 0x41, 0x44, 0x48, 0x89, 0x21, 0x14, 0x43, 0x80, 0x78, 0x48, 0x48,
  0x48, 0x48, 0x70, 0x20, 0x50, 0x92, 0x8A, 0x8E, 0x84, 0x8A, 0x73, 0xEA,
  0x80, 0x32, 0x44, 0xC8, 0x88, 0x88, 0x88, 0x44, 0x42, 0x30, 0x84, 0x42,
  0x22, 0x23, 0x33, 0x22, 0x22, 0x44, 0x80, 0x20, 0x8F, 0xCC, 0x53, 0x20,
  0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x7A, 0x80, 0xF0,
  0xF0, 0x06, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04,
  0x18, 0x00, 0x79, 0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x71, 0x49,
  0xE0, 0x13, 0xD1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF8, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x10, 0x82, 0x10, 0x83, 0xF0, 0xFA, 0x10, 0x41, 0x04, 0x27,
  0x02, 0x04, 0x10, 0x41, 0x8F, 0xE0, 0x04, 0x0C, 0x0C, 0x14, 0x14, 0x24,
  0x24, 0x44, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0x7E, 0x08, 0x20, 0x83,
  0xC8, 0x81, 0x04, 0x10, 0x41, 0x8F, 0xE0, 0x3D, 0x04, 0x20, 0x82, 0xEC,
  0xE1, 0x86, 0x18, 0x61, 0x45, 0xE0, 0xFC, 0x10, 0x42, 0x08, 0x21, 0x04,
  0x10, 0xC2, 0x08, 0x61, 0x00, 0x79, 0x0A, 0x14, 0x2C, 0x4D, 0x0C, 0x24,
  0x85, 0x0A, 0x1C, 0x28, 0x4F, 0x00, 0x7A, 0x38, 0x61, 0x86, 0x18, 0x53,
  0x34, 0x10, 0x42, 0x0B, 0xC0, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0xA0,
  0x06, 0x31, 0x84, 0x0C, 0x06, 0x03, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x80, 0xC0, 0x60, 0x30, 0xC6, 0x18, 0x40, 0xF8, 0x42, 0x10, 0x8C,
  0x44, 0x21, 0x00, 0x02, 0x30, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0xE5,
  0x24, 0x64, 0x8C, 0x91, 0x92, 0x32, 0x4A, 0x4D, 0x46, 0xC4, 0x00, 0x80,
  0x08, 0x40, 0xF0, 0x18, 0x18, 0x18, 0x14, 0x24, 0x24, 0x24, 0x22, 0x7E,
  0x42, 0x42, 0x41, 0xC1, 0x81, 0xFA, 0x38, 0x61, 0x86, 0x2F, 0x23, 0x86,
  0x18, 0x61, 0x8F, 0xE0, 0x08, 0x7D, 0x82, 0x0C, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x02, 0x04, 0x04, 0x0F, 0x80, 0xF9, 0x1A, 0x14, 0x38, 0x30, 0x60,
  0xC1, 0x83, 0x0E, 0x14, 0x28, 0x9E, 0x00, 0xFC, 0x21, 0x08, 0x43, 0xF0,
  0x84, 0x21, 0x08, 0x7C, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08,
  0x40, 0x3F, 0x30, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x0F, 0x81, 0xC0,
  0xD0, 0x68, 0x32, 0x18, 0xFC, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xAC, 0x8E, 0x29, 0xA4,
  0xA2, 0x8E, 0x28, 0xB2, 0x49, 0xA2, 0x8E, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x7C, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0x68,
  0x5A, 0x16, 0x89, 0x92, 0x64, 0x99, 0x46, 0x31, 0x8C, 0x63, 0x10, 0x83,
  0x87, 0x0E, 0x1A, 0x34, 0x64, 0xC9, 0x8B, 0x16, 0x3C, 0x38, 0x70, 0x40,
  0x3E, 0x21, 0x90, 0x50, 0x28, 0x14, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xB0,
  0x48, 0x26, 0x21, 0xF0, 0xFA, 0x28, 0xE1, 0x86, 0x38, 0xBC, 0x82, 0x08,
  0x20, 0x82, 0x00, 0x3E, 0x21, 0x90, 0x50, 0x28, 0x14, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xB0, 0x48, 0x26, 0x21, 0xE0, 0x10, 0x0C, 0x03, 0x00, 0xFA,
  0x28, 0x61, 0x86, 0x29, 0xB8, 0x92, 0x48, 0xA2, 0x8E, 0x10, 0x01, 0xF8,
  0x20, 0x82, 0x04, 0x0C, 0x18, 0x10, 0x41, 0x06, 0x3F, 0x80, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x43, 0x42,
  0x3C, 0x81, 0xC1, 0x42, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x24, 0x18,
  0x18, 0x18, 0x18, 0x83, 0x0F, 0x0C, 0x24, 0x30, 0x90, 0xC2, 0x45, 0x19,
  0x12, 0x42, 0x49, 0x09, 0x24, 0x24, 0x90, 0xA2, 0xC2, 0x8A, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x80, 0x42, 0x88, 0x91, 0x22, 0x83, 0x04, 0x0C, 0x28,
  0x58, 0x92, 0x24, 0x78, 0x40, 0x82, 0x89, 0x12, 0x22, 0x85, 0x0A, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0xF8, 0x46, 0x21, 0x18, 0x84, 0x42,
  0x11, 0x08, 0x7C, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0xC0, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40,
  0xC0, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x18,
  0x14, 0x24, 0x22, 0x42, 0xC1, 0xFF, 0xC8, 0x80, 0x72, 0x20, 0x82, 0x0D,
  0xF8, 0xE3, 0x8E, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x09, 0x94, 0xB0, 0xE1,
  0x83, 0x06, 0x0E, 0x1C, 0x38, 0xAF, 0x00, 0x3A, 0x31, 0x08, 0x42, 0x10,
  0x82, 0x1E, 0x06, 0x0C, 0x18, 0x33, 0x69, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x78, 0xDE, 0x80, 0x31, 0x28, 0x61, 0x87, 0xF8, 0x20, 0x81, 0x07,
  0xC0, 0x39, 0x08, 0x4F, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x80, 0x32,
  0x96, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x8D, 0xF8, 0x20, 0x40, 0xA3,
  0x38, 0x82, 0x08, 0x20, 0x9A, 0x9C, 0x71, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x40, 0xB0, 0xFF, 0xFF, 0xFC, 0x4C, 0x04, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x60, 0x82, 0x08, 0x20, 0x86, 0x29, 0xA4, 0xA2, 0xCD, 0x22, 0x8A, 0x38,
  0x40, 0xFF, 0xFE, 0xB9, 0x95, 0xCB, 0x11, 0xE2, 0x18, 0x43, 0x08, 0x61,
  0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0x80, 0x9A, 0x9C, 0x71, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x40, 0x38, 0x9A, 0x14, 0x28, 0x70, 0x61, 0xC2, 0x84,
  0x89, 0xE0, 0x99, 0x4B, 0x1E, 0x18, 0x30, 0x60, 0xE1, 0xC3, 0x8A, 0xF4,
  0x08, 0x10, 0x20, 0x40, 0x32, 0x96, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86,
  0x8D, 0xF8, 0x30, 0x60, 0xC1, 0x83, 0x9A, 0xCC, 0x88, 0x88, 0x88, 0x80,
  0x74, 0x61, 0x0C, 0x30, 0x41, 0x0C, 0xFC, 0x24, 0xF4, 0x44, 0x44, 0x44,
  0x46, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0x37, 0x40, 0x87,
  0x09, 0x12, 0x24, 0xC9, 0x0A, 0x14, 0x28, 0x60, 0x40, 0x84, 0x38, 0x85,
  0x19, 0xA5, 0x24, 0xA4, 0x94, 0x8A, 0x51, 0x8C, 0x31, 0x86, 0x30, 0xC6,
  0x00, 0xC4, 0x89, 0xB1, 0x42, 0x82, 0x0E, 0x14, 0x68, 0x8B, 0x18, 0x82,
  0x89, 0x12, 0x24, 0x45, 0x0A, 0x14, 0x28, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x60, 0xF1, 0x32, 0x24, 0x44, 0x88, 0xF0, 0x19, 0x08, 0x42, 0x10, 0x84,
  0xC1, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42,
  0x10, 0x86, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0xE3, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 5, 5, 7, 1, -14 },
  { 9, 8, 14, 9, 0, -14 },
  { 23, 7, 16, 8, 1, -15 },
  { 37, 11, 14, 12, 1, -14 },
  { 57, 8, 14, 9, 1, -14 },
  { 71, 2, 5, 4, 1, -14 },
  { 73, 4, 17, 6, 1, -14 },
  { 82, 4, 17, 6, 1, -14 },
  { 91, 6, 6, 7, 1, -15 },
  { 96, 7, 10, 8, 1, -12 },
  { 105, 2, 5, 4, 1, -2 },
  { 107, 4, 1, 5, 1, -6 },
  { 108, 2, 2, 4, 1, -2 },
  { 109, 7, 14, 7, 0, -14 },
  { 122, 6, 14, 8, 1, -14 },
  { 133, 4, 14, 8, 1, -14 },
  { 140, 6, 14, 8, 1, -14 },
  { 151, 6, 14, 8, 1, -14 },
  { 162, 8, 14, 8, 0, -14 },
  { 176, 6, 14, 8, 1, -14 },
  { 187, 6, 14, 8, 1, -14 },
  { 198, 6, 14, 8, 1, -14 },
  { 209, 7, 14, 8, 1, -14 },
  { 222, 6, 14, 8, 1, -14 },
  { 233, 2, 11, 4, 1, -11 },
  { 236, 2, 14, 4, 1, -11 },
  { 240, 7, 8, 8, 1, -11 },
  { 247, 7, 6, 8, 1, -10 },
  { 253, 7, 8, 8, 1, -11 },
  { 260, 5, 14, 6, 0, -14 },
  { 269, 11, 16, 13, 1, -14 },
  { 291, 8, 14, 8, 0, -14 },
  { 305, 6, 14, 9, 2, -14 },
  { 316, 7, 15, 9, 1, -15 },
  { 330, 7, 14, 10, 2, -14 },
  { 343, 5, 14, 8, 2, -14 },
  { 352, 5, 14, 7, 2, -14 },
  { 361, 9, 14, 11, 1, -14 },
  { 377, 7, 14, 10, 2, -14 },
  { 390, 3, 14, 5, 1, -14 },
  { 396, 4, 18, 4, -1, -14 },
  { 405, 6, 14, 8, 2, -14 },
  { 416, 5, 14, 7, 2, -14 },
  { 425, 10, 14, 14, 2, -14 },
  { 443, 7, 14, 11, 2, -14 },
  { 456, 9, 14, 11, 1, -14 },
  { 472, 6, 14, 8, 2, -14 },
  { 483, 9, 17, 11, 1, -14 },
  { 503, 6, 14, 9, 2, -14 },
  { 514, 6, 15, 8, 1, -15 },
  { 526, 7, 14, 7, 0, -14 },
  { 539, 8, 14, 10, 1, -14 },
  { 553, 8, 14, 8, 0, -14 },
  { 567, 14, 14, 14, 0, -14 },
  { 592, 7, 14, 7, 0, -14 },
  { 605, 7, 14, 7, 0, -14 },
  { 618, 5, 14, 7, 1, -14 },
  { 627, 4, 17, 6, 2, -14 },
  { 636, 7, 14, 7, 0, -14 },
  { 649, 4, 17, 6, 1, -14 },
  { 658, 8, 7, 8, 0, -14 },
  { 665, 8, 1, 8, 0, 2 },
  { 666, 3, 3, 5, 1, -15 },
  { 668, 6, 11, 8, 1, -11 },
  { 677, 7, 15, 9, 1, -15 },
  { 691, 5, 11, 7, 1, -11 },
  { 698, 7, 15, 9, 1, -15 },
  { 712, 6, 11, 8, 1, -11 },
  { 721, 5, 15, 5, 0, -15 },
  { 731, 7, 16, 9, 1, -11 },
  { 745, 6, 15, 9, 1, -15 },
  { 757, 2, 15, 4, 1, -15 },
  { 761, 3, 20, 4, 0, -15 },
  { 769, 6, 15, 7, 1, -15 },
  { 781, 1, 15, 4, 1, -15 },
  { 783, 11, 11, 13, 1, -11 },
  { 799, 6, 11, 9, 1, -11 },
  { 808, 7, 11, 8, 1, -11 },
  { 818, 7, 16, 9, 1, -11 },
  { 832, 7, 16, 9, 1, -11 },
  { 846, 4, 11, 6, 1, -11 },
  { 852, 5, 11, 7, 1, -11 },
  { 859, 4, 13, 5, 0, -13 },
  { 866, 6, 11, 9, 1, -11 },
  { 875, 7, 11, 7, 0, -11 },
  { 885, 11, 11, 11, 0, -11 },
  { 901, 7, 11, 7, 0, -11 },
  { 911, 7, 16, 7, 0, -11 },
  { 925, 4, 11, 6, 1, -11 },
  { 931, 5, 17, 7, 1, -14 },
  { 942, 1, 20, 8, 3, -15 },
  { 945, 5, 17, 7, 1, -14 },
  { 956, 7, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Light20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT20PT7B_H_
