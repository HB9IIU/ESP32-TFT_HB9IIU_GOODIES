#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light35pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x1F, 0x60, 0xC7,
  0xC7, 0xC3, 0xC3, 0xC2, 0xC2, 0xC2, 0xC2, 0x42, 0x04, 0x30, 0x30, 0xC0,
  0xC2, 0x03, 0x08, 0x0C, 0x20, 0x30, 0x80, 0x86, 0x3F, 0xFF, 0xFF, 0xFC,
  0x21, 0x81, 0x86, 0x06, 0x10, 0x18, 0x40, 0x61, 0x01, 0x0C, 0x04, 0x30,
  0xFF, 0xF8, 0x43, 0x03, 0x0C, 0x0C, 0x20, 0x30, 0x80, 0xC2, 0x03, 0x08,
  0x08, 0x60, 0x21, 0x80, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFC, 0x3F, 0xE6,
  0x62, 0x46, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x06, 0x60, 0x36, 0x01,
  0xE0, 0x07, 0x00, 0x7C, 0x06, 0x60, 0x63, 0x06, 0x30, 0x63, 0x06, 0x30,
  0x63, 0x06, 0x3C, 0x6E, 0xFF, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x3C, 0x06, 0x0C, 0xC0, 0x81, 0x88, 0x30, 0x21, 0x86, 0x04, 0x30, 0x80,
  0x86, 0x30, 0x30, 0xC6, 0x06, 0x18, 0x80, 0x43, 0x30, 0x08, 0x66, 0x01,
  0x0C, 0x9E, 0x21, 0xB2, 0x66, 0x26, 0xC6, 0x4C, 0x98, 0xCF, 0x32, 0x18,
  0x06, 0x43, 0x00, 0x88, 0x60, 0x31, 0x0C, 0x06, 0x21, 0x80, 0x84, 0x30,
  0x30, 0x86, 0x06, 0x18, 0xC0, 0x83, 0x18, 0x30, 0x36, 0x06, 0x07, 0x80,
  0x1F, 0x00, 0x66, 0x03, 0x18, 0x0C, 0x20, 0x30, 0x80, 0xC2, 0x03, 0x08,
  0x0C, 0x60, 0x11, 0x80, 0x6C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xD8,
  0x06, 0x31, 0x98, 0xC6, 0xC1, 0x9B, 0x03, 0x6C, 0x0D, 0x30, 0x1C, 0xC0,
  0x73, 0x01, 0xC6, 0x0D, 0x9E, 0xE6, 0x3F, 0x0C, 0xFF, 0xFF, 0x40, 0x0E,
  0x10, 0x61, 0x83, 0x04, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xC1,
  0x81, 0x81, 0x00, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06,
  0x18, 0x30, 0x61, 0x82, 0x0C, 0x30, 0x00, 0x04, 0x01, 0x00, 0x42, 0x11,
  0x75, 0xEF, 0xE0, 0xE0, 0x6C, 0x31, 0x0C, 0x62, 0x10, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x33,
  0x36, 0x66, 0x64, 0xC0, 0xFE, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x07, 0x71, 0x86, 0x30, 0x6C,
  0x0D, 0x81, 0xB0, 0x16, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x60, 0x6C, 0x0C, 0xC1,
  0x98, 0x61, 0xFC, 0x1F, 0x00, 0x06, 0x1C, 0x79, 0xBE, 0x68, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x3F, 0x87, 0xBC, 0x40, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0x8F, 0xBC, 0x40, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xF0, 0x1F,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x80, 0xEF, 0x3C, 0x7F, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x2C, 0x03, 0x60, 0x1B, 0x01, 0x98, 0x0C, 0xC0, 0xC6, 0x06,
  0x30, 0x61, 0x83, 0x0C, 0x30, 0x61, 0x83, 0x08, 0x18, 0xC0, 0xC4, 0x06,
  0x3F, 0xFE, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x7F, 0xCF, 0xF9, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0xFC, 0x7F, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xA0, 0x77, 0x3C, 0xFE, 0x00, 0x0F,
  0xC3, 0xD8, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x83, 0x7E, 0x78, 0xEE, 0x0D, 0x81, 0xB0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x06, 0xC1, 0x98, 0x31, 0x9C, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x00,
  0x1F, 0x83, 0x9C, 0x70, 0x66, 0x06, 0x60, 0x36, 0x03, 0x60, 0x36, 0x06,
  0x30, 0x63, 0x0C, 0x1D, 0x80, 0xF0, 0x0F, 0x01, 0x9C, 0x30, 0xE6, 0x06,
  0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x03, 0x60, 0x63, 0x9E,
  0x1F, 0x80, 0x1F, 0x83, 0xFC, 0x70, 0xC6, 0x06, 0x60, 0x64, 0x06, 0xC0,
  0x2C, 0x02, 0xC0, 0x3C, 0x03, 0x60, 0x76, 0x07, 0x60, 0x73, 0x1B, 0x3F,
  0x20, 0x42, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x86, 0x70, 0x7E, 0x00, 0x5F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x37, 0x72, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x76, 0x66, 0x4C,
  0x00, 0x10, 0x03, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x80, 0x00,
  0xFC, 0xEE, 0x83, 0x03, 0x03, 0x01, 0x03, 0x03, 0x03, 0x07, 0x06, 0x0C,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x30, 0x03, 0xF8, 0x01, 0xC7, 0x01, 0xC0, 0x60, 0x60, 0x0C, 0x30, 0x01,
  0x88, 0x00, 0x66, 0x00, 0x09, 0x03, 0xE3, 0xC3, 0x98, 0xF0, 0xC6, 0x3C,
  0x21, 0x87, 0x18, 0x61, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x06, 0x18,
  0x43, 0x86, 0x30, 0xF1, 0x8C, 0x3C, 0x63, 0x8B, 0x0D, 0xBE, 0xC1, 0xCF,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x02, 0x00,
  0xF7, 0x80, 0x1F, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xA0, 0x06,
  0xC0, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0x40, 0x31, 0x81, 0x86, 0x06,
  0x18, 0x18, 0x20, 0x60, 0xC1, 0xFF, 0x0F, 0xFC, 0x30, 0x30, 0xC0, 0x63,
  0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0C,
  0xFF, 0x0F, 0xF8, 0xC0, 0xCC, 0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x6C, 0x0C, 0xC1, 0xCF, 0xF0, 0xFF, 0x8C, 0x0C, 0xC0, 0x6C, 0x06,
  0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCF, 0xFC,
  0xFF, 0x00, 0x07, 0xF1, 0xE7, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xF7, 0x07, 0xF0, 0xFE, 0x07, 0xFC, 0x30, 0x71, 0x81, 0xCC, 0x06,
  0x60, 0x3B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C,
  0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80,
  0xEC, 0x06, 0x60, 0x73, 0x07, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFF, 0xFE,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x07, 0xF8, 0x1E, 0x78, 0x60,
  0x11, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x1B, 0x00, 0x37, 0x00, 0x66, 0x00,
  0xC6, 0x01, 0x8F, 0x9F, 0x07, 0xFC, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xFE, 0x70, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0xFE, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xD3, 0xBE, 0x00, 0xC0, 0x6C,
  0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0xC6, 0x0C, 0x60, 0xCC, 0x0C,
  0xC0, 0xD8, 0x0F, 0x80, 0xFC, 0x0E, 0xC0, 0xCE, 0x0C, 0x60, 0xC6, 0x0C,
  0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x70,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1E,
  0x80, 0x05, 0xB0, 0x03, 0x6C, 0x00, 0xDD, 0x00, 0x2F, 0x60, 0x1B, 0xD8,
  0x06, 0xF6, 0x01, 0xBC, 0x80, 0xCF, 0x30, 0x33, 0xCC, 0x0C, 0xF1, 0x02,
  0x3C, 0x61, 0x8F, 0x18, 0x63, 0xC2, 0x18, 0xF0, 0xCC, 0x3C, 0x33, 0x0F,
  0x0C, 0xC3, 0xC1, 0x20, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x03, 0xC0,
  0xC0, 0xC0, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x40, 0x3B, 0x01, 0xD8, 0x0F,
  0x60, 0x7B, 0x03, 0xCC, 0x1E, 0x60, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE1,
  0x8F, 0x0C, 0x78, 0x33, 0xC1, 0x9E, 0x06, 0xF0, 0x37, 0x81, 0xBC, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x18, 0x0F, 0xE0, 0x3D, 0xE0, 0xC0,
  0xE3, 0x80, 0xC6, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x33, 0x00, 0x66, 0x01, 0xCE, 0x03,
  0x0E, 0x0E, 0x0F, 0x78, 0x0F, 0xE0, 0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C,
  0x0D, 0x81, 0xB0, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xEC, 0x39,
  0xFE, 0x3E, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x3D, 0xE0, 0xC0, 0xE3, 0x80,
  0xC6, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1B, 0x00, 0x33, 0x00, 0x66, 0x01, 0xCE, 0x03, 0x0E, 0x0E,
  0x0F, 0x78, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0xFE, 0x0F, 0xF8, 0xC1, 0xCC, 0x0C, 0xC0, 0xCC,
  0x04, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0xFF, 0x0F,
  0xE0, 0xC6, 0x0C, 0x60, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC1, 0xCC,
  0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x70, 0x1F, 0xE3, 0xFE, 0x70, 0x26, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x80, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x1D, 0xC0, 0xC7,
  0xFE, 0x1F, 0xC0, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0xD8, 0x06, 0x60, 0x19,
  0x80, 0x62, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x81, 0x86, 0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x01, 0x20, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x06, 0x60, 0x18, 0x06, 0x60, 0x3C, 0x06, 0x60,
  0x3C, 0x06, 0x60, 0x3C, 0x06, 0x20, 0x2C, 0x0C, 0x30, 0x24, 0x0C, 0x30,
  0x66, 0x0C, 0x30, 0x66, 0x0C, 0x30, 0x66, 0x0C, 0x18, 0x46, 0x18, 0x18,
  0x42, 0x18, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x0C,
  0x83, 0x30, 0x0C, 0x81, 0x30, 0x0D, 0x81, 0xB0, 0x0D, 0x81, 0xB0, 0x0D,
  0x81, 0xA0, 0x05, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x60, 0x31, 0x81, 0x8C, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x60,
  0x63, 0x01, 0x98, 0x0D, 0x80, 0x2C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x16, 0x01, 0xB0, 0x0C, 0x80, 0xC6, 0x06, 0x30, 0x20, 0xC3, 0x06,
  0x18, 0x31, 0x80, 0xCC, 0x06, 0xE0, 0x38, 0xC0, 0x36, 0x03, 0x60, 0x36,
  0x06, 0x30, 0x63, 0x06, 0x30, 0xC1, 0x0C, 0x18, 0x81, 0x98, 0x09, 0x80,
  0xD0, 0x0F, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xF0,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF, 0x80, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0xFF, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80,
  0x02, 0x00, 0x38, 0x01, 0xC0, 0x1B, 0x00, 0x98, 0x0C, 0x60, 0x63, 0x06,
  0x0C, 0x30, 0x63, 0x01, 0x98, 0x0D, 0x80, 0x3C, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE1, 0x83, 0x06, 0x08, 0x10, 0x1F, 0x0F, 0xE2, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x0F, 0xCF, 0x97, 0x05, 0x81, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x61, 0x5C, 0xD3, 0xE4, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x8D, 0xFC, 0xD0, 0xEE,
  0x06, 0xE0, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x06, 0xF0, 0x6D, 0xDC, 0xCF, 0x80,
  0x1F, 0x1F, 0xDC, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x3C, 0xC7, 0xE0, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x1E, 0x67, 0xED,
  0x87, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x60, 0xEE, 0x64, 0xF8, 0x80,
  0x1E, 0x0F, 0xE6, 0x19, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x4E, 0x71, 0xF8,
  0x07, 0x07, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x3E, 0x7F, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x1E, 0x27, 0xED, 0x83, 0xF0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x60, 0xEF, 0x6C, 0xF9, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xDC, 0x71, 0xFC, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC7, 0x9B, 0xFB, 0x43,
  0x70, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x5F,
  0xA0, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x11, 0xCE, 0x20,
  0x00, 0x06, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0xB7, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31,
  0x8C, 0xC3, 0x30, 0xDC, 0x35, 0x8E, 0x63, 0x98, 0xC3, 0x30, 0xCC, 0x1B,
  0x06, 0xC1, 0xB0, 0x3C, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xCF, 0x0F, 0x37, 0xE7, 0xED, 0x1F, 0x1F, 0x83, 0x83, 0xE0, 0xE0, 0xF0,
  0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C,
  0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03,
  0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0C, 0xC7, 0x9B, 0xFB, 0x43, 0x70,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x1F, 0x07,
  0xF1, 0x83, 0x70, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x02, 0x60, 0xCF, 0x70, 0x7C,
  0x00, 0xC7, 0x8D, 0xFC, 0xD0, 0xEE, 0x06, 0xE0, 0x6E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x2E,
  0x06, 0xD0, 0x6D, 0x9C, 0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x1E, 0x27, 0xED, 0x87, 0xF0, 0x7C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x60, 0xEF, 0x6C, 0xF9, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xC7, 0xDE, 0xD8, 0xF0,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x1F, 0x3F, 0xD8, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xFB, 0x9F,
  0x80, 0x20, 0x40, 0x81, 0x07, 0xFF, 0xD8, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x4F, 0x80, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3B, 0x07, 0x61, 0xEE, 0x6C, 0xF9,
  0x80, 0xC0, 0x78, 0x0D, 0x81, 0xB0, 0x36, 0x04, 0xC1, 0x88, 0x31, 0x86,
  0x30, 0x86, 0x30, 0x46, 0x0C, 0xC1, 0x90, 0x36, 0x02, 0xC0, 0x58, 0x0E,
  0x01, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x68, 0x0C, 0x0D, 0x83, 0x81, 0xB0,
  0x78, 0x36, 0x0F, 0x04, 0xC1, 0x61, 0x8C, 0x64, 0x31, 0x8C, 0x86, 0x31,
  0x98, 0x86, 0x33, 0x30, 0x44, 0x66, 0x0D, 0x84, 0xC1, 0xB0, 0x98, 0x36,
  0x1A, 0x06, 0xC3, 0xC0, 0x50, 0x78, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x38,
  0x18, 0x00, 0xC0, 0xD8, 0x19, 0x86, 0x30, 0xC3, 0x10, 0x66, 0x06, 0xC0,
  0xF0, 0x0E, 0x01, 0x80, 0x78, 0x0F, 0x01, 0x30, 0x66, 0x0C, 0x43, 0x0C,
  0x61, 0x98, 0x1B, 0x03, 0x80, 0xC0, 0x36, 0x02, 0x60, 0x66, 0x06, 0x20,
  0x63, 0x04, 0x30, 0xC3, 0x0C, 0x10, 0xC1, 0x88, 0x19, 0x81, 0x98, 0x09,
  0x80, 0xD0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x0B, 0x80, 0xF0, 0x00, 0xFF, 0xFF,
  0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x60,
  0x60, 0x60, 0xC0, 0xFF, 0xFF, 0x03, 0x87, 0xC3, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC3, 0xC1, 0xC0, 0x30,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x3C, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x78, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0x80, 0x60, 0x1E, 0x07, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x87, 0x82, 0x00,
  0x7C, 0x0F, 0x79, 0xE0, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Light35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 25, 8, 2, -25 },
  { 11, 8, 9, 12, 2, -25 },
  { 20, 14, 25, 15, 1, -25 },
  { 64, 12, 29, 14, 1, -27 },
  { 108, 19, 25, 22, 1, -25 },
  { 168, 14, 25, 15, 1, -25 },
  { 212, 2, 9, 6, 2, -25 },
  { 215, 7, 31, 10, 2, -25 },
  { 243, 7, 31, 10, 1, -25 },
  { 271, 10, 11, 13, 1, -27 },
  { 285, 12, 17, 15, 1, -21 },
  { 311, 4, 9, 7, 1, -4 },
  { 316, 7, 1, 9, 1, -10 },
  { 317, 3, 3, 7, 2, -3 },
  { 319, 11, 25, 12, 1, -25 },
  { 354, 11, 25, 14, 2, -25 },
  { 389, 7, 25, 14, 2, -25 },
  { 411, 12, 25, 14, 1, -25 },
  { 449, 12, 25, 14, 1, -25 },
  { 487, 13, 25, 14, 1, -25 },
  { 528, 11, 25, 14, 2, -25 },
  { 563, 11, 25, 14, 2, -25 },
  { 598, 12, 25, 14, 1, -25 },
  { 636, 12, 25, 14, 1, -25 },
  { 674, 12, 25, 14, 1, -25 },
  { 712, 3, 19, 7, 2, -19 },
  { 720, 4, 24, 7, 1, -19 },
  { 732, 12, 15, 15, 1, -20 },
  { 755, 12, 9, 15, 1, -17 },
  { 769, 12, 15, 15, 1, -20 },
  { 792, 8, 25, 10, 1, -25 },
  { 817, 18, 28, 22, 2, -25 },
  { 880, 14, 25, 14, 0, -25 },
  { 924, 12, 25, 16, 3, -25 },
  { 962, 12, 25, 15, 2, -25 },
  { 1000, 13, 25, 17, 3, -25 },
  { 1041, 9, 25, 14, 3, -25 },
  { 1070, 9, 25, 13, 3, -25 },
  { 1099, 15, 25, 19, 2, -25 },
  { 1146, 12, 25, 18, 3, -25 },
  { 1184, 7, 25, 9, 1, -25 },
  { 1206, 7, 31, 7, -2, -25 },
  { 1234, 12, 25, 14, 3, -25 },
  { 1272, 9, 25, 12, 3, -25 },
  { 1301, 18, 25, 24, 3, -25 },
  { 1358, 13, 25, 19, 3, -25 },
  { 1399, 15, 25, 19, 2, -25 },
  { 1446, 11, 25, 15, 3, -25 },
  { 1481, 15, 31, 19, 2, -25 },
  { 1540, 12, 25, 15, 3, -25 },
  { 1578, 12, 25, 14, 1, -25 },
  { 1616, 12, 25, 13, 0, -25 },
  { 1654, 13, 25, 18, 2, -25 },
  { 1695, 14, 25, 14, 0, -25 },
  { 1739, 24, 25, 24, 0, -25 },
  { 1814, 13, 25, 13, 0, -25 },
  { 1855, 12, 25, 12, 0, -25 },
  { 1893, 10, 25, 12, 1, -25 },
  { 1925, 7, 31, 11, 3, -25 },
  { 1953, 11, 25, 12, 1, -25 },
  { 1988, 7, 31, 11, 1, -25 },
  { 2016, 13, 13, 15, 1, -25 },
  { 2038, 15, 2, 15, 0, 3 },
  { 2042, 6, 6, 9, 1, -27 },
  { 2047, 10, 19, 14, 1, -19 },
  { 2071, 12, 27, 16, 2, -27 },
  { 2112, 9, 19, 12, 2, -19 },
  { 2134, 11, 27, 16, 2, -27 },
  { 2172, 10, 19, 14, 2, -19 },
  { 2196, 9, 27, 8, 0, -27 },
  { 2227, 11, 27, 15, 2, -19 },
  { 2265, 11, 27, 15, 2, -27 },
  { 2303, 3, 26, 7, 2, -26 },
  { 2313, 5, 34, 7, 0, -26 },
  { 2335, 10, 27, 13, 2, -27 },
  { 2369, 2, 27, 7, 2, -27 },
  { 2376, 18, 19, 23, 2, -19 },
  { 2419, 11, 19, 15, 2, -19 },
  { 2446, 11, 19, 15, 2, -19 },
  { 2473, 12, 27, 16, 2, -19 },
  { 2514, 11, 27, 15, 2, -19 },
  { 2552, 8, 19, 10, 2, -19 },
  { 2571, 9, 19, 11, 1, -19 },
  { 2593, 7, 23, 8, 1, -23 },
  { 2614, 11, 19, 15, 2, -19 },
  { 2641, 11, 19, 12, 0, -19 },
  { 2668, 19, 19, 20, 0, -19 },
  { 2714, 11, 19, 12, 1, -19 },
  { 2741, 12, 27, 12, 0, -19 },
  { 2782, 8, 19, 10, 1, -19 },
  { 2801, 9, 31, 12, 2, -25 },
  { 2836, 2, 35, 14, 6, -27 },
  { 2845, 9, 31, 12, 2, -25 },
  { 2880, 13, 3, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Light35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT35PT7B_H_
