#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xCA, 0x52, 0x94, 0xA4, 0x09, 0x04, 0x41, 0x10, 0x44,
  0x7F, 0xC4, 0x41, 0x10, 0x48, 0x12, 0x04, 0x8F, 0xF8, 0x88, 0x22, 0x08,
  0x82, 0x20, 0x90, 0x10, 0x3C, 0x52, 0x90, 0x90, 0x90, 0x90, 0x70, 0x38,
  0x1C, 0x12, 0x13, 0x11, 0x13, 0x92, 0xFC, 0x10, 0x10, 0x20, 0x05, 0x08,
  0x88, 0x88, 0x90, 0x89, 0x08, 0x90, 0x8A, 0x08, 0xAE, 0x8A, 0x95, 0x49,
  0x25, 0x10, 0x51, 0x09, 0x10, 0x91, 0x08, 0x91, 0x09, 0x10, 0xE0, 0x10,
  0x34, 0x11, 0x08, 0x84, 0x42, 0x60, 0xA0, 0x70, 0x30, 0x28, 0x22, 0x51,
  0xA8, 0x54, 0x3A, 0x09, 0x8A, 0x79, 0x80, 0xD5, 0x50, 0x19, 0x08, 0x84,
  0x23, 0x18, 0x84, 0x21, 0x8C, 0x21, 0x08, 0x21, 0x04, 0x30, 0xC4, 0x62,
  0x21, 0x11, 0x11, 0x11, 0x11, 0x32, 0x24, 0x48, 0x10, 0x20, 0x47, 0xF3,
  0x05, 0x13, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x5E, 0x80, 0xF8, 0xF0, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0xC0, 0x18, 0x79, 0x1A,
  0x1C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x50, 0xB2, 0x3C,
  0x37, 0xD9, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x39, 0xFA, 0x18, 0x10,
  0x20, 0x40, 0x83, 0x04, 0x18, 0x20, 0x83, 0x04, 0x10, 0x60, 0xFE, 0x39,
  0xDA, 0x18, 0x10, 0x20, 0x41, 0x86, 0x38, 0x18, 0x08, 0x10, 0x20, 0x40,
  0xC3, 0xFC, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22,
  0x11, 0x10, 0x88, 0x4F, 0xF8, 0x10, 0x08, 0x04, 0x02, 0x00, 0x7E, 0x81,
  0x02, 0x0C, 0x18, 0x3E, 0x43, 0x02, 0x04, 0x08, 0x10, 0x20, 0x61, 0x7C,
  0x0C, 0x7D, 0x82, 0x04, 0x18, 0x20, 0x5E, 0xC7, 0x86, 0x0C, 0x18, 0x38,
  0x50, 0xA3, 0x3C, 0xFE, 0x04, 0x08, 0x30, 0x40, 0x83, 0x04, 0x08, 0x30,
  0x40, 0x83, 0x04, 0x08, 0x30, 0x18, 0x6C, 0xC2, 0x82, 0x82, 0xC2, 0x46,
  0x2C, 0x18, 0x6C, 0xC6, 0x82, 0x83, 0x83, 0x82, 0xC6, 0x7C, 0x38, 0xFB,
  0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC6, 0xDC, 0xE8, 0x10, 0x20, 0xC1, 0x06,
  0x78, 0xD0, 0x00, 0x07, 0xD0, 0x00, 0x05, 0xE8, 0x01, 0x06, 0x18, 0x60,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x06, 0x18, 0x30, 0xC0, 0x80, 0x33, 0xF0,
  0x41, 0x04, 0x10, 0xC2, 0x10, 0x42, 0x08, 0x20, 0x00, 0x0C, 0x30, 0x02,
  0x01, 0xDC, 0x30, 0x62, 0x02, 0x40, 0x14, 0x79, 0x4C, 0x98, 0x99, 0x89,
  0x98, 0x99, 0x89, 0x18, 0x91, 0x89, 0x9C, 0xEE, 0x40, 0x04, 0x00, 0x20,
  0x03, 0x08, 0x0F, 0x80, 0x0C, 0x07, 0x01, 0x40, 0x50, 0x12, 0x04, 0x83,
  0x20, 0x88, 0x23, 0x0F, 0xC6, 0x11, 0x04, 0x41, 0x90, 0x2C, 0x0A, 0x03,
  0xFC, 0x86, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x86, 0x82, 0x82, 0x83,
  0x82, 0x82, 0x86, 0xFC, 0x0E, 0x1F, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x31, 0x1F, 0xFC, 0x86, 0x82,
  0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x82, 0x82, 0x8C,
  0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x3F, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x07, 0x07, 0xF2, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0xFC, 0x07, 0x01, 0x40, 0x50, 0x16, 0x04, 0xC1, 0x1F, 0xC0, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3E, 0x86, 0x84, 0x8C,
  0x88, 0x90, 0x90, 0xA0, 0xE0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x84, 0x86,
  0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x3F, 0xC0, 0x3C, 0x03, 0xC0, 0x7A, 0x05, 0xA0, 0x5A, 0x0D, 0xB0, 0x99,
  0x09, 0x90, 0x99, 0x11, 0x89, 0x18, 0x91, 0x8B, 0x18, 0xE1, 0x86, 0x18,
  0x61, 0xC1, 0xE0, 0xF8, 0x74, 0x3A, 0x1C, 0x8E, 0x47, 0x33, 0x89, 0xC6,
  0xE1, 0x70, 0xB8, 0x3C, 0x1E, 0x0F, 0x03, 0x0C, 0x0F, 0xC6, 0x19, 0x02,
  0x40, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x40, 0xD0,
  0x26, 0x08, 0x86, 0x1F, 0x00, 0xFD, 0x0A, 0x1C, 0x18, 0x30, 0x61, 0xC2,
  0xF9, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x0C, 0x0F, 0xC6, 0x19, 0x02,
  0x40, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x40, 0xD0,
  0x26, 0x08, 0x86, 0x1E, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0xFC, 0x84,
  0x86, 0x82, 0x82, 0x86, 0x84, 0x8C, 0xF0, 0x98, 0x88, 0x8C, 0x84, 0x84,
  0x82, 0x83, 0x1C, 0xFF, 0x04, 0x08, 0x10, 0x30, 0x30, 0x38, 0x18, 0x18,
  0x10, 0x20, 0x40, 0xC3, 0xFC, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC2,
  0x7C, 0xC0, 0xE0, 0x50, 0x68, 0x24, 0x13, 0x08, 0x8C, 0x44, 0x22, 0x19,
  0x05, 0x82, 0x81, 0x40, 0xA0, 0x30, 0x10, 0xC1, 0x83, 0x41, 0x82, 0x41,
  0x82, 0x43, 0x82, 0x42, 0x86, 0x62, 0xC4, 0x22, 0x44, 0x22, 0x44, 0x26,
  0x4C, 0x24, 0x4C, 0x34, 0x68, 0x14, 0x28, 0x14, 0x28, 0x14, 0x38, 0x18,
  0x30, 0x18, 0x30, 0x43, 0x62, 0x22, 0x26, 0x14, 0x14, 0x18, 0x08, 0x18,
  0x14, 0x34, 0x26, 0x22, 0x42, 0x43, 0xC1, 0xC1, 0x42, 0x42, 0x62, 0x24,
  0x24, 0x34, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC,
  0x10, 0xC2, 0x08, 0x41, 0x0C, 0x20, 0x86, 0x10, 0x42, 0x08, 0x3F, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x02,
  0x03, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x0C,
  0x06, 0x04, 0x82, 0x42, 0x31, 0x09, 0x07, 0x81, 0xFF, 0xC0, 0x84, 0x63,
  0x7C, 0x10, 0x41, 0x04, 0xFC, 0x61, 0x86, 0x1C, 0xDD, 0x81, 0x02, 0x04,
  0x08, 0x17, 0xB1, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xE2, 0xBC,
  0x3D, 0x04, 0x30, 0x82, 0x08, 0x20, 0xC1, 0x06, 0x0F, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x7F, 0x43, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3,
  0x45, 0x39, 0x7C, 0x8F, 0x0C, 0x18, 0x3F, 0xE0, 0x40, 0xC0, 0x81, 0x89,
  0xF0, 0x08, 0xD2, 0x08, 0x20, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x80, 0x7D, 0x43, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xC3, 0x47, 0x3B, 0x03, 0x03, 0x02, 0x02, 0xFC, 0x30, 0x82, 0x08, 0x20,
  0x82, 0xFC, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x70, 0x15,
  0x55, 0x55, 0x40, 0x2C, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x97, 0xA0,
  0x82, 0x08, 0x20, 0x82, 0x38, 0xA4, 0xB2, 0x8F, 0x24, 0x92, 0x68, 0xA3,
  0x84, 0xFF, 0xFF, 0x80, 0xF9, 0xF9, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x10, 0xFF, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x42, 0xC2, 0x83, 0x83, 0x83,
  0x83, 0x83, 0xC3, 0x42, 0x46, 0x3C, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x0F, 0x15, 0xE8, 0x10, 0x20, 0x40, 0x80, 0x7D, 0x43, 0xC3,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0x47, 0x3B, 0x03, 0x03, 0x03,
  0x03, 0x03, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x88, 0x7E, 0x08, 0x20, 0xC1,
  0xC1, 0x82, 0x0C, 0x38, 0xBE, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xE0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xFD,
  0xC3, 0x42, 0x42, 0x46, 0x44, 0x24, 0x24, 0x2C, 0x28, 0x38, 0x18, 0x18,
  0xC2, 0x1A, 0x28, 0x91, 0x44, 0x8A, 0x24, 0x53, 0x32, 0x90, 0xA6, 0x85,
  0x14, 0x28, 0xA1, 0x46, 0x06, 0x30, 0x21, 0x80, 0x42, 0x66, 0x24, 0x34,
  0x18, 0x18, 0x18, 0x3C, 0x24, 0x24, 0x42, 0xC3, 0xC3, 0x42, 0x42, 0x42,
  0x26, 0x24, 0x24, 0x24, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30,
  0xE0, 0x40, 0xF8, 0xC4, 0x22, 0x11, 0x88, 0x46, 0x21, 0xF0, 0x1C, 0x43,
  0x0C, 0x30, 0xC3, 0x0C, 0x23, 0x02, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0x31,
  0x04, 0x10, 0x41, 0x04, 0x10, 0xC6, 0x30, 0xF1, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 5, 6, 8, 1, -16 },
  { 7, 10, 16, 10, 0, -16 },
  { 27, 8, 18, 9, 1, -17 },
  { 45, 12, 17, 14, 1, -17 },
  { 71, 9, 17, 10, 1, -17 },
  { 91, 2, 6, 4, 1, -16 },
  { 93, 5, 20, 6, 1, -16 },
  { 106, 4, 20, 6, 1, -16 },
  { 116, 7, 7, 8, 1, -18 },
  { 123, 8, 10, 10, 1, -13 },
  { 133, 2, 5, 5, 1, -2 },
  { 135, 5, 1, 6, 1, -7 },
  { 136, 2, 2, 5, 1, -2 },
  { 137, 8, 16, 8, 0, -16 },
  { 153, 7, 17, 9, 1, -17 },
  { 168, 4, 16, 9, 2, -16 },
  { 176, 7, 17, 9, 1, -17 },
  { 191, 7, 17, 9, 1, -17 },
  { 206, 9, 17, 9, 0, -17 },
  { 226, 7, 16, 9, 1, -16 },
  { 240, 7, 17, 9, 1, -17 },
  { 255, 7, 16, 9, 1, -16 },
  { 269, 8, 17, 9, 1, -17 },
  { 286, 7, 17, 9, 1, -17 },
  { 301, 2, 12, 5, 1, -12 },
  { 304, 2, 15, 5, 1, -12 },
  { 308, 8, 10, 10, 1, -13 },
  { 318, 8, 6, 10, 1, -11 },
  { 324, 8, 10, 10, 1, -13 },
  { 334, 6, 17, 7, 0, -17 },
  { 347, 12, 19, 14, 1, -17 },
  { 376, 10, 16, 10, 0, -16 },
  { 396, 8, 16, 10, 2, -16 },
  { 412, 8, 17, 10, 1, -17 },
  { 429, 8, 16, 11, 2, -16 },
  { 445, 6, 16, 9, 2, -16 },
  { 457, 6, 16, 8, 2, -16 },
  { 469, 10, 17, 12, 1, -17 },
  { 491, 8, 16, 12, 2, -16 },
  { 507, 4, 16, 6, 1, -16 },
  { 515, 4, 20, 5, -1, -16 },
  { 525, 8, 16, 10, 2, -16 },
  { 541, 6, 16, 8, 2, -16 },
  { 553, 12, 16, 16, 2, -16 },
  { 577, 9, 16, 12, 2, -16 },
  { 595, 10, 17, 12, 1, -17 },
  { 617, 7, 16, 10, 2, -16 },
  { 631, 10, 21, 12, 1, -17 },
  { 658, 8, 16, 10, 2, -16 },
  { 674, 7, 17, 9, 1, -17 },
  { 689, 8, 16, 8, 0, -16 },
  { 705, 8, 16, 12, 2, -16 },
  { 721, 9, 16, 9, 0, -16 },
  { 739, 16, 16, 16, 0, -16 },
  { 771, 8, 16, 8, 0, -16 },
  { 787, 8, 16, 8, 0, -16 },
  { 803, 6, 16, 8, 1, -16 },
  { 815, 4, 20, 7, 2, -16 },
  { 825, 8, 16, 8, 0, -16 },
  { 841, 4, 20, 7, 1, -16 },
  { 851, 9, 8, 10, 0, -16 },
  { 860, 10, 1, 10, 0, 2 },
  { 862, 4, 4, 6, 1, -18 },
  { 864, 6, 12, 9, 1, -12 },
  { 873, 7, 17, 10, 2, -17 },
  { 888, 6, 12, 8, 1, -12 },
  { 897, 8, 17, 10, 1, -17 },
  { 914, 7, 12, 9, 1, -12 },
  { 925, 6, 18, 5, 0, -18 },
  { 939, 8, 18, 10, 1, -12 },
  { 957, 6, 17, 10, 2, -17 },
  { 970, 2, 17, 4, 1, -17 },
  { 975, 3, 23, 4, 0, -17 },
  { 984, 6, 17, 8, 2, -17 },
  { 997, 1, 17, 4, 2, -17 },
  { 1000, 11, 12, 15, 2, -12 },
  { 1017, 6, 12, 10, 2, -12 },
  { 1026, 8, 12, 10, 1, -12 },
  { 1038, 7, 17, 10, 2, -12 },
  { 1053, 8, 17, 10, 1, -12 },
  { 1070, 4, 12, 7, 2, -12 },
  { 1076, 6, 12, 8, 1, -12 },
  { 1085, 5, 15, 5, 0, -15 },
  { 1095, 6, 12, 10, 2, -12 },
  { 1104, 8, 12, 8, 0, -12 },
  { 1116, 13, 12, 13, 0, -12 },
  { 1136, 8, 12, 8, 0, -12 },
  { 1148, 8, 18, 8, 0, -12 },
  { 1166, 5, 12, 6, 1, -12 },
  { 1174, 6, 20, 8, 1, -16 },
  { 1189, 1, 24, 9, 4, -18 },
  { 1192, 6, 20, 8, 1, -16 },
  { 1207, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Light23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT23PT7B_H_
