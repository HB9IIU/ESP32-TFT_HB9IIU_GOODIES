#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0xE3, 0xE3, 0xE3, 0xC3,
  0x43, 0x43, 0x43, 0x43, 0x43, 0x06, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x21,
  0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x3F, 0xFF, 0x7F, 0xFE, 0x10, 0x40,
  0x20, 0x80, 0x43, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0xFF,
  0xFD, 0xFF, 0xF8, 0x41, 0x00, 0x86, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x30,
  0x18, 0x60, 0x30, 0xC0, 0x61, 0x00, 0x02, 0x00, 0x10, 0x01, 0xC0, 0x3F,
  0xE3, 0xA7, 0x31, 0x01, 0x88, 0x18, 0x40, 0xC2, 0x06, 0x10, 0x10, 0x80,
  0xC4, 0x03, 0x20, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x02, 0xE0, 0x11, 0x80,
  0x86, 0x04, 0x30, 0x21, 0x81, 0x0C, 0x08, 0x70, 0x46, 0xE2, 0xF3, 0xFE,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x38, 0x02, 0x0F, 0x80, 0x83,
  0x18, 0x30, 0x63, 0x06, 0x0C, 0x60, 0x81, 0x04, 0x30, 0x20, 0x86, 0x04,
  0x10, 0x80, 0x82, 0x30, 0x10, 0x46, 0x02, 0x08, 0x80, 0x41, 0x33, 0xCC,
  0x66, 0x6D, 0x8C, 0x98, 0xD1, 0xB3, 0x1B, 0xE6, 0x43, 0x38, 0x88, 0x60,
  0x33, 0x04, 0x06, 0x60, 0x80, 0x8C, 0x10, 0x31, 0x82, 0x06, 0x10, 0xC0,
  0x82, 0x18, 0x30, 0x63, 0x06, 0x0C, 0x60, 0x80, 0xD8, 0x30, 0x1E, 0x00,
  0x07, 0x00, 0x3F, 0x00, 0x66, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x30, 0x18, 0x60, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0xC0, 0x39, 0x86, 0x61, 0x8C, 0xC3, 0x1B, 0x03, 0x36,
  0x06, 0xCC, 0x07, 0x98, 0x0F, 0x30, 0x0C, 0x30, 0x3C, 0x60, 0xFC, 0x7F,
  0x98, 0xFC, 0x38, 0xFF, 0xE4, 0x92, 0x40, 0x06, 0x18, 0x30, 0xC1, 0x86,
  0x0C, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x06,
  0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30,
  0xC1, 0x86, 0x0C, 0x30, 0xC0, 0x0C, 0x03, 0x00, 0xC2, 0x31, 0xFB, 0xCF,
  0x81, 0xC0, 0xD8, 0x33, 0x18, 0x62, 0x10, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x33, 0x33, 0x66, 0x64, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x01,
  0xF8, 0x31, 0xC6, 0x0C, 0x60, 0xCE, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0x60, 0x66, 0x0C, 0x70, 0xC3,
  0xF8, 0x1F, 0x00, 0x0E, 0x3C, 0xFB, 0xBC, 0x70, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x0F, 0x01, 0xFE, 0x1C, 0x38, 0x80, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x03,
  0xFC, 0xE0, 0xE4, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x1F, 0x81, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x80, 0x6F,
  0xBC, 0x7F, 0x80, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0x60,
  0x0D, 0x80, 0x26, 0x01, 0x98, 0x04, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x18,
  0x18, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x06,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x7F, 0xC6, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x0F, 0xF8, 0x81, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE8, 0x1C, 0xFF, 0x8F, 0xF0, 0x03, 0xC0, 0xFC, 0x1C, 0x23, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0D, 0xF8,
  0xDB, 0xCE, 0x0E, 0xE0, 0x6C, 0x06, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x06, 0xC0, 0x66, 0x06, 0x70, 0xC3, 0xBC, 0x1F, 0x80, 0xFF,
  0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xFE, 0x0E, 0x18, 0xE0,
  0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x31, 0x83, 0x8E, 0x18,
  0x3B, 0x80, 0xF8, 0x07, 0xC0, 0x77, 0x07, 0x1C, 0x70, 0x73, 0x01, 0x98,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x6C, 0x06, 0x70, 0x71, 0xEF,
  0x07, 0xF0, 0x07, 0x01, 0xFC, 0x38, 0xC7, 0x06, 0x60, 0x66, 0x03, 0x60,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x07, 0x30,
  0xF3, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0xC3, 0xF8, 0x3F, 0x00, 0x7F, 0xB0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xB0, 0x37, 0x73, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x33, 0x66, 0x64, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x00, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x10,
  0x00, 0x38, 0x7F, 0x31, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0x80, 0x18, 0x1C, 0x06, 0x01, 0x81, 0x80, 0x18, 0x60, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x03, 0x60, 0xFC, 0x68, 0x31, 0x8F, 0x0C, 0x31, 0xE1, 0x84,
  0x1C, 0x30, 0x83, 0x84, 0x10, 0x71, 0x86, 0x0E, 0x30, 0xC1, 0xC6, 0x18,
  0x38, 0xC3, 0x0F, 0x18, 0x61, 0xE1, 0x0C, 0x3C, 0x33, 0xCD, 0x83, 0xCF,
  0x90, 0x30, 0xC3, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x02, 0x00, 0xF1, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x98, 0x06, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x30, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x06,
  0x0F, 0xFC, 0x3F, 0xF8, 0x60, 0x30, 0xC0, 0x71, 0x80, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x30, 0x03, 0xE0, 0x07, 0x80, 0x0C, 0xFF, 0x8C, 0x3E,
  0xC0, 0x6C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06,
  0xC0, 0xCF, 0xF8, 0xFF, 0x8C, 0x0E, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x0E, 0xFF, 0xCF, 0xF8,
  0x03, 0xE0, 0x7F, 0xC7, 0x86, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x08, 0x7F, 0xC1, 0xFC, 0xFF, 0x86, 0x3E, 0x30,
  0x39, 0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0x60, 0x3B, 0x01, 0x98, 0x38, 0xFF,
  0x87, 0xF8, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xF0, 0x07,
  0xFE, 0x0E, 0x0E, 0x18, 0x02, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x7F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x30, 0x03, 0x38, 0x03, 0x1C, 0x03, 0x0F,
  0xFF, 0x07, 0xFE, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0xFE, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x3D, 0xFC, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x7E, 0x70, 0xC0, 0x7C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x38, 0xC3,
  0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xDC, 0x0D, 0x80, 0xFC, 0x0F, 0xC0, 0xE6,
  0x0C, 0x60, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0,
  0xEC, 0x06, 0xC0, 0x7C, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1B,
  0xF0, 0x01, 0xBD, 0x00, 0x1B, 0xD8, 0x01, 0x3D, 0x80, 0x33, 0xD8, 0x03,
  0x3C, 0xC0, 0x33, 0xCC, 0x06, 0x3C, 0xC0, 0x63, 0xC6, 0x06, 0x3C, 0x60,
  0x43, 0xC6, 0x0C, 0x3C, 0x20, 0xC3, 0xC3, 0x0C, 0x3C, 0x31, 0x83, 0xC3,
  0x18, 0x3C, 0x19, 0x83, 0xC1, 0xB0, 0x3C, 0x1B, 0x03, 0xC0, 0xB0, 0x3C,
  0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x0E, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x60, 0x3D, 0x80, 0xF3, 0x03, 0xCC, 0x0F, 0x18,
  0x3C, 0x60, 0xF1, 0x83, 0xC3, 0x0F, 0x0C, 0x3C, 0x18, 0xF0, 0x63, 0xC0,
  0xCF, 0x03, 0x3C, 0x0C, 0xF0, 0x1B, 0xC0, 0x6F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xF0, 0x1C, 0x38, 0x38,
  0x1C, 0x70, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x70, 0x0C, 0x30, 0x0C, 0x38, 0x18, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF,
  0x18, 0xFB, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x1D, 0xFF, 0x3F, 0xC6, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x03,
  0xC0, 0x0F, 0xF0, 0x1C, 0x38, 0x38, 0x1C, 0x70, 0x0C, 0x60, 0x0E, 0x60,
  0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x06, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x30, 0x0C, 0x38,
  0x18, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0xFF, 0x0C, 0x7C, 0xC0, 0xCC, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0xC3,
  0x8F, 0xF0, 0xFE, 0x0C, 0x70, 0xC3, 0x0C, 0x38, 0xC1, 0x8C, 0x18, 0xC0,
  0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x7C, 0x03, 0x07, 0xC1, 0xFF, 0x38,
  0x37, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x80, 0xEF, 0xFC, 0x7F,
  0x80, 0xFF, 0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xCC, 0x0E, 0x7F,
  0xE0, 0xFE, 0x00, 0xC0, 0x07, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0x66, 0x00,
  0xCC, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0x60, 0xC0,
  0xC1, 0x81, 0x83, 0x03, 0x06, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x33, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0xC0, 0x1C, 0x01, 0xB0, 0x0E, 0x00, 0xD8, 0x07,
  0x00, 0xEC, 0x03, 0x80, 0x66, 0x01, 0x60, 0x33, 0x01, 0xB0, 0x18, 0xC0,
  0xD8, 0x0C, 0x60, 0x6C, 0x0C, 0x30, 0x32, 0x06, 0x18, 0x19, 0x83, 0x0E,
  0x18, 0xC1, 0x83, 0x0C, 0x60, 0xC1, 0x86, 0x30, 0xC0, 0xC3, 0x08, 0x60,
  0x61, 0x86, 0x30, 0x19, 0x83, 0x18, 0x0C, 0xC1, 0x9C, 0x06, 0x60, 0xCC,
  0x03, 0x30, 0x26, 0x01, 0x98, 0x1B, 0x00, 0x68, 0x0D, 0x80, 0x3C, 0x07,
  0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x01, 0x80,
  0x38, 0x00, 0x70, 0x19, 0x81, 0x8C, 0x0C, 0x30, 0x61, 0x86, 0x0C, 0x30,
  0x33, 0x01, 0x98, 0x0C, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x30, 0xC1, 0x86,
  0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x1F, 0x00, 0xC0, 0xC0, 0x1B, 0x01,
  0x98, 0x0C, 0xC0, 0x63, 0x06, 0x18, 0x30, 0xC1, 0x83, 0x18, 0x18, 0xC0,
  0xC6, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0xFF, 0xFF, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x03,
  0x60, 0x0C, 0xC0, 0x63, 0x01, 0x86, 0x0C, 0x18, 0x30, 0x31, 0x80, 0xC6,
  0x01, 0xB0, 0x06, 0xC0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x60, 0xE0,
  0xC0, 0xC0, 0xC0, 0x1F, 0x87, 0xF8, 0x83, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x01, 0xE3, 0xFC, 0xE1, 0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0xEC, 0x1D, 0xCD, 0x9F, 0x30, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x0D, 0xFC, 0xF0, 0xCA,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xE0, 0x6A, 0x0C, 0xBB, 0xC9,
  0xF8, 0x0F, 0x9F, 0xDC, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0F, 0x63, 0xF0,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x1F, 0x33, 0xFB, 0x70, 0xB6, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xE0, 0x76, 0x0F, 0x7B, 0xB3, 0xF3, 0x1F, 0x07, 0xF1, 0xC3, 0x30, 0x6C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x04, 0xE7, 0x8F, 0xE0, 0x0F, 0x87,
  0x46, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x3F, 0x7F, 0x86, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0x33, 0xFB, 0x70, 0xF6, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x76, 0x0F, 0x3B, 0xB1, 0xF3,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0xC0, 0xCF, 0xF8,
  0x3F, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xCF, 0x1B, 0xF2, 0xC7, 0x50, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x30, 0x7F, 0x80, 0x03, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0x80, 0x19, 0xCE, 0x00, 0x00, 0x03, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x31, 0xBD, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0xF0, 0x6C, 0x33, 0x0C, 0xC6, 0x33, 0x8C, 0xC3, 0x60, 0x98,
  0x2F, 0x0A, 0xC3, 0x18, 0xC6, 0x31, 0x8C, 0x33, 0x0C, 0xC1, 0xB0, 0x6C,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x0F, 0x2F,
  0xE7, 0xEA, 0x1B, 0x1F, 0x03, 0x83, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C,
  0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03,
  0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0,
  0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0x8F, 0x13, 0xF2, 0x87, 0x70, 0x6C,
  0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0x1F, 0x03,
  0xFC, 0x70, 0xC6, 0x06, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0x60, 0x66,
  0x0E, 0x3B, 0xC1, 0xF8, 0x8F, 0x09, 0xFC, 0xB0, 0xCA, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x6C, 0x06, 0xE0, 0x6A, 0x0C, 0xBB, 0xCD, 0xF8, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x1F, 0x33, 0xFB, 0x70, 0xB6, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xE0, 0x76, 0x0B, 0x3B, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x8F, 0x3E, 0xC5, 0x0E,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x00, 0x1F, 0x8F, 0xF6, 0x0B, 0x80, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xE0,
  0x6F, 0x79, 0xFC, 0x30, 0x60, 0xC1, 0x87, 0xFF, 0xCC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x8F,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1B, 0x03, 0x60, 0x6C,
  0x15, 0xEE, 0x9F, 0x90, 0xC0, 0x3C, 0x03, 0x60, 0x36, 0x06, 0x60, 0x66,
  0x06, 0x30, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x98, 0x19, 0x81,
  0x98, 0x09, 0x80, 0xD0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0xC0, 0x70,
  0x36, 0x07, 0x03, 0x60, 0x70, 0x36, 0x05, 0x03, 0x60, 0xD0, 0x66, 0x0D,
  0x86, 0x30, 0xD8, 0x63, 0x0D, 0x86, 0x30, 0x98, 0x63, 0x18, 0x8C, 0x19,
  0x8C, 0xC1, 0x98, 0xCC, 0x19, 0x8C, 0xC1, 0x90, 0xC8, 0x1B, 0x05, 0x80,
  0xB0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0x60, 0x30,
  0xC0, 0x7C, 0x19, 0x83, 0x30, 0xE3, 0x18, 0x63, 0x06, 0xC0, 0xD8, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xB0, 0x36, 0x0C, 0x61, 0x8C, 0x60, 0xCC,
  0x1B, 0x03, 0x60, 0x30, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x30, 0x63,
  0x06, 0x30, 0x63, 0x06, 0x18, 0xC1, 0x8C, 0x18, 0xC1, 0x8C, 0x0D, 0x80,
  0xD8, 0x0D, 0x80, 0xD8, 0x05, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x80, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x3F, 0xFF, 0xF0, 0x07,
  0x87, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE1, 0xC0, 0xF0, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x06,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x07, 0x07, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC3, 0xC1, 0xC0, 0x3C, 0x0F, 0xF8,
  0x60, 0xFF, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 8, 9, 12, 2, -26 },
  { 17, 15, 26, 16, 1, -26 },
  { 66, 13, 30, 15, 1, -28 },
  { 115, 19, 27, 23, 2, -27 },
  { 180, 15, 27, 16, 1, -27 },
  { 231, 3, 9, 7, 2, -26 },
  { 235, 7, 33, 10, 2, -27 },
  { 264, 7, 33, 10, 1, -27 },
  { 293, 10, 11, 14, 2, -28 },
  { 307, 13, 18, 15, 1, -22 },
  { 337, 4, 9, 7, 1, -4 },
  { 342, 8, 2, 10, 1, -11 },
  { 344, 3, 3, 8, 2, -3 },
  { 346, 11, 26, 13, 1, -26 },
  { 382, 12, 27, 15, 2, -27 },
  { 423, 7, 26, 15, 3, -26 },
  { 446, 13, 27, 15, 1, -27 },
  { 490, 12, 27, 15, 1, -27 },
  { 531, 14, 27, 15, 1, -27 },
  { 579, 12, 26, 15, 2, -26 },
  { 618, 12, 27, 15, 2, -27 },
  { 659, 13, 26, 15, 1, -26 },
  { 702, 13, 27, 15, 1, -27 },
  { 746, 12, 27, 15, 1, -27 },
  { 787, 3, 20, 8, 2, -20 },
  { 795, 4, 25, 8, 1, -20 },
  { 808, 13, 16, 15, 1, -21 },
  { 834, 13, 10, 15, 1, -18 },
  { 851, 13, 16, 15, 1, -21 },
  { 877, 9, 27, 11, 1, -27 },
  { 908, 19, 30, 23, 2, -27 },
  { 980, 15, 26, 15, 0, -26 },
  { 1029, 12, 26, 17, 3, -26 },
  { 1068, 13, 27, 16, 2, -27 },
  { 1112, 13, 26, 18, 3, -26 },
  { 1155, 10, 26, 15, 3, -26 },
  { 1188, 10, 26, 14, 3, -26 },
  { 1221, 16, 27, 20, 2, -27 },
  { 1275, 13, 26, 19, 3, -26 },
  { 1318, 7, 26, 9, 1, -26 },
  { 1341, 7, 33, 8, -2, -26 },
  { 1370, 12, 26, 15, 3, -26 },
  { 1409, 10, 26, 13, 3, -26 },
  { 1442, 20, 26, 25, 3, -26 },
  { 1507, 14, 26, 20, 3, -26 },
  { 1553, 16, 27, 20, 2, -27 },
  { 1607, 11, 26, 16, 3, -26 },
  { 1643, 16, 33, 20, 2, -27 },
  { 1709, 12, 26, 16, 3, -26 },
  { 1748, 12, 27, 15, 1, -27 },
  { 1789, 13, 26, 13, 0, -26 },
  { 1832, 13, 26, 19, 3, -26 },
  { 1875, 15, 26, 15, 0, -26 },
  { 1924, 25, 26, 25, 0, -26 },
  { 2006, 13, 26, 14, 0, -26 },
  { 2049, 13, 26, 13, 0, -26 },
  { 2092, 11, 26, 13, 1, -26 },
  { 2128, 7, 33, 11, 3, -27 },
  { 2157, 11, 26, 13, 1, -26 },
  { 2193, 8, 33, 11, 1, -27 },
  { 2226, 14, 13, 16, 1, -26 },
  { 2249, 15, 2, 15, 0, 3 },
  { 2253, 7, 6, 9, 1, -28 },
  { 2259, 11, 20, 14, 1, -20 },
  { 2287, 12, 28, 16, 3, -28 },
  { 2329, 9, 20, 12, 2, -20 },
  { 2352, 12, 28, 16, 2, -28 },
  { 2394, 11, 20, 15, 2, -20 },
  { 2422, 9, 28, 9, 0, -28 },
  { 2454, 12, 29, 16, 2, -20 },
  { 2498, 11, 28, 16, 3, -28 },
  { 2537, 3, 27, 7, 2, -27 },
  { 2548, 5, 36, 7, 0, -27 },
  { 2571, 10, 28, 13, 3, -28 },
  { 2606, 2, 28, 7, 3, -28 },
  { 2613, 18, 20, 24, 3, -20 },
  { 2658, 11, 20, 16, 3, -20 },
  { 2686, 12, 20, 16, 2, -20 },
  { 2716, 12, 29, 16, 3, -20 },
  { 2760, 12, 29, 16, 2, -20 },
  { 2804, 7, 20, 10, 3, -20 },
  { 2822, 10, 20, 12, 1, -20 },
  { 2847, 7, 24, 9, 1, -24 },
  { 2868, 11, 20, 16, 2, -20 },
  { 2896, 12, 20, 12, 0, -20 },
  { 2926, 20, 20, 21, 0, -20 },
  { 2976, 11, 20, 13, 1, -20 },
  { 3004, 12, 29, 13, 0, -20 },
  { 3048, 9, 20, 10, 1, -20 },
  { 3071, 9, 32, 13, 2, -26 },
  { 3107, 2, 37, 15, 6, -28 },
  { 3117, 9, 32, 13, 2, -26 },
  { 3153, 13, 4, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Light37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT37PT7B_H_
