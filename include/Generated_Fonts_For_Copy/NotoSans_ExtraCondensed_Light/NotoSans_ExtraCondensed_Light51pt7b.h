#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00, 0x00, 0x04, 0x77, 0xFC, 0xE0,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0x60,
  0xEC, 0x1D, 0x83, 0xB0, 0x76, 0x0E, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF0, 0x30, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0xE0,
  0x06, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0x60, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x0E, 0x0E, 0x00,
  0x60, 0x70, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xC0, 0xE0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x7F, 0xC0, 0xFF, 0xF8, 0xF6, 0x3C, 0xE3, 0x04, 0x61, 0x80,
  0x70, 0xC0, 0x38, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x86,
  0x01, 0xC3, 0x00, 0x71, 0x80, 0x1C, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x06, 0xF0, 0x03, 0x1C, 0x01, 0x87, 0x00, 0xC1,
  0xC0, 0x60, 0xE0, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x0E, 0x03,
  0x07, 0x01, 0x87, 0x60, 0xC7, 0xBE, 0x6F, 0x9F, 0xFF, 0x81, 0xFE, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0x00, 0xE6, 0x00, 0xC0, 0x38, 0xE0, 0x18,
  0x06, 0x0C, 0x07, 0x00, 0xC1, 0xC0, 0xC0, 0x18, 0x38, 0x18, 0x07, 0x03,
  0x07, 0x00, 0xE0, 0x60, 0xC0, 0x1C, 0x0C, 0x18, 0x03, 0x81, 0x87, 0x00,
  0x70, 0x30, 0xC0, 0x0E, 0x06, 0x18, 0x01, 0xC0, 0xC7, 0x00, 0x38, 0x18,
  0xC0, 0x07, 0x07, 0x18, 0xF8, 0x60, 0xE7, 0x3F, 0x8C, 0x18, 0xC6, 0x39,
  0x83, 0x19, 0xC3, 0x38, 0xE7, 0x30, 0x73, 0xB8, 0xC6, 0x06, 0x3F, 0x18,
  0xC0, 0xC3, 0x87, 0x18, 0x18, 0x00, 0xC3, 0x03, 0x00, 0x18, 0x60, 0x60,
  0x07, 0x0C, 0x0C, 0x00, 0xC1, 0x81, 0x80, 0x18, 0x30, 0x30, 0x07, 0x06,
  0x06, 0x00, 0xC0, 0xC0, 0xC0, 0x18, 0x18, 0x18, 0x07, 0x03, 0x03, 0x00,
  0xC0, 0x60, 0xE0, 0x18, 0x0E, 0x18, 0x07, 0x00, 0xC7, 0x00, 0xC0, 0x1F,
  0xC0, 0x38, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1E, 0xF0, 0x01,
  0xC3, 0x80, 0x18, 0x38, 0x03, 0x83, 0x80, 0x38, 0x18, 0x03, 0x81, 0x80,
  0x38, 0x18, 0x03, 0x83, 0x80, 0x18, 0x38, 0x01, 0x83, 0x80, 0x1C, 0x30,
  0x01, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x07, 0x0E, 0x0E, 0x70,
  0xE0, 0xEE, 0x07, 0x0E, 0xE0, 0x30, 0xCE, 0x03, 0x9C, 0xC0, 0x1D, 0xCC,
  0x01, 0xDC, 0xC0, 0x0F, 0x8C, 0x00, 0xF8, 0xE0, 0x07, 0x0E, 0x00, 0xF8,
  0xE0, 0x0F, 0x87, 0x01, 0xDC, 0x78, 0x78, 0xE3, 0xFF, 0x0E, 0x1F, 0xE0,
  0x70, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0x01, 0x81, 0xC1, 0xC0,
  0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x06,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x1C, 0x61, 0xBF, 0x5F, 0xBF, 0xFC, 0x03,
  0x80, 0x0F, 0x80, 0x3B, 0x00, 0x63, 0x01, 0xC7, 0x07, 0x07, 0x04, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0xF3, 0x8E, 0x38, 0xC7,
  0x1C, 0x71, 0x8E, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x6F, 0xFF,
  0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0x83, 0x83,
  0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x18, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x30, 0x01, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0x70, 0x1C, 0x38,
  0x0E, 0x0E, 0x0E, 0x07, 0x8F, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xC1,
  0xF0, 0xFC, 0x77, 0x3D, 0xDE, 0x7E, 0x1F, 0x07, 0x41, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0xE0, 0x1F, 0xFC, 0x3F,
  0xFF, 0x0E, 0x03, 0x84, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1E, 0x03, 0xC4, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x40, 0x0F, 0x38, 0x0F, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07,
  0x38, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x30,
  0x70, 0x0E, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0x80,
  0xE0, 0x70, 0x1C, 0x0C, 0x03, 0x83, 0x80, 0x70, 0x60, 0x0E, 0x1C, 0x01,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xBF, 0x80, 0xFF,
  0xF0, 0x7C, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x80,
  0x1E, 0x70, 0x3E, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0x01, 0xFF, 0x81, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x83, 0x00, 0xC7, 0xF0, 0x67, 0xFC, 0x76, 0x0F, 0x3E, 0x03,
  0xDE, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xB0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x19,
  0xC0, 0x1C, 0x60, 0x0E, 0x38, 0x07, 0x1E, 0x07, 0x07, 0x87, 0x81, 0xFF,
  0x80, 0x7F, 0x80, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0x01, 0xC7, 0x80, 0x73, 0x80, 0x39, 0xC0,
  0x1C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x71, 0xC0, 0x70, 0x70, 0x70, 0x1C, 0x70, 0x07, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xEF, 0x01, 0xC3, 0xC1, 0xC0, 0xF1, 0xC0, 0x3C, 0xE0,
  0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x70, 0x07, 0x38, 0x07, 0x8F, 0x07,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x1B, 0x3C,
  0x3B, 0x1F, 0xF3, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x40, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x0C, 0x00, 0x7F,
  0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF,
  0x70, 0x39, 0xE7, 0x8E, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xCE, 0x38, 0xE3, 0x9C, 0x71, 0xC6,
  0x38, 0xE3, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x03, 0xFE, 0x3F, 0xF8, 0x81,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x38, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x38, 0x0F, 0xE0, 0xE6,
  0x03, 0xFC, 0x0D, 0xC0, 0xE1, 0x81, 0xB8, 0x38, 0x30, 0x37, 0x07, 0x06,
  0x06, 0xC0, 0xC0, 0xC0, 0xD8, 0x18, 0x18, 0x1F, 0x07, 0x03, 0x03, 0xE0,
  0xE0, 0x60, 0x7C, 0x1C, 0x0C, 0x0F, 0x83, 0x83, 0x81, 0xB0, 0x70, 0x70,
  0x36, 0x0E, 0x0E, 0x06, 0xC1, 0xC1, 0xC0, 0xD8, 0x38, 0x38, 0x1B, 0x03,
  0x05, 0x07, 0x60, 0x61, 0xA0, 0xCE, 0x0E, 0x36, 0x39, 0xC0, 0xFC, 0xFE,
  0x38, 0x0F, 0x0F, 0x83, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60,
  0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x03, 0x00, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x70, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x0F, 0x9C, 0x01, 0xCE, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73, 0x80, 0x79, 0xC1, 0xF8, 0xFF,
  0xF0, 0x7F, 0xFC, 0x38, 0x0F, 0x9C, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x1E, 0x7F,
  0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3C, 0x02, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC,
  0x18, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x06, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0x81, 0xF0, 0x70, 0x0F, 0x0E, 0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x70,
  0xE0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE,
  0x1F, 0x00, 0x60, 0xE0, 0x01, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xBC, 0x00, 0x0C, 0xE0,
  0x00, 0x67, 0x80, 0x03, 0x1E, 0x00, 0x18, 0x78, 0x00, 0xC1, 0xF0, 0x3E,
  0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x06, 0x00, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xBF, 0x87, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0xFF, 0xF0, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0xA3, 0xDF, 0xCF,
  0xC0, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0xEF,
  0x00, 0x7F, 0x80, 0x3E, 0xE0, 0x1E, 0x70, 0x0F, 0x1C, 0x07, 0x0E, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x07,
  0x0E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0x70,
  0x03, 0xB8, 0x01, 0xFC, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x37, 0xB8, 0x00,
  0x0F, 0xF7, 0x00, 0x01, 0xFF, 0x60, 0x00, 0x37, 0xEE, 0x00, 0x0E, 0xFD,
  0xC0, 0x01, 0xDF, 0x98, 0x00, 0x33, 0xF3, 0x00, 0x06, 0x7E, 0x70, 0x01,
  0xCF, 0xCE, 0x00, 0x39, 0xF8, 0xC0, 0x06, 0x3F, 0x1C, 0x01, 0xC7, 0xE3,
  0x80, 0x38, 0xFC, 0x30, 0x06, 0x1F, 0x86, 0x01, 0xC3, 0xF0, 0xE0, 0x38,
  0x7E, 0x1C, 0x06, 0x0F, 0xC1, 0x80, 0xC1, 0xF8, 0x38, 0x38, 0x3F, 0x07,
  0x07, 0x07, 0xE0, 0x60, 0xC0, 0xFC, 0x0E, 0x38, 0x1F, 0x81, 0xC7, 0x03,
  0xF0, 0x18, 0xC0, 0x7E, 0x03, 0x18, 0x0F, 0xC0, 0x77, 0x01, 0xF8, 0x0E,
  0xE0, 0x3F, 0x00, 0xD8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x70, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xD8, 0x00, 0x7D, 0xC0, 0x07, 0xEC, 0x00,
  0x7E, 0xE0, 0x07, 0xEE, 0x00, 0x7E, 0x70, 0x07, 0xE7, 0x00, 0x7E, 0x30,
  0x07, 0xE3, 0x80, 0x7E, 0x18, 0x07, 0xE1, 0xC0, 0x7E, 0x1C, 0x07, 0xE0,
  0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0x60, 0x7E, 0x07, 0x07, 0xE0, 0x30, 0x7E,
  0x03, 0x87, 0xE0, 0x38, 0x7E, 0x01, 0xC7, 0xE0, 0x1C, 0x7E, 0x00, 0xE7,
  0xE0, 0x0E, 0x7E, 0x00, 0x67, 0xE0, 0x07, 0x7E, 0x00, 0x77, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x81,
  0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0xC0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00,
  0x1C, 0x3C, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0xC1, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xE3, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3C, 0x07, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xC7, 0x00, 0x1C, 0x3C, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0xC1,
  0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x37, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0xFF, 0xE0, 0x7F, 0xFC, 0x38, 0x3F,
  0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x3C, 0xE0, 0x3C, 0x70, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0E, 0x1C, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x39,
  0xC0, 0x1C, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0x70, 0x03,
  0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0x3C, 0x06, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x80, 0x1E, 0xF8, 0x7C, 0xFF, 0xF8, 0x7F,
  0xF0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x39, 0xC0, 0x0E,
  0x78, 0x07, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x06, 0x38, 0x00, 0x70, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xC1,
  0xC0, 0x0E, 0x06, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x18, 0x03,
  0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x00, 0x1C, 0x38,
  0x00, 0x61, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0xE7, 0x00, 0x03,
  0x38, 0x00, 0x19, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0x00, 0x39, 0xC0, 0x07, 0x80, 0x07,
  0x38, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x00, 0x1C, 0xE0, 0x03, 0x60,
  0x03, 0x0E, 0x00, 0x6C, 0x00, 0xE1, 0xC0, 0x1D, 0x80, 0x1C, 0x38, 0x03,
  0xB8, 0x03, 0x87, 0x00, 0x77, 0x00, 0x70, 0x60, 0x0C, 0xE0, 0x1C, 0x0E,
  0x01, 0x8C, 0x03, 0x81, 0xC0, 0x71, 0x80, 0x70, 0x38, 0x0E, 0x38, 0x0E,
  0x07, 0x01, 0xC7, 0x01, 0x80, 0x60, 0x30, 0xE0, 0x70, 0x0E, 0x06, 0x0C,
  0x0E, 0x01, 0xC1, 0xC1, 0x81, 0xC0, 0x38, 0x38, 0x38, 0x38, 0x07, 0x07,
  0x07, 0x06, 0x00, 0x60, 0xC0, 0xE1, 0xC0, 0x0E, 0x18, 0x0C, 0x38, 0x01,
  0xC7, 0x01, 0x87, 0x00, 0x38, 0xE0, 0x30, 0xE0, 0x07, 0x1C, 0x07, 0x18,
  0x00, 0x63, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x0C, 0xE0, 0x01, 0xCC, 0x01,
  0x9C, 0x00, 0x3B, 0x80, 0x33, 0x80, 0x03, 0x70, 0x07, 0x60, 0x00, 0x6C,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x38, 0x01, 0xCE, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x0E, 0x1C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x18, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00,
  0x31, 0xC0, 0x0E, 0x60, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB8,
  0x00, 0xEE, 0x00, 0x39, 0x80, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0x83, 0x00,
  0xE0, 0xE0, 0x38, 0x38, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0,
  0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0x70, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xC0, 0x38,
  0x70, 0x0E, 0x1C, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x03, 0x30,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xB8, 0x00,
  0x39, 0xC0, 0x03, 0x1C, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x60,
  0x0C, 0x07, 0x01, 0xC0, 0x30, 0x18, 0x03, 0x83, 0x80, 0x18, 0x30, 0x01,
  0xC7, 0x00, 0x0C, 0x60, 0x00, 0xEE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0x81, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x1F, 0xE1, 0xFF, 0xCF, 0xC3, 0xBC, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3E,
  0xE0, 0xDD, 0xFF, 0xB9, 0xFC, 0x70, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x0C, 0x0E, 0x3F, 0x87,
  0x3F, 0xE3, 0xB8, 0x39, 0xD0, 0x0E, 0xF8, 0x07, 0x78, 0x01, 0xBC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xBE, 0x01, 0xDD, 0x01,
  0xEE, 0xE1, 0xE7, 0x3F, 0xE3, 0x8F, 0xE0, 0x00, 0x80, 0x00, 0xE0, 0x1F,
  0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x30, 0xFF, 0xC1, 0xFE, 0x00, 0x40,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x30, 0x70, 0xFF, 0x38, 0xFF, 0xDC, 0x70, 0x76, 0x70, 0x1B, 0x38, 0x07,
  0xB8, 0x03, 0xDC, 0x00, 0xEE, 0x00, 0x76, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03,
  0xCE, 0x01, 0xE7, 0x01, 0xB1, 0xC1, 0x98, 0xFF, 0xCC, 0x3F, 0xC6, 0x01,
  0x00, 0x00, 0x80, 0x07, 0xF0, 0x0F, 0xF8, 0x1C, 0x1C, 0x38, 0x0E, 0x30,
  0x0E, 0x70, 0x06, 0x70, 0x07, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x01, 0x1E, 0x06, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0xC0, 0x03,
  0xF0, 0x7F, 0x0F, 0x20, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xCF, 0xFC, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80,
  0x07, 0xF8, 0xC7, 0xFE, 0x63, 0x83, 0xB3, 0x80, 0xD9, 0xC0, 0x3D, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0x70,
  0x0B, 0x38, 0x0F, 0x8E, 0x0D, 0xC7, 0xFE, 0xE0, 0xFC, 0x70, 0x18, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE4, 0x00, 0xE3, 0xC3, 0xF1, 0xFF, 0xF0, 0x3F, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xC0, 0xE3,
  0xF8, 0xE7, 0xFC, 0xEE, 0x1E, 0xE8, 0x0E, 0xF8, 0x0E, 0xF0, 0x06, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x0C, 0x3C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0xE1, 0xC3, 0xAF, 0x7C, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x70,
  0x38, 0xE0, 0x71, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x38, 0x1C, 0x70,
  0x39, 0xC0, 0x73, 0xC0, 0xEF, 0x81, 0xFB, 0x83, 0xE7, 0x07, 0x86, 0x0F,
  0x0E, 0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x31, 0xC0, 0x73, 0x80,
  0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xC0, 0x0C, 0x1C, 0x7E, 0x0F, 0xE3, 0x9F, 0xE3, 0xFE, 0x76, 0x1E,
  0xE1, 0xEF, 0x81, 0xD8, 0x1D, 0xE0, 0x1E, 0x03, 0xBC, 0x03, 0xC0, 0x37,
  0x80, 0x70, 0x06, 0xF0, 0x0E, 0x00, 0xFE, 0x01, 0xC0, 0x1F, 0x80, 0x38,
  0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8,
  0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xFC, 0x01, 0xC0,
  0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x0F, 0xC0,
  0x1C, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00,
  0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0xE3, 0xF8, 0xE7, 0xFC, 0xEE, 0x1E, 0xF8, 0x0E, 0xF8, 0x0E, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0xC0, 0x03, 0xFC, 0x07,
  0xFF, 0x03, 0x83, 0xC3, 0x80, 0xF1, 0xC0, 0x39, 0xC0, 0x0C, 0xE0, 0x07,
  0x70, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xEC,
  0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0C, 0x70, 0x0E, 0x38, 0x0E,
  0x0F, 0x0F, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x71,
  0xFC, 0x39, 0xFF, 0x1D, 0xC1, 0xCE, 0x80, 0x77, 0xC0, 0x3B, 0xC0, 0x0D,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1D, 0xF0, 0x0E,
  0xEC, 0x0F, 0x77, 0x0F, 0x39, 0xFF, 0x1C, 0x7F, 0x0E, 0x04, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x03, 0xF8, 0xC7, 0xFE, 0x63, 0x83, 0xB3, 0x80, 0xD9, 0xC0, 0x3D, 0xC0,
  0x1E, 0xE0, 0x07, 0x70, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0x70,
  0x0B, 0x38, 0x0D, 0x8F, 0x0D, 0xC7, 0xFE, 0xE0, 0xFC, 0x70, 0x08, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0xDC, 0x7F, 0x9F, 0xF7, 0x1E, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x00, 0xFF, 0x8F, 0xFE, 0xE0, 0x6E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x77, 0x07, 0xBF, 0xF8, 0xFF, 0x80,
  0x60, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFF,
  0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xC0, 0x71, 0x1F, 0xC3, 0xF0, 0x30, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0x70, 0x0F, 0x70, 0x1F, 0x70, 0x17, 0x38, 0x77,
  0x3F, 0xE7, 0x1F, 0xC7, 0x02, 0x00, 0xE0, 0x03, 0xB0, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x71, 0x80, 0x30, 0xE0, 0x38, 0x70, 0x1C, 0x38,
  0x0E, 0x0C, 0x06, 0x06, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0x60, 0xC0,
  0x30, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x80,
  0x78, 0x03, 0x70, 0x0F, 0x80, 0x66, 0x01, 0xB0, 0x1C, 0xC0, 0x36, 0x03,
  0x9C, 0x0E, 0xC0, 0x73, 0x81, 0xD8, 0x0C, 0x70, 0x33, 0x81, 0x86, 0x06,
  0x70, 0x70, 0xC0, 0xC6, 0x0E, 0x1C, 0x38, 0xC1, 0x83, 0x87, 0x18, 0x30,
  0x70, 0xC3, 0x8E, 0x06, 0x18, 0x71, 0xC0, 0xE3, 0x06, 0x38, 0x1C, 0xE0,
  0xC6, 0x03, 0x9C, 0x1C, 0xC0, 0x33, 0x03, 0xB8, 0x06, 0x60, 0x77, 0x00,
  0xEC, 0x06, 0xC0, 0x1F, 0x80, 0xD8, 0x03, 0xE0, 0x1B, 0x00, 0x3C, 0x03,
  0xE0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x1C, 0x38,
  0x1C, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60,
  0x0C, 0x70, 0x1C, 0x30, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x70, 0x1C,
  0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06,
  0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x18, 0x18, 0x18, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30,
  0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xBC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x01, 0xF0, 0x1F, 0xC0, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x03, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x01, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x5F, 0xC0,
  0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0x80, 0x7F, 0x20, 0x03, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 36, 11, 3, -36 },
  { 24, 11, 13, 17, 3, -36 },
  { 42, 21, 36, 23, 1, -36 },
  { 137, 17, 42, 21, 2, -39 },
  { 227, 27, 37, 32, 2, -37 },
  { 352, 20, 38, 22, 2, -37 },
  { 447, 3, 13, 9, 3, -36 },
  { 452, 9, 45, 14, 3, -37 },
  { 503, 10, 45, 14, 2, -37 },
  { 560, 15, 15, 19, 2, -39 },
  { 589, 18, 24, 21, 2, -30 },
  { 643, 6, 13, 10, 2, -6 },
  { 653, 11, 3, 14, 1, -15 },
  { 658, 4, 5, 10, 3, -5 },
  { 661, 16, 37, 18, 1, -37 },
  { 735, 17, 37, 21, 2, -37 },
  { 814, 10, 36, 21, 4, -36 },
  { 859, 17, 37, 21, 2, -37 },
  { 938, 17, 38, 21, 2, -37 },
  { 1019, 19, 37, 21, 1, -37 },
  { 1107, 17, 36, 21, 2, -36 },
  { 1184, 17, 38, 21, 2, -37 },
  { 1265, 17, 36, 21, 2, -36 },
  { 1342, 17, 38, 21, 2, -37 },
  { 1423, 16, 38, 21, 2, -37 },
  { 1499, 4, 27, 10, 3, -27 },
  { 1513, 6, 34, 10, 2, -27 },
  { 1539, 19, 22, 21, 1, -29 },
  { 1592, 18, 14, 21, 2, -25 },
  { 1624, 18, 22, 21, 2, -29 },
  { 1674, 13, 37, 15, 1, -37 },
  { 1735, 27, 41, 32, 3, -37 },
  { 1874, 21, 36, 21, 0, -36 },
  { 1969, 17, 36, 23, 4, -36 },
  { 2046, 18, 38, 22, 3, -37 },
  { 2132, 19, 36, 25, 4, -36 },
  { 2218, 14, 36, 20, 4, -36 },
  { 2281, 14, 36, 19, 4, -36 },
  { 2344, 21, 38, 27, 3, -37 },
  { 2444, 18, 36, 26, 4, -36 },
  { 2525, 9, 36, 13, 2, -36 },
  { 2566, 9, 45, 10, -2, -36 },
  { 2617, 17, 36, 21, 4, -36 },
  { 2694, 13, 36, 18, 4, -36 },
  { 2753, 27, 36, 35, 4, -36 },
  { 2875, 20, 36, 27, 4, -36 },
  { 2965, 21, 38, 27, 3, -37 },
  { 3065, 16, 36, 21, 4, -36 },
  { 3137, 21, 46, 27, 3, -37 },
  { 3258, 17, 36, 22, 4, -36 },
  { 3335, 16, 38, 20, 2, -37 },
  { 3411, 18, 36, 18, 0, -36 },
  { 3492, 18, 37, 26, 4, -36 },
  { 3576, 21, 36, 21, 0, -36 },
  { 3671, 35, 36, 35, 0, -36 },
  { 3829, 18, 36, 19, 0, -36 },
  { 3910, 18, 36, 18, 0, -36 },
  { 3991, 15, 36, 17, 1, -36 },
  { 4059, 10, 45, 16, 4, -37 },
  { 4116, 16, 37, 18, 1, -37 },
  { 4190, 10, 45, 16, 2, -37 },
  { 4247, 20, 18, 21, 1, -36 },
  { 4292, 21, 3, 21, 0, 4 },
  { 4300, 9, 8, 13, 2, -39 },
  { 4309, 15, 29, 20, 2, -28 },
  { 4364, 17, 40, 23, 3, -39 },
  { 4449, 14, 29, 17, 2, -28 },
  { 4500, 17, 40, 23, 2, -39 },
  { 4585, 16, 29, 20, 2, -28 },
  { 4643, 12, 39, 12, 1, -39 },
  { 4702, 17, 40, 23, 2, -28 },
  { 4787, 16, 39, 22, 3, -39 },
  { 4865, 4, 37, 10, 3, -37 },
  { 4884, 7, 49, 10, 0, -37 },
  { 4927, 15, 39, 18, 3, -39 },
  { 5001, 3, 39, 10, 3, -39 },
  { 5016, 27, 28, 33, 3, -28 },
  { 5111, 16, 28, 22, 3, -28 },
  { 5167, 17, 29, 22, 2, -28 },
  { 5229, 17, 40, 23, 3, -28 },
  { 5314, 17, 40, 23, 2, -28 },
  { 5399, 11, 28, 14, 3, -28 },
  { 5438, 13, 29, 17, 2, -28 },
  { 5486, 10, 35, 12, 1, -34 },
  { 5530, 16, 28, 22, 3, -27 },
  { 5586, 17, 27, 17, 0, -27 },
  { 5644, 27, 27, 29, 1, -27 },
  { 5736, 16, 27, 18, 1, -27 },
  { 5790, 16, 39, 18, 1, -27 },
  { 5868, 12, 27, 14, 1, -27 },
  { 5909, 14, 45, 18, 2, -37 },
  { 5988, 2, 51, 20, 9, -39 },
  { 6001, 14, 45, 18, 2, -37 },
  { 6080, 18, 6, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Light51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT51PT7B_H_
