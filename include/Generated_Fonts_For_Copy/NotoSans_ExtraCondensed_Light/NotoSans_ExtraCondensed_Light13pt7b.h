#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0x80, 0x28, 0xA7, 0xD4, 0x53, 0xE5, 0x14, 0x50,
  0x23, 0xE9, 0x46, 0x18, 0xA5, 0xAB, 0x88, 0xCB, 0x4B, 0x37, 0xEC, 0xB2,
  0xD3, 0x4C, 0x71, 0x45, 0x08, 0x62, 0x69, 0xA2, 0x7C, 0xE0, 0x6A, 0xAA,
  0xA4, 0xC8, 0x92, 0x49, 0x2B, 0x00, 0x5D, 0x50, 0x21, 0x09, 0xF2, 0x10,
  0x58, 0xE0, 0x80, 0x11, 0x22, 0x24, 0x44, 0x80, 0xE9, 0x99, 0x99, 0x99,
  0xE0, 0x75, 0x55, 0x40, 0x70, 0x42, 0x21, 0x10, 0x88, 0xF8, 0xF0, 0x42,
  0x27, 0x04, 0x21, 0x70, 0x11, 0x8C, 0xA5, 0x4B, 0xE2, 0x10, 0xE8, 0x8E,
  0x11, 0x11, 0xE0, 0x68, 0x8E, 0x99, 0x99, 0xE0, 0xF8, 0x44, 0x21, 0x10,
  0x84, 0x40, 0x72, 0x52, 0xA3, 0x26, 0x31, 0x70, 0x74, 0x63, 0x15, 0x94,
  0x22, 0x60, 0x82, 0x40, 0x05, 0x80, 0x1B, 0x30, 0x60, 0x80, 0xF8, 0x3E,
  0xC1, 0x82, 0x6C, 0x00, 0xE1, 0x12, 0x44, 0x40, 0x40, 0x79, 0x0A, 0x4D,
  0x5C, 0xB9, 0x6D, 0x54, 0x80, 0xF0, 0x21, 0x94, 0xA5, 0x3E, 0x31, 0x88,
  0xF9, 0x99, 0xF9, 0x99, 0xF0, 0x78, 0x88, 0x88, 0x88, 0x70, 0xF4, 0xA3,
  0x18, 0xC6, 0x32, 0xE0, 0xF2, 0x4F, 0x24, 0xE0, 0xF8, 0x88, 0xE8, 0x88,
  0x80, 0x7C, 0x21, 0x09, 0xC6, 0x31, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31,
  0x88, 0xE9, 0x24, 0x92, 0xE0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x9A, 0xAC,
  0xCA, 0xA9, 0x90, 0x92, 0x49, 0x24, 0xE0, 0x83, 0x8F, 0x1E, 0x3A, 0xB5,
  0x6A, 0xD9, 0x92, 0x8E, 0x73, 0x5A, 0xD6, 0x73, 0x88, 0x74, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0xF9, 0x99, 0xE8, 0x88, 0x80, 0x74, 0x63, 0x18, 0xC6,
  0x31, 0x70, 0x86, 0xF9, 0x99, 0xEA, 0xA9, 0x90, 0xF8, 0x88, 0x61, 0x11,
  0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x70, 0x8C, 0x52, 0xA5, 0x29, 0x44, 0x20, 0x88, 0xC4, 0x65, 0x4A, 0xA5,
  0x52, 0xA9, 0x54, 0x44, 0x22, 0x00, 0xDA, 0x94, 0x42, 0x29, 0x4A, 0x88,
  0x9C, 0x94, 0xC2, 0x10, 0x84, 0x20, 0xF1, 0x22, 0x24, 0x44, 0xF0, 0xF2,
  0x49, 0x24, 0x93, 0x80, 0x84, 0x44, 0x22, 0x11, 0x10, 0xE4, 0x92, 0x49,
  0x27, 0x80, 0x22, 0x95, 0x90, 0xF8, 0xB0, 0x71, 0x17, 0x99, 0x70, 0x88,
  0x8E, 0x99, 0x99, 0x9E, 0x72, 0x49, 0x38, 0x11, 0x1F, 0x99, 0x99, 0x9F,
  0xE9, 0x9F, 0x88, 0xE0, 0x69, 0x74, 0x92, 0x48, 0xF9, 0x99, 0x99, 0xF1,
  0x1E, 0x88, 0x8E, 0x99, 0x99, 0x99, 0xDF, 0xC0, 0x51, 0x55, 0x55, 0x80,
  0x88, 0x8A, 0xAC, 0xCA, 0xA9, 0xFF, 0xC0, 0xED, 0x26, 0x4C, 0x99, 0x32,
  0x64, 0x80, 0xE9, 0x99, 0x99, 0x90, 0xE9, 0x99, 0x99, 0xE0, 0xE9, 0x99,
  0x99, 0xE8, 0x88, 0xF9, 0x99, 0x99, 0xF1, 0x11, 0xF2, 0x49, 0x20, 0x78,
  0x42, 0x11, 0xE0, 0x4B, 0xA4, 0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x99,
  0x95, 0x66, 0x20, 0x93, 0x26, 0x6B, 0x56, 0xCC, 0x89, 0x00, 0x95, 0x62,
  0x65, 0x90, 0x99, 0x55, 0x62, 0x22, 0x4C, 0xE4, 0xA4, 0xB8, 0x69, 0x25,
  0x12, 0x49, 0x80, 0xFF, 0xF8, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Light13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 4, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 5, 11, 5, 0, -10 },
  { 19, 6, 9, 8, 1, -9 },
  { 26, 6, 9, 6, 0, -9 },
  { 33, 1, 3, 2, 1, -9 },
  { 34, 2, 11, 4, 1, -9 },
  { 37, 3, 11, 4, 0, -9 },
  { 42, 3, 4, 5, 1, -10 },
  { 44, 5, 6, 5, 0, -8 },
  { 48, 2, 3, 3, 0, -1 },
  { 49, 3, 1, 4, 0, -4 },
  { 50, 1, 1, 3, 1, -1 },
  { 51, 4, 9, 5, 0, -9 },
  { 56, 4, 9, 5, 1, -9 },
  { 61, 2, 9, 5, 1, -9 },
  { 64, 5, 9, 5, 0, -9 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 5, 9, 5, 0, -9 },
  { 82, 4, 9, 5, 1, -9 },
  { 87, 4, 9, 5, 1, -9 },
  { 92, 5, 9, 5, 0, -9 },
  { 98, 5, 9, 5, 0, -9 },
  { 104, 5, 9, 5, 0, -9 },
  { 110, 1, 7, 3, 1, -7 },
  { 111, 2, 9, 3, 0, -7 },
  { 114, 5, 5, 5, 0, -7 },
  { 118, 5, 3, 5, 0, -6 },
  { 120, 5, 5, 5, 0, -7 },
  { 124, 4, 9, 4, 0, -9 },
  { 129, 7, 10, 8, 1, -9 },
  { 138, 5, 9, 5, 0, -9 },
  { 144, 4, 9, 6, 1, -9 },
  { 149, 4, 9, 6, 1, -9 },
  { 154, 5, 9, 6, 1, -9 },
  { 160, 3, 9, 5, 1, -9 },
  { 164, 4, 9, 5, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 3, 9, 3, 0, -9 },
  { 185, 3, 11, 3, -1, -9 },
  { 190, 4, 9, 5, 1, -9 },
  { 195, 3, 9, 5, 1, -9 },
  { 199, 7, 9, 9, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 5, 9, 7, 1, -9 },
  { 219, 4, 9, 5, 1, -9 },
  { 224, 5, 11, 7, 1, -9 },
  { 231, 4, 9, 6, 1, -9 },
  { 236, 4, 9, 5, 1, -9 },
  { 241, 5, 9, 5, 0, -9 },
  { 247, 5, 9, 7, 1, -9 },
  { 253, 5, 9, 5, 0, -9 },
  { 259, 9, 9, 9, 0, -9 },
  { 270, 5, 9, 5, 0, -9 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 4, 9, 4, 0, -9 },
  { 287, 3, 11, 4, 1, -9 },
  { 292, 4, 9, 5, 0, -9 },
  { 297, 3, 11, 4, 0, -9 },
  { 302, 5, 4, 5, 0, -9 },
  { 305, 5, 1, 5, 0, 1 },
  { 306, 2, 2, 3, 1, -10 },
  { 307, 4, 7, 5, 0, -7 },
  { 311, 4, 10, 6, 1, -10 },
  { 316, 3, 7, 4, 1, -7 },
  { 319, 4, 10, 6, 1, -10 },
  { 324, 4, 7, 5, 1, -7 },
  { 328, 3, 10, 3, 0, -10 },
  { 332, 4, 10, 6, 1, -7 },
  { 337, 4, 10, 6, 1, -10 },
  { 342, 1, 10, 3, 1, -10 },
  { 344, 2, 13, 3, 0, -10 },
  { 348, 4, 10, 5, 1, -10 },
  { 353, 1, 10, 2, 1, -10 },
  { 355, 7, 7, 8, 1, -7 },
  { 362, 4, 7, 6, 1, -7 },
  { 366, 4, 7, 6, 1, -7 },
  { 370, 4, 10, 6, 1, -7 },
  { 375, 4, 10, 6, 1, -7 },
  { 380, 3, 7, 4, 1, -7 },
  { 383, 4, 7, 4, 0, -7 },
  { 387, 3, 9, 3, 0, -9 },
  { 391, 4, 7, 6, 1, -7 },
  { 395, 4, 7, 4, 0, -7 },
  { 399, 7, 7, 7, 0, -7 },
  { 406, 4, 7, 4, 0, -7 },
  { 410, 4, 10, 4, 0, -7 },
  { 415, 3, 7, 4, 0, -7 },
  { 418, 3, 11, 5, 1, -9 },
  { 423, 1, 13, 5, 2, -10 },
  { 425, 3, 11, 5, 1, -9 },
  { 430, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Light13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT13PT7B_H_
