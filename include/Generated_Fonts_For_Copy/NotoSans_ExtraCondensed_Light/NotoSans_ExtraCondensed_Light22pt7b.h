#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x07, 0xCE, 0x72, 0x94, 0xA4, 0x09, 0x08, 0x84,
  0x42, 0x21, 0x13, 0xFC, 0x48, 0x24, 0x12, 0x11, 0x3F, 0xE4, 0x42, 0x21,
  0x20, 0x90, 0x48, 0x10, 0x21, 0xFE, 0x99, 0x12, 0x24, 0x68, 0x70, 0x38,
  0x58, 0x91, 0x22, 0x65, 0xFE, 0x10, 0x20, 0x60, 0x89, 0x08, 0x91, 0x08,
  0x90, 0x89, 0x08, 0xA0, 0x8A, 0x49, 0x2A, 0xD5, 0x26, 0x51, 0x09, 0x10,
  0x91, 0x09, 0x11, 0x13, 0x11, 0x21, 0x0E, 0x38, 0x24, 0x12, 0x09, 0x84,
  0x82, 0x40, 0xE0, 0x60, 0x50, 0x6C, 0xA2, 0x50, 0xE8, 0x64, 0x33, 0x3C,
  0xF3, 0xFD, 0x50, 0x13, 0x26, 0x44, 0xC8, 0x88, 0x88, 0xCC, 0x44, 0x62,
  0x10, 0x84, 0x42, 0x22, 0x31, 0x11, 0x11, 0x13, 0x22, 0x64, 0xC0, 0x30,
  0x49, 0x5E, 0x31, 0x24, 0xC0, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC4, 0x08,
  0x10, 0x20, 0x5E, 0x80, 0xFF, 0xF0, 0x02, 0x04, 0x18, 0x20, 0x41, 0x02,
  0x04, 0x10, 0x20, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0x38, 0xD9, 0x16, 0x38,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x28, 0x91, 0x1C, 0x13, 0xD9,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x79, 0x98, 0x10, 0x30, 0x60, 0xC1,
  0x02, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x20, 0x7F, 0x79, 0x18, 0x18, 0x10,
  0x60, 0x81, 0x3C, 0x1C, 0x08, 0x08, 0x10, 0x20, 0xE1, 0x7C, 0x02, 0x03,
  0x01, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x10, 0x9F, 0xF0,
  0x20, 0x10, 0x08, 0x04, 0x7C, 0x81, 0x06, 0x0C, 0x10, 0x24, 0x7E, 0x06,
  0x04, 0x08, 0x10, 0x20, 0xE1, 0x7C, 0x1C, 0x61, 0x02, 0x0C, 0x10, 0x26,
  0x52, 0xC7, 0x06, 0x0C, 0x18, 0x28, 0x51, 0x1E, 0xFE, 0x04, 0x08, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x83, 0x04, 0x08, 0x30, 0x38, 0x8B,
  0x0C, 0x18, 0x28, 0xDB, 0x1C, 0x28, 0x8A, 0x0C, 0x18, 0x30, 0x71, 0xBE,
  0x38, 0x9A, 0x14, 0x38, 0x30, 0x60, 0xC3, 0x46, 0xF4, 0x08, 0x30, 0x40,
  0x82, 0x38, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x05, 0xE8, 0x02, 0x04, 0x31,
  0x8C, 0x18, 0x1C, 0x0C, 0x06, 0x04, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x81, 0x81, 0x80, 0xC0, 0x60, 0xC3, 0x18, 0xC1, 0x00, 0x7B, 0x20, 0x41,
  0x04, 0x30, 0x86, 0x10, 0x82, 0x08, 0x00, 0x02, 0x08, 0x0F, 0x01, 0x0C,
  0x20, 0x44, 0x02, 0x40, 0x24, 0xF2, 0x89, 0x18, 0x91, 0x91, 0x19, 0x11,
  0x91, 0x18, 0x92, 0x8A, 0xE4, 0x44, 0x40, 0x06, 0x00, 0x30, 0x80, 0xF0,
  0x08, 0x0E, 0x05, 0x02, 0x81, 0x40, 0xB0, 0x88, 0x44, 0x22, 0x1F, 0x98,
  0x48, 0x24, 0x12, 0x0F, 0x07, 0x01, 0xF9, 0x1A, 0x1C, 0x18, 0x30, 0xE1,
  0x7C, 0x8D, 0x0E, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x1E, 0x31, 0x60, 0x40,
  0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x31, 0x1F,
  0xF0, 0x9C, 0x86, 0x82, 0x82, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82,
  0x82, 0x86, 0x8C, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3E, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFA, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x0F, 0x0C, 0x26, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x83, 0xE0, 0x3C, 0x0D, 0x03, 0x40, 0xD8, 0x33, 0x0C, 0x7E,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFF, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3E, 0x87, 0x0A,
  0x34, 0x49, 0x12, 0x28, 0x70, 0xF1, 0x22, 0x64, 0x48, 0x90, 0xA1, 0x41,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0x38,
  0x0F, 0x01, 0xE0, 0x3A, 0x0F, 0x41, 0x68, 0x2D, 0x85, 0x91, 0x32, 0x26,
  0x44, 0xC5, 0x18, 0xA3, 0x14, 0x63, 0x8C, 0x21, 0x81, 0xC1, 0xC1, 0xE1,
  0xA1, 0xA1, 0x91, 0x91, 0x99, 0x89, 0x8D, 0x85, 0x85, 0x83, 0x83, 0x81,
  0x1E, 0x0C, 0xC6, 0x19, 0x02, 0xC0, 0xB0, 0x28, 0x0A, 0x03, 0x80, 0xE0,
  0x2C, 0x0B, 0x02, 0x40, 0x90, 0x62, 0x10, 0x78, 0xF1, 0x3A, 0x14, 0x28,
  0x70, 0xA1, 0x42, 0xF9, 0xC2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1E, 0x0C,
  0xC6, 0x19, 0x02, 0xC0, 0xB0, 0x28, 0x0A, 0x03, 0x80, 0xE0, 0x2C, 0x0B,
  0x02, 0x40, 0x90, 0x62, 0x10, 0x78, 0x02, 0x00, 0x80, 0x10, 0x06, 0xF1,
  0x3A, 0x14, 0x28, 0x70, 0xA1, 0x46, 0xF9, 0x22, 0x64, 0x48, 0xD0, 0xA1,
  0x41, 0x3C, 0xC7, 0x04, 0x08, 0x10, 0x10, 0x18, 0x18, 0x08, 0x18, 0x10,
  0x20, 0xE1, 0x7C, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0x82, 0xC6, 0x7C, 0x80,
  0xE0, 0xD0, 0x48, 0x24, 0x12, 0x19, 0x88, 0x44, 0x22, 0x11, 0x0D, 0x02,
  0x81, 0x40, 0xA0, 0x60, 0x10, 0x81, 0x03, 0x82, 0x0D, 0x0A, 0x12, 0x14,
  0x24, 0x28, 0x48, 0x50, 0x98, 0xA3, 0x13, 0x64, 0x24, 0x48, 0x48, 0x90,
  0x91, 0x21, 0xA2, 0xC1, 0x45, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x43,
  0x42, 0x62, 0x26, 0x24, 0x14, 0x18, 0x18, 0x18, 0x18, 0x34, 0x24, 0x26,
  0x42, 0x42, 0xC3, 0x83, 0xC2, 0x42, 0x46, 0x64, 0x24, 0x24, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC, 0x10, 0x82, 0x08, 0x41,
  0x0C, 0x20, 0x86, 0x10, 0x42, 0x08, 0x3F, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xFF, 0xC0, 0x81, 0x01, 0x02, 0x06, 0x04, 0x08,
  0x18, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xFF, 0x08, 0x06, 0x05, 0x02, 0xC2, 0x21, 0x19,
  0x05, 0x83, 0xFF, 0x80, 0x84, 0x21, 0x79, 0x30, 0x41, 0x04, 0xF4, 0x61,
  0x86, 0x18, 0xDD, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xE6, 0xC2, 0xC3,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC2, 0xE2, 0xDC, 0x3D, 0x94, 0x20, 0x82,
  0x08, 0x20, 0x83, 0x04, 0x0F, 0x02, 0x04, 0x08, 0x10, 0x27, 0x51, 0xE1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xA3, 0x7A, 0x38, 0x89, 0x14, 0x18,
  0x3F, 0xE0, 0x40, 0x81, 0x81, 0x09, 0xE0, 0x1C, 0x82, 0x08, 0x23, 0xE2,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3A, 0x8F, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x85, 0x1B, 0xD0, 0x20, 0x40, 0xC3, 0xFC, 0xC1,
  0x83, 0x06, 0x0C, 0x1B, 0xB9, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC2, 0xF0, 0x55, 0x55, 0x55, 0x6C, 0x02, 0x49, 0x24, 0x92, 0x49,
  0x24, 0xBC, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xF1, 0x64, 0xD9, 0xA3, 0xC7,
  0xCC, 0x99, 0x31, 0x62, 0xC6, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x9C, 0xEE,
  0x52, 0xC6, 0x3C, 0x21, 0xC2, 0x1C, 0x21, 0xC2, 0x1C, 0x21, 0xC2, 0x1C,
  0x21, 0xC2, 0x1C, 0x21, 0x9D, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x10, 0x38, 0x8B, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x85,
  0x19, 0xE0, 0x9C, 0xA6, 0xC2, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xC2,
  0xE2, 0xDC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3A, 0xCF, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x85, 0x1B, 0xD0, 0x20, 0x40, 0x81, 0x02, 0x9F, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x7E, 0x61, 0x0C, 0x30, 0xC1, 0x08,
  0x63, 0xF0, 0x21, 0x3E, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1C, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x8D, 0x1B, 0xD0, 0x83, 0x85,
  0x1A, 0x24, 0x4C, 0x89, 0x14, 0x28, 0x50, 0x60, 0x80, 0x82, 0x1C, 0x61,
  0x46, 0x34, 0x72, 0x45, 0x24, 0x92, 0x29, 0x22, 0x94, 0x29, 0xC2, 0x8C,
  0x30, 0xC1, 0x0C, 0x42, 0x8C, 0x91, 0x63, 0x83, 0x06, 0x1C, 0x2C, 0x49,
  0x1E, 0x10, 0xC2, 0x85, 0x0A, 0x36, 0x44, 0x89, 0x16, 0x38, 0x30, 0x60,
  0xC1, 0x02, 0x04, 0x10, 0xE0, 0xF8, 0x84, 0x62, 0x11, 0x88, 0x44, 0x21,
  0xF0, 0x0C, 0x43, 0x08, 0x20, 0x82, 0x08, 0x23, 0x86, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xC1, 0xC1, 0xFF, 0xFF, 0xFC, 0xC1, 0x82, 0x0C, 0x30, 0xC3,
  0x0C, 0x10, 0x71, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0x8E, 0x20, 0xE3, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 16, 5, 1, -16 },
  { 5, 5, 6, 7, 1, -16 },
  { 9, 9, 16, 10, 0, -16 },
  { 27, 7, 18, 9, 1, -17 },
  { 43, 12, 16, 14, 1, -16 },
  { 67, 9, 16, 9, 1, -16 },
  { 85, 2, 6, 4, 1, -16 },
  { 87, 4, 19, 6, 1, -16 },
  { 97, 4, 19, 6, 1, -16 },
  { 107, 6, 7, 8, 1, -17 },
  { 113, 7, 10, 9, 1, -13 },
  { 122, 2, 5, 4, 1, -2 },
  { 124, 4, 2, 6, 1, -7 },
  { 125, 2, 2, 4, 1, -2 },
  { 126, 7, 16, 8, 0, -16 },
  { 140, 7, 16, 9, 1, -16 },
  { 154, 4, 16, 9, 2, -16 },
  { 162, 7, 16, 9, 1, -16 },
  { 176, 7, 16, 9, 1, -16 },
  { 190, 9, 16, 9, 0, -16 },
  { 208, 7, 16, 9, 1, -16 },
  { 222, 7, 16, 9, 1, -16 },
  { 236, 7, 16, 9, 1, -16 },
  { 250, 7, 16, 9, 1, -16 },
  { 264, 7, 16, 9, 1, -16 },
  { 278, 2, 12, 4, 1, -12 },
  { 281, 2, 15, 4, 1, -12 },
  { 285, 7, 10, 9, 1, -13 },
  { 294, 7, 6, 9, 1, -11 },
  { 300, 7, 10, 9, 1, -13 },
  { 309, 6, 16, 6, 0, -16 },
  { 321, 12, 18, 14, 1, -16 },
  { 348, 9, 16, 9, 0, -16 },
  { 366, 7, 16, 10, 2, -16 },
  { 380, 8, 16, 9, 1, -16 },
  { 396, 8, 16, 11, 2, -16 },
  { 412, 6, 16, 9, 2, -16 },
  { 424, 6, 16, 8, 2, -16 },
  { 436, 10, 16, 12, 1, -16 },
  { 456, 8, 16, 11, 2, -16 },
  { 472, 4, 16, 6, 1, -16 },
  { 480, 4, 20, 5, -1, -16 },
  { 490, 7, 16, 9, 2, -16 },
  { 504, 5, 16, 8, 2, -16 },
  { 514, 11, 16, 15, 2, -16 },
  { 536, 8, 16, 12, 2, -16 },
  { 552, 10, 16, 12, 1, -16 },
  { 572, 7, 16, 9, 2, -16 },
  { 586, 10, 20, 12, 1, -16 },
  { 611, 7, 16, 10, 2, -16 },
  { 625, 7, 16, 9, 1, -16 },
  { 639, 8, 16, 8, 0, -16 },
  { 655, 8, 16, 11, 2, -16 },
  { 671, 9, 16, 9, 0, -16 },
  { 689, 15, 16, 15, 0, -16 },
  { 719, 8, 16, 8, 0, -16 },
  { 735, 8, 16, 8, 0, -16 },
  { 751, 6, 16, 8, 1, -16 },
  { 763, 4, 20, 7, 2, -16 },
  { 773, 7, 16, 8, 0, -16 },
  { 787, 4, 20, 7, 1, -16 },
  { 797, 9, 8, 9, 0, -16 },
  { 806, 9, 1, 9, 0, 2 },
  { 808, 4, 4, 5, 1, -17 },
  { 810, 6, 12, 9, 1, -12 },
  { 819, 8, 17, 10, 1, -17 },
  { 836, 6, 12, 7, 1, -12 },
  { 845, 7, 17, 10, 1, -17 },
  { 860, 7, 12, 9, 1, -12 },
  { 871, 6, 17, 5, 0, -17 },
  { 884, 7, 17, 10, 1, -12 },
  { 899, 7, 17, 10, 1, -17 },
  { 914, 2, 16, 4, 1, -16 },
  { 918, 3, 21, 4, 0, -16 },
  { 926, 7, 17, 8, 1, -17 },
  { 941, 2, 17, 4, 1, -17 },
  { 946, 12, 12, 14, 1, -12 },
  { 964, 7, 12, 10, 1, -12 },
  { 975, 7, 12, 9, 1, -12 },
  { 986, 8, 17, 10, 1, -12 },
  { 1003, 7, 17, 10, 1, -12 },
  { 1018, 5, 12, 6, 1, -12 },
  { 1026, 5, 12, 7, 1, -12 },
  { 1034, 5, 14, 5, 0, -14 },
  { 1043, 7, 12, 10, 1, -12 },
  { 1054, 7, 12, 7, 0, -12 },
  { 1065, 12, 12, 12, 0, -12 },
  { 1083, 7, 12, 8, 0, -12 },
  { 1094, 7, 17, 8, 0, -12 },
  { 1109, 5, 12, 6, 1, -12 },
  { 1117, 6, 20, 8, 1, -16 },
  { 1132, 1, 22, 9, 4, -17 },
  { 1135, 6, 20, 8, 1, -16 },
  { 1150, 7, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Light22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT22PT7B_H_
