#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xD8,
  0xFC, 0x3E, 0x18, 0x18, 0x3C, 0x18, 0x00, 0x78, 0x18, 0x00, 0x78, 0x18,
  0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0xF0, 0x18, 0x00, 0xF0, 0x18,
  0x00, 0xF0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0x78, 0x18,
  0x00, 0x38, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x1F, 0x18, 0x00, 0x0F, 0xD8,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x19, 0xF0, 0x00, 0x18, 0xF8, 0x00, 0x18,
  0x3C, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x0E, 0x00, 0x18,
  0x0F, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x0F, 0x00, 0x18,
  0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x3C, 0x40, 0x18,
  0x7C, 0x78, 0x18, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x03,
  0x87, 0x00, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1C,
  0x1C, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x0E,
  0x01, 0xC3, 0x81, 0xE0, 0xE0, 0x1C, 0x38, 0x7F, 0x0E, 0x01, 0xC3, 0x8F,
  0xF8, 0x70, 0x1C, 0x70, 0xE3, 0xC7, 0x03, 0x87, 0x1C, 0x1E, 0x70, 0x38,
  0x71, 0xC0, 0xE7, 0x83, 0x8E, 0x1C, 0x0E, 0x38, 0x70, 0xE3, 0x80, 0xE3,
  0xFF, 0x1E, 0x38, 0x07, 0x1F, 0xE1, 0xC3, 0x80, 0x70, 0xFC, 0x1C, 0x38,
  0x07, 0x00, 0x03, 0xC3, 0x80, 0x70, 0x00, 0x38, 0x38, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x70, 0x00, 0x78, 0x38, 0x07, 0x00, 0x07, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x38, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0xE0,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x80, 0x1E,
  0x1C, 0x00, 0x70, 0x00, 0xF3, 0xC0, 0x07, 0x00, 0x07, 0xF8, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x0E, 0x01, 0xE3, 0xC1, 0xE0, 0x3C, 0x78, 0x1E, 0x07,
  0x9E, 0x03, 0xC0, 0xF3, 0xC0, 0x3C, 0x1C, 0x70, 0x03, 0x83, 0x9E, 0x00,
  0x78, 0xF3, 0xC0, 0x07, 0x1E, 0x78, 0x00, 0xF3, 0x8F, 0x00, 0x0F, 0xF1,
  0xE0, 0x01, 0xFE, 0x3C, 0x00, 0x1F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0xC1, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0x7F, 0x83,
  0xC0, 0x1E, 0x78, 0x7C, 0x0F, 0x8F, 0x07, 0xFF, 0xE0, 0xF0, 0x7F, 0xF8,
  0x1F, 0x07, 0xFE, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xFF, 0xBD, 0xEF, 0x7B,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x20, 0x38, 0x0F,
  0x87, 0x0F, 0xFE, 0xEF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0x70, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0x03,
  0xC0, 0xE0, 0xF0, 0x1E, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7,
  0x8F, 0x1C, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x03,
  0xE0, 0x78, 0x07, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0xE0, 0x01, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0,
  0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78,
  0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xF0,
  0x3F, 0x83, 0xDC, 0x3C, 0xE7, 0xCF, 0x7C, 0x7F, 0xC3, 0xFC, 0x1E, 0xC0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xF0,
  0x70, 0x03, 0xE0, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0x83, 0xF8, 0x3F, 0x0F, 0x80, 0x1F, 0x06, 0x00, 0x1F, 0x08, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC4, 0x00,
  0x0F, 0x8E, 0x00, 0x7E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x37, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1C,
  0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0E,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x80, 0x03, 0xE3,
  0xC0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFE,
  0x0C, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0xF1, 0xFF, 0x83,
  0xCF, 0xFF, 0x8F, 0x78, 0x3E, 0x3D, 0x80, 0x7C, 0xFC, 0x00, 0xF3, 0xF0,
  0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07,
  0x87, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1F,
  0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x03,
  0xC7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xF0, 0x1F,
  0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xC3, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x07, 0x87, 0x80, 0x0E,
  0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x3F, 0x78,
  0x00, 0xF8, 0xF0, 0x06, 0xE3, 0xE0, 0x3B, 0x87, 0xFF, 0xCE, 0x0F, 0xFE,
  0x38, 0x1F, 0xF0, 0xE0, 0x0F, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x7B,
  0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBE, 0xFF,
  0xFF, 0xDE, 0x3C, 0x7D, 0xFB, 0xF3, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC7, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E,
  0x38, 0x71, 0xE3, 0x87, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0x8F, 0x07, 0xE6, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0xFF, 0x80, 0xE3, 0xC0,
  0x1F, 0xFC, 0x0E, 0x38, 0x03, 0xE7, 0xC0, 0xF3, 0x80, 0x78, 0x3C, 0x07,
  0x78, 0x07, 0x03, 0x80, 0x77, 0x80, 0xF0, 0x38, 0x07, 0x70, 0x0E, 0x03,
  0x80, 0x77, 0x01, 0xE0, 0x38, 0x07, 0x70, 0x1C, 0x03, 0x80, 0x77, 0x01,
  0xC0, 0x38, 0x07, 0x70, 0x1C, 0x03, 0x80, 0x77, 0x01, 0xC0, 0x38, 0x07,
  0xF0, 0x1C, 0x03, 0x80, 0x7F, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0x1C, 0x03,
  0x80, 0x7F, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0x1C, 0x07, 0x80, 0x7F, 0x01,
  0xC0, 0x78, 0x07, 0x70, 0x1C, 0x07, 0x80, 0x77, 0x01, 0xC0, 0x78, 0x0F,
  0x70, 0x1C, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0xF8, 0x0E, 0x70, 0x0E, 0x0D,
  0xC1, 0xE7, 0x00, 0xF1, 0xDC, 0x3C, 0x78, 0x0F, 0xF8, 0xFF, 0xC7, 0x80,
  0x7F, 0x8F, 0xF8, 0x38, 0x03, 0xF0, 0x7F, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07,
  0x8F, 0x00, 0x1F, 0x1E, 0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xE3, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x1F,
  0x9E, 0x00, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x3E,
  0x07, 0xE0, 0x04, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x02, 0x03, 0xF0, 0x0E, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0x00, 0x7F, 0x07, 0x80, 0x0F,
  0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x0F,
  0x00, 0x3F, 0x07, 0x81, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x0E, 0x03, 0xE0,
  0x00, 0x10, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x07, 0x81,
  0xFC, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE8, 0x3E, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x80, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0,
  0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF8, 0x00, 0x7B, 0xF0, 0x00, 0xF7, 0xF0, 0x01, 0xFD, 0xE0, 0x03,
  0xFB, 0xE0, 0x07, 0xE3, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xEF, 0xFF, 0x00,
  0x00, 0x07, 0x7F, 0xB8, 0x00, 0x00, 0x7B, 0xFD, 0xC0, 0x00, 0x03, 0xDF,
  0xEF, 0x00, 0x00, 0x1C, 0xFF, 0x38, 0x00, 0x00, 0xE7, 0xF9, 0xC0, 0x00,
  0x0F, 0x3F, 0xCF, 0x00, 0x00, 0x71, 0xFE, 0x38, 0x00, 0x03, 0x8F, 0xF1,
  0xC0, 0x00, 0x3C, 0x7F, 0x8F, 0x00, 0x01, 0xE3, 0xFC, 0x78, 0x00, 0x0E,
  0x1F, 0xE1, 0xC0, 0x00, 0xF0, 0xFF, 0x0E, 0x00, 0x07, 0x87, 0xF8, 0x78,
  0x00, 0x38, 0x3F, 0xC1, 0xC0, 0x01, 0xC1, 0xFE, 0x0E, 0x00, 0x1E, 0x0F,
  0xF0, 0x78, 0x00, 0xE0, 0x7F, 0x83, 0xC0, 0x07, 0x03, 0xFC, 0x0E, 0x00,
  0x78, 0x1F, 0xE0, 0x70, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x1C, 0x07, 0xF8,
  0x0E, 0x01, 0xE0, 0x3F, 0xC0, 0x70, 0x0F, 0x01, 0xFE, 0x03, 0xC0, 0x70,
  0x0F, 0xF0, 0x0E, 0x03, 0x80, 0x7F, 0x80, 0x70, 0x3C, 0x03, 0xFC, 0x03,
  0xC1, 0xE0, 0x1F, 0xE0, 0x1E, 0x0E, 0x00, 0xFF, 0x00, 0x70, 0xF0, 0x07,
  0xF8, 0x03, 0x87, 0x80, 0x3F, 0xC0, 0x1E, 0x38, 0x01, 0xFE, 0x00, 0x71,
  0xC0, 0x0F, 0xF0, 0x03, 0x9E, 0x00, 0x7F, 0x80, 0x1E, 0xE0, 0x03, 0xFC,
  0x00, 0xF7, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFD, 0xE0, 0x00, 0x7F, 0x78, 0x00, 0x1F, 0xCE, 0x00, 0x07, 0xF3,
  0xC0, 0x01, 0xFC, 0x70, 0x00, 0x7F, 0x1E, 0x00, 0x1F, 0xC3, 0x80, 0x07,
  0xF0, 0xF0, 0x01, 0xFC, 0x3C, 0x00, 0x7F, 0x07, 0x80, 0x1F, 0xC1, 0xE0,
  0x07, 0xF0, 0x38, 0x01, 0xFC, 0x0F, 0x00, 0x7F, 0x01, 0xC0, 0x1F, 0xC0,
  0x78, 0x07, 0xF0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x7F, 0x00, 0xF0, 0x1F,
  0xC0, 0x1C, 0x07, 0xF0, 0x07, 0x81, 0xFC, 0x00, 0xE0, 0x7F, 0x00, 0x3C,
  0x1F, 0xC0, 0x0F, 0x07, 0xF0, 0x01, 0xE1, 0xFC, 0x00, 0x78, 0x7F, 0x00,
  0x0E, 0x1F, 0xC0, 0x03, 0xC7, 0xF0, 0x00, 0x71, 0xFC, 0x00, 0x1E, 0x7F,
  0x00, 0x07, 0x9F, 0xC0, 0x00, 0xF7, 0xF0, 0x00, 0x3D, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0x00, 0xFE, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x07, 0xE7, 0x81, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0x00, 0xFE, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x3C, 0x00, 0x0E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78,
  0x03, 0xF0, 0xF0, 0x3F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xF0,
  0xFC, 0x3F, 0x00, 0x30, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x80, 0x03, 0xE3, 0xC0, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3, 0xE0,
  0x03, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80,
  0x0F, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3D, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3B, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x1C, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x73, 0xC0, 0x03,
  0x81, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x1C, 0x00, 0x78,
  0x0E, 0x00, 0x3C, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x80,
  0xF0, 0x03, 0x87, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1C, 0x0F, 0x00, 0xE0, 0x07, 0x80,
  0x70, 0x3C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0xE0,
  0x1E, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x00, 0x1C, 0x1E, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x01, 0xE1, 0xC0, 0x0E,
  0x0E, 0x00, 0x07, 0x87, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0xF1,
  0xE0, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x07, 0x1E,
  0x00, 0x03, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x73, 0xC0,
  0x00, 0x1C, 0xE0, 0x01, 0xEF, 0x00, 0x00, 0x73, 0x80, 0x03, 0xBC, 0x00,
  0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x38, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x38, 0x1C, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x38, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC1,
  0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE7,
  0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xE1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x01,
  0xC0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x3C,
  0x00, 0x70, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xC1, 0xF8, 0x7C, 0x0C, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFE, 0x71, 0xF8, 0x07, 0x3E, 0x00, 0x73,
  0xC0, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0xF7, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01,
  0xF7, 0x80, 0x1F, 0x78, 0x03, 0x73, 0xC0, 0x77, 0x3F, 0x9E, 0x71, 0xFF,
  0xC7, 0x0F, 0xF8, 0x70, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0xE1, 0xFF, 0x83, 0x8F, 0xFF, 0x0E, 0x7E, 0xFE, 0x3B, 0x80,
  0x78, 0xEC, 0x00, 0xF3, 0xF0, 0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x1E,
  0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0xC0, 0x0F, 0x3B, 0x00, 0x7C, 0xEF, 0x03, 0xE3, 0x9F, 0xFF, 0x0E,
  0x3F, 0xF8, 0x38, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x7F, 0xFC, 0x3F, 0xDE, 0x0F, 0x80, 0x87, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0x10, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x0F, 0x03, 0xFE, 0x1E, 0x0F,
  0xFE, 0x3C, 0x3F, 0xBE, 0x78, 0xF8, 0x0E, 0xF3, 0xE0, 0x0D, 0xE7, 0x80,
  0x0F, 0xCF, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x7D, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0x00, 0x0F, 0xCF, 0x00,
  0x1F, 0x9F, 0x00, 0x6F, 0x1F, 0x01, 0xDE, 0x1F, 0xFF, 0x3C, 0x1F, 0xFC,
  0x38, 0x1F, 0xF0, 0x70, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x1F, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0x00, 0xF0, 0xF0,
  0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x1E,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x10, 0x7C, 0x03,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xC3, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC,
  0x3C, 0x1F, 0xFE, 0x78, 0x7F, 0x7C, 0xF1, 0xF0, 0x1D, 0xE7, 0xC0, 0x1F,
  0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0xFB, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0xFB, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x0F, 0xCE, 0x00, 0x1F,
  0x9E, 0x00, 0x7F, 0x3E, 0x00, 0xDE, 0x3E, 0x07, 0xBC, 0x3F, 0xFE, 0x78,
  0x3F, 0xF8, 0xF0, 0x3F, 0xE1, 0xE0, 0x0C, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x60, 0x01, 0xF0, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0xC0, 0xE1, 0xFF, 0x0E, 0x3F,
  0xF8, 0xE7, 0xFF, 0xCE, 0xE0, 0x3E, 0xEC, 0x01, 0xEF, 0xC0, 0x1E, 0xF8,
  0x00, 0xEF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0x33, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x03, 0x03,
  0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x7D, 0xFC, 0xFE, 0x7C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x07,
  0x8E, 0x00, 0xF1, 0xC0, 0x3C, 0x38, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x78,
  0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0xF0, 0x0E, 0x1E, 0x01, 0xC7, 0x80,
  0x38, 0xF0, 0x07, 0x3F, 0x00, 0xEF, 0xE0, 0x1D, 0xDE, 0x03, 0xF3, 0xC0,
  0x7C, 0x38, 0x0F, 0x87, 0x81, 0xE0, 0x70, 0x38, 0x0F, 0x07, 0x01, 0xE0,
  0xE0, 0x1C, 0x1C, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x8E, 0x00, 0xF1,
  0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x7B,
  0x80, 0x07, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x38, 0x7F, 0x80, 0xFF, 0x8E, 0x7F, 0xF0,
  0x7F, 0xF3, 0x9F, 0x7E, 0x3E, 0xFE, 0xEE, 0x07, 0x9C, 0x0F, 0xBB, 0x00,
  0xF6, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x07, 0xC0, 0x0F, 0xF0,
  0x01, 0xF0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07,
  0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x00, 0x7C, 0x0E, 0x1F, 0xF0, 0xE3, 0xFF, 0x8E, 0x7C,
  0xFC, 0xEE, 0x03, 0xEE, 0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x7F, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0x80, 0x00, 0xEF, 0x00,
  0x01, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3E,
  0x03, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7C, 0x03, 0x87, 0xFE, 0x0E, 0x3F, 0xFC, 0x39, 0xF3,
  0xF8, 0xE6, 0x01, 0xE3, 0xB0, 0x03, 0xCE, 0xC0, 0x0F, 0x3E, 0x00, 0x1E,
  0xF8, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBB, 0x00, 0x3C, 0xEE, 0x01, 0xF3, 0x9C, 0x0F, 0x8E,
  0x7F, 0xFC, 0x38, 0xFF, 0xE0, 0xE1, 0xFF, 0x03, 0x80, 0xF0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x3C, 0x1F, 0xFC,
  0x78, 0x7F, 0x7C, 0xF1, 0xF0, 0x1D, 0xE3, 0xC0, 0x1B, 0xCF, 0x00, 0x1F,
  0x9E, 0x00, 0x3F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xFB, 0xC0, 0x01,
  0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x7F,
  0x3E, 0x00, 0xDE, 0x3E, 0x07, 0xBC, 0x3F, 0xFE, 0x78, 0x3F, 0xF8, 0xF0,
  0x3F, 0xE1, 0xE0, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x7B, 0x87, 0xFE, 0x3F, 0xB9, 0xFE, 0xE7, 0x0B, 0xB8, 0x0E,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xFC, 0xFE, 0x3E, 0x3C, 0x01, 0x9E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0xC0, 0x07, 0xBC, 0x03, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0x03, 0x80, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xDC, 0x00, 0x3E, 0xE0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0xFD,
  0xE0, 0x06, 0xE7, 0x80, 0x77, 0x3E, 0x07, 0x38, 0xFF, 0xF1, 0xC7, 0xFF,
  0x0E, 0x1F, 0xF0, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1E,
  0x03, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x3C, 0x01,
  0xE0, 0xE0, 0x07, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x03, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80,
  0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x0F, 0x70, 0x01, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x80,
  0x0E, 0x78, 0x01, 0xFC, 0x01, 0xE7, 0x80, 0x3D, 0xC0, 0x1E, 0x38, 0x03,
  0x9C, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x1C, 0x3C, 0x03, 0x9C, 0x01, 0xC3,
  0xC0, 0x39, 0xE0, 0x3C, 0x3C, 0x07, 0x8E, 0x03, 0xC1, 0xC0, 0x70, 0xE0,
  0x38, 0x1C, 0x07, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0xE0, 0x78, 0x1E, 0x07,
  0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x70, 0x70, 0x0E, 0x0E, 0x07, 0x07, 0x00,
  0xE0, 0xE0, 0x70, 0x70, 0x0F, 0x0E, 0x07, 0x0F, 0x00, 0xF1, 0xE0, 0x78,
  0xF0, 0x07, 0x1E, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07, 0x9C,
  0x03, 0x8E, 0x00, 0x79, 0xC0, 0x39, 0xE0, 0x07, 0x9C, 0x03, 0xDC, 0x00,
  0x3B, 0xC0, 0x1D, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x01, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x78, 0x07, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xE3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xEF, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x70,
  0x07, 0x87, 0x80, 0x3C, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1F,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0xCF, 0x00,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xDE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x8F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 49, 15, 5, -49 },
  { 32, 15, 18, 23, 4, -49 },
  { 66, 28, 49, 30, 1, -49 },
  { 238, 24, 56, 28, 2, -52 },
  { 406, 36, 50, 42, 3, -49 },
  { 631, 27, 50, 29, 2, -49 },
  { 800, 5, 18, 13, 4, -49 },
  { 812, 14, 60, 19, 3, -49 },
  { 917, 13, 60, 19, 2, -49 },
  { 1015, 19, 20, 25, 3, -52 },
  { 1063, 24, 32, 28, 2, -40 },
  { 1159, 7, 16, 14, 3, -7 },
  { 1173, 14, 3, 18, 2, -20 },
  { 1179, 6, 6, 14, 4, -6 },
  { 1184, 22, 49, 24, 1, -49 },
  { 1319, 22, 50, 28, 3, -49 },
  { 1457, 13, 49, 28, 5, -49 },
  { 1537, 22, 49, 28, 3, -49 },
  { 1672, 23, 50, 28, 2, -49 },
  { 1816, 26, 49, 28, 1, -49 },
  { 1976, 22, 50, 28, 3, -49 },
  { 2114, 22, 50, 28, 3, -49 },
  { 2252, 22, 49, 28, 3, -49 },
  { 2387, 24, 50, 28, 2, -49 },
  { 2537, 22, 50, 28, 3, -49 },
  { 2675, 6, 36, 14, 4, -36 },
  { 2702, 7, 45, 14, 3, -36 },
  { 2742, 24, 29, 28, 2, -39 },
  { 2829, 24, 18, 28, 2, -33 },
  { 2883, 24, 29, 28, 2, -39 },
  { 2970, 17, 49, 20, 1, -49 },
  { 3075, 36, 55, 43, 3, -49 },
  { 3323, 28, 49, 28, 0, -49 },
  { 3495, 23, 49, 31, 5, -49 },
  { 3636, 24, 50, 29, 4, -49 },
  { 3786, 25, 49, 34, 5, -49 },
  { 3940, 18, 49, 27, 5, -49 },
  { 4051, 19, 49, 25, 5, -49 },
  { 4168, 29, 50, 36, 4, -49 },
  { 4350, 25, 49, 35, 5, -49 },
  { 4504, 13, 49, 17, 2, -49 },
  { 4584, 12, 62, 14, -3, -49 },
  { 4677, 23, 49, 28, 5, -49 },
  { 4818, 18, 49, 24, 5, -49 },
  { 4929, 37, 49, 47, 5, -49 },
  { 5156, 26, 49, 37, 5, -49 },
  { 5316, 29, 50, 36, 4, -49 },
  { 5498, 21, 49, 28, 5, -49 },
  { 5627, 29, 61, 36, 4, -49 },
  { 5849, 23, 49, 29, 5, -49 },
  { 5990, 22, 50, 27, 3, -49 },
  { 6128, 23, 49, 24, 1, -49 },
  { 6269, 25, 50, 34, 5, -49 },
  { 6426, 27, 49, 27, 0, -49 },
  { 6592, 46, 49, 46, 0, -49 },
  { 6874, 23, 49, 25, 1, -49 },
  { 7015, 24, 49, 24, 0, -49 },
  { 7162, 20, 49, 23, 2, -49 },
  { 7285, 14, 60, 21, 5, -49 },
  { 7390, 22, 49, 24, 1, -49 },
  { 7525, 14, 60, 21, 2, -49 },
  { 7630, 26, 24, 28, 1, -48 },
  { 7708, 28, 3, 28, 0, 6 },
  { 7719, 11, 11, 17, 3, -52 },
  { 7735, 20, 38, 27, 2, -37 },
  { 7830, 22, 53, 30, 5, -52 },
  { 7976, 18, 38, 22, 3, -37 },
  { 8062, 23, 53, 30, 3, -52 },
  { 8215, 21, 38, 27, 3, -37 },
  { 8315, 16, 52, 16, 1, -52 },
  { 8419, 23, 53, 30, 3, -37 },
  { 8572, 20, 52, 29, 5, -52 },
  { 8702, 5, 50, 13, 4, -50 },
  { 8734, 9, 66, 13, 0, -50 },
  { 8809, 19, 52, 25, 5, -52 },
  { 8933, 3, 52, 13, 5, -52 },
  { 8953, 34, 37, 44, 5, -37 },
  { 9111, 20, 37, 29, 5, -37 },
  { 9204, 23, 38, 29, 3, -37 },
  { 9314, 22, 53, 30, 5, -37 },
  { 9460, 23, 53, 30, 3, -37 },
  { 9613, 14, 37, 19, 5, -37 },
  { 9678, 18, 38, 22, 2, -37 },
  { 9764, 14, 46, 16, 1, -45 },
  { 9845, 21, 37, 29, 4, -36 },
  { 9943, 22, 36, 23, 0, -36 },
  { 10042, 36, 36, 38, 1, -36 },
  { 10204, 21, 36, 23, 1, -36 },
  { 10299, 22, 52, 23, 1, -36 },
  { 10442, 16, 36, 19, 2, -36 },
  { 10514, 18, 60, 24, 3, -49 },
  { 10649, 3, 68, 27, 12, -52 },
  { 10675, 18, 60, 24, 3, -49 },
  { 10810, 24, 7, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Light68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT68PT7B_H_
