#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0x80,
  0x18, 0x83, 0x10, 0x42, 0x08, 0x41, 0x18, 0x23, 0x3F, 0xF8, 0x88, 0x11,
  0x06, 0x20, 0xC4, 0x10, 0x8F, 0xFD, 0xFF, 0x88, 0x81, 0x10, 0x22, 0x0C,
  0x41, 0x88, 0x21, 0x00, 0x08, 0x02, 0x03, 0xF9, 0xA2, 0xC8, 0x22, 0x08,
  0x83, 0x20, 0xC8, 0x1A, 0x01, 0xC0, 0x38, 0x0B, 0x82, 0x20, 0x8C, 0x23,
  0x08, 0x82, 0x6E, 0xF1, 0xF8, 0x08, 0x02, 0x00, 0x80, 0x78, 0x30, 0x90,
  0x41, 0x10, 0x86, 0x23, 0x0C, 0x44, 0x10, 0x88, 0x21, 0x20, 0x62, 0x40,
  0xC4, 0xBC, 0x8A, 0x49, 0x25, 0x9B, 0xDB, 0x10, 0x24, 0x20, 0x48, 0x41,
  0x90, 0x82, 0x21, 0x04, 0x62, 0x18, 0x4C, 0x20, 0x90, 0x40, 0xE0, 0x3C,
  0x04, 0xC1, 0x88, 0x31, 0x06, 0x20, 0x44, 0x09, 0x81, 0xA0, 0x1C, 0x03,
  0x01, 0xA0, 0x26, 0x2C, 0x65, 0x84, 0xA0, 0xF4, 0x0C, 0xC1, 0x98, 0x39,
  0x99, 0x3E, 0x30, 0xEA, 0xA8, 0x0C, 0x61, 0x0C, 0x21, 0x86, 0x10, 0x41,
  0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x08, 0x30, 0xC1, 0x83, 0xC2,
  0x08, 0x63, 0x08, 0x63, 0x18, 0x42, 0x10, 0x84, 0x21, 0x18, 0xC4, 0x23,
  0x11, 0x98, 0x18, 0x08, 0x89, 0xFF, 0x18, 0x34, 0x26, 0x42, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x3F, 0xFF, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x6D, 0xA5, 0xA0, 0xFC, 0xBC, 0x01, 0x03, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60,
  0x40, 0x40, 0xC0, 0x80, 0x1E, 0x19, 0x98, 0x4C, 0x34, 0x1E, 0x0F, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x05, 0x06, 0x83, 0x61, 0xB0,
  0x8C, 0xC3, 0xC0, 0x08, 0xDB, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x7E, 0x61, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30,
  0x30, 0x1F, 0xF0, 0x7E, 0x61, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x06, 0x1E, 0x03, 0x80, 0x60, 0x18, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xF0,
  0xDF, 0xC0, 0x01, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x58, 0x0B, 0x02, 0x60,
  0x4C, 0x11, 0x82, 0x30, 0xC6, 0x10, 0xC6, 0x18, 0x83, 0x3F, 0xF8, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x7F, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x7E, 0x23, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xB1, 0xDF, 0xC0, 0x0F, 0x0C, 0x0C, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xDF, 0x70, 0xB8, 0x78, 0x1C, 0x0E, 0x07, 0x02, 0x81, 0x41,
  0xB0, 0xCC, 0xC3, 0xC0, 0xFF, 0x80, 0x40, 0x60, 0x30, 0x10, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x08,
  0x0C, 0x06, 0x00, 0x3E, 0x18, 0xC4, 0x1B, 0x02, 0xC0, 0x90, 0x64, 0x19,
  0x8C, 0x36, 0x07, 0x03, 0x61, 0x8C, 0x41, 0xB0, 0x2C, 0x0F, 0x03, 0xC0,
  0xB0, 0x66, 0x38, 0xFC, 0x3E, 0x31, 0x90, 0x58, 0x3C, 0x1E, 0x0F, 0x03,
  0x83, 0xC1, 0xA0, 0xD8, 0xA7, 0xD0, 0x98, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x81, 0x8F, 0x80, 0xFC, 0x00, 0x00, 0xBC, 0x6D, 0x80, 0x00, 0x00, 0x06,
  0xDA, 0x5A, 0x00, 0x00, 0x40, 0x70, 0x70, 0x70, 0x70, 0x30, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x02, 0x00, 0xFC, 0x46, 0x02, 0x02, 0x03,
  0x02, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x10, 0x00, 0x00,
  0x10, 0x30, 0x30, 0x07, 0xE0, 0x18, 0x60, 0x60, 0x21, 0x80, 0x62, 0x00,
  0x4C, 0x10, 0xD0, 0xF8, 0xA3, 0x31, 0x44, 0x62, 0x88, 0xC7, 0x11, 0x8E,
  0x23, 0x1C, 0x46, 0x38, 0x88, 0x51, 0x19, 0xA3, 0x56, 0x43, 0x18, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x82, 0x01, 0xFC, 0x00, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xB0, 0x0B, 0x01, 0x90, 0x19, 0x01, 0x18, 0x11, 0x81, 0x08,
  0x30, 0x83, 0xFC, 0x3F, 0xC2, 0x0C, 0x60, 0x46, 0x06, 0x40, 0x64, 0x06,
  0xC0, 0x2C, 0x03, 0xFE, 0x31, 0xCC, 0x1B, 0x06, 0xC0, 0xB0, 0x2C, 0x1B,
  0x06, 0xC3, 0x3F, 0x0C, 0x33, 0x06, 0xC0, 0xB0, 0x3C, 0x0F, 0x03, 0xC0,
  0xB0, 0x6C, 0x73, 0xF8, 0x0F, 0xC6, 0x13, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0xC4, 0x3F, 0xFC, 0x33, 0xCC, 0x1B, 0x02, 0xC0, 0xF0,
  0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F,
  0x03, 0xC1, 0xB0, 0x6C, 0x73, 0xF0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x07, 0xE1,
  0xC3, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC1, 0xF4, 0x01, 0x40, 0x14, 0x01, 0x60, 0x16, 0x01, 0x20, 0x13,
  0x01, 0x1C, 0x30, 0xFF, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x7F, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x09, 0xF0, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x76, 0xE0, 0xC1, 0xB0,
  0x6C, 0x33, 0x08, 0xC6, 0x31, 0x0C, 0xC3, 0x60, 0xD0, 0x3E, 0x0F, 0x83,
  0x30, 0xCC, 0x31, 0x8C, 0x63, 0x08, 0xC3, 0x30, 0x4C, 0x1B, 0x03, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0xF0, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x5F, 0x00, 0xBA, 0x03, 0x74, 0x04, 0xEC, 0x09, 0xD8, 0x33, 0x90, 0x47,
  0x20, 0x8E, 0x63, 0x1C, 0x46, 0x38, 0x88, 0x71, 0x90, 0xE3, 0x61, 0xC2,
  0x83, 0x85, 0x07, 0x0E, 0x0E, 0x0C, 0x10, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x07, 0xA0, 0xF6, 0x1E, 0x43, 0xCC, 0x78, 0x8F, 0x19, 0xE3, 0x3C,
  0x27, 0x86, 0xF0, 0x5E, 0x0F, 0xC0, 0xB8, 0x1F, 0x03, 0xE0, 0x30, 0x0F,
  0x81, 0x8C, 0x30, 0x66, 0x02, 0x60, 0x34, 0x03, 0x40, 0x14, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x36, 0x03, 0x60,
  0x23, 0x06, 0x18, 0xC0, 0xF8, 0xFC, 0x67, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0x61, 0xBF, 0x9F, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x00, 0x0F, 0x81, 0x8C, 0x30, 0x66, 0x02, 0x60, 0x34,
  0x03, 0x40, 0x14, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x36, 0x03, 0x60, 0x23, 0x06, 0x18, 0xC0, 0xF8, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0xFC, 0x33, 0xCC, 0x33, 0x06, 0xC1,
  0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0x31, 0xCF, 0xC3, 0x30, 0xC4, 0x31, 0x8C,
  0x23, 0x0C, 0xC3, 0x30, 0x6C, 0x1B, 0x03, 0x3F, 0xB8, 0xD0, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x0C, 0x02,
  0x03, 0x01, 0x80, 0xF1, 0xDF, 0xC0, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xD0, 0x36, 0x18, 0xFC, 0xC0, 0x38, 0x0D, 0x01,
  0xA0, 0x36, 0x04, 0xC1, 0x88, 0x31, 0x06, 0x30, 0x86, 0x10, 0xC6, 0x08,
  0xC1, 0x10, 0x32, 0x06, 0xC0, 0x58, 0x0A, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0xC0, 0x40, 0x78, 0x0C, 0x0D, 0x03, 0x81, 0x20, 0x50, 0x26, 0x0A, 0x0C,
  0xC1, 0x41, 0x88, 0x2C, 0x31, 0x0D, 0x84, 0x21, 0x90, 0x86, 0x22, 0x30,
  0xC4, 0x46, 0x08, 0x8C, 0xC1, 0x31, 0x90, 0x26, 0x12, 0x06, 0x82, 0xC0,
  0xD0, 0x58, 0x0A, 0x0B, 0x01, 0xC1, 0xC0, 0x38, 0x18, 0x06, 0x03, 0x00,
  0x60, 0xD8, 0x22, 0x18, 0xC6, 0x11, 0x04, 0xC1, 0xA0, 0x28, 0x0E, 0x03,
  0x00, 0xE0, 0x38, 0x1A, 0x04, 0xC3, 0x30, 0xC4, 0x21, 0x98, 0x24, 0x0B,
  0x03, 0xC0, 0xD0, 0x24, 0x19, 0x86, 0x21, 0x08, 0x43, 0x30, 0x48, 0x12,
  0x07, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0x80, 0xFF, 0xFF, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3F, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30,
  0x10, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x03, 0x01,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3F, 0x06, 0x00, 0xC0, 0x3C, 0x04, 0x81, 0x98, 0x21, 0x0C,
  0x31, 0x02, 0x60, 0x58, 0x0C, 0xFF, 0xFF, 0xFF, 0xC3, 0x0C, 0x30, 0x3E,
  0x62, 0x03, 0x01, 0x01, 0x01, 0x0F, 0x39, 0x41, 0xC1, 0xC1, 0xC3, 0xC3,
  0x45, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x46, 0xC1,
  0x60, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC1, 0xE0, 0xF0, 0x54,
  0x69, 0xE0, 0x1F, 0x31, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x31, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x33, 0xEC, 0xCF, 0x61, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xD0, 0x36, 0x1D, 0x8F, 0x3E, 0xC0, 0x1E, 0x19, 0x98, 0x48,
  0x3C, 0x1E, 0x07, 0xFF, 0xFF, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x01, 0x88,
  0x7C, 0x1E, 0x60, 0xC1, 0x83, 0x06, 0x3F, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x3E, 0xCC, 0xF6, 0x1D,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x61,
  0xD8, 0xF3, 0xEC, 0x03, 0x00, 0x80, 0x20, 0x0A, 0x06, 0x7F, 0x0F, 0x00,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9E, 0xA3, 0xC3, 0xC1, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xBC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x23, 0x30, 0x00, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0xEC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x83,
  0x86, 0x84, 0x8C, 0x98, 0x90, 0xB0, 0xB8, 0xC8, 0x8C, 0x84, 0x86, 0x86,
  0x82, 0x83, 0xFF, 0xFF, 0xF8, 0x9C, 0x7A, 0x9A, 0x3C, 0x28, 0xF0, 0xC1,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x9E, 0xA3, 0xC3, 0xC1,
  0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E,
  0x0C, 0xC6, 0x19, 0x02, 0xC0, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x09, 0x02, 0x61, 0x88, 0xC1, 0xE0, 0x9E, 0x51, 0xB0, 0x58, 0x3C, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x78, 0x3C, 0x15, 0x1A, 0x79, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1E, 0xCC, 0xF6, 0x1D, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x61, 0xDC,
  0xB3, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x9E,
  0xDA, 0x30, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3E,
  0xC7, 0x04, 0x0C, 0x18, 0x1C, 0x1C, 0x0C, 0x0C, 0x08, 0x10, 0x70, 0xFF,
  0x00, 0x42, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x61,
  0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x83, 0xC3, 0xC5, 0x79, 0xC0, 0xE0, 0xD0, 0x68, 0x26, 0x13, 0x18, 0x8C,
  0x44, 0x32, 0x1B, 0x05, 0x82, 0x81, 0x40, 0xE0, 0x30, 0xC1, 0x82, 0x83,
  0x05, 0x06, 0x1A, 0x1C, 0x36, 0x2C, 0x4C, 0x48, 0x88, 0x91, 0x13, 0x26,
  0x36, 0x4C, 0x68, 0xD0, 0x50, 0xA0, 0xA1, 0x41, 0x43, 0x83, 0x86, 0x06,
  0x0C, 0x00, 0x61, 0xB0, 0x88, 0xC6, 0x61, 0x20, 0xF0, 0x30, 0x18, 0x1C,
  0x0B, 0x0C, 0x86, 0x62, 0x13, 0x0F, 0x06, 0xC0, 0xA0, 0x58, 0x6C, 0x32,
  0x11, 0x08, 0x8C, 0x66, 0x12, 0x09, 0x05, 0x83, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0x0C, 0x06, 0x02, 0x0F, 0x06, 0x00, 0xFC, 0x30, 0xC2, 0x18,
  0x61, 0x0C, 0x21, 0x86, 0x10, 0xC2, 0x0F, 0xC0, 0x07, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x70, 0xE0, 0x10, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0E,
  0x07, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0xF0,
  0xF8, 0x63, 0xF8, 0x10,
};

const GFXglyph NotoSans_ExtraCondensed_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 6, 7, 9, 2, -20 },
  { 12, 11, 20, 12, 1, -20 },
  { 40, 10, 23, 12, 1, -21 },
  { 69, 15, 20, 17, 1, -20 },
  { 107, 11, 20, 12, 1, -20 },
  { 135, 2, 7, 5, 2, -20 },
  { 137, 6, 24, 8, 1, -20 },
  { 155, 5, 24, 8, 1, -20 },
  { 170, 8, 8, 10, 1, -21 },
  { 178, 10, 13, 12, 1, -16 },
  { 195, 3, 7, 6, 1, -3 },
  { 198, 6, 1, 8, 1, -8 },
  { 199, 2, 3, 6, 2, -3 },
  { 200, 8, 20, 10, 1, -20 },
  { 220, 9, 20, 12, 1, -20 },
  { 243, 5, 20, 12, 2, -20 },
  { 256, 9, 20, 12, 1, -20 },
  { 279, 9, 20, 12, 1, -20 },
  { 302, 11, 20, 12, 0, -20 },
  { 330, 9, 20, 12, 1, -20 },
  { 353, 9, 20, 12, 1, -20 },
  { 376, 9, 20, 12, 1, -20 },
  { 399, 10, 20, 12, 1, -20 },
  { 424, 9, 20, 12, 1, -20 },
  { 447, 2, 15, 6, 2, -15 },
  { 451, 3, 19, 6, 1, -15 },
  { 459, 10, 12, 12, 1, -16 },
  { 474, 10, 8, 12, 1, -14 },
  { 484, 10, 12, 12, 1, -16 },
  { 499, 8, 20, 8, 0, -20 },
  { 519, 15, 22, 18, 1, -20 },
  { 561, 12, 20, 12, 0, -20 },
  { 591, 10, 20, 13, 2, -20 },
  { 616, 10, 20, 12, 1, -20 },
  { 641, 10, 20, 14, 2, -20 },
  { 666, 8, 20, 11, 2, -20 },
  { 686, 8, 20, 10, 2, -20 },
  { 706, 12, 20, 15, 1, -20 },
  { 736, 10, 20, 14, 2, -20 },
  { 761, 5, 20, 7, 1, -20 },
  { 774, 5, 25, 6, -1, -20 },
  { 790, 10, 20, 12, 2, -20 },
  { 815, 7, 20, 10, 2, -20 },
  { 833, 15, 20, 19, 2, -20 },
  { 871, 11, 20, 15, 2, -20 },
  { 899, 12, 20, 15, 1, -20 },
  { 929, 9, 20, 12, 2, -20 },
  { 952, 12, 25, 15, 1, -20 },
  { 990, 10, 20, 12, 2, -20 },
  { 1015, 9, 20, 11, 1, -20 },
  { 1038, 10, 20, 10, 0, -20 },
  { 1063, 10, 20, 14, 2, -20 },
  { 1088, 11, 20, 11, 0, -20 },
  { 1116, 19, 20, 19, 0, -20 },
  { 1164, 10, 20, 10, 0, -20 },
  { 1189, 10, 20, 10, 0, -20 },
  { 1214, 8, 20, 10, 1, -20 },
  { 1234, 6, 24, 9, 2, -20 },
  { 1252, 8, 20, 10, 1, -20 },
  { 1272, 5, 24, 9, 1, -20 },
  { 1287, 11, 10, 12, 0, -20 },
  { 1301, 12, 2, 12, 0, 2 },
  { 1304, 5, 4, 7, 1, -21 },
  { 1307, 8, 15, 11, 1, -15 },
  { 1322, 9, 21, 12, 2, -21 },
  { 1346, 8, 15, 9, 1, -15 },
  { 1361, 10, 21, 12, 1, -21 },
  { 1388, 9, 15, 11, 1, -15 },
  { 1405, 7, 21, 7, 0, -21 },
  { 1424, 10, 22, 12, 1, -15 },
  { 1452, 8, 21, 12, 2, -21 },
  { 1473, 2, 21, 5, 2, -21 },
  { 1479, 4, 28, 5, 0, -21 },
  { 1493, 8, 21, 10, 2, -21 },
  { 1514, 1, 21, 5, 2, -21 },
  { 1517, 14, 15, 18, 2, -15 },
  { 1544, 8, 15, 12, 2, -15 },
  { 1559, 10, 15, 12, 1, -15 },
  { 1578, 9, 22, 12, 2, -15 },
  { 1603, 10, 22, 12, 1, -15 },
  { 1631, 6, 15, 8, 2, -15 },
  { 1643, 7, 15, 9, 1, -15 },
  { 1657, 5, 18, 7, 1, -18 },
  { 1669, 8, 15, 12, 2, -15 },
  { 1684, 9, 15, 9, 0, -15 },
  { 1701, 15, 15, 16, 0, -15 },
  { 1730, 9, 15, 10, 0, -15 },
  { 1747, 9, 22, 10, 0, -15 },
  { 1772, 6, 15, 8, 1, -15 },
  { 1784, 8, 24, 10, 1, -20 },
  { 1808, 1, 28, 11, 5, -21 },
  { 1812, 8, 24, 10, 1, -20 },
  { 1836, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Light28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT28PT7B_H_
