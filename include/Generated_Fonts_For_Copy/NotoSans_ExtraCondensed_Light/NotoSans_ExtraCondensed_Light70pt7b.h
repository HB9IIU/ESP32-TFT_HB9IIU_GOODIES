#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDC, 0x07, 0xB8, 0x0F,
  0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0xDC,
  0x07, 0xB8, 0x0F, 0x70, 0x0E, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0x30, 0xF8, 0xF8,
  0x60, 0x31, 0xE0, 0xC0, 0x07, 0x81, 0x80, 0x0F, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x60,
  0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0F, 0x03, 0x00, 0x0F, 0x06, 0x00,
  0x1F, 0x0C, 0x00, 0x1F, 0x18, 0x00, 0x1F, 0xB0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0D, 0xFC, 0x00, 0x18, 0xFC, 0x00, 0x30, 0x7C, 0x00, 0x60, 0x78, 0x00,
  0xC0, 0x78, 0x01, 0x80, 0xF0, 0x03, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0C,
  0x03, 0x80, 0x18, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xC0,
  0x78, 0x01, 0x80, 0xE8, 0x03, 0x03, 0xD8, 0x06, 0x0F, 0x3E, 0x0C, 0x7E,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xC0, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x78, 0xF0, 0x00, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x07, 0x80,
  0xE0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x1C, 0x38,
  0x00, 0x0E, 0x00, 0xE1, 0xC0, 0xF0, 0x70, 0x0F, 0x0E, 0x1F, 0xC3, 0xC0,
  0x70, 0xE1, 0xFF, 0x0E, 0x03, 0x87, 0x0E, 0x3C, 0x70, 0x1C, 0x38, 0xF0,
  0xF3, 0x80, 0xE3, 0x87, 0x03, 0x9E, 0x0E, 0x1C, 0x78, 0x1C, 0x70, 0x71,
  0xE3, 0x80, 0xF3, 0xEF, 0x8E, 0x1C, 0x07, 0x8F, 0xF8, 0x70, 0xE0, 0x1C,
  0x3F, 0x87, 0x87, 0x00, 0xE0, 0x70, 0x38, 0x38, 0x07, 0x00, 0x01, 0xC3,
  0xC0, 0x38, 0x00, 0x1E, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0xF0, 0x0E, 0x00,
  0x07, 0x07, 0x80, 0x70, 0x00, 0x78, 0x3C, 0x03, 0x80, 0x03, 0x81, 0xE0,
  0x1C, 0x00, 0x1C, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x1E, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0x1E, 0x1C, 0x00,
  0x78, 0x00, 0x79, 0xE0, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x70, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x1E, 0x01, 0xE1,
  0xE1, 0xE0, 0x1E, 0x3C, 0x0F, 0x01, 0xC3, 0x80, 0x70, 0x1C, 0x78, 0x07,
  0x81, 0xC7, 0x80, 0x3C, 0x3C, 0x70, 0x03, 0xC3, 0xCF, 0x00, 0x1E, 0x3C,
  0xF0, 0x01, 0xE3, 0x8F, 0x00, 0x0F, 0x78, 0xF0, 0x00, 0x7F, 0x8F, 0x00,
  0x07, 0xF0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xF0, 0x78, 0x00, 0x7F, 0x07, 0xC0, 0x0F, 0x78, 0x3C,
  0x01, 0xF7, 0xC3, 0xF0, 0x3E, 0x3C, 0x1F, 0xFF, 0xC1, 0xE0, 0xFF, 0xF8,
  0x1E, 0x07, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xBD,
  0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x40, 0x60, 0x6F,
  0x86, 0x1F, 0xFF, 0x6F, 0xF7, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x39, 0xC0, 0x07, 0x9E, 0x00, 0xF0, 0xE0, 0x0E, 0x0F,
  0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC0, 0xC0, 0x30, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C,
  0xF1, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x79, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x3E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0xF3, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x78, 0x07,
  0xE1, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1E,
  0xF0, 0xF3, 0xCF, 0x8F, 0x7C, 0x3F, 0xE0, 0xFF, 0x03, 0xD8, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0x7E, 0x0E, 0x00, 0x3E, 0x08,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0xFC, 0x07, 0xE3, 0xC0,
  0x07, 0xC4, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE8, 0x00, 0x1F, 0x3C, 0x01, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1E, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x18, 0x00, 0x7E, 0x3C, 0x01, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0x00, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x07, 0xF0,
  0x0E, 0x1F, 0xF8, 0x1C, 0xFF, 0xF8, 0x79, 0xF3, 0xF8, 0xF7, 0x00, 0xF1,
  0xFC, 0x00, 0xF3, 0xF0, 0x01, 0xE7, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0xBE, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0xC0, 0x3C, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7C,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x07, 0x81, 0xF0, 0x03, 0xE3, 0xE0,
  0x01, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3E, 0x00, 0x3C, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xC0,
  0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0x78, 0x00, 0x7D, 0xE0, 0x03, 0xF7, 0xC0, 0x0D, 0xCF, 0x80, 0x7F, 0x1F,
  0x8F, 0xBC, 0x7F, 0xFC, 0xF0, 0x7F, 0xE3, 0xC0, 0xFF, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x08, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x11, 0xE7, 0xFF, 0xFD, 0xF7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x79, 0xFF, 0xFF, 0x7D, 0xE0, 0x08, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x8F, 0x1E, 0x3C, 0xF9, 0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xC3,
  0x8F, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x70, 0x1F, 0x10, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x03, 0xFE,
  0x03, 0x8F, 0x00, 0x7F, 0xF0, 0x1C, 0x70, 0x07, 0xEF, 0x80, 0xF3, 0x80,
  0x3C, 0x1C, 0x03, 0x9C, 0x03, 0xC0, 0xE0, 0x1D, 0xE0, 0x1C, 0x07, 0x00,
  0xEF, 0x01, 0xE0, 0x38, 0x07, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0x80, 0x70,
  0x0E, 0x01, 0xFC, 0x07, 0x80, 0x70, 0x0F, 0xE0, 0x3C, 0x03, 0x80, 0x7F,
  0x01, 0xC0, 0x1C, 0x03, 0xF8, 0x0E, 0x01, 0xE0, 0x1F, 0xC0, 0x70, 0x0F,
  0x00, 0xFE, 0x03, 0x80, 0x78, 0x07, 0x70, 0x1C, 0x03, 0xC0, 0x3B, 0x80,
  0xE0, 0x1E, 0x01, 0xDC, 0x07, 0x00, 0xF0, 0x0E, 0xE0, 0x38, 0x07, 0x80,
  0x77, 0x01, 0xC0, 0x3C, 0x03, 0xB8, 0x0F, 0x01, 0xE0, 0x3D, 0xC0, 0x78,
  0x1B, 0x01, 0xCE, 0x01, 0xC0, 0xD8, 0x0E, 0x70, 0x0F, 0x0E, 0xE0, 0xF3,
  0xC0, 0x3C, 0x77, 0x8F, 0x1E, 0x01, 0xFF, 0x1F, 0xF0, 0x70, 0x07, 0xF0,
  0xFF, 0x83, 0x80, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0x07, 0xE0,
  0x02, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x01, 0x03, 0xF8, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF8, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0x38, 0x1F, 0x00,
  0x00, 0x41, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0E,
  0x3E, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x1C, 0x0F,
  0x80, 0x00, 0xE0, 0x7F, 0x80, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFE, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0x7E, 0x00,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00,
  0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF3, 0xE0, 0x00,
  0xF7, 0xF0, 0x00, 0xF7, 0xF0, 0x00, 0xFE, 0x78, 0x00, 0xFE, 0x78, 0x00,
  0xFC, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80,
  0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFD, 0xC0, 0x00, 0x00, 0xEF, 0xF7, 0x00, 0x00, 0x03, 0xBF,
  0xDE, 0x00, 0x00, 0x1E, 0xFF, 0x78, 0x00, 0x00, 0x7B, 0xFC, 0xE0, 0x00,
  0x01, 0xCF, 0xF3, 0x80, 0x00, 0x0F, 0x3F, 0xCF, 0x00, 0x00, 0x3C, 0xFF,
  0x1C, 0x00, 0x00, 0xE3, 0xFC, 0x70, 0x00, 0x03, 0x8F, 0xF1, 0xE0, 0x00,
  0x1E, 0x3F, 0xC7, 0x80, 0x00, 0x78, 0xFF, 0x0E, 0x00, 0x01, 0xC3, 0xFC,
  0x3C, 0x00, 0x0F, 0x0F, 0xF0, 0xF0, 0x00, 0x3C, 0x3F, 0xC1, 0xC0, 0x00,
  0xE0, 0xFF, 0x07, 0x00, 0x07, 0x83, 0xFC, 0x1E, 0x00, 0x1E, 0x0F, 0xF0,
  0x38, 0x00, 0x70, 0x3F, 0xC0, 0xE0, 0x01, 0xC0, 0xFF, 0x03, 0xC0, 0x0F,
  0x03, 0xFC, 0x0F, 0x00, 0x3C, 0x0F, 0xF0, 0x1C, 0x00, 0xE0, 0x3F, 0xC0,
  0x78, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x1E, 0x03, 0xFC, 0x03, 0x80, 0x70,
  0x0F, 0xF0, 0x0E, 0x01, 0xC0, 0x3F, 0xC0, 0x3C, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x3C, 0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x0F, 0xF0, 0x07, 0x87, 0x80,
  0x3F, 0xC0, 0x1E, 0x1E, 0x00, 0xFF, 0x00, 0x38, 0x70, 0x03, 0xFC, 0x00,
  0xE3, 0xC0, 0x0F, 0xF0, 0x03, 0xCF, 0x00, 0x3F, 0xC0, 0x0F, 0x38, 0x00,
  0xFF, 0x00, 0x1C, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF7, 0x80, 0x00, 0xFE, 0xF0, 0x00,
  0x1F, 0xCF, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x7F, 0x1C, 0x00, 0x0F, 0xE3,
  0xC0, 0x01, 0xFC, 0x78, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xF0, 0xF0, 0x00,
  0xFE, 0x0F, 0x00, 0x1F, 0xC1, 0xE0, 0x03, 0xF8, 0x1C, 0x00, 0x7F, 0x03,
  0xC0, 0x0F, 0xE0, 0x78, 0x01, 0xFC, 0x07, 0x80, 0x3F, 0x80, 0xF0, 0x07,
  0xF0, 0x0F, 0x00, 0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x1C, 0x03, 0xF8, 0x03,
  0xC0, 0x7F, 0x00, 0x78, 0x0F, 0xE0, 0x07, 0x81, 0xFC, 0x00, 0xF0, 0x3F,
  0x80, 0x0F, 0x07, 0xF0, 0x01, 0xE0, 0xFE, 0x00, 0x1E, 0x1F, 0xC0, 0x03,
  0xC3, 0xF8, 0x00, 0x78, 0x7F, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0xF1, 0xFC,
  0x00, 0x0F, 0x3F, 0x80, 0x01, 0xE7, 0xF0, 0x00, 0x1E, 0xFE, 0x00, 0x03,
  0xDF, 0xC0, 0x00, 0x7B, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x3C, 0x1F, 0xF8, 0xF0, 0x03, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00,
  0x3C, 0xF0, 0x03, 0xF3, 0xC0, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF0, 0x03,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x0F,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0x80, 0x78, 0xF8, 0x00, 0x63, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xEC, 0x00,
  0x1F, 0x3E, 0x01, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1,
  0xF0, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0xF0,
  0x00, 0x3C, 0x1C, 0x00, 0x0E, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x70,
  0x00, 0x78, 0x1E, 0x00, 0x0E, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x70,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x38,
  0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x1C,
  0x01, 0xE0, 0x07, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x1C,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x07,
  0x07, 0x80, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x07,
  0x07, 0x00, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x07,
  0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x03,
  0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x03,
  0x9E, 0x00, 0x00, 0x73, 0x80, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0x80, 0x01,
  0xDE, 0x00, 0x00, 0x7B, 0x80, 0x01, 0xDE, 0x00, 0x00, 0x7B, 0x80, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xC3, 0xC0, 0x01,
  0xE3, 0xC0, 0x01, 0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0xF7, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xE3, 0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xC0, 0x07,
  0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x03, 0x81,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x1C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x30,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF0, 0xFC, 0x18, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFC, 0x0F, 0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0x7C, 0x0E, 0x77, 0xF3, 0xE7, 0x3F, 0xFC, 0x71, 0xFF, 0x07, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x3F, 0x00,
  0xF1, 0xFF, 0x81, 0xE7, 0xFF, 0x83, 0xDF, 0xBF, 0x87, 0xB8, 0x0F, 0x8E,
  0xE0, 0x0F, 0x9D, 0x80, 0x0F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0xBE, 0x00, 0x1E, 0x76, 0x00, 0x3C, 0xEE, 0x00, 0xF1, 0xCE,
  0x03, 0xE3, 0x8F, 0xFF, 0x87, 0x1F, 0xFE, 0x0E, 0x0F, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFB, 0xE0,
  0xF8, 0x04, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x01, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x7E, 0x07, 0x03, 0xFF, 0x0E,
  0x0F, 0xFF, 0x1C, 0x3F, 0xBF, 0x38, 0xF8, 0x0F, 0x71, 0xE0, 0x0E, 0xE7,
  0x80, 0x0F, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xCF,
  0x00, 0x0F, 0x9E, 0x00, 0x37, 0x1E, 0x00, 0xEE, 0x3E, 0x03, 0x9C, 0x3F,
  0xFF, 0x38, 0x3F, 0xFC, 0x70, 0x3F, 0xE0, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x01,
  0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x38, 0x00, 0x79,
  0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x20, 0xF8, 0x03, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3C, 0x10, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x1C,
  0x1F, 0xFE, 0x38, 0x7F, 0x7E, 0x71, 0xF0, 0x1E, 0xE3, 0xC0, 0x0D, 0xCF,
  0x00, 0x1F, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0x9E,
  0x00, 0x1F, 0x3C, 0x00, 0x6E, 0x3C, 0x01, 0xDC, 0x7C, 0x07, 0x38, 0x7F,
  0xFC, 0x70, 0x7F, 0xF0, 0xE0, 0x7F, 0xC1, 0xC0, 0x1E, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x80, 0x01, 0xF0, 0xE0, 0x07, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x0F, 0xC0, 0xF1, 0xFF, 0x87, 0x9F, 0xFE, 0x3D, 0xFF, 0xF9, 0xCE,
  0x07, 0xCE, 0xE0, 0x1F, 0x76, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x0E,
  0xF8, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0x80, 0x7B, 0xFF, 0xF7, 0xBC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C,
  0x1E, 0xFF, 0x7F, 0x3F, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01,
  0xEF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE3, 0xE0, 0x0E,
  0x3E, 0x00, 0xE7, 0xE0, 0x0E, 0xFF, 0x00, 0xEE, 0xF0, 0x0F, 0xC7, 0x80,
  0xF8, 0x78, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x0F, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x1C, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0xFC, 0x0E, 0x1F, 0xF0, 0x1F, 0xF0, 0xE3, 0xFF, 0x83, 0xFF, 0x8E,
  0x7D, 0xFC, 0x7D, 0xFC, 0xEE, 0x03, 0xCE, 0x07, 0xCE, 0xC0, 0x3C, 0xC0,
  0x3E, 0xF8, 0x01, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0x80, 0x1E, 0xF8, 0x01,
  0xF8, 0x01, 0xEF, 0x00, 0x0F, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0x00, 0xEF,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7E, 0x07, 0x0F, 0xFC, 0x38, 0xFF, 0xF1, 0xCF, 0xDF, 0xCE,
  0x70, 0x3E, 0x77, 0x00, 0xFB, 0xB0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00,
  0xF7, 0xC0, 0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x0F,
  0x81, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x01, 0xC3, 0xFF, 0x03, 0x8F, 0xFF, 0x07, 0x3F,
  0x3F, 0x0E, 0x70, 0x1F, 0x1D, 0xC0, 0x1F, 0x3B, 0x00, 0x1E, 0x7C, 0x00,
  0x3C, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x00,
  0xEF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x77, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7E, 0x00, 0x3C, 0xEC, 0x00,
  0x79, 0xDC, 0x01, 0xE3, 0x9C, 0x07, 0xC7, 0x9F, 0xFF, 0x0F, 0x1F, 0xFC,
  0x1E, 0x1F, 0xF0, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x1C, 0x1F,
  0xFE, 0x38, 0x7F, 0xFE, 0x71, 0xF0, 0x1E, 0xE3, 0xC0, 0x1D, 0xCF, 0x00,
  0x1B, 0x9E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0x9E, 0x00,
  0x1F, 0x3E, 0x00, 0x6E, 0x3C, 0x01, 0xDC, 0x7E, 0x07, 0x38, 0x7F, 0xFC,
  0x70, 0x7F, 0xF0, 0xE0, 0x7F, 0xC1, 0xC0, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x87, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE7, 0x87, 0x98, 0x0E, 0xE0, 0x3B, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xE7,
  0xE3, 0xE0, 0x18, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xD8, 0x00, 0xFB,
  0xC0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0x78, 0x07, 0x77, 0xC0, 0xF7,
  0x3F, 0xFE, 0x71, 0xFF, 0xC7, 0x0F, 0xF8, 0x30, 0x1C, 0x00, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x38, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0E,
  0x03, 0xC0, 0x1C, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x70,
  0x78, 0x00, 0xE0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0x8F,
  0x00, 0x07, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0xE0,
  0x01, 0xF8, 0x00, 0xF7, 0x00, 0x0F, 0xC0, 0x07, 0x3C, 0x00, 0xFE, 0x00,
  0x39, 0xE0, 0x07, 0x70, 0x03, 0xCF, 0x00, 0x3B, 0x80, 0x1E, 0x38, 0x01,
  0xDE, 0x00, 0xF1, 0xC0, 0x0E, 0x70, 0x07, 0x0F, 0x00, 0xF3, 0x80, 0x38,
  0x78, 0x07, 0x1C, 0x03, 0xC3, 0xC0, 0x38, 0xE0, 0x1E, 0x0E, 0x01, 0xC7,
  0x80, 0xE0, 0x78, 0x1E, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0xE0, 0x78, 0x1E,
  0x07, 0x07, 0x03, 0xC0, 0x70, 0x38, 0x38, 0x1E, 0x03, 0x81, 0xC1, 0xE0,
  0xE0, 0x1E, 0x1E, 0x07, 0x07, 0x00, 0xF0, 0xF0, 0x38, 0x78, 0x07, 0x87,
  0x01, 0xC3, 0xC0, 0x1C, 0x38, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x78, 0xE0,
  0x07, 0x9E, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x0E, 0x78, 0x00, 0xE7, 0x00,
  0x73, 0xC0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x1E, 0xE0, 0x01,
  0xFE, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x07,
  0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xF1, 0xC0, 0x01, 0xCF,
  0x00, 0x07, 0xB8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1E, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x00, 0x1E, 0x1E,
  0x00, 0x78, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x38, 0x07, 0x81,
  0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x79, 0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0x8F, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xE0,
  0x70, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x1C,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xE1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x3C,
  0x00, 0x0E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x9F, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xF4, 0x00,
  0x3F, 0xF2, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 50, 15, 5, -50 },
  { 33, 15, 18, 24, 4, -50 },
  { 67, 29, 50, 31, 1, -50 },
  { 249, 23, 57, 29, 3, -53 },
  { 413, 37, 52, 43, 3, -51 },
  { 654, 28, 52, 30, 2, -51 },
  { 836, 5, 18, 13, 4, -50 },
  { 848, 14, 61, 19, 3, -50 },
  { 955, 14, 61, 19, 2, -50 },
  { 1062, 20, 20, 26, 3, -53 },
  { 1112, 25, 33, 29, 2, -41 },
  { 1216, 7, 17, 14, 3, -8 },
  { 1231, 15, 4, 19, 2, -21 },
  { 1239, 6, 6, 14, 4, -6 },
  { 1244, 21, 50, 25, 2, -50 },
  { 1376, 23, 52, 29, 3, -51 },
  { 1526, 14, 50, 29, 5, -50 },
  { 1614, 23, 51, 29, 3, -51 },
  { 1761, 22, 52, 29, 3, -51 },
  { 1904, 27, 50, 29, 1, -50 },
  { 2073, 23, 51, 29, 3, -50 },
  { 2220, 23, 52, 29, 3, -51 },
  { 2370, 23, 50, 29, 3, -50 },
  { 2514, 24, 52, 29, 2, -51 },
  { 2670, 22, 52, 29, 3, -51 },
  { 2813, 6, 38, 14, 4, -38 },
  { 2842, 7, 47, 14, 3, -38 },
  { 2884, 25, 30, 29, 2, -40 },
  { 2978, 25, 18, 29, 2, -34 },
  { 3035, 25, 30, 29, 2, -40 },
  { 3129, 18, 51, 20, 1, -51 },
  { 3244, 37, 56, 44, 4, -50 },
  { 3503, 29, 50, 29, 0, -50 },
  { 3685, 24, 50, 32, 5, -50 },
  { 3835, 24, 52, 30, 4, -51 },
  { 3991, 26, 50, 35, 5, -50 },
  { 4154, 19, 50, 27, 5, -50 },
  { 4273, 19, 50, 26, 5, -50 },
  { 4392, 29, 52, 37, 4, -51 },
  { 4581, 25, 50, 36, 5, -50 },
  { 4738, 12, 50, 18, 3, -50 },
  { 4813, 12, 63, 14, -3, -50 },
  { 4908, 24, 50, 29, 5, -50 },
  { 5058, 19, 50, 25, 5, -50 },
  { 5177, 38, 50, 48, 5, -50 },
  { 5415, 27, 50, 38, 5, -50 },
  { 5584, 30, 52, 37, 4, -51 },
  { 5779, 22, 50, 29, 5, -50 },
  { 5917, 30, 63, 37, 4, -51 },
  { 6154, 24, 50, 30, 5, -50 },
  { 6304, 22, 52, 28, 3, -51 },
  { 6447, 23, 50, 25, 1, -50 },
  { 6591, 25, 51, 35, 5, -50 },
  { 6751, 28, 50, 28, 0, -50 },
  { 6926, 48, 50, 48, 0, -50 },
  { 7226, 24, 50, 26, 1, -50 },
  { 7376, 25, 50, 25, 0, -50 },
  { 7533, 21, 50, 24, 2, -50 },
  { 7665, 14, 61, 22, 5, -50 },
  { 7772, 21, 50, 24, 2, -50 },
  { 7904, 14, 61, 22, 2, -50 },
  { 8011, 27, 25, 29, 1, -50 },
  { 8096, 29, 3, 29, 0, 6 },
  { 8107, 11, 12, 17, 3, -54 },
  { 8124, 20, 39, 27, 3, -38 },
  { 8222, 23, 54, 31, 5, -53 },
  { 8378, 19, 39, 23, 3, -38 },
  { 8471, 23, 54, 31, 3, -53 },
  { 8627, 22, 39, 28, 3, -38 },
  { 8735, 17, 54, 16, 1, -54 },
  { 8850, 23, 55, 31, 3, -38 },
  { 9009, 21, 53, 30, 5, -53 },
  { 9149, 5, 51, 14, 4, -51 },
  { 9181, 9, 68, 14, 0, -51 },
  { 9258, 20, 53, 25, 5, -53 },
  { 9391, 4, 53, 13, 5, -53 },
  { 9418, 36, 38, 45, 5, -38 },
  { 9589, 21, 38, 30, 5, -38 },
  { 9689, 24, 39, 30, 3, -38 },
  { 9806, 23, 55, 31, 5, -38 },
  { 9965, 23, 55, 31, 3, -38 },
  { 10124, 14, 38, 20, 5, -38 },
  { 10191, 19, 39, 23, 2, -38 },
  { 10284, 14, 47, 16, 1, -46 },
  { 10367, 20, 38, 30, 5, -37 },
  { 10462, 23, 37, 23, 0, -37 },
  { 10569, 37, 37, 39, 1, -37 },
  { 10741, 22, 37, 24, 1, -37 },
  { 10843, 23, 54, 24, 1, -37 },
  { 10999, 16, 37, 20, 2, -37 },
  { 11073, 19, 61, 25, 3, -50 },
  { 11218, 3, 70, 27, 12, -53 },
  { 11245, 18, 61, 25, 3, -50 },
  { 11383, 25, 7, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Light70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT70PT7B_H_
