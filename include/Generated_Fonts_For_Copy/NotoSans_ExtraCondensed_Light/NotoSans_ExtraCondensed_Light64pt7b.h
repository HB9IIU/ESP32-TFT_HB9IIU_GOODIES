#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x73, 0xFF, 0xFF, 0xBC, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEF,
  0x03, 0xBC, 0x0E, 0xE0, 0x39, 0x80, 0xE6, 0x03, 0x98, 0x0E, 0x60, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x18,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0xE0, 0x01,
  0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x01,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0x07, 0xFF, 0xFE, 0x1E, 0x30, 0xF0, 0xF0, 0xC0, 0x47, 0x83, 0x00,
  0x1C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x38,
  0x0C, 0x00, 0xE0, 0x30, 0x03, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C,
  0x00, 0x78, 0x30, 0x00, 0xF0, 0xC0, 0x01, 0xF3, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x37, 0xE0, 0x00, 0xC7, 0xC0, 0x03, 0x0F, 0x80, 0x0C, 0x1E, 0x00, 0x30,
  0x3C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x1C,
  0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x0F, 0x00, 0x30, 0x3A, 0x00,
  0xC1, 0xEF, 0x03, 0x1F, 0x3F, 0xCF, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x07, 0xF0, 0x00, 0x70, 0x03, 0x8E, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x70, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x38, 0x0E,
  0x03, 0x80, 0x0E, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x70, 0x00, 0xE0,
  0x38, 0x1C, 0x00, 0x38, 0x0E, 0x06, 0x00, 0x0E, 0x03, 0x83, 0x80, 0x03,
  0x80, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x30, 0x00, 0x38, 0x0E, 0x1C, 0x00,
  0x0E, 0x03, 0x87, 0x07, 0x83, 0x80, 0xE1, 0x87, 0xF8, 0xE0, 0x38, 0xE1,
  0xFF, 0x38, 0x0E, 0x38, 0xE1, 0xC7, 0x03, 0x0C, 0x30, 0x39, 0xC1, 0xC7,
  0x1C, 0x0E, 0x78, 0x71, 0xC7, 0x03, 0x8F, 0x78, 0xE1, 0xC0, 0xE1, 0xFC,
  0x38, 0x70, 0x18, 0x3E, 0x0E, 0x38, 0x07, 0x00, 0x07, 0x0E, 0x01, 0xC0,
  0x01, 0xC3, 0x80, 0x70, 0x00, 0x70, 0xE0, 0x1C, 0x00, 0x38, 0x38, 0x07,
  0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x70, 0x01, 0xC0, 0xE0,
  0x1C, 0x00, 0x70, 0x38, 0x07, 0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x0E, 0x01,
  0x80, 0x70, 0x03, 0x80, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x70,
  0x07, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x70, 0x03,
  0x80, 0x0F, 0x3C, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x38, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0,
  0x01, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0x8E, 0x01, 0xC3, 0xC3, 0xC0, 0x70, 0xE0, 0x78, 0x1C, 0x78,
  0x0E, 0x07, 0x1C, 0x03, 0xC3, 0xCF, 0x00, 0x70, 0xF3, 0xC0, 0x1E, 0x38,
  0xF0, 0x03, 0x8E, 0x38, 0x00, 0xF7, 0x8E, 0x00, 0x1F, 0xC3, 0x80, 0x03,
  0xF0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x81, 0xC0,
  0x03, 0xF0, 0x78, 0x01, 0xFC, 0x1E, 0x00, 0xF7, 0x83, 0xC0, 0x78, 0xF0,
  0xFF, 0xFC, 0x3C, 0x1F, 0xFE, 0x07, 0x81, 0xFF, 0x01, 0xF0, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x66, 0x60, 0x00, 0x78,
  0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x0C, 0x0C, 0x0B, 0xE3, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0x70, 0x01, 0xCE, 0x00, 0xE3, 0xC0, 0x78, 0x70,
  0x3C, 0x0E, 0x0E, 0x03, 0xC1, 0x80, 0x40, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0xF0, 0x78, 0x1E, 0x03, 0x83, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00,
  0xE7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xE0,
  0x3C, 0x1F, 0x07, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x83, 0xDC,
  0x7C, 0xE7, 0xC7, 0x7C, 0x3F, 0xC1, 0xCC, 0x0E, 0x40, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xF8, 0x0F, 0x83, 0x00, 0x3E, 0x10, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF1, 0xF8, 0x0F, 0x87, 0x00, 0x1E, 0x10, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF4, 0x00, 0x0F, 0x1C, 0x01, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x80,
  0x1C, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xE0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0xC0, 0x80, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE4, 0x00, 0x3E,
  0x38, 0x03, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xC0,
  0x40, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x3F, 0x81, 0xE7, 0xFF, 0x0F, 0x7F, 0xFC, 0x7F, 0x81, 0xE3,
  0xB0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x3C,
  0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x1F, 0xBF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8,
  0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x78,
  0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0x38, 0x00,
  0x78, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x7C, 0x01, 0xF3, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x3C, 0x0F,
  0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03,
  0xDE, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07,
  0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x81, 0xE0, 0x3C,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00,
  0x1E, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7C, 0xE0, 0x03, 0xE7,
  0x80, 0x37, 0x1E, 0x03, 0xB8, 0xFC, 0xF9, 0xC3, 0xFF, 0x8E, 0x0F, 0xF8,
  0xF0, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0xFB,
  0xC0, 0x1E, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x38,
  0x71, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x70, 0x3E, 0x40,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x7F, 0x80, 0xE3, 0x80,
  0x3F, 0xF0, 0x38, 0xE0, 0x1E, 0x3C, 0x0E, 0x70, 0x0F, 0x07, 0x01, 0xDC,
  0x03, 0x81, 0xC0, 0x77, 0x01, 0xC0, 0x70, 0x1D, 0xC0, 0x70, 0x1C, 0x07,
  0x70, 0x3C, 0x07, 0x01, 0xDC, 0x0E, 0x03, 0xC0, 0x7E, 0x03, 0x80, 0xF0,
  0x1F, 0x80, 0xE0, 0x3C, 0x07, 0xE0, 0x38, 0x0F, 0x01, 0xF8, 0x0E, 0x03,
  0x80, 0x7E, 0x03, 0x80, 0xE0, 0x1F, 0x80, 0xE0, 0x38, 0x07, 0xE0, 0x38,
  0x0E, 0x01, 0xF8, 0x0E, 0x03, 0x80, 0x7E, 0x03, 0x80, 0xE0, 0x1F, 0x80,
  0xE0, 0x38, 0x0E, 0xF0, 0x38, 0x1E, 0x03, 0x9C, 0x0F, 0x06, 0xC0, 0xE7,
  0x01, 0xC3, 0xB0, 0x71, 0xC0, 0x78, 0xCE, 0x3C, 0x70, 0x0F, 0xF3, 0xFE,
  0x1C, 0x01, 0xF8, 0x7F, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0x3C, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x01,
  0xC0, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x38, 0x07, 0xF0, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0x38,
  0x00, 0x3C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00,
  0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x3C,
  0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0,
  0x3F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xE0, 0x03,
  0xE3, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01,
  0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8E,
  0x00, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0xE0, 0x7C,
  0x00, 0x40, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x30, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0E, 0x00, 0x7E, 0x1C, 0x00, 0x7C, 0x38, 0x00, 0x7C, 0x70,
  0x00, 0x7C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00,
  0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xE0, 0x01,
  0xE1, 0xC0, 0x0F, 0x83, 0x80, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xB8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0xE0,
  0x00, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xF7, 0xFC, 0xFF, 0x07, 0x80, 0xE0,
  0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xE0, 0x01,
  0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x03,
  0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x3C, 0x03, 0x80,
  0xE0, 0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x87, 0x80,
  0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0x9F, 0x00, 0x0E,
  0xFC, 0x00, 0x3B, 0xF8, 0x00, 0xFD, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F,
  0x00, 0x3C, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38,
  0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0x78, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0F, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x7B, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0xE0, 0x00,
  0x01, 0xDF, 0xB8, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x1D, 0xFB, 0xC0,
  0x00, 0x0E, 0x7E, 0x70, 0x00, 0x03, 0x9F, 0x9C, 0x00, 0x00, 0xE7, 0xE7,
  0x00, 0x00, 0x79, 0xF8, 0xE0, 0x00, 0x1C, 0x7E, 0x38, 0x00, 0x07, 0x1F,
  0x8E, 0x00, 0x03, 0xC7, 0xE3, 0xC0, 0x00, 0xE1, 0xF8, 0x70, 0x00, 0x38,
  0x7E, 0x1C, 0x00, 0x0E, 0x1F, 0x87, 0x80, 0x07, 0x87, 0xE0, 0xE0, 0x01,
  0xC1, 0xF8, 0x38, 0x00, 0x70, 0x7E, 0x0E, 0x00, 0x3C, 0x1F, 0x83, 0xC0,
  0x0E, 0x07, 0xE0, 0x70, 0x03, 0x81, 0xF8, 0x1C, 0x00, 0xE0, 0x7E, 0x07,
  0x80, 0x70, 0x1F, 0x80, 0xE0, 0x1C, 0x07, 0xE0, 0x38, 0x07, 0x01, 0xF8,
  0x0F, 0x03, 0xC0, 0x7E, 0x01, 0xC0, 0xE0, 0x1F, 0x80, 0x70, 0x38, 0x07,
  0xE0, 0x1C, 0x1E, 0x01, 0xF8, 0x07, 0x87, 0x00, 0x7E, 0x00, 0xE1, 0xC0,
  0x1F, 0x80, 0x38, 0x70, 0x07, 0xE0, 0x0F, 0x3C, 0x01, 0xF8, 0x01, 0xCE,
  0x00, 0x7E, 0x00, 0x73, 0x80, 0x1F, 0x80, 0x1D, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xDC, 0x00,
  0x0F, 0xEF, 0x00, 0x07, 0xF3, 0x80, 0x03, 0xF9, 0xE0, 0x01, 0xFC, 0xF0,
  0x00, 0xFE, 0x38, 0x00, 0x7F, 0x1E, 0x00, 0x3F, 0x87, 0x00, 0x1F, 0xC3,
  0xC0, 0x0F, 0xE0, 0xE0, 0x07, 0xF0, 0x78, 0x03, 0xF8, 0x1C, 0x01, 0xFC,
  0x0E, 0x00, 0xFE, 0x07, 0x80, 0x7F, 0x01, 0xC0, 0x3F, 0x80, 0xF0, 0x1F,
  0xC0, 0x38, 0x0F, 0xE0, 0x1E, 0x07, 0xF0, 0x07, 0x03, 0xF8, 0x03, 0x81,
  0xFC, 0x01, 0xE0, 0xFE, 0x00, 0x70, 0x7F, 0x00, 0x3C, 0x3F, 0x80, 0x0E,
  0x1F, 0xC0, 0x07, 0x8F, 0xE0, 0x01, 0xC7, 0xF0, 0x00, 0xF3, 0xF8, 0x00,
  0x79, 0xFC, 0x00, 0x1C, 0xFE, 0x00, 0x0F, 0x7F, 0x00, 0x03, 0xBF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x38,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x0F, 0xF8, 0xE0, 0x0F, 0xCE, 0x00, 0x3C,
  0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x07, 0xCE, 0x01, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xE0,
  0x0F, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3,
  0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80,
  0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x1F,
  0x0E, 0x01, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0E,
  0x07, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x0E, 0x01,
  0xE0, 0x38, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38,
  0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE3, 0xF0, 0x1E, 0x3C, 0x00, 0x27, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE8, 0x00, 0x3C, 0xE0, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xBC, 0x00, 0x07, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0x8E, 0x00, 0x07, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xFC, 0x00, 0x1E, 0x3C, 0x00, 0x1B, 0x80, 0x03, 0xC7, 0x80, 0x07,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x9C, 0x00, 0x78, 0x3C, 0x00, 0x73, 0x80, 0x0F,
  0x07, 0x80, 0x1C, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x8F, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0xE0, 0x0F, 0x01, 0xC0, 0x0E, 0x1C, 0x01, 0xE0, 0x3C, 0x01,
  0xC3, 0x80, 0x3C, 0x07, 0x80, 0x70, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x01, 0xC0, 0x38, 0x1C, 0x07,
  0x80, 0x3C, 0x07, 0x03, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00,
  0x70, 0x38, 0x0F, 0x03, 0x80, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x01, 0xE0,
  0xE0, 0x1C, 0x1E, 0x00, 0x3C, 0x1C, 0x03, 0x83, 0xC0, 0x07, 0x87, 0x80,
  0x70, 0x70, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0xE3,
  0xC0, 0x01, 0xE3, 0x80, 0x1C, 0x78, 0x00, 0x3C, 0x70, 0x03, 0x8E, 0x00,
  0x07, 0x9E, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x00, 0x0E,
  0x70, 0x00, 0xEF, 0x00, 0x01, 0xCE, 0x00, 0x1D, 0xE0, 0x00, 0x3D, 0xC0,
  0x03, 0xB8, 0x00, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0x80,
  0x07, 0x8F, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xE0, 0x0E,
  0x03, 0x80, 0x78, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x70, 0x3C, 0x01,
  0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0x73,
  0xC0, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x0F, 0x3C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x07, 0x80,
  0x1C, 0x0E, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x1E, 0x01, 0xC0, 0x78,
  0x07, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x01,
  0xC7, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0x87, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x1C,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x0F, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xF0,
  0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x70,
  0x1C, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xC7, 0xC0, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x03, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7E, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03,
  0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3E, 0xE0, 0x07, 0xDE, 0x01, 0xBB, 0xE0, 0x77,
  0x3E, 0x1C, 0xE3, 0xFF, 0x1C, 0x3F, 0xC3, 0x80, 0xC0, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0x80, 0x3C, 0x3F, 0xC0, 0xF3, 0xFF, 0x83, 0xDF, 0xBF, 0x0F,
  0x70, 0x1E, 0x3F, 0x00, 0x38, 0xFC, 0x00, 0xF3, 0xE0, 0x01, 0xCF, 0x80,
  0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x1E,
  0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0x3F, 0x00, 0x3C, 0xFE,
  0x01, 0xE3, 0xDC, 0x0F, 0x8E, 0x7E, 0xFC, 0x38, 0xFF, 0xE0, 0xE0, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFD,
  0xE1, 0xF0, 0x11, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0x0F, 0xEF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0,
  0xE0, 0xFF, 0x87, 0x0F, 0xFE, 0x38, 0xFE, 0xF9, 0xC7, 0x80, 0xEE, 0x78,
  0x03, 0x73, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x01, 0xEE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDE,
  0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x1B, 0x9F, 0x01, 0xDC, 0x7E, 0x7C,
  0xE1, 0xFF, 0xC7, 0x07, 0xFC, 0x38, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x1E, 0x07, 0x83, 0xC0, 0x3C,
  0x38, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x21, 0xF0, 0x0E, 0x0F, 0xE7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0x80, 0x07, 0x80, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x3C, 0x10, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xF0, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0xE1, 0xC3, 0xFF, 0x8E, 0x3F, 0xBE, 0x71, 0xE0, 0x3B,
  0x9E, 0x00, 0xDC, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0x7B, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x01,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x5C, 0xF0, 0x06, 0xE3, 0xC0, 0x67, 0x1F,
  0xDF, 0x38, 0x7F, 0xF1, 0xC1, 0xFF, 0x0E, 0x01, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x20, 0x00, 0xF1,
  0xC0, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x07, 0x8F,
  0xF8, 0xF3, 0xFF, 0x9E, 0xFF, 0xFB, 0xDC, 0x0F, 0x7F, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x77, 0xBF, 0xFF, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xC0, 0x07, 0x07, 0x83, 0xE1, 0xF0, 0xF0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x9F, 0xCF, 0xC7, 0xC0,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x1E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x0F,
  0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x1E,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x3D,
  0xF8, 0x07, 0xF7, 0x80, 0xFE, 0xF0, 0x1F, 0x8E, 0x03, 0xE1, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0xC1, 0xE0, 0x38, 0x3C, 0x07, 0x07, 0x80, 0xF0, 0xF0,
  0x0E, 0x1E, 0x01, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x07, 0x3C, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0xE0, 0x70, 0xFF, 0x03, 0xFE, 0x38, 0xFF, 0xC3, 0xFF, 0x9C, 0xFB,
  0xF1, 0xE7, 0xCE, 0x60, 0x79, 0xC0, 0xF7, 0x60, 0x1D, 0xC0, 0x7B, 0xE0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0xF8,
  0x00, 0xF0, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x7F,
  0x00, 0x1E, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0x1F, 0xC0, 0x07, 0x00, 0x0F,
  0xE0, 0x03, 0x80, 0x07, 0xF0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x01,
  0xFC, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x1C, 0x00,
  0x3F, 0x80, 0x0E, 0x00, 0x1F, 0xC0, 0x07, 0x00, 0x0F, 0xE0, 0x03, 0x80,
  0x07, 0xF0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x70,
  0x00, 0xFE, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x0E,
  0x00, 0x1F, 0xC0, 0x07, 0x00, 0x0F, 0xE0, 0x03, 0x80, 0x07, 0xF0, 0x01,
  0xC0, 0x03, 0xF8, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x3C, 0x1C, 0x3F, 0xE3, 0x8F, 0xFE, 0x73, 0xE7, 0xEE, 0x70, 0x3D, 0xD8,
  0x03, 0xFB, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xE0, 0x3C,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x73, 0x80,
  0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x00,
  0xE7, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x0F,
  0xDF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0x83, 0xFC, 0x0E, 0x3F, 0xF8, 0x38, 0xF3, 0xF0, 0xE7, 0x01, 0xE3,
  0xB8, 0x03, 0xCE, 0xC0, 0x0F, 0x3E, 0x00, 0x1C, 0xF8, 0x00, 0x7B, 0xE0,
  0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x80, 0x07,
  0xBE, 0x00, 0x1C, 0xF8, 0x00, 0xF3, 0xF0, 0x03, 0xCF, 0xE0, 0x1E, 0x3D,
  0xC0, 0xF8, 0xF3, 0xFF, 0xC3, 0xCF, 0xFE, 0x0F, 0x0F, 0xF0, 0x3C, 0x06,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE1, 0xC3, 0xFF, 0x8E,
  0x3F, 0xBE, 0x71, 0xE0, 0x3B, 0x9E, 0x00, 0xDC, 0xF0, 0x03, 0xEF, 0x00,
  0x1F, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xDC, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x9C, 0x00, 0x5C, 0xF0,
  0x06, 0xE3, 0xC0, 0x67, 0x1F, 0xDF, 0x38, 0x7F, 0xF1, 0xC1, 0xFF, 0x0E,
  0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x33, 0x87, 0xFE, 0x3F, 0xB8, 0xFE, 0xE7,
  0x03, 0x98, 0x0E, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0xE7, 0xE3, 0xE7, 0xC0, 0x33, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3A, 0x00, 0x3D,
  0xC0, 0x3E, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x30, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xB8, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x0D, 0xCF, 0x03, 0xB9, 0xFF,
  0xE7, 0x1F, 0xFC, 0x61, 0xFE, 0x0C, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x7B,
  0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x0F, 0x1C, 0x00,
  0x78, 0xE0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0x6E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xFF,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x0E, 0x70, 0x03, 0xF0, 0x03,
  0x9C, 0x00, 0xFC, 0x00, 0xE7, 0x00, 0x3F, 0x00, 0x79, 0xE0, 0x1C, 0xC0,
  0x1C, 0x78, 0x07, 0x38, 0x07, 0x0E, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0x73,
  0x80, 0x70, 0xE0, 0x1C, 0xE0, 0x3C, 0x3C, 0x0E, 0x3C, 0x0E, 0x07, 0x03,
  0x87, 0x03, 0x81, 0xC0, 0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x70, 0x38, 0x1E,
  0x0E, 0x1C, 0x1E, 0x07, 0x87, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0xE1, 0xC0,
  0x38, 0x70, 0x38, 0x70, 0x0E, 0x1C, 0x0E, 0x3C, 0x03, 0xC7, 0x03, 0x8E,
  0x00, 0x73, 0x80, 0x73, 0x80, 0x1C, 0xE0, 0x1C, 0xE0, 0x07, 0x38, 0x07,
  0x38, 0x01, 0xCE, 0x01, 0xDE, 0x00, 0x7B, 0x80, 0x77, 0x00, 0x0F, 0xC0,
  0x0D, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x1E, 0x38, 0x01, 0xE3,
  0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0xF0, 0x70,
  0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xDC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xDC, 0x00, 0x39, 0xC0, 0x07,
  0x9E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x81,
  0xE0, 0x38, 0x1C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1E,
  0x70, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0x9C, 0x00,
  0x3C, 0xE0, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0x70, 0xE0, 0x07, 0x87,
  0x00, 0x3C, 0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x38, 0x07,
  0x81, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x1E, 0x01, 0xC0, 0xF0, 0x0E,
  0x07, 0x00, 0x78, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xE0,
  0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x1E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x02, 0x7F, 0xC0, 0x07, 0xFF, 0xE0,
  0x3F, 0x87, 0xF9, 0xFC, 0x03, 0xFF, 0xD0, 0x01, 0xFF, 0x20, 0x00, 0x70,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 46, 14, 4, -46 },
  { 30, 14, 17, 22, 4, -46 },
  { 60, 26, 46, 28, 1, -46 },
  { 210, 22, 53, 26, 2, -49 },
  { 356, 34, 47, 40, 3, -46 },
  { 556, 26, 47, 28, 2, -46 },
  { 709, 4, 17, 12, 4, -46 },
  { 718, 13, 56, 18, 3, -46 },
  { 809, 13, 56, 18, 2, -46 },
  { 900, 18, 19, 24, 3, -49 },
  { 943, 23, 30, 27, 2, -38 },
  { 1030, 7, 15, 13, 2, -7 },
  { 1044, 13, 3, 17, 2, -19 },
  { 1049, 5, 6, 13, 4, -6 },
  { 1053, 20, 46, 22, 1, -46 },
  { 1168, 20, 47, 26, 3, -46 },
  { 1286, 13, 46, 26, 4, -46 },
  { 1361, 21, 46, 26, 2, -46 },
  { 1482, 21, 47, 26, 2, -46 },
  { 1606, 25, 46, 26, 1, -46 },
  { 1750, 21, 47, 26, 3, -46 },
  { 1874, 21, 47, 26, 3, -46 },
  { 1998, 22, 46, 26, 2, -46 },
  { 2125, 22, 47, 26, 2, -46 },
  { 2255, 21, 47, 26, 2, -46 },
  { 2379, 5, 34, 13, 4, -34 },
  { 2401, 7, 42, 13, 2, -34 },
  { 2438, 23, 27, 27, 2, -36 },
  { 2516, 23, 17, 27, 2, -31 },
  { 2565, 23, 27, 27, 2, -36 },
  { 2643, 16, 46, 19, 1, -46 },
  { 2735, 34, 52, 40, 3, -46 },
  { 2956, 27, 46, 27, 0, -46 },
  { 3112, 22, 46, 29, 5, -46 },
  { 3239, 23, 47, 28, 3, -46 },
  { 3375, 23, 46, 32, 5, -46 },
  { 3508, 17, 46, 25, 5, -46 },
  { 3606, 17, 46, 23, 5, -46 },
  { 3704, 28, 47, 34, 3, -46 },
  { 3869, 23, 46, 33, 5, -46 },
  { 4002, 12, 46, 16, 2, -46 },
  { 4071, 11, 58, 13, -3, -46 },
  { 4151, 22, 46, 26, 5, -46 },
  { 4278, 17, 46, 23, 5, -46 },
  { 4376, 34, 46, 44, 5, -46 },
  { 4572, 25, 46, 34, 5, -46 },
  { 4716, 28, 47, 34, 3, -46 },
  { 4881, 20, 46, 27, 5, -46 },
  { 4996, 28, 57, 34, 3, -46 },
  { 5196, 22, 46, 28, 5, -46 },
  { 5323, 20, 47, 26, 3, -46 },
  { 5441, 21, 46, 23, 1, -46 },
  { 5562, 24, 47, 32, 4, -46 },
  { 5703, 26, 46, 26, 0, -46 },
  { 5853, 43, 46, 44, 0, -46 },
  { 6101, 22, 46, 23, 1, -46 },
  { 6228, 23, 46, 23, 0, -46 },
  { 6361, 19, 46, 22, 2, -46 },
  { 6471, 13, 56, 20, 5, -46 },
  { 6562, 20, 46, 22, 1, -46 },
  { 6677, 13, 56, 20, 2, -46 },
  { 6768, 25, 23, 27, 1, -46 },
  { 6840, 27, 2, 27, 0, 6 },
  { 6847, 10, 10, 16, 3, -49 },
  { 6860, 19, 36, 25, 2, -35 },
  { 6946, 22, 50, 28, 4, -49 },
  { 7084, 17, 36, 21, 3, -35 },
  { 7161, 21, 50, 28, 3, -49 },
  { 7293, 20, 36, 26, 3, -35 },
  { 7383, 15, 49, 15, 1, -49 },
  { 7475, 21, 50, 28, 3, -35 },
  { 7607, 19, 49, 28, 4, -49 },
  { 7724, 5, 47, 12, 4, -47 },
  { 7754, 9, 62, 12, 0, -47 },
  { 7824, 19, 49, 23, 4, -49 },
  { 7941, 4, 49, 12, 4, -49 },
  { 7966, 33, 35, 41, 4, -35 },
  { 8111, 19, 35, 28, 4, -35 },
  { 8195, 21, 36, 27, 3, -35 },
  { 8290, 22, 50, 28, 4, -35 },
  { 8428, 21, 50, 28, 3, -35 },
  { 8560, 14, 35, 18, 4, -35 },
  { 8622, 17, 36, 21, 2, -35 },
  { 8699, 13, 43, 15, 1, -42 },
  { 8769, 19, 35, 28, 4, -34 },
  { 8853, 21, 34, 21, 0, -34 },
  { 8943, 34, 34, 36, 1, -34 },
  { 9088, 20, 34, 22, 1, -34 },
  { 9173, 21, 49, 22, 1, -34 },
  { 9302, 15, 34, 18, 2, -34 },
  { 9366, 17, 56, 23, 3, -46 },
  { 9485, 3, 64, 25, 11, -49 },
  { 9509, 17, 56, 23, 3, -46 },
  { 9628, 23, 7, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Light64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT64PT7B_H_
