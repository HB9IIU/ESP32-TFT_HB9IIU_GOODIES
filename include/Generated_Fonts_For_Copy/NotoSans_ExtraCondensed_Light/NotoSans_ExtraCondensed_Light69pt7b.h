#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70,
  0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x30,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x18,
  0x3C, 0x3C, 0x18, 0x04, 0x38, 0x18, 0x00, 0x78, 0x18, 0x00, 0x70, 0x18,
  0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0xF0, 0x18, 0x00, 0xF0, 0x18,
  0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0x78, 0x18, 0x00, 0x78, 0x18,
  0x00, 0x3C, 0x18, 0x00, 0x3E, 0x18, 0x00, 0x1F, 0x98, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x1B, 0xF0, 0x00, 0x18, 0xF8, 0x00, 0x18, 0x7C, 0x00, 0x18,
  0x3E, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x0F, 0x00, 0x18,
  0x0F, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18,
  0x0F, 0x00, 0x18, 0x0F, 0x00, 0x18, 0x1E, 0x00, 0x18, 0x1E, 0x60, 0x18,
  0x3C, 0x7C, 0x18, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x07, 0xFC, 0x00, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0xF0, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x00, 0xF0,
  0x1C, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x38, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x0F,
  0x03, 0x80, 0x03, 0x80, 0x78, 0x3C, 0x00, 0x1C, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0x1E, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x07, 0x87,
  0x00, 0x01, 0xC0, 0x38, 0x38, 0x00, 0x0E, 0x01, 0xC3, 0xC3, 0xF0, 0x70,
  0x0E, 0x1C, 0x3F, 0xC3, 0xC0, 0x70, 0xE1, 0xEF, 0x0E, 0x03, 0x8F, 0x1C,
  0x3C, 0x70, 0x1C, 0x71, 0xE0, 0xE3, 0x81, 0xC3, 0x8E, 0x07, 0x8E, 0x0E,
  0x3C, 0x70, 0x1C, 0x78, 0xE1, 0xC3, 0x80, 0xE1, 0xFF, 0x0E, 0x3C, 0x07,
  0x07, 0xF0, 0xE1, 0xC0, 0x38, 0x1F, 0x07, 0x0E, 0x01, 0xE0, 0x00, 0x38,
  0x70, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x78, 0x00, 0x1C, 0x1C, 0x03, 0xC0,
  0x00, 0xE0, 0xE0, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x38,
  0x07, 0x80, 0x03, 0x81, 0xC0, 0x3C, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x01,
  0xC0, 0x70, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1E, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x1C, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x00, 0x1E, 0x78, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70,
  0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x1E, 0x01, 0xC3,
  0xC0, 0xE0, 0x3C, 0x38, 0x0F, 0x03, 0xC7, 0x80, 0x78, 0x3C, 0x78, 0x07,
  0x83, 0xC7, 0x00, 0x3C, 0x38, 0xF0, 0x03, 0xC3, 0x8F, 0x00, 0x1E, 0x78,
  0xF0, 0x00, 0xE7, 0x8F, 0x00, 0x0F, 0x70, 0xF0, 0x00, 0x7F, 0x0F, 0x00,
  0x07, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x07, 0xF0, 0x78, 0x00, 0xF7, 0x83, 0xC0, 0x1E, 0x78, 0x3E,
  0x07, 0xE3, 0xC1, 0xFF, 0xFC, 0x3C, 0x0F, 0xFF, 0x01, 0xE0, 0x7F, 0xE0,
  0x1F, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x0E, 0x0E, 0xFC, 0x67, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0x9C,
  0x00, 0x71, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xF0, 0x3C, 0x07, 0x81, 0xC0,
  0x38, 0x08, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x3C, 0x79, 0xE3,
  0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE3, 0x8F, 0x1C, 0x38, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0x03, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x38, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x87, 0xDC, 0x7C, 0xE7, 0xC7, 0x7C, 0x3F, 0xC1, 0xDC, 0x0E, 0x40,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x78, 0x03, 0xE1, 0xC0, 0x07, 0xC2, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0xFF, 0x03, 0xFE, 0x7F, 0x8F, 0xC0, 0x1F, 0x0E, 0x00, 0x1F,
  0x08, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x88, 0x00, 0x1F, 0x1E, 0x00, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x1E,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x38, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x7E, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x08, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0xC0, 0x03, 0xE3, 0xC0, 0x1F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x70, 0xFF, 0x83, 0xC7, 0xFF, 0x0F, 0x3F, 0xFE, 0x3D, 0xE0, 0x7C, 0xF6,
  0x00, 0xF3, 0xF0, 0x01, 0xEF, 0xC0, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x77, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xE0, 0x00,
  0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xE3, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38,
  0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x0F,
  0x00, 0x78, 0x0F, 0x80, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3E, 0x03, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0x73, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0xFD, 0xE0,
  0x03, 0xF3, 0xC0, 0x1F, 0xCF, 0xC1, 0xEF, 0x1F, 0xFF, 0x3C, 0x3F, 0xF8,
  0xF0, 0x7F, 0xC3, 0xC0, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x04, 0x03, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x79,
  0xFF, 0xFF, 0xFD, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x7F,
  0xFF, 0xDF, 0x78, 0x1C, 0x7C, 0xFB, 0xF3, 0xE7, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7,
  0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xF9, 0xFC, 0x60, 0x1F, 0x10, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x0E,
  0x70, 0x03, 0xFF, 0x80, 0xE7, 0x00, 0x78, 0x38, 0x0E, 0x70, 0x0F, 0x03,
  0x80, 0xEF, 0x00, 0xE0, 0x38, 0x0F, 0xF0, 0x1E, 0x07, 0x80, 0xFE, 0x01,
  0xC0, 0x78, 0x07, 0xE0, 0x3C, 0x07, 0x80, 0x7E, 0x03, 0xC0, 0x78, 0x07,
  0xE0, 0x38, 0x07, 0x80, 0x7E, 0x03, 0x80, 0x78, 0x07, 0xE0, 0x38, 0x07,
  0x80, 0x7E, 0x03, 0x80, 0x78, 0x07, 0xE0, 0x38, 0x07, 0x80, 0x7E, 0x03,
  0x80, 0x70, 0x07, 0xE0, 0x38, 0x07, 0x00, 0x7E, 0x03, 0x80, 0x70, 0x0F,
  0xE0, 0x38, 0x07, 0x00, 0xFE, 0x03, 0x80, 0xF0, 0x0E, 0xE0, 0x38, 0x0F,
  0x00, 0xEE, 0x03, 0xC0, 0xF0, 0x0E, 0xE0, 0x3C, 0x0F, 0x81, 0xEE, 0x01,
  0xC1, 0xD8, 0x1C, 0xE0, 0x1E, 0x39, 0xC3, 0xCF, 0x00, 0xFF, 0x9F, 0xF8,
  0x70, 0x07, 0xF0, 0xFF, 0x07, 0x00, 0x3E, 0x07, 0xE0, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF8, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x01,
  0xF0, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0xF8, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x06, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0x03, 0xF8, 0x06, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0xF0,
  0x01, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8,
  0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x03, 0xF0,
  0x3C, 0x1F, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0x80, 0x1F, 0x03, 0xF0, 0x00, 0x10, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0xF0,
  0x7C, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x3C, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC1, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE8, 0x3E, 0xFF, 0xCF,
  0xFC, 0xFF, 0x83, 0xC0, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0,
  0x00, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF3, 0xE0,
  0x00, 0xF7, 0xE0, 0x00, 0xF7, 0xF0, 0x00, 0xFE, 0xF0, 0x00, 0xFE, 0x78,
  0x00, 0xFC, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xDF, 0xFC, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0x00, 0xF7, 0xF7,
  0x00, 0x00, 0x07, 0xBF, 0xBC, 0x00, 0x00, 0x39, 0xFD, 0xE0, 0x00, 0x03,
  0xDF, 0xE7, 0x00, 0x00, 0x1E, 0xFF, 0x38, 0x00, 0x00, 0xE7, 0xF9, 0xE0,
  0x00, 0x07, 0x3F, 0xC7, 0x00, 0x00, 0x79, 0xFE, 0x38, 0x00, 0x03, 0x8F,
  0xF1, 0xE0, 0x00, 0x1C, 0x7F, 0x8F, 0x00, 0x01, 0xE3, 0xFC, 0x38, 0x00,
  0x0F, 0x1F, 0xE1, 0xC0, 0x00, 0x70, 0xFF, 0x0F, 0x00, 0x07, 0x87, 0xF8,
  0x38, 0x00, 0x3C, 0x3F, 0xC1, 0xC0, 0x01, 0xC1, 0xFE, 0x0F, 0x00, 0x0E,
  0x0F, 0xF0, 0x78, 0x00, 0xF0, 0x7F, 0x81, 0xC0, 0x07, 0x83, 0xFC, 0x0F,
  0x00, 0x38, 0x1F, 0xE0, 0x78, 0x03, 0xC0, 0xFF, 0x01, 0xC0, 0x1E, 0x07,
  0xF8, 0x0E, 0x00, 0xE0, 0x3F, 0xC0, 0x78, 0x07, 0x01, 0xFE, 0x01, 0xC0,
  0x78, 0x0F, 0xF0, 0x0E, 0x03, 0x80, 0x7F, 0x80, 0x78, 0x1C, 0x03, 0xFC,
  0x03, 0xC1, 0xE0, 0x1F, 0xE0, 0x0E, 0x0F, 0x00, 0xFF, 0x00, 0x78, 0x70,
  0x07, 0xF8, 0x03, 0xC7, 0x80, 0x3F, 0xC0, 0x0E, 0x3C, 0x01, 0xFE, 0x00,
  0x71, 0xC0, 0x0F, 0xF0, 0x03, 0xCE, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03,
  0xFC, 0x00, 0x77, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xF7, 0x80, 0x01, 0xFE, 0xF0, 0x00, 0x3F, 0xCE, 0x00, 0x07, 0xF9, 0xE0,
  0x00, 0xFF, 0x1C, 0x00, 0x1F, 0xE3, 0xC0, 0x03, 0xFC, 0x78, 0x00, 0x7F,
  0x87, 0x80, 0x0F, 0xF0, 0xF0, 0x01, 0xFE, 0x0F, 0x00, 0x3F, 0xC1, 0xE0,
  0x07, 0xF8, 0x1C, 0x00, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0x78, 0x03, 0xFC,
  0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0xE0,
  0x3F, 0xC0, 0x1C, 0x07, 0xF8, 0x03, 0xC0, 0xFF, 0x00, 0x78, 0x1F, 0xE0,
  0x07, 0x83, 0xFC, 0x00, 0xF0, 0x7F, 0x80, 0x0F, 0x0F, 0xF0, 0x01, 0xE1,
  0xFE, 0x00, 0x1E, 0x3F, 0xC0, 0x03, 0xC7, 0xF8, 0x00, 0x38, 0xFF, 0x00,
  0x07, 0x9F, 0xE0, 0x00, 0xF3, 0xFC, 0x00, 0x0F, 0x7F, 0x80, 0x01, 0xEF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7C, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3C, 0x07, 0xF8, 0xF0,
  0x03, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03,
  0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x07, 0xE3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0xE0,
  0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0x00, 0x70, 0xF8, 0x00, 0x47, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF2, 0x00, 0x0F, 0xCF, 0x80, 0x7E,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xC7,
  0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x70, 0x00,
  0x3C, 0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1D, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x8E, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0xE0, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xC1, 0xC0, 0x0F, 0x00,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x0E, 0x01, 0xE0, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x00, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x3C,
  0x0E, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xF0, 0x00, 0x78,
  0x38, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x01, 0xE1,
  0xE0, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x0E, 0x1E, 0x00, 0x03, 0x87,
  0x00, 0x1C, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x00, 0xF7, 0x00, 0x07, 0x78, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x0F,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x03,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x01,
  0xE3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xC3, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xC0, 0x07,
  0x81, 0xE0, 0x07, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC1, 0xC0, 0x03,
  0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE7, 0x80, 0x00,
  0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00,
  0x70, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x1E, 0x01,
  0xC0, 0x01, 0xC0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x78, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xE0, 0x3E, 0x08, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xF8, 0x71, 0xF8, 0x07, 0x3E, 0x00, 0x73, 0xC0,
  0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF7,
  0x80, 0x1F, 0x7C, 0x03, 0x73, 0xC0, 0x77, 0x3F, 0x9E, 0x71, 0xFF, 0xC7,
  0x0F, 0xF8, 0x30, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x7F, 0x80, 0xE1, 0xFF, 0xC1, 0xC7, 0xFF, 0xC3, 0x9E, 0x0F, 0x87,
  0x70, 0x0F, 0x8E, 0xC0, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3B, 0x00, 0x3C, 0x77, 0x00, 0x78, 0xE7,
  0x03, 0xE1, 0xCF, 0xFF, 0xC3, 0x8F, 0xFF, 0x07, 0x07, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x02, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x10, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xFF, 0x0F, 0x07, 0xFF, 0x1E, 0x1F, 0xFF, 0x3C, 0x7E, 0x0F, 0x78, 0xF0,
  0x07, 0xF3, 0xE0, 0x07, 0xE7, 0x80, 0x0F, 0xCE, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0x80,
  0x03, 0xE7, 0x80, 0x0F, 0xCF, 0x00, 0x1B, 0x9F, 0x00, 0x77, 0x1F, 0x01,
  0xCE, 0x1F, 0xFF, 0x1C, 0x1F, 0xFC, 0x38, 0x1F, 0xF0, 0x70, 0x07, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xC0, 0xF0,
  0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x1C, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00,
  0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x10, 0x3E, 0x01, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7E, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x01, 0xFE, 0x0E, 0x0F, 0xFE, 0x1C, 0x3F, 0xFE, 0x38,
  0xFC, 0x1E, 0x71, 0xE0, 0x0F, 0xE7, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0xBC,
  0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF7,
  0x80, 0x03, 0xEF, 0x00, 0x07, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x1E,
  0x00, 0xDE, 0x3E, 0x03, 0xBC, 0x3F, 0xFE, 0x78, 0x3F, 0xF8, 0xF0, 0x3F,
  0xE1, 0xE0, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x60, 0x00, 0xF8,
  0xF0, 0x07, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xF0, 0xE1, 0xFF, 0x8E, 0x3F, 0xFC,
  0xE7, 0x87, 0xEE, 0xE0, 0x1E, 0xEC, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x23, 0xFF, 0xFF, 0xBC, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x02, 0x03, 0xC3,
  0xE1, 0xF0, 0xF8, 0x3C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x3E, 0xFE, 0x7F, 0x3F,
  0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0,
  0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x0E,
  0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x1E, 0x00,
  0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE3, 0xE0, 0x0E, 0x7E, 0x00, 0xEF, 0xF0,
  0x0E, 0xEF, 0x00, 0xFC, 0x70, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x03,
  0xC0, 0xE0, 0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xE0,
  0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0x8E,
  0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xFE, 0x01, 0xFE,
  0x1C, 0x7F, 0xE0, 0x7F, 0xE3, 0x9F, 0xFE, 0x1F, 0xFE, 0x73, 0x83, 0xE7,
  0x07, 0xCE, 0xC0, 0x3D, 0xC0, 0x7D, 0xD8, 0x07, 0xB0, 0x07, 0xBE, 0x00,
  0x7E, 0x00, 0x77, 0xC0, 0x0F, 0x80, 0x0F, 0xF0, 0x01, 0xF0, 0x01, 0xFE,
  0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0x70, 0x00,
  0xFF, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x38,
  0x00, 0x7F, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x1C, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x00, 0x70, 0x00, 0xFE,
  0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x38, 0x00,
  0x7F, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x1C,
  0x00, 0x3F, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x00, 0x70, 0x00, 0xFE, 0x00,
  0x0E, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x7F,
  0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x1C, 0x00,
  0x3F, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x0E,
  0x00, 0x1E, 0xE0, 0xFF, 0x0E, 0x3F, 0xF8, 0xE7, 0xFF, 0xCE, 0x70, 0x3E,
  0xEE, 0x01, 0xEE, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7C, 0x1F, 0x81, 0xE0,
  0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xCF, 0x00,
  0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3E, 0x03,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0xFF, 0x01, 0xC3, 0xFF, 0x83, 0x8F, 0xFF, 0x87, 0x38, 0x1F,
  0x0E, 0xE0, 0x1F, 0x1D, 0x80, 0x1F, 0x3F, 0x00, 0x1E, 0x7C, 0x00, 0x3C,
  0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x80, 0x03,
  0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x76, 0x00, 0x78, 0xEE, 0x01, 0xF1,
  0xCE, 0x07, 0xC3, 0x9F, 0xFF, 0x87, 0x1F, 0xFE, 0x0E, 0x0F, 0xF0, 0x1C,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x0E, 0x0F, 0xFE, 0x1C, 0x3F, 0xFE, 0x38, 0x7C, 0x1E, 0x71, 0xF0, 0x0C,
  0xE7, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x3E,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07,
  0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x1E, 0x00, 0xDE, 0x3E, 0x03, 0xBC,
  0x3F, 0xFE, 0x78, 0x3F, 0xF8, 0xF0, 0x3F, 0xE1, 0xE0, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0xE0, 0xFF, 0x87, 0xFE, 0x3F,
  0xF9, 0xF6, 0xE7, 0x03, 0xB8, 0x0E, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x0E, 0x7C, 0x00, 0x9E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x07, 0xBC, 0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xC0, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x37, 0x78, 0x07, 0x77, 0xC0, 0xE7,
  0x3F, 0xFE, 0x73, 0xFF, 0xC7, 0x0F, 0xF0, 0x70, 0x1C, 0x00, 0xF0, 0x00,
  0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1D, 0xE0,
  0x01, 0xF0, 0x00, 0xE7, 0x00, 0x1F, 0x80, 0x0F, 0x38, 0x00, 0xEE, 0x00,
  0x79, 0xE0, 0x07, 0x70, 0x03, 0xCF, 0x00, 0x3B, 0x80, 0x1C, 0x78, 0x01,
  0xDC, 0x00, 0xE1, 0xC0, 0x1E, 0xE0, 0x0F, 0x0F, 0x00, 0xE7, 0x80, 0x78,
  0x78, 0x07, 0x1C, 0x03, 0x83, 0xC0, 0x38, 0xE0, 0x1C, 0x0E, 0x01, 0xC7,
  0x01, 0xE0, 0x70, 0x1E, 0x38, 0x0F, 0x03, 0xC0, 0xE1, 0xE0, 0x78, 0x1E,
  0x07, 0x07, 0x03, 0x80, 0xF0, 0x38, 0x38, 0x1C, 0x03, 0x83, 0xC1, 0xC1,
  0xE0, 0x1C, 0x1E, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0x78, 0x70, 0x07, 0x87,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x71, 0xE0,
  0x07, 0x1E, 0x03, 0x8F, 0x00, 0x3C, 0xE0, 0x1E, 0x70, 0x01, 0xE7, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x1D, 0xE0, 0x01,
  0xDC, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F,
  0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xCF,
  0x00, 0x07, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x1C,
  0x00, 0x78, 0x78, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x1E, 0x07, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3,
  0x80, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xC0,
  0x0F, 0x07, 0x00, 0x38, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x1E,
  0x03, 0x80, 0x70, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x70, 0x3C, 0x01,
  0xC0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFF, 0x1F, 0xE1, 0xFE, 0x01,
  0xFF, 0xF6, 0x00, 0x3F, 0xF2, 0x00, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 49, 15, 5, -49 },
  { 32, 15, 18, 23, 4, -49 },
  { 66, 28, 49, 31, 1, -49 },
  { 238, 24, 56, 28, 2, -52 },
  { 406, 37, 51, 43, 3, -50 },
  { 642, 28, 51, 30, 2, -50 },
  { 821, 5, 18, 13, 4, -49 },
  { 833, 14, 60, 19, 3, -49 },
  { 938, 14, 60, 19, 2, -49 },
  { 1043, 20, 21, 25, 3, -53 },
  { 1096, 25, 32, 29, 2, -40 },
  { 1196, 7, 16, 14, 3, -7 },
  { 1210, 15, 4, 19, 2, -21 },
  { 1218, 6, 6, 14, 4, -6 },
  { 1223, 21, 49, 24, 2, -49 },
  { 1352, 22, 51, 28, 3, -50 },
  { 1493, 13, 49, 28, 5, -49 },
  { 1573, 22, 50, 28, 3, -50 },
  { 1711, 23, 51, 28, 2, -50 },
  { 1858, 27, 50, 28, 1, -50 },
  { 2027, 22, 50, 28, 3, -49 },
  { 2165, 22, 51, 28, 3, -50 },
  { 2306, 22, 49, 28, 3, -49 },
  { 2441, 24, 51, 28, 2, -50 },
  { 2594, 22, 51, 28, 3, -50 },
  { 2735, 6, 37, 14, 4, -37 },
  { 2763, 7, 46, 14, 3, -37 },
  { 2804, 25, 29, 29, 2, -39 },
  { 2895, 25, 18, 29, 2, -33 },
  { 2952, 25, 29, 29, 2, -39 },
  { 3043, 18, 50, 20, 1, -50 },
  { 3156, 36, 56, 43, 4, -50 },
  { 3408, 29, 49, 29, 0, -49 },
  { 3586, 24, 49, 31, 5, -49 },
  { 3733, 24, 51, 30, 4, -50 },
  { 3886, 26, 49, 34, 5, -49 },
  { 4046, 19, 49, 27, 5, -49 },
  { 4163, 19, 49, 25, 5, -49 },
  { 4280, 29, 51, 37, 4, -50 },
  { 4465, 25, 49, 35, 5, -49 },
  { 4619, 13, 49, 17, 2, -49 },
  { 4699, 12, 62, 14, -3, -49 },
  { 4792, 24, 49, 29, 5, -49 },
  { 4939, 18, 49, 25, 5, -49 },
  { 5050, 37, 49, 47, 5, -49 },
  { 5277, 27, 49, 37, 5, -49 },
  { 5443, 29, 51, 37, 4, -50 },
  { 5628, 22, 49, 29, 5, -49 },
  { 5763, 29, 62, 37, 4, -50 },
  { 5988, 24, 49, 30, 5, -49 },
  { 6135, 22, 51, 28, 3, -50 },
  { 6276, 23, 49, 25, 1, -49 },
  { 6417, 25, 50, 35, 5, -49 },
  { 6574, 28, 49, 28, 0, -49 },
  { 6746, 47, 49, 47, 0, -49 },
  { 7034, 24, 49, 25, 1, -49 },
  { 7181, 24, 49, 24, 0, -49 },
  { 7328, 20, 49, 24, 2, -49 },
  { 7451, 14, 60, 21, 5, -49 },
  { 7556, 21, 49, 24, 2, -49 },
  { 7685, 14, 60, 21, 2, -49 },
  { 7790, 27, 25, 29, 1, -49 },
  { 7875, 29, 3, 29, 0, 6 },
  { 7886, 11, 11, 17, 3, -53 },
  { 7902, 20, 38, 27, 2, -37 },
  { 7997, 23, 53, 31, 5, -52 },
  { 8150, 18, 38, 23, 3, -37 },
  { 8236, 23, 53, 31, 3, -52 },
  { 8389, 22, 38, 28, 3, -37 },
  { 8494, 17, 53, 16, 1, -53 },
  { 8607, 23, 54, 31, 3, -37 },
  { 8763, 20, 52, 30, 5, -52 },
  { 8893, 5, 51, 13, 4, -51 },
  { 8925, 9, 68, 13, 0, -51 },
  { 9002, 20, 52, 25, 5, -52 },
  { 9132, 3, 52, 13, 5, -52 },
  { 9152, 35, 37, 45, 5, -37 },
  { 9314, 20, 37, 30, 5, -37 },
  { 9407, 23, 38, 29, 3, -37 },
  { 9517, 23, 53, 31, 5, -37 },
  { 9670, 23, 53, 31, 3, -37 },
  { 9823, 14, 37, 20, 5, -37 },
  { 9888, 18, 38, 23, 2, -37 },
  { 9974, 14, 46, 16, 1, -45 },
  { 10055, 20, 38, 30, 5, -37 },
  { 10150, 23, 37, 23, 0, -37 },
  { 10257, 37, 37, 39, 1, -37 },
  { 10429, 22, 37, 24, 1, -37 },
  { 10531, 22, 54, 24, 1, -37 },
  { 10680, 16, 37, 19, 2, -37 },
  { 10754, 18, 60, 24, 3, -49 },
  { 10889, 3, 69, 27, 12, -53 },
  { 10915, 18, 60, 24, 3, -49 },
  { 11050, 25, 7, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Light69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT69PT7B_H_
