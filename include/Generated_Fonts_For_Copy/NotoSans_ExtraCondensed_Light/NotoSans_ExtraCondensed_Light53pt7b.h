#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xE6, 0x66, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0E, 0xE0, 0xE6, 0x0E, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x06, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x70,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x81, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x30,
  0x03, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x83, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x07, 0x00,
  0x30, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0xE3, 0xCC,
  0x71, 0xC3, 0x04, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00,
  0xE0, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0x70, 0xC0, 0x0E,
  0x30, 0x03, 0xEC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x03, 0x7C, 0x00, 0xC7, 0x80, 0x30, 0xE0, 0x0C, 0x1C, 0x03, 0x07,
  0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0xA0,
  0x30, 0xEC, 0x0C, 0x73, 0xFB, 0xF8, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0x80,
  0x1C, 0x01, 0xFC, 0x00, 0xE0, 0x0C, 0x70, 0x06, 0x00, 0xE1, 0x80, 0x70,
  0x06, 0x0E, 0x03, 0x80, 0x30, 0x30, 0x18, 0x01, 0x81, 0x81, 0xC0, 0x1C,
  0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x60, 0x07, 0x03, 0x87, 0x00, 0x38, 0x1C,
  0x30, 0x01, 0xC0, 0xE1, 0x80, 0x0E, 0x07, 0x1C, 0x00, 0x70, 0x38, 0xC0,
  0x03, 0x81, 0x86, 0x00, 0x1C, 0x0C, 0x71, 0xF0, 0x60, 0x63, 0x1F, 0xC3,
  0x03, 0x18, 0xC7, 0x18, 0x39, 0xCE, 0x18, 0xE1, 0x8C, 0x60, 0xE3, 0x9C,
  0x63, 0x03, 0x1F, 0xC7, 0x18, 0x18, 0x7C, 0x31, 0xC0, 0xC0, 0x01, 0x8E,
  0x06, 0x00, 0x1C, 0x70, 0x30, 0x00, 0xC3, 0x81, 0xC0, 0x06, 0x1C, 0x0E,
  0x00, 0x70, 0xE0, 0x70, 0x03, 0x07, 0x03, 0x00, 0x18, 0x38, 0x18, 0x01,
  0xC1, 0xC0, 0xC0, 0x0C, 0x06, 0x06, 0x00, 0x60, 0x30, 0x30, 0x07, 0x01,
  0x83, 0x80, 0x30, 0x0E, 0x18, 0x01, 0x80, 0x31, 0xC0, 0x1C, 0x01, 0xFC,
  0x00, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0x8E, 0x00,
  0x38, 0x70, 0x01, 0x81, 0x80, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x01,
  0xC3, 0x80, 0x06, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0xDC, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1C,
  0x70, 0x39, 0xC1, 0xC1, 0xCC, 0x0E, 0x0C, 0xE0, 0x38, 0xE7, 0x01, 0xC7,
  0x38, 0x07, 0x39, 0xC0, 0x39, 0xCE, 0x00, 0xFC, 0x70, 0x03, 0xE3, 0x80,
  0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0xC7, 0x80, 0x7E, 0x1C, 0x07, 0x38,
  0xF8, 0xF9, 0xC3, 0xFF, 0x87, 0x0F, 0xF0, 0x3C, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x38, 0x00, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x08, 0x18, 0x3E,
  0x33, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0x80, 0x0F, 0x80, 0x39, 0x80, 0x63,
  0x81, 0xC3, 0x87, 0x07, 0x86, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xE3, 0x1C, 0x71, 0xC6,
  0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xBF, 0xE7, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFC,
  0x03, 0xCF, 0x03, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0,
  0x0E, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x0C, 0x70, 0x0E, 0x38, 0x07, 0x1E, 0x07, 0x07, 0x03, 0x83, 0xE7,
  0x80, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x1F, 0xCF,
  0x77, 0x9F, 0xC7, 0xC1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0x1F, 0x8E,
  0x03, 0xC2, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0x1F, 0x9C, 0x01, 0xC4, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xA0, 0x03, 0xDE, 0x07, 0xCF, 0xFF, 0xC3, 0xFF, 0x80, 0x06,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x07, 0x70, 0x00, 0x67, 0x00,
  0x0E, 0x70, 0x00, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x38, 0x70,
  0x03, 0x07, 0x00, 0x70, 0x70, 0x06, 0x07, 0x00, 0xE0, 0x70, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xDF, 0x80, 0xFF, 0xF8,
  0x7F, 0xFE, 0x10, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x20, 0x0F, 0x1C, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x7E, 0x30, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x04, 0x01, 0x8F, 0xF0, 0x67, 0xFE, 0x1B,
  0x87, 0xC6, 0xC0, 0x73, 0xE0, 0x1C, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x01, 0x9C, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0x9C, 0x00, 0xE7, 0x00, 0x38, 0xC0, 0x0E, 0x38, 0x03, 0x8E,
  0x01, 0xC1, 0xC0, 0x70, 0x78, 0x78, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C,
  0x78, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0,
  0xE0, 0x38, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x1E, 0x3C, 0x0F, 0x07, 0x83, 0x80, 0x71, 0xC0, 0x1E, 0x70, 0x03, 0xB8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0x9C, 0x00, 0xE7, 0x80, 0x70, 0xF0, 0x7C,
  0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x07,
  0x8F, 0x07, 0x03, 0xC7, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x0E,
  0xE0, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xEF,
  0x01, 0xF3, 0xC1, 0xB8, 0xFF, 0xDC, 0x3F, 0xCE, 0x07, 0x87, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x04, 0x1F, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x77, 0xBE, 0xE7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xF7, 0xFC, 0xE0,
  0x39, 0xF7, 0xCE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C, 0xE3, 0x8E, 0x31, 0xC7, 0x18,
  0x63, 0x8C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xC7, 0xFF, 0x3C, 0x7C,
  0x80, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x02, 0x00, 0xE7,
  0x01, 0xFE, 0x0E, 0x60, 0x3F, 0xE0, 0x66, 0x03, 0x86, 0x06, 0xE0, 0x70,
  0x60, 0x6E, 0x06, 0x06, 0x07, 0xE0, 0xE0, 0xE0, 0x7C, 0x0E, 0x0E, 0x07,
  0xC0, 0xC0, 0xE0, 0x7C, 0x0C, 0x0E, 0x07, 0xC0, 0xC0, 0xE0, 0x7C, 0x0C,
  0x0E, 0x07, 0xC0, 0xC0, 0xE0, 0x7C, 0x0C, 0x0E, 0x07, 0xC0, 0xC0, 0xE0,
  0x6C, 0x0C, 0x0E, 0x06, 0xC0, 0xC0, 0xE0, 0xEC, 0x0E, 0x1E, 0x0E, 0xE0,
  0xE1, 0xE0, 0xCE, 0x07, 0x33, 0xBC, 0xE0, 0x3F, 0x3F, 0x86, 0x01, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x03, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1D, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0x60, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xC0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0x60, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x07,
  0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80,
  0x38, 0xE0, 0x3E, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0x83, 0xF8, 0xE0, 0x0F,
  0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x8F, 0x07, 0x80,
  0x21, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0x03, 0xE0, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x02, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x70, 0x1F, 0x0E, 0x00, 0xF1,
  0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x00, 0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x07, 0x9C, 0x01, 0xE3, 0x80, 0x78, 0x7F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xE0, 0x7F, 0x0F, 0xC3, 0xE0, 0x06, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCF, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xC1, 0xF8, 0x1F,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xE8, 0xF7, 0xFB, 0xF8, 0xF0, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x73,
  0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0xE0, 0xE0,
  0x38, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x38, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0xF8, 0x03,
  0xFE, 0x00, 0xFB, 0xC0, 0x3C, 0x70, 0x0F, 0x1E, 0x03, 0x83, 0x80, 0xE0,
  0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x07,
  0x0E, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x73,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1B, 0xFC,
  0x00, 0x03, 0xBE, 0xC0, 0x00, 0x3B, 0xEE, 0x00, 0x03, 0x3E, 0xE0, 0x00,
  0x73, 0xE6, 0x00, 0x07, 0x3E, 0x70, 0x00, 0x63, 0xE7, 0x00, 0x0E, 0x3E,
  0x70, 0x00, 0xE3, 0xE3, 0x00, 0x0E, 0x3E, 0x38, 0x00, 0xC3, 0xE3, 0x80,
  0x1C, 0x3E, 0x18, 0x01, 0xC3, 0xE1, 0xC0, 0x18, 0x3E, 0x1C, 0x03, 0x83,
  0xE0, 0xC0, 0x38, 0x3E, 0x0C, 0x03, 0x83, 0xE0, 0xE0, 0x30, 0x3E, 0x0E,
  0x07, 0x03, 0xE0, 0x60, 0x70, 0x3E, 0x07, 0x06, 0x03, 0xE0, 0x70, 0xE0,
  0x3E, 0x03, 0x0E, 0x03, 0xE0, 0x38, 0xC0, 0x3E, 0x03, 0x9C, 0x03, 0xE0,
  0x39, 0xC0, 0x3E, 0x01, 0x9C, 0x03, 0xE0, 0x1D, 0x80, 0x3E, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3E,
  0x00, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0xE0, 0x03, 0xEE,
  0x00, 0x3E, 0x70, 0x03, 0xE7, 0x00, 0x3E, 0x30, 0x03, 0xE3, 0x80, 0x3E,
  0x38, 0x03, 0xE1, 0xC0, 0x3E, 0x1C, 0x03, 0xE0, 0xE0, 0x3E, 0x0E, 0x03,
  0xE0, 0x70, 0x3E, 0x07, 0x03, 0xE0, 0x70, 0x3E, 0x03, 0x83, 0xE0, 0x38,
  0x3E, 0x01, 0xC3, 0xE0, 0x1C, 0x3E, 0x00, 0xE3, 0xE0, 0x0E, 0x3E, 0x00,
  0xE3, 0xE0, 0x07, 0x3E, 0x00, 0x73, 0xE0, 0x03, 0xBE, 0x00, 0x3B, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x7C, 0x07, 0x80,
  0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0xEF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0x70, 0x03, 0xC1,
  0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1C, 0x07, 0xCE, 0x00,
  0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x0F, 0x8F, 0xFF, 0x87, 0xFF,
  0x03, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x7C, 0x07, 0x80, 0x78, 0x1C, 0x00,
  0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xEF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xE0, 0x1E, 0x03,
  0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0x80, 0xF8, 0xE0, 0x0E, 0x38, 0x03, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38,
  0x07, 0x8E, 0x07, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0E, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0,
  0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0xE0, 0x0F, 0x38,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0x07,
  0xFE, 0x07, 0xFF, 0xC7, 0xE7, 0xC7, 0x80, 0x27, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xA0,
  0x07, 0x9F, 0x8F, 0xCF, 0xFF, 0xC3, 0xFF, 0x80, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x79, 0xE0, 0x0E, 0x1F, 0x07, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0C,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE6, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x77, 0x00,
  0x0F, 0x00, 0x07, 0x70, 0x00, 0xF0, 0x00, 0x67, 0x00, 0x0F, 0x00, 0x0E,
  0x70, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x0E, 0x38, 0x01, 0xF8,
  0x00, 0xE3, 0x80, 0x1F, 0x80, 0x1C, 0x38, 0x01, 0xD8, 0x01, 0xC3, 0x80,
  0x19, 0x80, 0x1C, 0x38, 0x01, 0x9C, 0x01, 0xC1, 0xC0, 0x39, 0xC0, 0x1C,
  0x1C, 0x03, 0x9C, 0x03, 0x81, 0xC0, 0x38, 0xC0, 0x38, 0x1C, 0x03, 0x0C,
  0x03, 0x81, 0xC0, 0x30, 0xE0, 0x38, 0x0E, 0x07, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0xE0, 0x70, 0x0E, 0x07, 0x06, 0x07, 0x00, 0xE0, 0x60, 0x60, 0x70,
  0x06, 0x06, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x70, 0x60, 0x07, 0x0E, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x30, 0xE0, 0x07, 0x0C, 0x03, 0x0E, 0x00, 0x30,
  0xC0, 0x38, 0xE0, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x39, 0xC0,
  0x03, 0x9C, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x19, 0xC0, 0x01, 0x98, 0x01,
  0x9C, 0x00, 0x1D, 0x80, 0x1D, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE7,
  0x00, 0x38, 0xE0, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x01,
  0xC6, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x6E, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0xE1, 0x80, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0xE0, 0x60, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x1C, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00,
  0x1D, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xFE, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xC0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x30, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x0C,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x38, 0x00, 0x77, 0x00, 0x0E,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x01, 0xD8, 0x00, 0x19, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x06, 0xE0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x3F, 0xF0, 0xFF,
  0xF1, 0xC0, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x03, 0xE0, 0xFF, 0xC7, 0xFF, 0x9E,
  0x07, 0x78, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1E, 0xE0, 0x6D, 0xE1, 0xD9, 0xFF, 0x31,
  0xFC, 0x60, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x1C, 0x0C, 0x7F, 0x86, 0x7F, 0xE3, 0x70, 0x79,
  0xB0, 0x1C, 0xD0, 0x07, 0x78, 0x03, 0xB8, 0x00, 0xDC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xED, 0x80, 0xE6, 0x60,
  0xF3, 0x3F, 0xF1, 0x8F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC7, 0x81, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF0, 0x43, 0xFF, 0x07, 0xFC, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x07, 0x07, 0x07, 0xF1, 0xC3, 0xFE, 0x71, 0xE0, 0xDC, 0xF0,
  0x1F, 0x38, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0xC0,
  0x07, 0x70, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x1F, 0x3C, 0x07,
  0xC7, 0x87, 0x70, 0xFF, 0x8C, 0x1F, 0xC3, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0x83, 0xC3, 0x80, 0xE1, 0xC0, 0x38, 0xC0,
  0x1C, 0xE0, 0x06, 0x70, 0x03, 0x38, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x87, 0xC1, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0,
  0x02, 0x00, 0x00, 0x80, 0x3F, 0xC3, 0xFC, 0x1C, 0x20, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F,
  0xE3, 0xFF, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x01,
  0xFE, 0x70, 0xFF, 0xDC, 0x78, 0x37, 0x3C, 0x07, 0xCE, 0x00, 0xF7, 0x00,
  0x3D, 0xC0, 0x0F, 0x70, 0x01, 0xDC, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF7, 0x00,
  0x3D, 0xC0, 0x0F, 0x38, 0x07, 0xCF, 0x01, 0x71, 0xE1, 0xDC, 0x3F, 0xE7,
  0x07, 0xF1, 0xC0, 0x60, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x90, 0x01, 0xC7, 0x01,
  0xF1, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x0F, 0x0C, 0x7F, 0x99, 0xFF, 0xB7, 0x0F,
  0x6C, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x6F,
  0xFF, 0x70, 0x00, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x0C, 0x3C, 0x78, 0xF0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x83,
  0x0E, 0x1D, 0xFB, 0xE7, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x01, 0xD8, 0x07, 0x30, 0x0E, 0x60, 0x38, 0xC0,
  0xE1, 0x81, 0xC3, 0x07, 0x06, 0x0E, 0x0C, 0x38, 0x18, 0xE0, 0x31, 0xC0,
  0x67, 0x80, 0xCF, 0x01, 0xB7, 0x03, 0xEE, 0x07, 0x8E, 0x0E, 0x1C, 0x18,
  0x1C, 0x30, 0x38, 0x60, 0x70, 0xC0, 0x71, 0x80, 0xE3, 0x00, 0xE6, 0x01,
  0xCC, 0x03, 0x98, 0x03, 0xB0, 0x07, 0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x18, 0xFE, 0x0F,
  0xE3, 0x3F, 0xE3, 0xFE, 0x6C, 0x1C, 0xC1, 0xED, 0x01, 0xD0, 0x1D, 0xE0,
  0x3E, 0x03, 0xB8, 0x07, 0x80, 0x37, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00,
  0xFC, 0x01, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xF0, 0x07, 0x00, 0x7C, 0x00,
  0xE0, 0x0F, 0x80, 0x1C, 0x01, 0xF0, 0x03, 0x80, 0x3E, 0x00, 0x70, 0x07,
  0xC0, 0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x38, 0x03, 0xE0, 0x07,
  0x00, 0x7C, 0x00, 0xE0, 0x0F, 0x80, 0x1C, 0x01, 0xF0, 0x03, 0x80, 0x3E,
  0x00, 0x70, 0x07, 0xC0, 0x0E, 0x00, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x38,
  0x03, 0xE0, 0x07, 0x00, 0x7C, 0x00, 0xE0, 0x0E, 0x01, 0xE1, 0x8F, 0xF3,
  0x3F, 0xF6, 0xE0, 0xED, 0x81, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x78, 0x3C,
  0x3C, 0x07, 0x0E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01, 0xDC,
  0x00, 0x76, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8F,
  0x01, 0xC1, 0xE1, 0xE0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x10, 0x00, 0x01,
  0xE0, 0x63, 0xFC, 0x33, 0xFF, 0x19, 0x83, 0xCD, 0x80, 0xE6, 0x80, 0x3B,
  0xC0, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D,
  0xE0, 0x0E, 0xD0, 0x0F, 0x6C, 0x07, 0x33, 0x0F, 0x99, 0xFF, 0x8C, 0x3F,
  0x86, 0x02, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x70, 0xFF, 0xDC,
  0x78, 0x37, 0x3C, 0x07, 0xCE, 0x01, 0xF7, 0x80, 0x3D, 0xC0, 0x0F, 0x70,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D,
  0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D, 0xE0, 0x0F, 0x38,
  0x07, 0xCF, 0x01, 0x71, 0xE1, 0xDC, 0x3F, 0xE7, 0x07, 0xF1, 0xC0, 0x20,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x01, 0xF8, 0xFB, 0x3F, 0x67, 0x2D, 0x81, 0xB0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x80, 0x7F, 0xE3,
  0xFF, 0x9E, 0x06, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x3A, 0x00, 0xEE, 0x0F, 0x3F, 0xFC, 0x7F, 0xC0, 0x10,
  0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xFF,
  0xFF, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x21, 0xFC,
  0x3F, 0x80, 0x80, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x07, 0x70,
  0x0F, 0x70, 0x0B, 0x78, 0x1B, 0x3C, 0x33, 0x3F, 0xF3, 0x1F, 0xE3, 0x01,
  0x00, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x67, 0x00, 0x71,
  0x80, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x38, 0x0E, 0x0C, 0x07, 0x07, 0x03,
  0x83, 0x81, 0x81, 0xC1, 0xC0, 0x60, 0xE0, 0x38, 0x70, 0x1C, 0x30, 0x0E,
  0x18, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x1B, 0x80,
  0x0D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E,
  0x00, 0xF0, 0x06, 0x60, 0x1F, 0x00, 0xE7, 0x01, 0xF8, 0x0E, 0x70, 0x1B,
  0x80, 0xE7, 0x01, 0x98, 0x0C, 0x70, 0x39, 0x81, 0xC3, 0x03, 0x9C, 0x1C,
  0x38, 0x39, 0xC1, 0xC3, 0x83, 0x1C, 0x1C, 0x38, 0x30, 0xC1, 0x81, 0x87,
  0x0C, 0x38, 0x18, 0x70, 0xE3, 0x81, 0xC7, 0x0E, 0x38, 0x1C, 0x60, 0xE3,
  0x01, 0xC6, 0x06, 0x30, 0x0C, 0xE0, 0x67, 0x00, 0xCE, 0x07, 0x70, 0x0E,
  0xE0, 0x77, 0x00, 0xEC, 0x07, 0x60, 0x0E, 0xC0, 0x36, 0x00, 0x6C, 0x03,
  0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00,
  0x38, 0x01, 0xC0, 0xF0, 0x07, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x38,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x07, 0x70, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x38,
  0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xB8, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x31,
  0xC0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x06, 0x0E, 0x07, 0x03, 0x83,
  0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x30, 0xE0, 0x18, 0x70, 0x0E, 0x38, 0x07,
  0x18, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x3B, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0xC0, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFC, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0x00, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0xFE,
  0x03, 0xE0, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0x07, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 38, 11, 4, -38 },
  { 20, 12, 14, 18, 3, -38 },
  { 41, 21, 38, 23, 1, -38 },
  { 141, 18, 43, 22, 2, -40 },
  { 238, 29, 38, 33, 2, -38 },
  { 376, 21, 39, 23, 2, -38 },
  { 479, 4, 14, 10, 3, -38 },
  { 486, 10, 46, 15, 3, -38 },
  { 544, 10, 46, 15, 2, -38 },
  { 602, 15, 15, 20, 2, -40 },
  { 631, 18, 25, 22, 2, -31 },
  { 688, 6, 13, 11, 2, -6 },
  { 698, 12, 3, 14, 1, -16 },
  { 703, 5, 5, 11, 3, -5 },
  { 707, 17, 38, 19, 1, -38 },
  { 788, 17, 38, 22, 2, -38 },
  { 869, 10, 38, 22, 4, -38 },
  { 917, 17, 38, 22, 2, -38 },
  { 998, 17, 39, 22, 2, -38 },
  { 1081, 20, 38, 22, 1, -38 },
  { 1176, 17, 38, 22, 3, -38 },
  { 1257, 18, 39, 22, 2, -38 },
  { 1345, 18, 38, 22, 2, -38 },
  { 1431, 18, 39, 22, 2, -38 },
  { 1519, 17, 39, 22, 2, -38 },
  { 1602, 5, 28, 11, 3, -28 },
  { 1620, 6, 35, 11, 2, -28 },
  { 1647, 18, 23, 22, 2, -30 },
  { 1699, 18, 14, 22, 2, -26 },
  { 1731, 18, 23, 22, 2, -30 },
  { 1783, 13, 38, 15, 1, -38 },
  { 1845, 28, 43, 33, 3, -38 },
  { 1996, 22, 38, 22, 0, -38 },
  { 2101, 18, 38, 24, 4, -38 },
  { 2187, 19, 39, 23, 3, -38 },
  { 2280, 19, 38, 26, 4, -38 },
  { 2371, 14, 38, 21, 4, -38 },
  { 2438, 14, 38, 19, 4, -38 },
  { 2505, 22, 39, 28, 3, -38 },
  { 2613, 19, 38, 27, 4, -38 },
  { 2704, 9, 38, 13, 2, -38 },
  { 2747, 9, 48, 11, -2, -38 },
  { 2801, 18, 38, 22, 4, -38 },
  { 2887, 14, 38, 19, 4, -38 },
  { 2954, 28, 38, 36, 4, -38 },
  { 3087, 20, 38, 28, 4, -38 },
  { 3182, 22, 39, 28, 3, -38 },
  { 3290, 17, 38, 22, 4, -38 },
  { 3371, 22, 47, 28, 3, -38 },
  { 3501, 18, 38, 23, 4, -38 },
  { 3587, 17, 39, 21, 2, -38 },
  { 3670, 19, 38, 19, 0, -38 },
  { 3761, 19, 39, 27, 4, -38 },
  { 3854, 21, 38, 21, 0, -38 },
  { 3954, 36, 38, 36, 0, -38 },
  { 4125, 19, 38, 19, 0, -38 },
  { 4216, 19, 38, 19, 0, -38 },
  { 4307, 16, 38, 18, 1, -38 },
  { 4383, 11, 46, 16, 4, -38 },
  { 4447, 17, 38, 19, 1, -38 },
  { 4528, 10, 46, 16, 2, -38 },
  { 4586, 20, 19, 22, 1, -38 },
  { 4634, 22, 2, 22, 0, 5 },
  { 4640, 9, 9, 13, 2, -41 },
  { 4651, 15, 30, 21, 2, -29 },
  { 4708, 17, 41, 23, 4, -40 },
  { 4796, 14, 30, 17, 2, -29 },
  { 4849, 18, 41, 23, 2, -40 },
  { 4942, 17, 30, 21, 2, -29 },
  { 5006, 13, 41, 12, 1, -41 },
  { 5073, 18, 42, 23, 2, -29 },
  { 5168, 15, 40, 23, 4, -40 },
  { 5243, 4, 39, 10, 3, -39 },
  { 5263, 7, 52, 10, 0, -39 },
  { 5309, 15, 40, 19, 4, -40 },
  { 5384, 2, 40, 10, 4, -40 },
  { 5394, 27, 29, 34, 4, -29 },
  { 5492, 15, 29, 23, 4, -29 },
  { 5547, 18, 30, 22, 2, -29 },
  { 5615, 17, 42, 23, 4, -29 },
  { 5705, 18, 42, 23, 2, -29 },
  { 5800, 11, 29, 15, 4, -29 },
  { 5840, 14, 30, 17, 2, -29 },
  { 5893, 11, 36, 12, 1, -35 },
  { 5943, 16, 29, 23, 3, -28 },
  { 6001, 17, 28, 18, 0, -28 },
  { 6061, 28, 28, 30, 1, -28 },
  { 6159, 16, 28, 18, 1, -28 },
  { 6215, 17, 41, 18, 1, -28 },
  { 6303, 13, 28, 15, 1, -28 },
  { 6349, 14, 46, 19, 2, -38 },
  { 6430, 3, 53, 21, 9, -40 },
  { 6450, 14, 46, 19, 2, -38 },
  { 6531, 18, 6, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Light53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT53PT7B_H_
