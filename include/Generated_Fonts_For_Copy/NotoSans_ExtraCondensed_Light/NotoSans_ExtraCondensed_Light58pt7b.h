#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0x7B, 0xFE, 0xF0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x06,
  0xE0, 0x60, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01,
  0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x07, 0x03, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x06,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xC6,
  0x1C, 0x78, 0x60, 0x47, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0,
  0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x07,
  0x06, 0x00, 0x78, 0x60, 0x03, 0xC6, 0x00, 0x1F, 0x60, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x06, 0xF8, 0x00, 0x63,
  0xC0, 0x06, 0x1E, 0x00, 0x60, 0xE0, 0x06, 0x0F, 0x00, 0x60, 0x70, 0x06,
  0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x0E, 0x00,
  0x60, 0xEC, 0x06, 0x1C, 0xF0, 0x67, 0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x00, 0xF7,
  0x80, 0x1C, 0x01, 0xC3, 0x00, 0x30, 0x03, 0x07, 0x00, 0xE0, 0x0E, 0x0E,
  0x01, 0xC0, 0x1C, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x60, 0x38,
  0x1C, 0x00, 0xC0, 0x70, 0x30, 0x01, 0x80, 0xE0, 0xE0, 0x07, 0x01, 0xC1,
  0xC0, 0x0E, 0x03, 0x83, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x18, 0x0E, 0x1C,
  0x00, 0x30, 0x1C, 0x30, 0x00, 0x60, 0x38, 0xE0, 0x00, 0xC0, 0x71, 0xC7,
  0xE1, 0x80, 0xC3, 0x1F, 0xE3, 0x81, 0x8E, 0x38, 0xE7, 0x07, 0x1C, 0xE1,
  0xC6, 0x0E, 0x31, 0xC1, 0x8E, 0x38, 0xE3, 0x03, 0x8F, 0xF1, 0x8E, 0x07,
  0x1F, 0xC7, 0x1C, 0x0E, 0x0F, 0x0E, 0x38, 0x0C, 0x00, 0x18, 0x70, 0x18,
  0x00, 0x70, 0xE0, 0x30, 0x00, 0xE1, 0xC0, 0x60, 0x01, 0x83, 0x80, 0xC0,
  0x07, 0x07, 0x01, 0x80, 0x0E, 0x0E, 0x03, 0x00, 0x18, 0x1C, 0x06, 0x00,
  0x70, 0x38, 0x0C, 0x00, 0xE0, 0x70, 0x38, 0x01, 0x80, 0xE0, 0x70, 0x07,
  0x00, 0xC0, 0xE0, 0x0E, 0x01, 0xC1, 0x80, 0x18, 0x03, 0x87, 0x00, 0x70,
  0x03, 0x8E, 0x00, 0xE0, 0x07, 0xF8, 0x01, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x70,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0x38, 0x0E, 0x38,
  0x78, 0x1C, 0xE0, 0x70, 0x79, 0xC0, 0xF0, 0xE7, 0x00, 0xE1, 0xCE, 0x00,
  0xE3, 0x9C, 0x01, 0xC7, 0x38, 0x01, 0xDC, 0x70, 0x03, 0xF8, 0xE0, 0x03,
  0xF1, 0xC0, 0x07, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0F, 0x00, 0x3F,
  0x0E, 0x00, 0xFE, 0x1E, 0x03, 0xCE, 0x1F, 0x3F, 0x1E, 0x1F, 0xFC, 0x1C,
  0x1F, 0xE0, 0x3C, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x02, 0x06, 0x0D, 0xE3,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFC, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xEE, 0x00,
  0xE3, 0x80, 0x70, 0xE0, 0x70, 0x70, 0x78, 0x1C, 0x08, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7,
  0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x78,
  0x3C, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x0E, 0x70, 0x03, 0x9C,
  0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E,
  0x38, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xEE, 0x7D, 0xDE, 0x3F,
  0x87, 0x60, 0xE8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x3E, 0x07, 0x83, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7C, 0x07,
  0xC6, 0x00, 0x78, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xB0, 0x01, 0xE7,
  0xE1, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xEF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x30, 0x07, 0xCF, 0x8F, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0x02, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x38, 0xFF, 0x0E, 0x7F, 0xE3,
  0xB8, 0x7C, 0xFC, 0x07, 0xBE, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D,
  0xC0, 0x0F, 0x78, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0x70, 0x7C, 0x7C, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x78,
  0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x78, 0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x38,
  0x1E, 0x07, 0x80, 0xF1, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0x1E, 0x01, 0xE0, 0xF0, 0x3C, 0x07, 0x83, 0x80,
  0x3C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF0, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x70, 0x07, 0x1E, 0x00,
  0xE3, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xEE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x3E, 0x70, 0x07,
  0xCF, 0x01, 0xB8, 0xFD, 0xE7, 0x0F, 0xFC, 0xE0, 0xFE, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x81, 0x87, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38,
  0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xC3, 0xFF, 0xE3, 0x03, 0xC4, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x3F, 0x01, 0x8E,
  0x01, 0xFF, 0x03, 0x9C, 0x07, 0x8E, 0x07, 0x38, 0x0E, 0x0C, 0x0E, 0x70,
  0x38, 0x38, 0x0C, 0xC0, 0x60, 0x70, 0x1B, 0x81, 0xC0, 0xE0, 0x3F, 0x03,
  0x81, 0xC0, 0x7E, 0x07, 0x03, 0x80, 0xFC, 0x0E, 0x07, 0x01, 0xF8, 0x18,
  0x0E, 0x03, 0xF0, 0x30, 0x1C, 0x07, 0xE0, 0x60, 0x38, 0x0F, 0xC0, 0xC0,
  0x70, 0x1B, 0x81, 0x80, 0xE0, 0x37, 0x03, 0x01, 0xC0, 0xEE, 0x06, 0x07,
  0x81, 0xDC, 0x0E, 0x0F, 0x03, 0xB8, 0x1C, 0x1E, 0x06, 0x70, 0x38, 0x6C,
  0x1C, 0x60, 0x38, 0xCC, 0x78, 0xE0, 0x7F, 0x9F, 0xE1, 0xC0, 0x7E, 0x1F,
  0x83, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x60, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xF0, 0x3F, 0x8F, 0x00,
  0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x00, 0x7C, 0xF0, 0x03,
  0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF,
  0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xC0, 0xE0, 0xF8, 0x01, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x40, 0x7F, 0x3E, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x01, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0x0F, 0xF0, 0x3C,
  0x03, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0E, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0x73, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x7E, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x7E, 0x03, 0xE0, 0x7C, 0x00, 0x20, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9E,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x38,
  0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x1E, 0x07, 0xF1, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x38, 0xFF, 0xFF, 0xF0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE3, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0xC7, 0xDF, 0xF3, 0xFC, 0x1C, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x7C,
  0x00, 0xFF, 0xC0, 0x0F, 0xDE, 0x00, 0xF8, 0xE0, 0x0F, 0x8F, 0x00, 0xF0,
  0x70, 0x0F, 0x07, 0x80, 0xF0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x0F,
  0x01, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x0F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0xCF, 0x00, 0x1C, 0xF0, 0x01,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFD,
  0xC0, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x1F, 0xF7, 0x00, 0x00, 0x77, 0xE7,
  0x00, 0x00, 0xEF, 0xCE, 0x00, 0x01, 0xDF, 0x9C, 0x00, 0x03, 0xBF, 0x18,
  0x00, 0x0E, 0x7E, 0x38, 0x00, 0x1C, 0xFC, 0x70, 0x00, 0x39, 0xF8, 0xE0,
  0x00, 0xE3, 0xF0, 0xE0, 0x01, 0xC7, 0xE1, 0xC0, 0x03, 0x8F, 0xC3, 0x80,
  0x0E, 0x1F, 0x83, 0x80, 0x1C, 0x3F, 0x07, 0x00, 0x38, 0x7E, 0x0E, 0x00,
  0x70, 0xFC, 0x1C, 0x01, 0xC1, 0xF8, 0x1C, 0x03, 0x83, 0xF0, 0x38, 0x07,
  0x07, 0xE0, 0x70, 0x1C, 0x0F, 0xC0, 0x70, 0x38, 0x1F, 0x80, 0xE0, 0x70,
  0x3F, 0x01, 0xC0, 0xE0, 0x7E, 0x01, 0x83, 0x80, 0xFC, 0x03, 0x87, 0x01,
  0xF8, 0x07, 0x0E, 0x03, 0xF0, 0x0E, 0x38, 0x07, 0xE0, 0x0E, 0x70, 0x0F,
  0xC0, 0x1C, 0xE0, 0x1F, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x01, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFD, 0xC0, 0x01,
  0xFB, 0x80, 0x03, 0xF3, 0x80, 0x07, 0xE7, 0x00, 0x0F, 0xCF, 0x00, 0x1F,
  0x8E, 0x00, 0x3F, 0x1C, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x38, 0x01, 0xF8,
  0x38, 0x03, 0xF0, 0x70, 0x07, 0xE0, 0xF0, 0x0F, 0xC0, 0xE0, 0x1F, 0x81,
  0xC0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x03, 0x81, 0xF8, 0x07,
  0x03, 0xF0, 0x0F, 0x07, 0xE0, 0x0E, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x1C,
  0x3F, 0x00, 0x38, 0x7E, 0x00, 0x38, 0xFC, 0x00, 0x71, 0xF8, 0x00, 0xF3,
  0xF0, 0x00, 0xE7, 0xE0, 0x01, 0xEF, 0xC0, 0x01, 0xDF, 0x80, 0x03, 0xBF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x70, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0x0F, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x70, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF1, 0xFF, 0x0F, 0x00, 0xF8, 0xF0, 0x07,
  0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00,
  0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x1C, 0xF0,
  0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0x07, 0x00,
  0xF0, 0x78, 0x0F, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x1C,
  0x0F, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x0F, 0x00,
  0x78, 0xF0, 0x03, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xCF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0x81, 0xE3, 0xC0, 0x04, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x38, 0x03, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1C,
  0xF0, 0x00, 0xE3, 0x80, 0x0F, 0x1F, 0x00, 0xF0, 0x7E, 0x3F, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xCF, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x78, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0xE0, 0x00,
  0x78, 0x00, 0x1D, 0xC0, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xE0, 0x00,
  0xF7, 0x80, 0x07, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0xC0, 0x03, 0x8E, 0x00,
  0x1F, 0x80, 0x07, 0x1C, 0x00, 0x37, 0x00, 0x1E, 0x38, 0x00, 0xEE, 0x00,
  0x3C, 0x78, 0x01, 0xDC, 0x00, 0x70, 0x70, 0x03, 0x98, 0x00, 0xE0, 0xE0,
  0x07, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x70, 0x07, 0x83, 0x80, 0x38, 0xE0,
  0x0E, 0x07, 0x80, 0x71, 0xC0, 0x1C, 0x07, 0x00, 0xE1, 0x80, 0x38, 0x0E,
  0x01, 0xC3, 0x80, 0x70, 0x1C, 0x03, 0x87, 0x01, 0xE0, 0x38, 0x0E, 0x0E,
  0x03, 0x80, 0x78, 0x1C, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x18, 0x0E, 0x00,
  0xE0, 0x70, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x70, 0x78, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x01, 0x83, 0x80,
  0x0E, 0x1C, 0x03, 0x8F, 0x00, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0x3C, 0xE0,
  0x0E, 0x38, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x18, 0xE0,
  0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x03, 0x98,
  0x00, 0xEE, 0x00, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x01, 0xB8,
  0x00, 0x0F, 0xC0, 0x03, 0x70, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0xF7, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x1C,
  0x03, 0xC1, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00,
  0xF0, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0,
  0x03, 0x9C, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x81,
  0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7B, 0x80,
  0x03, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0,
  0xF0, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x0E, 0x00, 0xF0, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x00,
  0xF1, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xB8,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xEE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x1E, 0x0E,
  0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xE0, 0x78, 0x03, 0x81,
  0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x00,
  0x03, 0xBC, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0x07, 0x8F, 0x82, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0x87, 0x3E, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xDC,
  0x03, 0xEF, 0x03, 0x77, 0xC3, 0xB9, 0xFF, 0x9C, 0x7F, 0x8E, 0x06, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0xF8, 0x39, 0xFF, 0x87,
  0x3C, 0xF8, 0xEC, 0x07, 0x9F, 0x00, 0x73, 0xE0, 0x0F, 0x78, 0x00, 0xEF,
  0x00, 0x1D, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1D, 0xE0, 0x03, 0xBE, 0x00, 0xF7, 0xC0, 0x1C, 0xEC,
  0x07, 0x9D, 0xE3, 0xE3, 0x9F, 0xF8, 0x71, 0xFE, 0x00, 0x03, 0x00, 0x03,
  0xFC, 0x1F, 0xFC, 0x7E, 0x71, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x0F, 0xE1, 0xC3, 0xFE, 0x38, 0xF9,
  0xE7, 0x3C, 0x06, 0xEF, 0x00, 0xDD, 0xC0, 0x0F, 0xB8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0xFB, 0xC0, 0x17, 0x3C, 0x06,
  0xE7, 0xC3, 0x9C, 0x7F, 0xE3, 0x87, 0xF8, 0x70, 0x08, 0x00, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xE3, 0xE0, 0xF0, 0x38, 0x38, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x06, 0x1F, 0x07, 0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x7D, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x07, 0xF0, 0xE1, 0xFF, 0x9C, 0x7C, 0xF3, 0x9E, 0x03,
  0x77, 0x80, 0x3E, 0xE0, 0x07, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0x70, 0x03, 0xEE, 0x00, 0x7D, 0xE0, 0x1B, 0x9E, 0x03, 0x73, 0xE1, 0xCE,
  0x3F, 0xF1, 0xC3, 0xFC, 0x38, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x40, 0x07, 0x8E, 0x03, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x0F, 0xE3, 0x9F, 0xF9, 0xDF, 0x7E,
  0xEC, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70,
  0xEF, 0xFF, 0x60, 0x00, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x0E, 0x0F, 0x0F,
  0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0xFC, 0xF8, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x7B, 0x80,
  0x39, 0xC0, 0x3C, 0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0E, 0x0E,
  0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0x80, 0x73, 0xC0,
  0x39, 0xE0, 0x1D, 0xF8, 0x0F, 0xDC, 0x07, 0xCF, 0x03, 0xE3, 0x81, 0xE1,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0xB8, 0x01,
  0xDC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xF8, 0x1F, 0xC3,
  0x1F, 0xF0, 0xFF, 0x8E, 0xF3, 0xE7, 0x9F, 0x3B, 0x03, 0x98, 0x1E, 0xF8,
  0x0F, 0xC0, 0x7B, 0xC0, 0x1F, 0x00, 0xEF, 0x00, 0x78, 0x03, 0xBC, 0x01,
  0xE0, 0x0E, 0xE0, 0x07, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0xFE, 0x00, 0x70,
  0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00,
  0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F,
  0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0,
  0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01,
  0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70,
  0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00,
  0x7E, 0x00, 0x70, 0x01, 0xC0, 0xC1, 0xFC, 0x73, 0xFF, 0x3B, 0xCF, 0xDD,
  0x81, 0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0xFC, 0x1E, 0x03, 0xC7, 0x80, 0x38, 0xE0,
  0x07, 0x9C, 0x00, 0x77, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x77, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x78, 0xE0, 0x0E, 0x1E, 0x03, 0xC1, 0xF1, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x02, 0x00, 0xC1, 0xFC, 0x1C, 0xFF, 0xC3, 0x9E, 0x7C, 0x76, 0x03,
  0xCF, 0x80, 0x39, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0E,
  0xF0, 0x01, 0xDF, 0x00, 0x7B, 0xE0, 0x0E, 0x76, 0x03, 0xCE, 0xF1, 0xF1,
  0xCF, 0xFC, 0x38, 0x7F, 0x07, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0xF0, 0xE1, 0xFF, 0x9C, 0x7C, 0xF3, 0x9E, 0x07, 0x73,
  0x80, 0x6E, 0xF0, 0x07, 0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x70,
  0x01, 0xEE, 0x00, 0x7D, 0xE0, 0x1B, 0x9E, 0x03, 0x73, 0xE1, 0xCE, 0x3F,
  0xF1, 0xC1, 0xFC, 0x38, 0x04, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0xC1, 0xFC, 0x7F, 0xE7, 0xEE, 0xE0, 0xEC, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0xF8, 0x3F, 0xFC, 0xF8, 0xF3, 0xC0, 0x27, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x7E, 0x01, 0xEF, 0x8F, 0xDF, 0xFF, 0x1F, 0xF8, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF1, 0x0F, 0xF0, 0x7F, 0x00, 0x80, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xDC, 0x03, 0xEF, 0x03, 0x77, 0xC7,
  0x99, 0xFF, 0x8C, 0x7F, 0x86, 0x06, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x3D,
  0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x00,
  0xC1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x06, 0x38, 0x00,
  0xE6, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x06, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x77, 0x00, 0x3E, 0x00,
  0xE7, 0x00, 0x7C, 0x01, 0xCE, 0x01, 0xD8, 0x03, 0x9C, 0x03, 0xB0, 0x0E,
  0x38, 0x07, 0x70, 0x1C, 0x70, 0x0E, 0xE0, 0x38, 0x70, 0x19, 0xC0, 0x70,
  0xE0, 0x73, 0x80, 0xE1, 0xC0, 0xE3, 0x03, 0x83, 0x81, 0xC7, 0x07, 0x07,
  0x83, 0x8E, 0x0E, 0x07, 0x06, 0x1C, 0x1C, 0x0E, 0x1C, 0x38, 0x30, 0x1C,
  0x38, 0x30, 0xE0, 0x38, 0x70, 0x71, 0xC0, 0x38, 0xC0, 0xE3, 0x80, 0x73,
  0x81, 0xC7, 0x00, 0xE7, 0x03, 0x8C, 0x01, 0xCE, 0x03, 0x38, 0x03, 0x9C,
  0x07, 0x70, 0x03, 0xB0, 0x0E, 0xE0, 0x07, 0x60, 0x1D, 0xC0, 0x0F, 0xC0,
  0x3B, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x03,
  0xDC, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x3C, 0x07, 0x07, 0x03, 0x81,
  0xE0, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x0E,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x78, 0x78, 0x1C, 0x0E, 0x0F, 0x03, 0xC3, 0x80, 0x70, 0xE0,
  0x1C, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x3C, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0x70, 0x70, 0x1C, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x33, 0x80,
  0x0E, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0x80, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x1E, 0x1F,
  0xC7, 0xC0, 0x7F, 0xF8, 0x01, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 41, 12, 4, -41 },
  { 27, 12, 15, 19, 4, -41 },
  { 50, 24, 41, 26, 1, -41 },
  { 173, 20, 47, 24, 2, -44 },
  { 291, 31, 43, 36, 2, -42 },
  { 458, 23, 43, 25, 2, -42 },
  { 582, 3, 15, 11, 4, -41 },
  { 588, 11, 51, 16, 3, -42 },
  { 659, 11, 51, 16, 2, -42 },
  { 730, 17, 17, 21, 2, -44 },
  { 767, 20, 27, 24, 2, -34 },
  { 835, 7, 14, 12, 2, -6 },
  { 848, 12, 3, 16, 2, -17 },
  { 853, 4, 5, 12, 4, -5 },
  { 856, 18, 42, 20, 1, -42 },
  { 951, 18, 42, 24, 3, -42 },
  { 1046, 11, 41, 24, 4, -41 },
  { 1103, 19, 42, 24, 2, -42 },
  { 1203, 19, 43, 24, 2, -42 },
  { 1306, 22, 42, 24, 1, -42 },
  { 1422, 18, 42, 24, 3, -41 },
  { 1517, 18, 43, 24, 3, -42 },
  { 1614, 19, 41, 24, 2, -41 },
  { 1712, 20, 43, 24, 2, -42 },
  { 1820, 19, 43, 24, 2, -42 },
  { 1923, 4, 31, 12, 4, -31 },
  { 1939, 7, 39, 12, 2, -31 },
  { 1974, 20, 25, 24, 2, -33 },
  { 2037, 20, 15, 24, 2, -28 },
  { 2075, 20, 25, 24, 2, -33 },
  { 2138, 15, 42, 17, 1, -42 },
  { 2217, 31, 47, 36, 3, -42 },
  { 2400, 24, 41, 24, 0, -41 },
  { 2523, 20, 41, 26, 4, -41 },
  { 2626, 21, 43, 25, 3, -42 },
  { 2739, 22, 41, 29, 4, -41 },
  { 2852, 16, 41, 23, 4, -41 },
  { 2934, 16, 41, 21, 4, -41 },
  { 3016, 25, 43, 31, 3, -42 },
  { 3151, 21, 41, 30, 4, -41 },
  { 3259, 10, 41, 15, 2, -41 },
  { 3311, 11, 52, 12, -3, -41 },
  { 3383, 20, 41, 24, 4, -41 },
  { 3486, 16, 41, 21, 4, -41 },
  { 3568, 31, 41, 40, 4, -41 },
  { 3727, 23, 41, 31, 4, -41 },
  { 3845, 25, 43, 31, 3, -42 },
  { 3980, 18, 41, 24, 4, -41 },
  { 4073, 25, 52, 31, 3, -42 },
  { 4236, 20, 41, 25, 4, -41 },
  { 4339, 19, 43, 23, 2, -42 },
  { 4442, 19, 41, 21, 1, -41 },
  { 4540, 21, 42, 29, 4, -41 },
  { 4651, 23, 41, 23, 0, -41 },
  { 4769, 39, 41, 40, 0, -41 },
  { 4969, 20, 41, 21, 1, -41 },
  { 5072, 21, 41, 21, 0, -41 },
  { 5180, 17, 41, 20, 2, -41 },
  { 5268, 11, 51, 18, 5, -42 },
  { 5339, 18, 42, 20, 1, -42 },
  { 5434, 11, 51, 18, 2, -42 },
  { 5505, 22, 21, 24, 1, -41 },
  { 5563, 24, 3, 24, 0, 5 },
  { 5572, 10, 9, 14, 2, -44 },
  { 5584, 17, 32, 23, 2, -31 },
  { 5652, 19, 45, 26, 4, -44 },
  { 5759, 15, 32, 19, 3, -31 },
  { 5819, 19, 45, 26, 3, -44 },
  { 5926, 18, 32, 23, 3, -31 },
  { 5998, 14, 44, 13, 1, -44 },
  { 6075, 19, 45, 26, 3, -31 },
  { 6182, 17, 44, 25, 4, -44 },
  { 6276, 4, 42, 11, 4, -42 },
  { 6297, 8, 56, 11, 0, -42 },
  { 6353, 17, 44, 21, 4, -44 },
  { 6447, 3, 44, 11, 4, -44 },
  { 6464, 30, 31, 37, 4, -31 },
  { 6581, 17, 31, 25, 4, -31 },
  { 6647, 19, 32, 25, 3, -31 },
  { 6723, 19, 45, 26, 4, -31 },
  { 6830, 19, 45, 26, 3, -31 },
  { 6937, 12, 31, 16, 4, -31 },
  { 6984, 15, 32, 19, 2, -31 },
  { 7044, 12, 39, 14, 1, -38 },
  { 7103, 17, 32, 25, 4, -31 },
  { 7171, 19, 31, 19, 0, -31 },
  { 7245, 31, 31, 32, 1, -31 },
  { 7366, 18, 31, 20, 1, -31 },
  { 7436, 18, 45, 20, 1, -31 },
  { 7538, 13, 31, 16, 2, -31 },
  { 7589, 15, 51, 21, 3, -42 },
  { 7685, 3, 58, 23, 10, -44 },
  { 7707, 15, 51, 21, 3, -42 },
  { 7803, 20, 6, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Light58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT58PT7B_H_
