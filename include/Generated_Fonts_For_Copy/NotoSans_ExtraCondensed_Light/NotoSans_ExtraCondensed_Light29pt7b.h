#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0xCF, 0x3C, 0xE3, 0x8E, 0x38,
  0xE3, 0x08, 0xC1, 0x10, 0x62, 0x0C, 0x41, 0x08, 0x21, 0x3F, 0xFF, 0xFF,
  0x11, 0x82, 0x20, 0xC4, 0x18, 0x83, 0x11, 0xFF, 0xC8, 0x41, 0x18, 0x23,
  0x04, 0x60, 0x88, 0x31, 0x06, 0x20, 0x08, 0x02, 0x01, 0xF1, 0xE6, 0x48,
  0x32, 0x08, 0x83, 0x20, 0xC8, 0x1A, 0x03, 0x80, 0x78, 0x0F, 0x02, 0x60,
  0x8C, 0x23, 0x08, 0xC2, 0x38, 0x8B, 0xFE, 0x7E, 0x02, 0x00, 0x80, 0x20,
  0x38, 0x10, 0x6C, 0x30, 0x44, 0x20, 0xC4, 0x20, 0xC4, 0x60, 0xC4, 0x40,
  0xC4, 0x40, 0xC4, 0xC0, 0xC4, 0x88, 0xC4, 0x96, 0x45, 0xA2, 0x6D, 0x22,
  0x39, 0x23, 0x03, 0x23, 0x02, 0x23, 0x02, 0x23, 0x06, 0x23, 0x04, 0x23,
  0x04, 0x22, 0x0C, 0x32, 0x08, 0x1C, 0x1C, 0x03, 0x60, 0x22, 0x06, 0x30,
  0x63, 0x02, 0x30, 0x22, 0x03, 0x60, 0x34, 0x01, 0xC0, 0x38, 0x06, 0xC0,
  0x44, 0x6C, 0x66, 0xC3, 0x48, 0x14, 0x81, 0xCC, 0x18, 0xC1, 0xC6, 0x36,
  0x3E, 0x70, 0xFF, 0xAA, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x18, 0x41, 0x04,
  0x30, 0xC3, 0x0C, 0x10, 0x41, 0x86, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x10,
  0xC1, 0x06, 0x0C, 0x30, 0x41, 0x86, 0x08, 0x20, 0x83, 0x0C, 0x30, 0xC2,
  0x08, 0x61, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x00, 0x08, 0x08, 0x09, 0xFF,
  0x1C, 0x14, 0x36, 0x63, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F,
  0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x6D, 0xA5, 0xA0,
  0xFF, 0xF0, 0xBC, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x08,
  0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x08, 0x00, 0x1E, 0x0F, 0xC2, 0x11, 0x86, 0x41, 0x90, 0x2C, 0x0B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x09, 0x02, 0x40,
  0x98, 0x66, 0x18, 0xCC, 0x1E, 0x00, 0x0C, 0x73, 0xDB, 0xCC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3E, 0x3D,
  0xC4, 0x18, 0x06, 0x01, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xFF,
  0xC0, 0x3E, 0x3D, 0xC8, 0x18, 0x06, 0x00, 0x80, 0x20, 0x18, 0x06, 0x03,
  0x03, 0x83, 0xE0, 0x0C, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x80, 0x20,
  0x1B, 0x0C, 0xFE, 0x00, 0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80,
  0x48, 0x0C, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0x82, 0x08, 0x20, 0x86,
  0x08, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x48, 0x1F,
  0xC0, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x1B,
  0x0C, 0x7E, 0x00, 0x0F, 0x87, 0xE3, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xCE, 0x37, 0xCE, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x40,
  0xD8, 0x26, 0x18, 0xCE, 0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x00, 0x1E, 0x0C, 0xC6,
  0x19, 0x02, 0x40, 0x90, 0x24, 0x09, 0x86, 0x33, 0x07, 0x81, 0xE0, 0xCC,
  0x61, 0xB0, 0x2C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x09, 0x86, 0x3F, 0x00,
  0x1E, 0x1F, 0x98, 0x48, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x50,
  0x6E, 0x53, 0xC8, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC8, 0xC7, 0xC0,
  0xBC, 0x00, 0x00, 0x2F, 0x2D, 0x80, 0x00, 0x00, 0x00, 0xDB, 0x4B, 0x40,
  0x00, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x18, 0x1C, 0x1C,
  0x1C, 0x0C, 0x02, 0x00, 0x7C, 0xEE, 0x02, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x06, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x00, 0x00, 0x10, 0x38,
  0x30, 0x03, 0xE0, 0x0E, 0x70, 0x18, 0x08, 0x10, 0x04, 0x30, 0x06, 0x20,
  0x02, 0x61, 0xE2, 0x43, 0x23, 0x46, 0x23, 0x44, 0x23, 0x44, 0x23, 0xC4,
  0x23, 0xC4, 0x63, 0xC4, 0x63, 0x44, 0x62, 0x46, 0x62, 0x43, 0xBE, 0x41,
  0x9C, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x10, 0x0F, 0xF0, 0x01,
  0x00, 0x06, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x09, 0x00, 0x90, 0x19, 0x01,
  0x98, 0x19, 0x81, 0x08, 0x10, 0x83, 0x0C, 0x3F, 0xC3, 0xFC, 0x20, 0x46,
  0x06, 0x60, 0x66, 0x06, 0x40, 0x2C, 0x03, 0xC0, 0x30, 0xFC, 0x3F, 0xCC,
  0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0B, 0x02, 0xC1, 0xBF, 0xCF, 0xF3, 0x06,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x1E, 0xFE, 0x00,
  0x0F, 0x8F, 0x73, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xE3, 0x1F, 0xC0, 0xFC, 0x1F, 0xE3, 0x06, 0x60, 0x6C, 0x0D, 0x80, 0xB0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x02, 0xC0, 0xD8, 0x1B, 0x06, 0x67, 0x8F, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x0F, 0xC1, 0xEF, 0x30, 0x26, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x81, 0xF8, 0x1F, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x03, 0x70, 0x33, 0x87, 0x0F, 0xE0, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x06, 0xFB, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x4F, 0x80, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x37, 0x80, 0xC0, 0xF0,
  0x6C, 0x1B, 0x0C, 0xC2, 0x31, 0x8C, 0xC3, 0x30, 0xD8, 0x36, 0x0F, 0x83,
  0xB0, 0xCC, 0x31, 0x0C, 0x63, 0x08, 0xC3, 0x30, 0x4C, 0x1B, 0x02, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xD0, 0x0B, 0xD0, 0x0B,
  0xD8, 0x1B, 0xD8, 0x13, 0xC8, 0x13, 0xC8, 0x33, 0xCC, 0x33, 0xC4, 0x23,
  0xC4, 0x63, 0xC6, 0x63, 0xC2, 0x43, 0xC2, 0x43, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xA0,
  0x76, 0x0E, 0x41, 0xCC, 0x38, 0x87, 0x18, 0xE3, 0x1C, 0x23, 0x86, 0x70,
  0x4E, 0x0D, 0xC0, 0xB8, 0x1F, 0x03, 0xE0, 0x3C, 0x06, 0x1F, 0x03, 0xF8,
  0x60, 0xC4, 0x06, 0xC0, 0x6C, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x64, 0x06,
  0x60, 0xC3, 0x1C, 0x1F, 0x80, 0xF8, 0x7F, 0xB0, 0xD8, 0x3C, 0x1E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0xDF, 0xCF, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0x03, 0xF8, 0x60, 0xC4, 0x06, 0xC0,
  0x6C, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x64, 0x06, 0x60, 0xC3, 0x1C, 0x1F,
  0x80, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0xF8, 0x3F, 0xCC, 0x33,
  0x06, 0xC1, 0xB0, 0x2C, 0x0B, 0x06, 0xC1, 0xB0, 0x4C, 0xF3, 0xF0, 0xC4,
  0x31, 0x8C, 0x63, 0x0C, 0xC3, 0x30, 0x4C, 0x1B, 0x02, 0xC0, 0xC0, 0x1F,
  0x1F, 0xD8, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x1C, 0x07, 0x80,
  0xE0, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x78, 0x6F, 0xE0, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x58, 0x09, 0x83, 0x38, 0xC3, 0xF0, 0xC0, 0x3C, 0x02, 0x40, 0x24,
  0x06, 0x60, 0x66, 0x04, 0x60, 0x42, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x81,
  0x18, 0x11, 0x81, 0x98, 0x19, 0x00, 0x90, 0x0B, 0x00, 0xF0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x60, 0x3C, 0x06, 0x02, 0x40, 0x60, 0x24, 0x0E,
  0x06, 0x60, 0xF0, 0x66, 0x0F, 0x06, 0x60, 0xB0, 0x42, 0x09, 0x04, 0x21,
  0x90, 0xC3, 0x19, 0x0C, 0x31, 0x98, 0xC3, 0x11, 0x88, 0x11, 0x09, 0x81,
  0x30, 0x98, 0x1B, 0x09, 0x81, 0xB0, 0xD0, 0x0A, 0x0D, 0x00, 0xA0, 0x70,
  0x0A, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x60, 0xD8, 0x32, 0x08,
  0xC6, 0x31, 0x84, 0x41, 0xB0, 0x2C, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0A,
  0x06, 0xC1, 0x30, 0xC4, 0x31, 0x88, 0x66, 0x09, 0x03, 0xC0, 0xC0, 0xC0,
  0xF0, 0x34, 0x0D, 0x82, 0x61, 0x88, 0x63, 0x10, 0xCC, 0x12, 0x06, 0x81,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0xFF, 0xFF, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xFF, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0xFF, 0xF0, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xFF, 0xF0, 0x02, 0x00, 0x60, 0x07, 0x00, 0xD0, 0x09, 0x81, 0x88,
  0x10, 0xC3, 0x04, 0x20, 0x66, 0x06, 0xC0, 0x30, 0xFF, 0xF0, 0xC3, 0x0C,
  0x30, 0x1C, 0x7F, 0x43, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x71, 0x41, 0xC1,
  0xC1, 0xC1, 0xC3, 0x67, 0x7D, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0xC3, 0xFC, 0xE1, 0xB0, 0x6C, 0x0B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xB0, 0x2C, 0x0B, 0x06, 0xA3, 0x27, 0x80, 0x0E, 0x3F, 0x30,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x31,
  0x1F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xCC, 0xFB, 0x61,
  0xD8, 0x34, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x34,
  0x0D, 0x87, 0x31, 0x4F, 0x90, 0x0C, 0x1F, 0x98, 0x4C, 0x34, 0x0E, 0x07,
  0x03, 0xFF, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x00, 0xC2, 0x3E, 0x1E,
  0x34, 0xC1, 0x83, 0x06, 0x0C, 0x7E, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x0C, 0x0F, 0x96, 0x1D, 0x83,
  0x40, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD8,
  0x73, 0x3C, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x9D, 0xC3, 0xE0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x31, 0xFE, 0xA3, 0x60, 0xB0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0C, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x33, 0x00, 0x00, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x32, 0xEC, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC1, 0xC2, 0xC6, 0xC4, 0xCC, 0xD8, 0xD0, 0xB8, 0xA8,
  0xCC, 0xCC, 0xC4, 0xC6, 0xC2, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x31, 0x7C, 0xFA, 0x8E, 0x16, 0x1C, 0x3C, 0x10, 0x78, 0x20,
  0xF0, 0x41, 0xE0, 0x83, 0xC1, 0x07, 0x82, 0x0F, 0x04, 0x1E, 0x08, 0x3C,
  0x10, 0x78, 0x20, 0xF0, 0x41, 0xE0, 0x83, 0x0C, 0x5F, 0xA8, 0xD8, 0x2C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x0E, 0x0F, 0xC6, 0x19, 0x82, 0x40, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0D, 0x03, 0x40, 0xD8, 0x23, 0x18, 0x7C, 0x0C, 0x2F, 0xCA,
  0x1B, 0x06, 0xC0, 0xB0, 0x2C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0B, 0x02,
  0xC1, 0xA8, 0x6E, 0x33, 0x78, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x0C, 0x0F, 0x96, 0x1D, 0x83, 0x40, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD8, 0x73, 0x3C, 0xFB, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0E, 0x7A, 0x28, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x1C, 0x7E, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x06, 0x02, 0x03, 0x02, 0x86, 0xFC, 0x63,
  0x18, 0xCF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x0E, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78,
  0x3C, 0x3B, 0x3D, 0xF6, 0xC0, 0xA0, 0xD0, 0x6C, 0x36, 0x11, 0x18, 0x8C,
  0x66, 0x32, 0x09, 0x05, 0x82, 0xC1, 0xC0, 0x60, 0x30, 0xC1, 0x83, 0x41,
  0x83, 0x41, 0xC2, 0x63, 0xC2, 0x63, 0x46, 0x22, 0x46, 0x22, 0x44, 0x32,
  0x64, 0x36, 0x64, 0x36, 0x2C, 0x14, 0x2C, 0x14, 0x28, 0x14, 0x38, 0x1C,
  0x38, 0x0C, 0x18, 0x61, 0x88, 0x63, 0x30, 0x4C, 0x1A, 0x07, 0x80, 0xC0,
  0x30, 0x1E, 0x07, 0x81, 0x20, 0xCC, 0x21, 0x18, 0x6C, 0x0C, 0xC0, 0xD0,
  0x26, 0x19, 0x86, 0x21, 0x88, 0x43, 0x30, 0xCC, 0x13, 0x04, 0x81, 0xE0,
  0x78, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0xB0,
  0x38, 0x00, 0xFC, 0x18, 0x30, 0x41, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x82,
  0x0C, 0x18, 0x3F, 0x80, 0x03, 0x0F, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x10, 0xF0, 0xF0, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x08, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0xF0,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x07, 0x07,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xF0, 0x80,
  0x70, 0x7F, 0x18, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 6, 8, 10, 2, -21 },
  { 13, 11, 21, 13, 1, -21 },
  { 42, 10, 24, 12, 1, -22 },
  { 72, 16, 21, 18, 1, -21 },
  { 114, 12, 21, 13, 1, -21 },
  { 146, 2, 8, 5, 2, -21 },
  { 148, 6, 26, 8, 1, -21 },
  { 168, 6, 26, 8, 1, -21 },
  { 188, 8, 8, 11, 1, -22 },
  { 196, 10, 13, 12, 1, -17 },
  { 213, 3, 7, 6, 1, -3 },
  { 216, 6, 2, 8, 1, -9 },
  { 218, 2, 3, 6, 2, -3 },
  { 219, 9, 21, 10, 1, -21 },
  { 243, 10, 21, 12, 1, -21 },
  { 270, 6, 21, 12, 2, -21 },
  { 286, 10, 21, 12, 1, -21 },
  { 313, 10, 21, 12, 1, -21 },
  { 340, 12, 21, 12, 0, -21 },
  { 372, 10, 21, 12, 1, -21 },
  { 399, 10, 21, 12, 1, -21 },
  { 426, 10, 21, 12, 1, -21 },
  { 453, 10, 21, 12, 1, -21 },
  { 480, 9, 21, 12, 1, -21 },
  { 504, 2, 16, 6, 2, -16 },
  { 508, 3, 20, 6, 1, -16 },
  { 516, 10, 12, 12, 1, -16 },
  { 531, 10, 8, 12, 1, -14 },
  { 541, 10, 12, 12, 1, -16 },
  { 556, 8, 21, 8, 0, -21 },
  { 577, 16, 24, 18, 1, -21 },
  { 625, 12, 21, 12, 0, -21 },
  { 657, 10, 21, 13, 2, -21 },
  { 684, 10, 21, 13, 2, -21 },
  { 711, 11, 21, 14, 2, -21 },
  { 740, 8, 21, 11, 2, -21 },
  { 761, 8, 21, 11, 2, -21 },
  { 782, 12, 21, 15, 2, -21 },
  { 814, 11, 21, 15, 2, -21 },
  { 843, 5, 21, 7, 1, -21 },
  { 857, 5, 26, 6, -1, -21 },
  { 874, 10, 21, 12, 2, -21 },
  { 901, 8, 21, 10, 2, -21 },
  { 922, 16, 21, 20, 2, -21 },
  { 964, 11, 21, 16, 2, -21 },
  { 993, 12, 21, 15, 2, -21 },
  { 1025, 9, 21, 12, 2, -21 },
  { 1049, 12, 26, 15, 2, -21 },
  { 1088, 10, 21, 13, 2, -21 },
  { 1115, 9, 21, 12, 1, -21 },
  { 1139, 10, 21, 10, 0, -21 },
  { 1166, 11, 21, 15, 2, -21 },
  { 1195, 12, 21, 12, 0, -21 },
  { 1227, 20, 21, 20, 0, -21 },
  { 1280, 10, 21, 11, 0, -21 },
  { 1307, 10, 21, 10, 0, -21 },
  { 1334, 8, 21, 10, 1, -21 },
  { 1355, 6, 26, 9, 2, -21 },
  { 1375, 9, 21, 10, 1, -21 },
  { 1399, 6, 26, 9, 1, -21 },
  { 1419, 12, 11, 12, 0, -21 },
  { 1436, 12, 1, 12, 0, 3 },
  { 1438, 5, 4, 7, 1, -22 },
  { 1441, 8, 16, 11, 1, -16 },
  { 1457, 10, 22, 13, 2, -22 },
  { 1485, 8, 16, 10, 1, -16 },
  { 1501, 10, 22, 13, 1, -22 },
  { 1529, 9, 16, 12, 1, -16 },
  { 1547, 7, 22, 7, 0, -22 },
  { 1567, 10, 23, 13, 1, -16 },
  { 1596, 9, 22, 13, 2, -22 },
  { 1621, 2, 21, 6, 2, -21 },
  { 1627, 4, 28, 6, 0, -21 },
  { 1641, 8, 22, 11, 2, -22 },
  { 1663, 2, 22, 5, 2, -22 },
  { 1669, 15, 16, 19, 2, -16 },
  { 1699, 9, 16, 13, 2, -16 },
  { 1717, 10, 16, 12, 1, -16 },
  { 1737, 10, 23, 13, 2, -16 },
  { 1766, 10, 23, 13, 1, -16 },
  { 1795, 6, 16, 8, 2, -16 },
  { 1807, 8, 16, 9, 1, -16 },
  { 1823, 5, 19, 7, 1, -19 },
  { 1835, 9, 15, 13, 2, -15 },
  { 1852, 9, 15, 10, 0, -15 },
  { 1869, 16, 15, 16, 0, -15 },
  { 1899, 10, 15, 10, 0, -15 },
  { 1918, 10, 22, 10, 0, -15 },
  { 1946, 7, 15, 8, 1, -15 },
  { 1960, 8, 26, 10, 1, -21 },
  { 1986, 1, 29, 11, 5, -22 },
  { 1990, 8, 26, 10, 1, -21 },
  { 2016, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Light29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT29PT7B_H_
