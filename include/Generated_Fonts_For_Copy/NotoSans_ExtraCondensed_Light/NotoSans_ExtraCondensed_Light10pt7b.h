#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x55, 0xF6, 0xF6, 0x60, 0x27, 0xAA, 0x63, 0x3E, 0x20,
  0xEA, 0xCB, 0xAD, 0x74, 0xD2, 0x80, 0x66, 0x64, 0xB9, 0xF0, 0xC0, 0x5A,
  0xA5, 0x40, 0xD5, 0x55, 0x80, 0x5D, 0x80, 0x22, 0xF2, 0x20, 0xC0, 0xC0,
  0x80, 0x24, 0xA4, 0xA0, 0x69, 0x99, 0x99, 0x60, 0x75, 0x54, 0xE1, 0x12,
  0x24, 0xF0, 0xE1, 0x26, 0x11, 0xE0, 0x22, 0x66, 0xA7, 0x20, 0xE8, 0xC3,
  0x11, 0xE0, 0x68, 0xAD, 0x99, 0x60, 0xF1, 0x22, 0x24, 0x40, 0x79, 0x66,
  0x99, 0x60, 0x69, 0x9F, 0x11, 0xE0, 0x88, 0x8C, 0x12, 0xC2, 0x10, 0xF0,
  0xF0, 0x86, 0x16, 0x80, 0xE4, 0xA4, 0x10, 0xF4, 0x7B, 0x5A, 0xFA, 0x0C,
  0x26, 0x65, 0xB9, 0x90, 0xF6, 0xFB, 0x78, 0xF2, 0x49, 0x38, 0xF6, 0xDB,
  0x70, 0xEB, 0xAC, 0xEB, 0xA8, 0xF8, 0x8B, 0x99, 0xF0, 0xB6, 0xFB, 0x68,
  0xD5, 0x5C, 0xFF, 0x80, 0xBB, 0x4D, 0x68, 0xAA, 0xAC, 0x8C, 0x67, 0xBD,
  0xF6, 0xA0, 0x99, 0xDD, 0xBB, 0x90, 0xE9, 0x99, 0x99, 0xE0, 0xF6, 0xE9,
  0x20, 0xE9, 0x99, 0x99, 0xE2, 0x20, 0xF6, 0xED, 0x68, 0x78, 0x86, 0x11,
  0xE0, 0xE9, 0x24, 0x90, 0xB6, 0xDB, 0x78, 0x99, 0x96, 0x66, 0x20, 0x93,
  0x26, 0xD3, 0x66, 0xCD, 0x92, 0x00, 0x96, 0x64, 0x6A, 0x90, 0x9A, 0x64,
  0x44, 0x40, 0xE4, 0xA5, 0x38, 0xEA, 0xAA, 0xC0, 0x89, 0x22, 0x48, 0xD5,
  0x55, 0xC0, 0x26, 0x90, 0xF0, 0x90, 0x65, 0xDE, 0x93, 0x5B, 0x6F, 0x72,
  0x46, 0x11, 0x35, 0x99, 0x97, 0x79, 0xE8, 0x70, 0x6B, 0x24, 0x92, 0x79,
  0x99, 0x71, 0x70, 0x93, 0x5B, 0x6D, 0xBE, 0xBF, 0x80, 0x92, 0x69, 0xB5,
  0xFF, 0xFD, 0x6B, 0x5A, 0x80, 0xF6, 0xDA, 0x79, 0x99, 0x60, 0xF6, 0xDF,
  0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0xF1, 0x1E, 0x7A, 0xA4, 0xB6,
  0xDE, 0xB6, 0xA4, 0xAD, 0x6E, 0xB4, 0x80, 0xA9, 0x3A, 0xB5, 0xA4, 0xB0,
  0xE9, 0x4E, 0x69, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 3, 1, -7 },
  { 3, 4, 7, 4, 0, -7 },
  { 7, 4, 9, 4, 0, -8 },
  { 12, 6, 7, 6, 0, -7 },
  { 18, 4, 7, 4, 0, -7 },
  { 22, 1, 2, 2, 0, -7 },
  { 23, 2, 9, 3, 0, -7 },
  { 26, 2, 9, 3, 0, -7 },
  { 29, 3, 3, 4, 0, -8 },
  { 31, 4, 5, 4, 0, -6 },
  { 34, 1, 2, 2, 0, -1 },
  { 35, 2, 1, 3, 0, -3 },
  { 36, 1, 1, 2, 1, -1 },
  { 37, 3, 7, 4, 0, -7 },
  { 40, 4, 7, 4, 0, -7 },
  { 44, 2, 7, 4, 1, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 1, 5, 2, 1, -5 },
  { 79, 1, 6, 2, 0, -5 },
  { 80, 4, 5, 4, 0, -6 },
  { 83, 4, 3, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -6 },
  { 88, 3, 7, 3, 0, -7 },
  { 91, 5, 8, 6, 1, -7 },
  { 96, 4, 7, 4, 0, -7 },
  { 100, 3, 7, 5, 1, -7 },
  { 103, 3, 7, 4, 1, -7 },
  { 106, 3, 7, 5, 1, -7 },
  { 109, 2, 7, 4, 1, -7 },
  { 111, 2, 7, 4, 1, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 3, 7, 5, 1, -7 },
  { 120, 2, 7, 3, 0, -7 },
  { 122, 1, 9, 2, 0, -7 },
  { 124, 3, 7, 4, 1, -7 },
  { 127, 2, 7, 4, 1, -7 },
  { 129, 5, 7, 7, 1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 4, 7, 5, 1, -7 },
  { 142, 3, 7, 4, 1, -7 },
  { 145, 4, 9, 5, 1, -7 },
  { 150, 3, 7, 4, 1, -7 },
  { 153, 4, 7, 4, 0, -7 },
  { 157, 3, 7, 4, 0, -7 },
  { 160, 3, 7, 5, 1, -7 },
  { 163, 4, 7, 4, 0, -7 },
  { 167, 7, 7, 7, 0, -7 },
  { 174, 4, 7, 4, 0, -7 },
  { 178, 4, 7, 4, 0, -7 },
  { 182, 3, 7, 3, 0, -7 },
  { 185, 2, 9, 3, 1, -7 },
  { 188, 3, 7, 3, 0, -7 },
  { 191, 2, 9, 3, 0, -7 },
  { 194, 4, 3, 4, 0, -7 },
  { 196, 4, 1, 4, 0, 1 },
  { 197, 2, 2, 2, 0, -8 },
  { 198, 3, 5, 4, 0, -5 },
  { 200, 3, 8, 4, 1, -8 },
  { 203, 3, 5, 3, 0, -5 },
  { 205, 4, 8, 4, 0, -8 },
  { 209, 4, 5, 4, 0, -5 },
  { 212, 3, 8, 2, 0, -8 },
  { 215, 4, 7, 4, 0, -5 },
  { 219, 3, 8, 4, 1, -8 },
  { 222, 1, 7, 2, 0, -7 },
  { 223, 1, 9, 2, 0, -7 },
  { 225, 3, 8, 4, 1, -8 },
  { 228, 1, 8, 2, 0, -8 },
  { 229, 5, 5, 6, 1, -5 },
  { 233, 3, 5, 4, 1, -5 },
  { 235, 4, 5, 4, 0, -5 },
  { 238, 3, 7, 4, 1, -5 },
  { 241, 4, 7, 4, 0, -5 },
  { 245, 2, 5, 3, 1, -5 },
  { 247, 3, 5, 3, 0, -5 },
  { 249, 2, 7, 2, 0, -7 },
  { 251, 3, 5, 4, 1, -5 },
  { 253, 3, 5, 3, 0, -5 },
  { 255, 5, 5, 6, 0, -5 },
  { 259, 3, 5, 3, 0, -5 },
  { 261, 3, 7, 3, 0, -5 },
  { 264, 3, 5, 3, 0, -5 },
  { 266, 3, 9, 4, 0, -7 },
  { 270, 1, 10, 4, 1, -8 },
  { 272, 3, 9, 4, 0, -7 },
  { 276, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Light10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT10PT7B_H_
