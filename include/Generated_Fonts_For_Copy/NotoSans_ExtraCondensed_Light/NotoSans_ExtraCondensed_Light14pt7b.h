#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xB6, 0xD0, 0x28, 0xA2, 0x9F, 0x29, 0x2F, 0xD4, 0x51,
  0x40, 0x21, 0xD9, 0x4A, 0x30, 0x65, 0x2D, 0x5C, 0x40, 0xC9, 0x52, 0xA5,
  0x8B, 0xFB, 0x4A, 0x95, 0x2A, 0x9C, 0x31, 0x45, 0x14, 0x21, 0x99, 0x62,
  0x89, 0xD0, 0xF0, 0x5A, 0xAA, 0xA5, 0xC8, 0x92, 0x49, 0x25, 0x60, 0x44,
  0xFA, 0x21, 0x09, 0xF2, 0x10, 0xF0, 0xE0, 0x80, 0x08, 0x84, 0x22, 0x11,
  0x08, 0x44, 0x00, 0x69, 0x99, 0x99, 0x99, 0x96, 0x3C, 0x92, 0x49, 0x24,
  0xE1, 0x11, 0x12, 0x44, 0x8F, 0xF0, 0x42, 0x13, 0x08, 0x21, 0x0B, 0x80,
  0x10, 0x42, 0x8A, 0x49, 0x28, 0xBF, 0x08, 0x20, 0xF8, 0x88, 0xE1, 0x11,
  0x1E, 0x78, 0x88, 0xF9, 0x99, 0x96, 0xF1, 0x12, 0x22, 0x44, 0x48, 0x72,
  0x52, 0x93, 0x29, 0x31, 0x4B, 0xC0, 0xE9, 0x99, 0x9F, 0x11, 0x2E, 0xC1,
  0xC3, 0xC0, 0x09, 0xB0, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0xC1, 0x06, 0x32,
  0x60, 0xE1, 0x11, 0x24, 0x40, 0x04, 0x38, 0x8A, 0x0D, 0xDA, 0xB5, 0x6A,
  0xD5, 0x95, 0x01, 0xE0, 0x20, 0xC3, 0x14, 0x49, 0x27, 0xA2, 0x86, 0x10,
  0xF4, 0x63, 0x1F, 0x4A, 0x31, 0x8F, 0x80, 0x7C, 0x21, 0x08, 0x42, 0x10,
  0x83, 0xC0, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0x80, 0xF8, 0x88, 0xF8,
  0x88, 0x8F, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x7E, 0x08, 0x20, 0x82, 0x78,
  0x61, 0x85, 0xF0, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x8C, 0x40, 0xE9, 0x24,
  0x92, 0x5C, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x9C, 0xA9, 0x4C, 0x52, 0x92,
  0x94, 0x40, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x83, 0xC3, 0xC3, 0xC5, 0xA5,
  0xA5, 0xA9, 0x99, 0x99, 0x91, 0x8E, 0x73, 0x5A, 0xD6, 0x73, 0x8C, 0x40,
  0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x89, 0xC0, 0xF9, 0x99, 0x9E, 0x88,
  0x88, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0x89, 0xC1, 0x02, 0xF4, 0xA3,
  0x29, 0x72, 0x92, 0x94, 0x40, 0xF8, 0x88, 0x42, 0x11, 0x1E, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x00, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0x80,
  0x86, 0x28, 0x92, 0x49, 0x45, 0x0C, 0x30, 0x80, 0x88, 0xE2, 0x28, 0xC9,
  0x32, 0x54, 0x95, 0x45, 0x30, 0xCC, 0x23, 0x08, 0x80, 0x8A, 0x94, 0x62,
  0x11, 0x4A, 0x4C, 0x40, 0x8C, 0x54, 0xA5, 0x10, 0x84, 0x21, 0x00, 0xF0,
  0x84, 0x42, 0x11, 0x08, 0x47, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x82,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x40, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x20,
  0xC4, 0x92, 0x8C, 0xFC, 0xA4, 0x22, 0x82, 0x36, 0xC6, 0x2F, 0x84, 0x21,
  0x4D, 0x46, 0x31, 0x8C, 0xBC, 0x72, 0x49, 0x27, 0x11, 0x17, 0x99, 0x99,
  0x99, 0xF0, 0x69, 0x99, 0xE8, 0x87, 0x34, 0x4E, 0x44, 0x44, 0x44, 0x40,
  0x69, 0x99, 0x99, 0x9F, 0x11, 0xF0, 0x88, 0x8A, 0xD9, 0x99, 0x99, 0x90,
  0x9F, 0xC0, 0x41, 0x55, 0x55, 0xC0, 0x88, 0x89, 0xAA, 0xCA, 0xAA, 0x90,
  0xFF, 0xE0, 0x65, 0x36, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0x2D, 0x99, 0x99,
  0x99, 0x69, 0x99, 0x99, 0x9E, 0x26, 0xA3, 0x18, 0xC6, 0x5E, 0x84, 0x20,
  0x69, 0x99, 0x99, 0x9F, 0x11, 0x10, 0x3A, 0x49, 0x24, 0x34, 0x84, 0x21,
  0x1F, 0x5D, 0x24, 0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x9C, 0x94, 0xA6,
  0x10, 0x80, 0x99, 0x9A, 0x5A, 0x5A, 0x66, 0x64, 0x24, 0xDA, 0x88, 0x45,
  0x2A, 0x60, 0x8A, 0x94, 0xA5, 0x10, 0x84, 0x26, 0x00, 0x72, 0x24, 0x44,
  0xF0, 0x29, 0x24, 0xA2, 0x49, 0x30, 0xFF, 0xFC, 0x89, 0x24, 0x8A, 0x49,
  0x60, 0x6C, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 3, 4, 5, 1, -10 },
  { 5, 6, 10, 6, 0, -10 },
  { 13, 5, 12, 6, 0, -11 },
  { 21, 7, 10, 9, 1, -10 },
  { 30, 6, 10, 6, 0, -10 },
  { 38, 1, 4, 3, 1, -10 },
  { 39, 2, 12, 4, 1, -10 },
  { 42, 3, 12, 4, 0, -10 },
  { 47, 4, 4, 5, 1, -11 },
  { 49, 5, 6, 6, 0, -8 },
  { 53, 1, 4, 3, 1, -2 },
  { 54, 3, 1, 4, 0, -4 },
  { 55, 1, 1, 3, 1, -1 },
  { 56, 5, 10, 5, 0, -10 },
  { 63, 4, 10, 6, 1, -10 },
  { 68, 3, 10, 6, 1, -10 },
  { 72, 4, 10, 6, 1, -10 },
  { 77, 5, 10, 6, 0, -10 },
  { 84, 6, 10, 6, 0, -10 },
  { 92, 4, 10, 6, 1, -10 },
  { 97, 4, 10, 6, 1, -10 },
  { 102, 4, 10, 6, 1, -10 },
  { 107, 5, 10, 6, 0, -10 },
  { 114, 4, 10, 6, 1, -10 },
  { 119, 1, 8, 3, 1, -8 },
  { 120, 1, 10, 3, 1, -8 },
  { 122, 5, 6, 6, 0, -8 },
  { 126, 5, 4, 6, 0, -7 },
  { 129, 5, 6, 6, 0, -8 },
  { 133, 4, 10, 4, 0, -10 },
  { 138, 7, 11, 9, 1, -10 },
  { 148, 6, 10, 6, 0, -10 },
  { 156, 5, 10, 6, 1, -10 },
  { 163, 5, 10, 6, 1, -10 },
  { 170, 5, 10, 7, 1, -10 },
  { 177, 4, 10, 5, 1, -10 },
  { 182, 4, 10, 5, 1, -10 },
  { 187, 6, 10, 7, 1, -10 },
  { 195, 5, 10, 7, 1, -10 },
  { 202, 3, 10, 4, 0, -10 },
  { 206, 3, 13, 3, -1, -10 },
  { 211, 5, 10, 6, 1, -10 },
  { 218, 4, 10, 5, 1, -10 },
  { 223, 8, 10, 10, 1, -10 },
  { 233, 5, 10, 8, 1, -10 },
  { 240, 6, 10, 7, 1, -10 },
  { 248, 4, 10, 6, 1, -10 },
  { 253, 6, 12, 7, 1, -10 },
  { 262, 5, 10, 6, 1, -10 },
  { 269, 4, 10, 6, 1, -10 },
  { 274, 5, 10, 5, 0, -10 },
  { 281, 5, 10, 7, 1, -10 },
  { 288, 6, 10, 6, 0, -10 },
  { 296, 10, 10, 10, 0, -10 },
  { 309, 5, 10, 5, 0, -10 },
  { 316, 5, 10, 5, 0, -10 },
  { 323, 5, 10, 5, 0, -10 },
  { 330, 3, 12, 4, 1, -10 },
  { 335, 5, 10, 5, 0, -10 },
  { 342, 3, 12, 4, 0, -10 },
  { 347, 6, 5, 6, 0, -10 },
  { 351, 6, 1, 6, 0, 1 },
  { 352, 2, 3, 3, 1, -11 },
  { 353, 5, 8, 5, 0, -8 },
  { 358, 5, 11, 6, 1, -11 },
  { 365, 3, 8, 5, 1, -8 },
  { 368, 4, 11, 6, 1, -11 },
  { 374, 4, 8, 6, 1, -8 },
  { 378, 4, 11, 3, 0, -11 },
  { 384, 4, 11, 6, 1, -8 },
  { 390, 4, 11, 6, 1, -11 },
  { 396, 1, 10, 3, 1, -10 },
  { 398, 2, 13, 3, 0, -10 },
  { 402, 4, 11, 5, 1, -11 },
  { 408, 1, 11, 3, 1, -11 },
  { 410, 7, 8, 9, 1, -8 },
  { 417, 4, 8, 6, 1, -8 },
  { 421, 4, 8, 6, 1, -8 },
  { 425, 5, 11, 6, 1, -8 },
  { 432, 4, 11, 6, 1, -8 },
  { 438, 3, 8, 4, 1, -8 },
  { 441, 4, 8, 5, 0, -8 },
  { 445, 3, 9, 3, 0, -9 },
  { 449, 4, 7, 6, 1, -7 },
  { 453, 5, 7, 5, 0, -7 },
  { 458, 8, 7, 8, 0, -7 },
  { 465, 5, 7, 5, 0, -7 },
  { 470, 5, 10, 5, 0, -7 },
  { 477, 4, 7, 4, 0, -7 },
  { 481, 3, 12, 5, 1, -10 },
  { 486, 1, 14, 5, 2, -11 },
  { 488, 3, 12, 5, 1, -10 },
  { 493, 5, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Light14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT14PT7B_H_
