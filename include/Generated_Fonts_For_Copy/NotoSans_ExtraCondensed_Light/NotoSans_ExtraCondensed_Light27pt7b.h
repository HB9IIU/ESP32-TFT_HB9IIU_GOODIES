#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x18,
  0x84, 0x61, 0x10, 0x44, 0x11, 0x3F, 0xF1, 0x10, 0xC4, 0x31, 0x08, 0xC2,
  0x30, 0x88, 0xFF, 0xC8, 0x82, 0x20, 0x88, 0x62, 0x10, 0x84, 0x60, 0x08,
  0x04, 0x07, 0x8F, 0xF4, 0x86, 0x42, 0x21, 0x10, 0xC8, 0x34, 0x0E, 0x01,
  0xC0, 0xB0, 0x4C, 0x22, 0x11, 0x08, 0x84, 0xFA, 0xCF, 0xC0, 0x80, 0x40,
  0x20, 0x10, 0x00, 0xF0, 0x41, 0x21, 0x86, 0x62, 0x08, 0x44, 0x10, 0x98,
  0x21, 0x20, 0x42, 0x40, 0x85, 0xB9, 0x9A, 0x59, 0x25, 0x13, 0xDA, 0x21,
  0x24, 0x40, 0x48, 0xC1, 0x91, 0x82, 0x23, 0x04, 0x44, 0x18, 0x88, 0x21,
  0x90, 0xC1, 0xC0, 0x08, 0x07, 0x80, 0x98, 0x31, 0x06, 0x20, 0xC4, 0x09,
  0x81, 0x20, 0x3C, 0x03, 0x00, 0xE0, 0x36, 0x2C, 0x45, 0x0D, 0xA0, 0xA4,
  0x1C, 0x81, 0x98, 0x71, 0x9B, 0x3E, 0x30, 0xFE, 0x0C, 0x43, 0x08, 0x61,
  0x84, 0x10, 0x43, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x08, 0x30,
  0x40, 0xC0, 0xC3, 0x08, 0x63, 0x08, 0x63, 0x18, 0x42, 0x10, 0x84, 0x63,
  0x18, 0x8C, 0x62, 0x33, 0x00, 0x18, 0x18, 0x18, 0xDB, 0x3C, 0x18, 0x24,
  0x66, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x6D, 0xA5, 0xA0, 0xFC, 0xF0, 0x03, 0x02, 0x02,
  0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60,
  0x40, 0xC0, 0xC0, 0x80, 0x08, 0x1F, 0x18, 0xCC, 0x24, 0x12, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x41, 0x31,
  0x8C, 0x87, 0xC0, 0x19, 0xDB, 0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x18, 0x3F, 0x30, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30,
  0x1F, 0xF0, 0x08, 0x3F, 0x30, 0xC0, 0x20, 0x10, 0x0C, 0x04, 0x06, 0x02,
  0x1E, 0x0F, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xDF,
  0xC0, 0x01, 0x80, 0x70, 0x0E, 0x02, 0xC0, 0x58, 0x13, 0x02, 0x60, 0xCC,
  0x11, 0x86, 0x30, 0x86, 0x30, 0xC4, 0x19, 0xFF, 0xFF, 0xF8, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xB8, 0xFE, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x43,
  0xBF, 0x00, 0x02, 0x0F, 0x8C, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0xDE,
  0x7B, 0xB8, 0x58, 0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x41, 0xB0, 0x88, 0xC7,
  0xC0, 0xFF, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x08, 0x00, 0x08,
  0x1F, 0x18, 0xC8, 0x3C, 0x1E, 0x0D, 0x06, 0xC6, 0x36, 0x0E, 0x0F, 0x8C,
  0x64, 0x16, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0xD8, 0xC7, 0xC0, 0x08, 0x1F,
  0x18, 0xC8, 0x2C, 0x16, 0x0B, 0x07, 0x83, 0xC1, 0xE0, 0xD0, 0xEF, 0xF1,
  0x98, 0x08, 0x04, 0x02, 0x03, 0x01, 0x03, 0x8F, 0x80, 0xF0, 0x00, 0x02,
  0xF0, 0x6C, 0x00, 0x00, 0x00, 0x36, 0xD2, 0xD0, 0x00, 0x81, 0xC3, 0x87,
  0x0E, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x20, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x0C,
  0x0C, 0x18, 0x38, 0x70, 0x20, 0x00, 0x11, 0xF9, 0x18, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x18, 0x60, 0x81, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x07, 0xE0, 0x30, 0x60, 0x40, 0x61, 0x00, 0x46, 0x00, 0x48, 0x78, 0x91,
  0x91, 0x22, 0x23, 0xC4, 0x47, 0x98, 0x8F, 0x31, 0x1E, 0x62, 0x3C, 0xC4,
  0x58, 0x98, 0x91, 0x2B, 0x21, 0x9C, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC1, 0x00, 0xFE, 0x00, 0x0E, 0x01, 0x40, 0x28, 0x05, 0x01, 0xB0, 0x32,
  0x04, 0x40, 0x88, 0x11, 0x86, 0x30, 0xC2, 0x1F, 0xC2, 0x0C, 0xC1, 0x98,
  0x12, 0x02, 0x40, 0x78, 0x0F, 0x01, 0x80, 0xFE, 0x61, 0xB0, 0x78, 0x3C,
  0x1E, 0x0F, 0x05, 0x86, 0xFE, 0x7F, 0xB0, 0x58, 0x3C, 0x0E, 0x07, 0x03,
  0x83, 0xC1, 0xE3, 0xBF, 0x80, 0x02, 0x03, 0xF3, 0x84, 0xC0, 0x60, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x84, 0x3F, 0xFE, 0x30, 0xCC, 0x1B, 0x06, 0xC0,
  0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0B, 0x06, 0xC3, 0x31, 0xCF, 0xC0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xF8, 0xFF,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x00, 0x01, 0x00, 0xFF, 0x18, 0x23, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC1, 0xFC, 0x1F, 0xC0, 0x34,
  0x03, 0x40, 0x36, 0x03, 0x20, 0x33, 0x03, 0x18, 0x30, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8A,
  0xDC, 0xC1, 0xE1, 0xB0, 0x98, 0xCC, 0x46, 0x63, 0x61, 0xA0, 0xF0, 0x7C,
  0x32, 0x19, 0x8C, 0xC6, 0x33, 0x19, 0x86, 0xC3, 0x60, 0xF0, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0xF8, 0xC0, 0x0F, 0xC0, 0x1E, 0x80, 0x7D, 0x00, 0xFB,
  0x01, 0x72, 0x02, 0xE4, 0x0D, 0xC8, 0x13, 0x98, 0x27, 0x10, 0xCE, 0x21,
  0x9C, 0x62, 0x38, 0x44, 0x70, 0x98, 0xE1, 0xA1, 0xC3, 0x43, 0x83, 0x87,
  0x06, 0x0E, 0x0C, 0x18, 0xC0, 0x78, 0x1A, 0x06, 0x81, 0xB0, 0x64, 0x19,
  0x86, 0x21, 0x8C, 0x61, 0x18, 0x66, 0x19, 0x82, 0x60, 0xD8, 0x16, 0x07,
  0x80, 0xE0, 0x38, 0x0C, 0x02, 0x01, 0xF8, 0x30, 0xC2, 0x06, 0x60, 0x24,
  0x02, 0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34,
  0x03, 0x40, 0x36, 0x02, 0x60, 0x63, 0x06, 0x38, 0xC1, 0xF8, 0xFC, 0xC7,
  0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xCE, 0xFC, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x02, 0x01, 0xF8, 0x30, 0xC2, 0x06, 0x60,
  0x24, 0x02, 0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x34, 0x03, 0x40, 0x36, 0x02, 0x60, 0x63, 0x06, 0x38, 0xC1, 0xF8, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0xFC, 0x63, 0xB0, 0xD8, 0x2C,
  0x16, 0x0B, 0x05, 0x86, 0xC3, 0x7F, 0x3E, 0x19, 0x8C, 0x46, 0x33, 0x09,
  0x86, 0xC3, 0x60, 0xF0, 0x60, 0x08, 0x1F, 0xD8, 0x58, 0x0C, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x30, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xB1, 0xDF, 0xC0, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x98,
  0xE3, 0xF0, 0xC0, 0x78, 0x09, 0x01, 0x20, 0x66, 0x0C, 0xC1, 0x88, 0x21,
  0x04, 0x31, 0x86, 0x30, 0x44, 0x08, 0x81, 0x30, 0x36, 0x06, 0x80, 0x50,
  0x0A, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x50, 0x30, 0x34, 0x0C, 0x0D,
  0x03, 0x83, 0x60, 0xA0, 0x98, 0x68, 0x22, 0x12, 0x18, 0x84, 0x86, 0x21,
  0x31, 0x0C, 0x44, 0x43, 0x31, 0x10, 0x4C, 0x4C, 0x12, 0x13, 0x04, 0x86,
  0x81, 0xA0, 0xA0, 0x78, 0x28, 0x0E, 0x0E, 0x03, 0x03, 0x80, 0xC0, 0xC0,
  0x60, 0xD8, 0x62, 0x18, 0xC4, 0x13, 0x04, 0x81, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xE0, 0x78, 0x12, 0x0C, 0xC3, 0x10, 0x84, 0x61, 0x90, 0x2C, 0x0C,
  0xC0, 0xD0, 0x64, 0x19, 0x84, 0x23, 0x08, 0xC3, 0x20, 0x58, 0x16, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0xFF, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x40, 0xC0, 0x80, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0xC0,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04,
  0x04, 0x06, 0x02, 0x02, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x06, 0x01, 0xC0, 0x2C,
  0x0C, 0x81, 0x18, 0x61, 0x08, 0x23, 0x06, 0x40, 0x58, 0x0C, 0xFF, 0xFF,
  0xFC, 0xC3, 0x08, 0x61, 0x80, 0x18, 0x7E, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x3F, 0x63, 0xC3, 0xC3, 0x83, 0xC3, 0xC5, 0x79, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x21, 0x7C, 0xA3, 0x60, 0xB0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xE0, 0xB0, 0x54, 0x69, 0xE0, 0x0C, 0x7D, 0x82, 0x04,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x06, 0x0C, 0x4F, 0x80, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x62, 0x7D, 0x61, 0xA0, 0xF0, 0x78, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xA0, 0xD0, 0x6C, 0x53, 0xC8, 0x08, 0x1F,
  0x18, 0xC8, 0x24, 0x16, 0x0F, 0x07, 0xFF, 0xC0, 0x60, 0x30, 0x08, 0x06,
  0x01, 0x08, 0x7C, 0x0C, 0x3C, 0xC1, 0x83, 0x06, 0x0C, 0x7E, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x18, 0x1F,
  0x58, 0x68, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x28, 0x34,
  0x1B, 0x14, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x70, 0x67, 0xE0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x8C, 0xBE, 0xE3, 0xC3, 0xC3, 0xC3, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xB8, 0x0A, 0xAA, 0xAA,
  0xAA, 0x23, 0x20, 0x00, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x2E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x86, 0x84,
  0x8C, 0x98, 0x90, 0xB0, 0xB8, 0xD8, 0x88, 0x8C, 0x84, 0x86, 0x86, 0x83,
  0xFF, 0xFF, 0xF8, 0x08, 0x62, 0xFB, 0xEC, 0x70, 0xB0, 0xC3, 0x83, 0x0E,
  0x0C, 0x38, 0x20, 0xE0, 0x83, 0x82, 0x0E, 0x08, 0x38, 0x20, 0xE0, 0x83,
  0x82, 0x0E, 0x08, 0x38, 0x20, 0xC0, 0x08, 0xBE, 0xC3, 0xC3, 0xC3, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x0C, 0x1F, 0x98,
  0x48, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x28, 0x34, 0x1B,
  0x18, 0xF8, 0x08, 0x5F, 0x28, 0xD8, 0x2C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x78, 0x2C, 0x15, 0x1A, 0x79, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x08, 0x1F, 0x58, 0xA8, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x28, 0x34, 0x1B, 0x14, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0D, 0xE9, 0x8C, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x00,
  0x18, 0xFF, 0x04, 0x08, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x18, 0x30, 0x70,
  0xBF, 0x00, 0x42, 0x10, 0x8F, 0xA1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x63, 0xC0, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0xC3, 0xC5, 0x79, 0xC1, 0xA0, 0x90, 0x4C, 0x66, 0x31, 0x10, 0x88,
  0x44, 0x36, 0x0A, 0x05, 0x02, 0x81, 0xC0, 0x40, 0xC1, 0x86, 0x87, 0x09,
  0x0A, 0x13, 0x14, 0x26, 0x28, 0xC4, 0x59, 0x89, 0x92, 0x12, 0x24, 0x34,
  0x48, 0x68, 0xB0, 0x51, 0xC0, 0xE1, 0x81, 0x83, 0x03, 0x06, 0x00, 0x61,
  0x91, 0x88, 0x86, 0x41, 0x60, 0xE0, 0x30, 0x38, 0x14, 0x1B, 0x0C, 0x84,
  0x66, 0x16, 0x0C, 0xC1, 0xA0, 0xD8, 0x4C, 0x22, 0x31, 0x18, 0xC8, 0x64,
  0x16, 0x0B, 0x05, 0x03, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x1E, 0x04, 0x00, 0xFC, 0x30, 0x86, 0x10, 0x43, 0x08, 0x61, 0x84, 0x30,
  0x83, 0xF0, 0x0E, 0x30, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC6,
  0x03, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x60, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x20, 0x30, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x38, 0x00,
  0x70, 0xEF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Light27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 10, 19, 12, 1, -19 },
  { 35, 9, 23, 11, 1, -21 },
  { 61, 15, 20, 17, 1, -20 },
  { 99, 11, 20, 12, 1, -20 },
  { 127, 1, 7, 5, 2, -19 },
  { 128, 6, 23, 7, 1, -19 },
  { 146, 5, 23, 7, 1, -19 },
  { 161, 8, 8, 10, 1, -21 },
  { 169, 9, 13, 11, 1, -16 },
  { 184, 3, 7, 5, 1, -3 },
  { 187, 6, 1, 7, 1, -8 },
  { 188, 2, 2, 5, 2, -2 },
  { 189, 8, 19, 9, 1, -19 },
  { 208, 9, 20, 11, 1, -20 },
  { 231, 5, 19, 11, 2, -19 },
  { 243, 9, 20, 11, 1, -20 },
  { 266, 9, 20, 11, 1, -20 },
  { 289, 11, 19, 11, 0, -19 },
  { 316, 9, 19, 11, 1, -19 },
  { 338, 9, 20, 11, 1, -20 },
  { 361, 9, 19, 11, 1, -19 },
  { 383, 9, 20, 11, 1, -20 },
  { 406, 9, 20, 11, 1, -20 },
  { 429, 2, 14, 6, 2, -14 },
  { 433, 3, 18, 5, 1, -14 },
  { 440, 9, 11, 11, 1, -15 },
  { 453, 9, 7, 11, 1, -13 },
  { 461, 9, 11, 11, 1, -15 },
  { 474, 7, 20, 8, 0, -20 },
  { 492, 15, 21, 17, 1, -19 },
  { 532, 11, 19, 11, 0, -19 },
  { 559, 9, 19, 12, 2, -19 },
  { 581, 10, 20, 12, 1, -20 },
  { 606, 10, 19, 13, 2, -19 },
  { 630, 7, 19, 11, 2, -19 },
  { 647, 7, 19, 10, 2, -19 },
  { 664, 12, 20, 14, 1, -20 },
  { 694, 10, 19, 14, 2, -19 },
  { 718, 5, 19, 7, 1, -19 },
  { 730, 5, 24, 6, -1, -19 },
  { 745, 9, 19, 11, 2, -19 },
  { 767, 7, 19, 10, 2, -19 },
  { 784, 15, 19, 19, 2, -19 },
  { 820, 10, 19, 15, 2, -19 },
  { 844, 12, 20, 14, 1, -20 },
  { 874, 8, 19, 11, 2, -19 },
  { 893, 12, 25, 14, 1, -20 },
  { 931, 9, 19, 12, 2, -19 },
  { 953, 9, 20, 11, 1, -20 },
  { 976, 9, 19, 10, 0, -19 },
  { 998, 10, 19, 14, 2, -19 },
  { 1022, 11, 19, 11, 0, -19 },
  { 1049, 18, 19, 18, 0, -19 },
  { 1092, 10, 19, 10, 0, -19 },
  { 1116, 10, 19, 10, 0, -19 },
  { 1140, 8, 19, 9, 1, -19 },
  { 1159, 5, 23, 8, 2, -19 },
  { 1174, 8, 19, 9, 1, -19 },
  { 1193, 5, 23, 8, 1, -19 },
  { 1208, 11, 10, 11, 0, -19 },
  { 1222, 11, 2, 11, 0, 2 },
  { 1225, 5, 5, 7, 1, -21 },
  { 1229, 8, 15, 11, 1, -15 },
  { 1244, 9, 21, 12, 2, -21 },
  { 1268, 7, 15, 9, 1, -15 },
  { 1282, 9, 21, 12, 1, -21 },
  { 1306, 9, 15, 11, 1, -15 },
  { 1323, 7, 21, 6, 0, -21 },
  { 1342, 9, 22, 12, 1, -15 },
  { 1367, 8, 21, 12, 2, -21 },
  { 1388, 2, 20, 5, 2, -20 },
  { 1393, 4, 27, 5, 0, -20 },
  { 1407, 8, 21, 10, 2, -21 },
  { 1428, 1, 21, 5, 2, -21 },
  { 1431, 14, 15, 17, 2, -15 },
  { 1458, 8, 15, 12, 2, -15 },
  { 1473, 9, 15, 11, 1, -15 },
  { 1490, 9, 21, 12, 2, -15 },
  { 1514, 9, 21, 12, 1, -15 },
  { 1538, 5, 15, 8, 2, -15 },
  { 1548, 7, 15, 9, 1, -15 },
  { 1562, 5, 18, 6, 1, -18 },
  { 1574, 8, 14, 12, 2, -14 },
  { 1588, 9, 14, 9, 0, -14 },
  { 1604, 15, 14, 15, 0, -14 },
  { 1631, 9, 14, 9, 0, -14 },
  { 1647, 9, 21, 9, 0, -14 },
  { 1671, 6, 14, 8, 1, -14 },
  { 1682, 7, 23, 10, 1, -19 },
  { 1703, 1, 27, 11, 5, -21 },
  { 1707, 7, 23, 10, 1, -19 },
  { 1728, 9, 3, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Light27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT27PT7B_H_
