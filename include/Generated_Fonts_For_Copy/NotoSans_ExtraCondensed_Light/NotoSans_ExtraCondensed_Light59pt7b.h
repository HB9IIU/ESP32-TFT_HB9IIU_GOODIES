#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0x00,
  0x7B, 0xFF, 0xFF, 0x80, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x70,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60,
  0x01, 0xC0, 0x60, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x01, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0,
  0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x01, 0xC0,
  0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x00,
  0x0E, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0C, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0xE3, 0xE6, 0x3C, 0x38, 0x60, 0x47, 0x06, 0x00, 0x70, 0x60,
  0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06,
  0x00, 0xE0, 0x60, 0x07, 0x06, 0x00, 0x70, 0x60, 0x03, 0x86, 0x00, 0x3E,
  0x60, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x67, 0xC0, 0x06, 0x3E, 0x00, 0x60, 0xE0, 0x06, 0x0F,
  0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60,
  0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x0E, 0xC0, 0x61, 0xEF, 0x86,
  0x7C, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x38, 0x03, 0x8E, 0x00, 0x70,
  0x06, 0x0E, 0x00, 0xC0, 0x1C, 0x0C, 0x03, 0x80, 0x38, 0x18, 0x07, 0x00,
  0x70, 0x38, 0x0C, 0x00, 0xC0, 0x70, 0x38, 0x01, 0x80, 0xE0, 0x70, 0x03,
  0x01, 0xC0, 0xC0, 0x06, 0x03, 0x83, 0x80, 0x0C, 0x07, 0x07, 0x00, 0x18,
  0x0E, 0x0C, 0x00, 0x30, 0x1C, 0x38, 0x00, 0x60, 0x38, 0x70, 0x00, 0xC0,
  0x70, 0xC0, 0x01, 0x80, 0xE3, 0x83, 0xC3, 0x81, 0xC7, 0x1F, 0xC7, 0x03,
  0x8C, 0x3B, 0xCE, 0x06, 0x38, 0xE1, 0x9C, 0x1C, 0x71, 0x83, 0x9C, 0x38,
  0xC7, 0x07, 0x38, 0xE3, 0x8E, 0x06, 0x3F, 0xC7, 0x18, 0x0E, 0x3F, 0x0C,
  0x30, 0x1C, 0x38, 0x38, 0x60, 0x38, 0x00, 0x71, 0xC0, 0x70, 0x00, 0xC3,
  0x80, 0xE0, 0x03, 0x87, 0x01, 0xC0, 0x07, 0x0E, 0x03, 0x80, 0x0C, 0x1C,
  0x07, 0x00, 0x38, 0x38, 0x0E, 0x00, 0x70, 0x30, 0x1C, 0x00, 0xC0, 0x60,
  0x38, 0x03, 0x80, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0xC0, 0x0C, 0x03, 0x81,
  0x80, 0x38, 0x07, 0x07, 0x00, 0x70, 0x06, 0x0E, 0x00, 0xC0, 0x0E, 0x38,
  0x03, 0x80, 0x0F, 0xF0, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x06, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x3C, 0x70, 0x1C, 0x78, 0x38, 0x1C, 0x70, 0x3C, 0x1C, 0x70, 0x1C, 0x1C,
  0xF0, 0x1E, 0x3C, 0xE0, 0x0E, 0x38, 0xE0, 0x07, 0x38, 0xE0, 0x07, 0x38,
  0xE0, 0x03, 0xF0, 0xE0, 0x03, 0xF0, 0xE0, 0x01, 0xF0, 0xE0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xF0, 0x78, 0x07, 0xF8, 0x78, 0x0F, 0x38,
  0x3E, 0x7E, 0x3C, 0x1F, 0xFC, 0x1E, 0x0F, 0xF8, 0x0F, 0x01, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x02, 0x06, 0x05, 0xE3, 0x1E, 0xFF, 0xFF, 0xBF, 0xFF, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x70, 0xE0, 0x78, 0x70,
  0x78, 0x1C, 0x18, 0x0E, 0x04, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x38, 0x71,
  0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x8F, 0x01, 0xC0, 0xF0, 0x78,
  0x0E, 0x0E, 0x01, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x79, 0xC0,
  0x07, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x0E, 0xF0, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01,
  0xC7, 0x80, 0x38, 0x70, 0x0F, 0x0F, 0x01, 0xC0, 0xF0, 0x78, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F,
  0x0F, 0x71, 0xE7, 0x3C, 0x77, 0x87, 0xF0, 0x76, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xE1, 0xF0, 0x70, 0x07, 0x82, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xFC, 0x3E, 0x0F, 0xCF, 0x00, 0x78, 0xC0, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF6, 0x00, 0x3C, 0xFC, 0x3F, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x30, 0x07, 0xC7, 0xC7, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xF0, 0xC0,
  0xF8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x3F, 0x83, 0x9F, 0xF8, 0x77,
  0xFF, 0x8E, 0xE0, 0xF9, 0xF0, 0x07, 0x3E, 0x00, 0xF7, 0x80, 0x0E, 0xF0,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3D, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xE0,
  0x3C, 0x1F, 0x1F, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x78, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0xC0, 0x3C,
  0x1E, 0x03, 0x80, 0xF0, 0xF0, 0x07, 0x9F, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x83, 0xC0,
  0x3C, 0x38, 0x01, 0xC7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C,
  0x1F, 0x0F, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x8F, 0x83, 0xC0, 0x78, 0x70, 0x07,
  0x1E, 0x00, 0xF3, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1E,
  0xF0, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x77, 0x1F, 0xFC, 0xE1, 0xFF, 0x9C,
  0x0F, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x39, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x6F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x08,
  0x78, 0xF9, 0xF3, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xE1,
  0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x7F, 0xC3, 0xFF, 0xE7, 0x87, 0xC4, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x71, 0xC0, 0x06, 0x00, 0xE3, 0x80, 0x7F, 0xC1, 0xCE, 0x01, 0xFF,
  0x81, 0x9C, 0x07, 0x87, 0x03, 0xB8, 0x1E, 0x0E, 0x07, 0x70, 0x38, 0x1C,
  0x0E, 0xC0, 0x70, 0x38, 0x1F, 0x81, 0xC0, 0x70, 0x3F, 0x03, 0x80, 0xE0,
  0x7E, 0x07, 0x01, 0xC0, 0xFC, 0x0E, 0x03, 0x01, 0xF8, 0x1C, 0x0E, 0x03,
  0xF0, 0x38, 0x1C, 0x07, 0xE0, 0x70, 0x38, 0x0F, 0xC0, 0xE0, 0x70, 0x1F,
  0x81, 0xC0, 0xE0, 0x3F, 0x03, 0x81, 0xC0, 0x7E, 0x07, 0x03, 0x80, 0xFC,
  0x0E, 0x05, 0x03, 0xB8, 0x1C, 0x1B, 0x07, 0x70, 0x1C, 0x36, 0x0E, 0x60,
  0x3C, 0xCE, 0x78, 0xE0, 0x3F, 0x8F, 0xE1, 0xC0, 0x3E, 0x1F, 0x83, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00,
  0x78, 0xF0, 0x7F, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x01, 0xF8, 0xF0,
  0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x07, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xE1, 0xE0,
  0x7C, 0x01, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x02, 0x03, 0xF9,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x03, 0xC3, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x1F, 0x0F, 0x01, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7C, 0x00, 0x70, 0x3C, 0x00, 0x08,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x1C, 0x3E, 0x00, 0x0E, 0x0F, 0x80, 0x07, 0x03, 0xFC,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFC, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xD0, 0xFB, 0xFE, 0x7F, 0x87, 0xC0, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C,
  0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1C,
  0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x70, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0x7C,
  0x00, 0x7F, 0xF0, 0x03, 0xF3, 0x80, 0x1F, 0x1E, 0x00, 0xF8, 0x70, 0x07,
  0x83, 0xC0, 0x3C, 0x0E, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x38, 0x3C,
  0x01, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0xC0, 0x07,
  0x9E, 0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xEE, 0x00, 0x00, 0x3F, 0xEE, 0x00, 0x00,
  0x77, 0xEE, 0x00, 0x00, 0x77, 0xF7, 0x00, 0x00, 0x77, 0xF7, 0x00, 0x00,
  0xE7, 0xF7, 0x00, 0x00, 0xE7, 0xF3, 0x80, 0x00, 0xE7, 0xF3, 0x80, 0x00,
  0xE7, 0xF3, 0x80, 0x01, 0xC7, 0xF3, 0x80, 0x01, 0xC7, 0xF1, 0xC0, 0x01,
  0xC7, 0xF1, 0xC0, 0x03, 0x87, 0xF1, 0xC0, 0x03, 0x87, 0xF0, 0xE0, 0x03,
  0x87, 0xF0, 0xE0, 0x07, 0x87, 0xF0, 0xE0, 0x07, 0x07, 0xF0, 0x60, 0x07,
  0x07, 0xF0, 0x70, 0x07, 0x07, 0xF0, 0x70, 0x0E, 0x07, 0xF0, 0x70, 0x0E,
  0x07, 0xF0, 0x38, 0x0E, 0x07, 0xF0, 0x38, 0x1C, 0x07, 0xF0, 0x38, 0x1C,
  0x07, 0xF0, 0x1C, 0x1C, 0x07, 0xF0, 0x1C, 0x1C, 0x07, 0xF0, 0x1C, 0x38,
  0x07, 0xF0, 0x1C, 0x38, 0x07, 0xF0, 0x0E, 0x38, 0x07, 0xF0, 0x0E, 0x70,
  0x07, 0xF0, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xE0,
  0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFD,
  0xC0, 0x01, 0xFB, 0x80, 0x03, 0xFB, 0x80, 0x07, 0xF7, 0x00, 0x0F, 0xEF,
  0x00, 0x1F, 0xCE, 0x00, 0x3F, 0x9C, 0x00, 0x7F, 0x1C, 0x00, 0xFE, 0x38,
  0x01, 0xFC, 0x38, 0x03, 0xF8, 0x70, 0x07, 0xF0, 0xF0, 0x0F, 0xE0, 0xE0,
  0x1F, 0xC1, 0xC0, 0x3F, 0x81, 0xC0, 0x7F, 0x03, 0x80, 0xFE, 0x03, 0x81,
  0xFC, 0x07, 0x03, 0xF8, 0x0F, 0x07, 0xF0, 0x0E, 0x0F, 0xE0, 0x1E, 0x1F,
  0xC0, 0x1C, 0x3F, 0x80, 0x38, 0x7F, 0x00, 0x38, 0xFE, 0x00, 0x71, 0xFC,
  0x00, 0xF3, 0xF8, 0x00, 0xE7, 0xF0, 0x01, 0xEF, 0xE0, 0x01, 0xDF, 0xC0,
  0x03, 0xBF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x07, 0x80, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0xF0,
  0x1F, 0x00, 0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x78,
  0x0F, 0xCF, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0,
  0x0F, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xC1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x1F, 0x00,
  0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xE0, 0x3F, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07,
  0x1E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x39, 0xE0,
  0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38,
  0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x1F, 0x0F, 0x03,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xF0, 0x78, 0x07,
  0x81, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x3C, 0x3C,
  0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xE7, 0xE3, 0xE0, 0x04, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF7, 0x00, 0x7C, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xC3,
  0xE0, 0x1E, 0x07, 0xF3, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x81, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03,
  0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x80, 0x01,
  0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x3E, 0x00, 0x0E, 0x78, 0x00, 0x7E,
  0x00, 0x0E, 0x38, 0x00, 0x7E, 0x00, 0x1E, 0x38, 0x00, 0x7E, 0x00, 0x1C,
  0x38, 0x00, 0x76, 0x00, 0x1C, 0x3C, 0x00, 0x77, 0x00, 0x1C, 0x1C, 0x00,
  0xE7, 0x00, 0x1C, 0x1C, 0x00, 0xE7, 0x00, 0x3C, 0x1C, 0x00, 0xE7, 0x00,
  0x38, 0x1C, 0x00, 0xE7, 0x00, 0x38, 0x1E, 0x00, 0xE3, 0x80, 0x38, 0x0E,
  0x01, 0xC3, 0x80, 0x78, 0x0E, 0x01, 0xC3, 0x80, 0x78, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x0F, 0x01, 0xC1, 0xC0, 0x70,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0xE0,
  0xE0, 0x03, 0x87, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x01, 0xCE, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x00, 0xEE,
  0x00, 0x33, 0x80, 0x00, 0xEC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1E,
  0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x80, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x39,
  0xE0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x78, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1E, 0x07,
  0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x3C, 0x38, 0x01, 0xC7, 0x80,
  0x1C, 0x70, 0x01, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x01, 0xE3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xF0,
  0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xF0, 0x78, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xF1, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xF7,
  0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x3C, 0x0E,
  0x00, 0x38, 0x3C, 0x00, 0x78, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80,
  0x00, 0xEF, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x03, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x83, 0x81, 0xE1,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x0F, 0xFE, 0x1F,
  0xFF, 0x1F, 0x83, 0x9E, 0x01, 0xDE, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xEE, 0x01, 0xF7, 0x80, 0xF9, 0xE1, 0xCC, 0xFF, 0xC6, 0x3F, 0xC3, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F,
  0x80, 0xE3, 0xFE, 0x0E, 0x7F, 0xF0, 0xEE, 0x07, 0x8E, 0xC0, 0x3C, 0xF8,
  0x03, 0xCF, 0x80, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xCF, 0x80, 0x1C, 0xF8, 0x03, 0xCE, 0xC0, 0x78, 0xE7,
  0x0F, 0x8E, 0x7F, 0xF0, 0xE1, 0xFE, 0x00, 0x02, 0x00, 0x01, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF8, 0xF8, 0x23, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xF1, 0xC3, 0xFF, 0x83, 0xFF, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x07, 0xC1, 0xC3, 0xFE, 0x38, 0xFF,
  0xE7, 0x3E, 0x0E, 0xE7, 0x80, 0xFD, 0xE0, 0x0F, 0xB8, 0x00, 0xF7, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x1F, 0x78, 0x03,
  0xE7, 0x80, 0xDC, 0x78, 0x7B, 0x8F, 0xFE, 0x30, 0x7F, 0x86, 0x01, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x38, 0x38, 0x07,
  0x1E, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x01, 0xB8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0x87, 0xC1, 0xE0, 0xFF, 0xF8, 0x0F,
  0xF8, 0x00, 0x60, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x0F, 0xFF, 0x3F, 0xFC, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0x07, 0x73, 0xC0, 0x7E, 0xF0,
  0x07, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xEE, 0x00,
  0x3D, 0xC0, 0x0F, 0xBC, 0x01, 0xF3, 0xC0, 0x6E, 0x3E, 0x39, 0xC7, 0xFF,
  0x38, 0x3F, 0x87, 0x00, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xD0, 0x00, 0x71, 0x80, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x3E, 0x0E, 0x3F, 0xE3, 0x9F,
  0xFC, 0xEE, 0x0F, 0x3B, 0x01, 0xEF, 0x80, 0x3B, 0xE0, 0x0E, 0xF0, 0x03,
  0xBC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0xEF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0xFC,
  0xFC, 0xF8, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x3D, 0xC0, 0x1C,
  0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x07,
  0x03, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x1C,
  0xF8, 0x0E, 0xFC, 0x07, 0xEF, 0x03, 0xE3, 0x81, 0xF1, 0xC0, 0xF0, 0x70,
  0x70, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0xB8, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xC3, 0x8F,
  0xF0, 0x7F, 0x8E, 0x7F, 0xE3, 0xFF, 0x3B, 0x87, 0x9C, 0x1E, 0xEC, 0x0F,
  0x60, 0x3B, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0x7C, 0x01, 0xFC, 0x01, 0xE0,
  0x07, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01,
  0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E,
  0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80,
  0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03,
  0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01,
  0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E,
  0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0xF8, 0x38, 0xFF, 0x8E,
  0x7F, 0xF3, 0xB8, 0x3C, 0xEC, 0x07, 0xBE, 0x00, 0xEF, 0x80, 0x3B, 0xC0,
  0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x07, 0x1C,
  0x01, 0xC3, 0xC0, 0x78, 0x3E, 0x3E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x40, 0x00, 0x00, 0xF8, 0x0E, 0x3F, 0xE0, 0xE7, 0xFF, 0x0E, 0xE0, 0x78,
  0xEC, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF8, 0x01, 0xCE, 0xC0, 0x3C,
  0xEE, 0x07, 0x8E, 0x71, 0xF0, 0xE7, 0xFF, 0x0E, 0x1F, 0xC0, 0xE0, 0x20,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0x07, 0x73, 0xC0, 0x7E, 0xF0, 0x07, 0xDC,
  0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0,
  0x0F, 0xBC, 0x01, 0xF3, 0xC0, 0x6E, 0x3E, 0x39, 0xC7, 0xFF, 0x38, 0x3F,
  0x87, 0x00, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0xFE, 0x3F, 0xE7, 0xFE, 0x71, 0xEE, 0x0E, 0xC0, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0xF0, 0x3F, 0xFC, 0xFF, 0xFB, 0xE0, 0x67, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xDF, 0x1F, 0xBF, 0xFE, 0x1F, 0xF8, 0x03,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x10, 0xFF, 0x07, 0xF0,
  0x08, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xDC, 0x03, 0x6F, 0x03,
  0xB7, 0xC7, 0x99, 0xFF, 0x8C, 0x7F, 0x86, 0x07, 0x00, 0xF0, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0xF1, 0xC0, 0x1C, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x07,
  0x38, 0x00, 0xE7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x80,
  0x3E, 0x00, 0xF7, 0x00, 0x6C, 0x01, 0xCE, 0x00, 0xDC, 0x03, 0x9C, 0x03,
  0xB8, 0x07, 0x38, 0x07, 0x70, 0x0E, 0x38, 0x0E, 0xE0, 0x38, 0x70, 0x1C,
  0xC0, 0x70, 0xE0, 0x31, 0xC0, 0xE1, 0xC0, 0xE3, 0x81, 0xC3, 0x81, 0xC7,
  0x03, 0x83, 0x83, 0x8E, 0x0E, 0x07, 0x07, 0x0C, 0x1C, 0x0E, 0x1C, 0x1C,
  0x38, 0x1C, 0x38, 0x38, 0x70, 0x3C, 0x70, 0x70, 0xC0, 0x38, 0xE0, 0xE3,
  0x80, 0x71, 0x80, 0xC7, 0x00, 0xE7, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x9C,
  0x01, 0xDC, 0x07, 0x30, 0x03, 0xB8, 0x0E, 0xE0, 0x07, 0x60, 0x0D, 0xC0,
  0x0E, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xF0, 0x03, 0xDE, 0x00, 0xE3, 0x80, 0x78, 0xF0, 0x1C, 0x1C, 0x07, 0x07,
  0x03, 0x80, 0xE0, 0xE0, 0x38, 0x78, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x7B,
  0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x3C, 0x03,
  0xC7, 0x00, 0xE1, 0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x1E, 0x70, 0x03, 0x9C, 0x00, 0xFF, 0x00, 0x1C, 0xE0, 0x01,
  0xFE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0xF0, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0xFE, 0x01, 0xE0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x01, 0xF8, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x3C,
  0x01, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x0B, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xC1, 0xFF, 0xF8, 0x03, 0xFF,
  0x40, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 42, 13, 4, -42 },
  { 28, 12, 15, 20, 4, -42 },
  { 51, 24, 42, 26, 1, -42 },
  { 177, 20, 48, 24, 2, -45 },
  { 297, 31, 44, 36, 3, -43 },
  { 468, 24, 44, 25, 2, -43 },
  { 600, 3, 15, 11, 4, -42 },
  { 606, 11, 51, 16, 3, -42 },
  { 677, 11, 51, 16, 2, -42 },
  { 748, 17, 18, 22, 2, -45 },
  { 787, 21, 28, 24, 2, -35 },
  { 861, 7, 14, 12, 2, -6 },
  { 874, 12, 4, 16, 2, -18 },
  { 880, 4, 5, 12, 4, -5 },
  { 883, 19, 42, 21, 1, -42 },
  { 983, 19, 43, 24, 3, -43 },
  { 1086, 12, 42, 24, 4, -42 },
  { 1149, 20, 43, 24, 2, -43 },
  { 1257, 19, 44, 24, 2, -43 },
  { 1362, 23, 42, 24, 1, -42 },
  { 1483, 19, 43, 24, 3, -42 },
  { 1586, 19, 44, 24, 3, -43 },
  { 1691, 20, 42, 24, 2, -42 },
  { 1796, 20, 44, 24, 2, -43 },
  { 1906, 19, 44, 24, 2, -43 },
  { 2011, 4, 32, 12, 4, -32 },
  { 2027, 7, 40, 12, 2, -32 },
  { 2062, 21, 26, 24, 2, -34 },
  { 2131, 21, 16, 24, 2, -29 },
  { 2173, 21, 26, 24, 2, -34 },
  { 2242, 15, 43, 17, 1, -43 },
  { 2323, 31, 47, 37, 3, -42 },
  { 2506, 24, 42, 24, 0, -42 },
  { 2632, 20, 42, 27, 4, -42 },
  { 2737, 21, 44, 25, 3, -43 },
  { 2853, 22, 42, 29, 4, -42 },
  { 2969, 16, 42, 23, 4, -42 },
  { 3053, 16, 42, 22, 4, -42 },
  { 3137, 25, 44, 31, 3, -43 },
  { 3275, 22, 42, 30, 4, -42 },
  { 3391, 11, 42, 15, 2, -42 },
  { 3449, 11, 53, 12, -3, -42 },
  { 3522, 21, 42, 24, 4, -42 },
  { 3633, 16, 42, 21, 4, -42 },
  { 3717, 32, 42, 40, 4, -42 },
  { 3885, 23, 42, 32, 4, -42 },
  { 4006, 25, 44, 31, 3, -43 },
  { 4144, 19, 42, 25, 4, -42 },
  { 4244, 25, 53, 31, 3, -43 },
  { 4410, 21, 42, 26, 4, -42 },
  { 4521, 19, 44, 24, 2, -43 },
  { 4626, 20, 42, 21, 1, -42 },
  { 4731, 22, 43, 30, 4, -42 },
  { 4850, 24, 42, 24, 0, -42 },
  { 4976, 40, 42, 40, 0, -42 },
  { 5186, 20, 42, 22, 1, -42 },
  { 5291, 21, 42, 21, 0, -42 },
  { 5402, 17, 42, 20, 2, -42 },
  { 5492, 11, 51, 18, 5, -42 },
  { 5563, 19, 42, 21, 1, -42 },
  { 5663, 12, 51, 18, 2, -42 },
  { 5740, 23, 21, 25, 1, -42 },
  { 5801, 25, 3, 24, 0, 5 },
  { 5811, 10, 9, 15, 2, -45 },
  { 5823, 17, 33, 23, 2, -32 },
  { 5894, 20, 46, 26, 4, -45 },
  { 6009, 15, 33, 19, 3, -32 },
  { 6071, 19, 46, 26, 3, -45 },
  { 6181, 18, 33, 24, 3, -32 },
  { 6256, 14, 45, 14, 1, -45 },
  { 6335, 19, 46, 26, 3, -32 },
  { 6445, 18, 45, 25, 4, -45 },
  { 6547, 4, 43, 11, 4, -43 },
  { 6569, 8, 57, 11, 0, -43 },
  { 6626, 17, 45, 21, 4, -45 },
  { 6722, 3, 45, 11, 4, -45 },
  { 6739, 30, 32, 38, 4, -32 },
  { 6859, 18, 32, 25, 4, -32 },
  { 6931, 19, 33, 25, 3, -32 },
  { 7010, 20, 46, 26, 4, -32 },
  { 7125, 19, 46, 26, 3, -32 },
  { 7235, 12, 32, 17, 4, -32 },
  { 7283, 15, 33, 19, 2, -32 },
  { 7345, 12, 40, 14, 1, -39 },
  { 7405, 17, 32, 25, 4, -31 },
  { 7473, 19, 31, 20, 0, -31 },
  { 7547, 31, 31, 33, 1, -31 },
  { 7668, 18, 31, 20, 1, -31 },
  { 7738, 19, 45, 20, 1, -31 },
  { 7845, 13, 31, 17, 2, -31 },
  { 7896, 15, 51, 21, 3, -42 },
  { 7992, 3, 59, 23, 10, -45 },
  { 8015, 15, 51, 21, 3, -42 },
  { 8111, 21, 6, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Light59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT59PT7B_H_
