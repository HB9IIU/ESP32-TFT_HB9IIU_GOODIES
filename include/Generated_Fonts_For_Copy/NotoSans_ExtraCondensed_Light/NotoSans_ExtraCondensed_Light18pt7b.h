#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0xAA, 0xA2, 0xC0, 0x99, 0x99, 0x90, 0x12, 0x14, 0x14, 0x24,
  0x7F, 0x24, 0x24, 0x24, 0xFE, 0x24, 0x28, 0x48, 0x48, 0x20, 0x8F, 0xA8,
  0xA2, 0x8E, 0x0C, 0x28, 0x92, 0x49, 0xF8, 0x82, 0x00, 0x62, 0x51, 0x25,
  0x12, 0x89, 0x44, 0xDA, 0xAA, 0xD5, 0x14, 0x8A, 0x44, 0xA4, 0x52, 0x38,
  0x70, 0xA2, 0x42, 0x85, 0x0C, 0x18, 0x52, 0x95, 0x1A, 0x34, 0x6F, 0x60,
  0xF8, 0x29, 0x29, 0x24, 0x92, 0x44, 0x89, 0x91, 0x22, 0x49, 0x24, 0x94,
  0xA4, 0x21, 0x3E, 0x45, 0x48, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20,
  0xEA, 0xF0, 0xB0, 0x04, 0x10, 0x82, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10,
  0xC0, 0x71, 0x28, 0xA2, 0x86, 0x18, 0x61, 0x86, 0x28, 0x92, 0x70, 0x13,
  0xD1, 0x11, 0x11, 0x11, 0x11, 0x10, 0xF2, 0x20, 0x82, 0x08, 0x21, 0x84,
  0x20, 0x84, 0x20, 0xFC, 0xF2, 0x20, 0x82, 0x08, 0x47, 0x02, 0x08, 0x10,
  0x82, 0xF0, 0x0C, 0x18, 0x50, 0xA2, 0x44, 0x91, 0x22, 0x45, 0xFC, 0x10,
  0x20, 0x40, 0xFA, 0x08, 0x20, 0x83, 0xC0, 0x82, 0x04, 0x10, 0x82, 0xF0,
  0x39, 0x04, 0x20, 0x82, 0xCC, 0xA2, 0x86, 0x18, 0x62, 0x78, 0xFC, 0x20,
  0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10, 0x40, 0x72, 0x28, 0xE2, 0x89,
  0x43, 0x32, 0x8E, 0x18, 0x62, 0x78, 0x72, 0x28, 0xA2, 0x8A, 0x38, 0x9E,
  0x08, 0x20, 0x84, 0xF0, 0xB0, 0x00, 0xB0, 0xB0, 0x00, 0xEA, 0x04, 0x66,
  0x20, 0x40, 0xC0, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x19,
  0x88, 0x00, 0xF0, 0x42, 0x10, 0x88, 0x84, 0x21, 0x00, 0x46, 0x00, 0x1E,
  0x10, 0x90, 0x28, 0x19, 0xEC, 0x96, 0x4B, 0x49, 0x94, 0xCA, 0x66, 0xD0,
  0x04, 0x01, 0x10, 0x70, 0x10, 0x30, 0xA1, 0x42, 0x84, 0x89, 0x22, 0x7C,
  0x85, 0x0C, 0x18, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x3F, 0xA1, 0x86, 0x18,
  0x61, 0xF8, 0x3D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x3C,
  0xF9, 0x1A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14, 0x6F, 0x80,
  0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x0F, 0x80, 0xFC, 0x21, 0x08,
  0x43, 0xF0, 0x84, 0x21, 0x08, 0x00, 0x3E, 0x62, 0x40, 0x80, 0x80, 0x80,
  0x8F, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xE9, 0x24, 0x92, 0x49, 0x2E,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x86, 0x38, 0xA4, 0x92, 0x8A, 0x34,
  0x92, 0x28, 0xA1, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F,
  0x80, 0xC0, 0xF0, 0x3A, 0x0E, 0x83, 0xA1, 0x68, 0x59, 0x16, 0x49, 0x92,
  0x62, 0x98, 0xC6, 0x31, 0x84, 0x40, 0xC3, 0x86, 0x8D, 0x1A, 0x32, 0x64,
  0xC5, 0x8B, 0x0E, 0x1C, 0x38, 0x20, 0x3C, 0x46, 0x42, 0x82, 0x82, 0x81,
  0x81, 0x81, 0x83, 0x82, 0xC2, 0x46, 0x3C, 0xF2, 0x28, 0x61, 0x86, 0x18,
  0xBC, 0x82, 0x08, 0x20, 0x80, 0x3C, 0x46, 0x42, 0x82, 0x83, 0x81, 0x81,
  0x81, 0x83, 0x82, 0xC2, 0x46, 0x3C, 0x08, 0x04, 0x06, 0xF2, 0x28, 0x61,
  0x86, 0x1F, 0xA4, 0x92, 0x28, 0xA1, 0x84, 0x7A, 0x08, 0x20, 0x81, 0x03,
  0x06, 0x08, 0x30, 0x82, 0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0A, 0x27, 0xC0, 0x83, 0x05, 0x0A, 0x24, 0x48, 0x91, 0x12, 0x28, 0x50,
  0xA0, 0xC1, 0x00, 0x82, 0x18, 0x61, 0x46, 0x14, 0x61, 0x45, 0x24, 0x52,
  0x49, 0x22, 0x92, 0x29, 0x42, 0x8C, 0x28, 0xC3, 0x0C, 0x10, 0xC0, 0x45,
  0x14, 0x8A, 0x28, 0x41, 0x0C, 0x28, 0xA4, 0x51, 0x84, 0x86, 0x14, 0x52,
  0x48, 0xA3, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7C, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x21, 0x84, 0x10, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0xE4,
  0x92, 0x49, 0x24, 0x92, 0x4F, 0x10, 0x30, 0xA1, 0x24, 0x48, 0x60, 0x80,
  0xFF, 0x89, 0x80, 0x74, 0xC2, 0x13, 0xE6, 0x31, 0x9F, 0x40, 0x82, 0x08,
  0x20, 0xBB, 0x3C, 0x61, 0x86, 0x18, 0x61, 0xC6, 0xE0, 0x3A, 0x21, 0x08,
  0x42, 0x10, 0x83, 0xC0, 0x04, 0x10, 0x41, 0x35, 0x38, 0xE1, 0x86, 0x18,
  0x61, 0x8D, 0xD0, 0x32, 0x63, 0x1F, 0xC2, 0x10, 0x83, 0xC0, 0x39, 0x10,
  0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x35, 0x38, 0x61, 0x86, 0x18,
  0x61, 0x8D, 0xD0, 0x41, 0x0B, 0xE0, 0x82, 0x08, 0x20, 0xB3, 0x2C, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x10, 0x9F, 0xF8, 0x41, 0x55, 0x55, 0x55, 0xC0,
  0x84, 0x21, 0x08, 0xC6, 0x54, 0xA6, 0xA5, 0x28, 0xC4, 0xFF, 0xFC, 0xB3,
  0x66, 0x63, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0xB3,
  0x2C, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x31, 0x28, 0x61, 0x86, 0x18,
  0x61, 0x89, 0xE0, 0xBB, 0x3C, 0x61, 0x86, 0x18, 0x61, 0xC6, 0xE8, 0x20,
  0x82, 0x00, 0x35, 0x38, 0xE1, 0x86, 0x18, 0x61, 0x8D, 0xD0, 0x41, 0x04,
  0x10, 0xBC, 0xC8, 0x88, 0x88, 0x88, 0x79, 0x88, 0xC2, 0x11, 0x1F, 0x44,
  0xF4, 0x44, 0x44, 0x44, 0x43, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x8D,
  0xD0, 0x86, 0x14, 0x92, 0x49, 0x23, 0x0C, 0x30, 0xC0, 0x84, 0x63, 0x14,
  0xC9, 0x32, 0x4A, 0x94, 0xA5, 0x28, 0xCC, 0x33, 0x08, 0x40, 0xC5, 0x24,
  0x8C, 0x30, 0xC3, 0x12, 0x4B, 0x10, 0x85, 0x14, 0x52, 0x48, 0xA2, 0x8C,
  0x30, 0x41, 0x08, 0x23, 0x00, 0x78, 0x84, 0x22, 0x10, 0x88, 0x47, 0xC0,
  0x19, 0x08, 0x42, 0x10, 0x98, 0x41, 0x08, 0x42, 0x10, 0x83, 0xFF, 0xFF,
  0xC0, 0xC3, 0x08, 0x42, 0x10, 0x87, 0x31, 0x08, 0x42, 0x11, 0x98, 0xE6,
  0x60,
};

const GFXglyph NotoSans_ExtraCondensed_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 4, 5, 6, 1, -13 },
  { 8, 8, 13, 8, 0, -13 },
  { 21, 6, 15, 7, 1, -14 },
  { 33, 9, 13, 11, 1, -13 },
  { 48, 7, 13, 8, 1, -13 },
  { 60, 1, 5, 3, 1, -13 },
  { 61, 3, 16, 5, 1, -13 },
  { 67, 3, 16, 5, 1, -13 },
  { 73, 5, 6, 7, 1, -14 },
  { 77, 6, 9, 7, 1, -11 },
  { 84, 2, 4, 4, 1, -2 },
  { 85, 4, 1, 5, 0, -5 },
  { 86, 2, 2, 4, 1, -2 },
  { 87, 6, 13, 6, 0, -13 },
  { 97, 6, 13, 7, 1, -13 },
  { 107, 4, 13, 7, 1, -13 },
  { 114, 6, 13, 7, 1, -13 },
  { 124, 6, 13, 7, 1, -13 },
  { 134, 7, 13, 7, 0, -13 },
  { 146, 6, 13, 7, 1, -13 },
  { 156, 6, 13, 7, 1, -13 },
  { 166, 6, 13, 7, 1, -13 },
  { 176, 6, 13, 7, 1, -13 },
  { 186, 6, 13, 7, 1, -13 },
  { 196, 2, 10, 4, 1, -10 },
  { 199, 2, 12, 4, 1, -10 },
  { 202, 6, 7, 7, 1, -10 },
  { 208, 6, 5, 7, 1, -9 },
  { 212, 6, 7, 7, 1, -10 },
  { 218, 5, 13, 5, 0, -13 },
  { 227, 9, 15, 11, 1, -13 },
  { 244, 7, 13, 7, 0, -13 },
  { 256, 6, 13, 8, 1, -13 },
  { 266, 6, 13, 8, 1, -13 },
  { 276, 7, 13, 9, 1, -13 },
  { 288, 5, 13, 7, 1, -13 },
  { 297, 5, 13, 7, 1, -13 },
  { 306, 8, 13, 10, 1, -13 },
  { 319, 7, 13, 9, 1, -13 },
  { 331, 3, 13, 5, 1, -13 },
  { 336, 3, 16, 4, -1, -13 },
  { 342, 6, 13, 7, 1, -13 },
  { 352, 5, 13, 6, 1, -13 },
  { 361, 10, 13, 12, 1, -13 },
  { 378, 7, 13, 10, 1, -13 },
  { 390, 8, 13, 10, 1, -13 },
  { 403, 6, 13, 8, 1, -13 },
  { 413, 8, 16, 10, 1, -13 },
  { 429, 6, 13, 8, 1, -13 },
  { 439, 6, 13, 7, 1, -13 },
  { 449, 6, 13, 6, 0, -13 },
  { 459, 7, 13, 9, 1, -13 },
  { 471, 7, 13, 7, 0, -13 },
  { 483, 12, 13, 12, 0, -13 },
  { 503, 6, 13, 7, 0, -13 },
  { 513, 6, 13, 6, 0, -13 },
  { 523, 6, 13, 6, 0, -13 },
  { 533, 4, 16, 6, 1, -13 },
  { 541, 6, 13, 6, 0, -13 },
  { 551, 3, 16, 6, 1, -13 },
  { 557, 7, 7, 8, 0, -13 },
  { 564, 8, 1, 7, 0, 1 },
  { 565, 3, 3, 4, 1, -14 },
  { 567, 5, 10, 7, 1, -10 },
  { 574, 6, 14, 8, 1, -14 },
  { 585, 5, 10, 6, 1, -10 },
  { 592, 6, 14, 8, 1, -14 },
  { 603, 5, 10, 7, 1, -10 },
  { 610, 5, 14, 4, 0, -14 },
  { 619, 6, 14, 8, 1, -10 },
  { 630, 6, 14, 8, 1, -14 },
  { 641, 1, 13, 3, 1, -13 },
  { 643, 2, 17, 3, 0, -13 },
  { 648, 5, 14, 7, 1, -14 },
  { 657, 1, 14, 3, 1, -14 },
  { 659, 9, 10, 12, 1, -10 },
  { 671, 6, 10, 8, 1, -10 },
  { 679, 6, 10, 8, 1, -10 },
  { 687, 6, 14, 8, 1, -10 },
  { 698, 6, 14, 8, 1, -10 },
  { 709, 4, 10, 5, 1, -10 },
  { 714, 4, 10, 6, 1, -10 },
  { 719, 4, 12, 4, 0, -12 },
  { 725, 6, 10, 8, 1, -10 },
  { 733, 6, 10, 6, 0, -10 },
  { 741, 10, 10, 10, 0, -10 },
  { 754, 6, 10, 6, 0, -10 },
  { 762, 6, 14, 6, 0, -10 },
  { 773, 5, 10, 5, 0, -10 },
  { 780, 5, 16, 6, 1, -13 },
  { 790, 1, 18, 7, 3, -14 },
  { 793, 5, 16, 6, 1, -13 },
  { 803, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Light18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT18PT7B_H_
