#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x8B, 0x99, 0x99, 0x14, 0x48, 0x93, 0xF2, 0x44, 0x89,
  0x7F, 0x28, 0x91, 0x22, 0x40, 0x23, 0xAB, 0x4A, 0x51, 0x86, 0x29, 0x4B,
  0xF2, 0x10, 0xE2, 0x52, 0x29, 0x14, 0x8A, 0x85, 0x5B, 0xB2, 0x29, 0x14,
  0x8A, 0x49, 0x24, 0x60, 0x72, 0x49, 0x14, 0x61, 0x8A, 0x25, 0x96, 0x28,
  0xBD, 0xF0, 0x29, 0x49, 0x24, 0x92, 0x44, 0x88, 0x89, 0x22, 0x49, 0x25,
  0x25, 0x20, 0x21, 0x3E, 0xC9, 0x00, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08,
  0xEA, 0xF0, 0xC0, 0x0C, 0x20, 0x84, 0x10, 0x42, 0x08, 0x21, 0x04, 0x30,
  0x74, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x62, 0xE0, 0x35, 0x91, 0x11, 0x11,
  0x11, 0x11, 0xF0, 0x42, 0x10, 0x88, 0x44, 0x22, 0x21, 0xF0, 0xF0, 0x42,
  0x11, 0x30, 0x41, 0x08, 0x43, 0xE0, 0x08, 0x30, 0x60, 0xC2, 0x85, 0x12,
  0x24, 0xFE, 0x10, 0x20, 0x40, 0xFC, 0x21, 0x08, 0x78, 0x21, 0x08, 0x43,
  0xE0, 0x7A, 0x21, 0x0A, 0x6E, 0x31, 0x8C, 0x62, 0xE0, 0xF8, 0x42, 0x21,
  0x08, 0x84, 0x22, 0x10, 0x80, 0x74, 0x63, 0x15, 0x11, 0x51, 0x8C, 0x62,
  0xE0, 0x74, 0x63, 0x18, 0xC7, 0x65, 0x08, 0x45, 0xC0, 0xC1, 0x80, 0xA0,
  0x03, 0xA8, 0x02, 0x18, 0xC6, 0x06, 0x02, 0x03, 0x01, 0xFC, 0x00, 0x3F,
  0x83, 0x03, 0x03, 0x18, 0x8C, 0x20, 0xF0, 0x82, 0x21, 0x10, 0x88, 0x40,
  0x10, 0xC0, 0x3E, 0x20, 0x90, 0x51, 0x99, 0x4D, 0x26, 0x93, 0x49, 0xA4,
  0xCD, 0xA0, 0x08, 0x02, 0x60, 0xC0, 0x10, 0x50, 0xA1, 0x42, 0x85, 0x11,
  0x3E, 0x44, 0x8A, 0x0C, 0x10, 0xFA, 0x18, 0x61, 0x8B, 0xC8, 0xA1, 0x86,
  0x18, 0x7E, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0x04, 0x0F, 0xF9,
  0x1A, 0x14, 0x28, 0x50, 0x60, 0xC2, 0x85, 0x0A, 0x27, 0x80, 0xFC, 0x21,
  0x08, 0x7E, 0x10, 0x84, 0x21, 0xF0, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84,
  0x21, 0x00, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x23, 0xC1, 0x83, 0x85, 0x09,
  0xF0, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x61, 0xE9, 0x24,
  0x92, 0x49, 0x70, 0x24, 0x92, 0x49, 0x24, 0x92, 0x78, 0x86, 0x29, 0x24,
  0xA2, 0x8E, 0x24, 0x92, 0x28, 0xA1, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF0, 0xC0, 0xE0, 0xF0, 0x74, 0x3A, 0x1D, 0x16, 0x4B, 0x25, 0x94,
  0xC6, 0x63, 0x31, 0x10, 0xC3, 0x86, 0x8D, 0x1A, 0x32, 0x64, 0xC5, 0x8B,
  0x0E, 0x1C, 0x10, 0x7C, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05,
  0x11, 0xC0, 0xFA, 0x28, 0x61, 0x8A, 0x2F, 0x20, 0x82, 0x08, 0x20, 0x7C,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x11, 0xC0, 0x80, 0x81,
  0x00, 0xFA, 0x28, 0x61, 0x8A, 0x2F, 0x24, 0x92, 0x28, 0xA1, 0x7C, 0x21,
  0x08, 0x30, 0x41, 0x08, 0x43, 0xE0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x14, 0x5E,
  0x83, 0x09, 0x12, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x50, 0x40, 0x80, 0x84,
  0x38, 0x62, 0x46, 0x24, 0x62, 0x4A, 0x24, 0xA4, 0x49, 0x42, 0x94, 0x29,
  0x43, 0x14, 0x30, 0x81, 0x08, 0x45, 0x24, 0x8A, 0x30, 0x43, 0x0C, 0x29,
  0x24, 0x61, 0x85, 0x24, 0x92, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x04, 0x78,
  0x42, 0x21, 0x08, 0x84, 0x42, 0x11, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0xF0, 0xC1, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81,
  0xE4, 0x92, 0x49, 0x24, 0x92, 0x78, 0x10, 0x50, 0xA2, 0x24, 0x50, 0x40,
  0xFE, 0x88, 0x80, 0xF0, 0x82, 0x1F, 0xC6, 0x33, 0xE8, 0x82, 0x08, 0x20,
  0xBB, 0x28, 0x61, 0x86, 0x18, 0x72, 0xB8, 0x78, 0x88, 0x88, 0x88, 0x70,
  0x08, 0x42, 0x17, 0xC6, 0x31, 0x8C, 0x63, 0x17, 0x80, 0x74, 0x63, 0x1F,
  0xC2, 0x10, 0x78, 0x34, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x40, 0x7C, 0x63,
  0x18, 0xC6, 0x31, 0x78, 0x42, 0x1F, 0x00, 0x84, 0x21, 0x0B, 0xE6, 0x31,
  0x8C, 0x63, 0x18, 0x80, 0x9F, 0xF0, 0x41, 0x55, 0x55, 0x57, 0x84, 0x21,
  0x08, 0xCA, 0x94, 0xE4, 0xA5, 0x28, 0x80, 0xFF, 0xF8, 0xF7, 0x44, 0x62,
  0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0xBE, 0x63, 0x18, 0xC6,
  0x31, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xBB, 0x28, 0x61, 0x86,
  0x18, 0x72, 0xBA, 0x08, 0x20, 0x80, 0x7C, 0x63, 0x18, 0xC6, 0x31, 0x78,
  0x42, 0x10, 0x80, 0xBC, 0x88, 0x88, 0x88, 0x80, 0xF8, 0x88, 0x61, 0x11,
  0xE0, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x78, 0x8E, 0x24, 0x92, 0x51, 0x43, 0x0C, 0x20, 0x88, 0xC6, 0x53, 0x2A,
  0x95, 0x52, 0x98, 0xCC, 0x46, 0x22, 0x00, 0xCD, 0x23, 0x0C, 0x30, 0xC5,
  0x12, 0x8C, 0x85, 0x24, 0x92, 0x48, 0xC3, 0x0C, 0x30, 0x82, 0x08, 0xC0,
  0x71, 0x12, 0x24, 0x44, 0xF0, 0x32, 0x44, 0x44, 0x4C, 0x44, 0x44, 0x42,
  0x10, 0xFF, 0xFF, 0x80, 0xC4, 0x22, 0x22, 0x23, 0x22, 0x22, 0x24, 0x80,
  0xE6, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 6, 1, -12 },
  { 6, 7, 12, 8, 0, -12 },
  { 17, 5, 14, 7, 1, -13 },
  { 26, 9, 12, 11, 1, -12 },
  { 40, 6, 12, 7, 1, -12 },
  { 49, 1, 4, 3, 1, -12 },
  { 50, 3, 15, 5, 1, -12 },
  { 56, 3, 15, 5, 1, -12 },
  { 62, 5, 5, 6, 1, -13 },
  { 66, 6, 8, 7, 1, -10 },
  { 72, 2, 4, 3, 1, -2 },
  { 73, 4, 1, 5, 0, -5 },
  { 74, 1, 2, 3, 1, -2 },
  { 75, 6, 12, 6, 0, -12 },
  { 84, 5, 12, 7, 1, -12 },
  { 92, 4, 12, 7, 1, -12 },
  { 98, 5, 12, 7, 1, -12 },
  { 106, 5, 12, 7, 1, -12 },
  { 114, 7, 12, 7, 0, -12 },
  { 125, 5, 12, 7, 1, -12 },
  { 133, 5, 12, 7, 1, -12 },
  { 141, 5, 12, 7, 1, -12 },
  { 149, 5, 12, 7, 1, -12 },
  { 157, 5, 12, 7, 1, -12 },
  { 165, 1, 9, 3, 1, -9 },
  { 167, 2, 11, 3, 1, -9 },
  { 170, 7, 8, 7, 0, -10 },
  { 177, 6, 4, 7, 1, -8 },
  { 180, 6, 8, 7, 1, -10 },
  { 186, 5, 12, 5, 0, -12 },
  { 194, 9, 14, 11, 1, -12 },
  { 210, 7, 12, 7, 0, -12 },
  { 221, 6, 12, 8, 1, -12 },
  { 230, 6, 12, 7, 1, -12 },
  { 239, 7, 12, 8, 1, -12 },
  { 250, 5, 12, 7, 1, -12 },
  { 258, 5, 12, 6, 1, -12 },
  { 266, 7, 12, 9, 1, -12 },
  { 277, 6, 12, 9, 1, -12 },
  { 286, 3, 12, 4, 1, -12 },
  { 291, 3, 15, 3, -1, -12 },
  { 297, 6, 12, 7, 1, -12 },
  { 306, 5, 12, 6, 1, -12 },
  { 314, 9, 12, 12, 1, -12 },
  { 328, 7, 12, 9, 1, -12 },
  { 339, 7, 12, 9, 1, -12 },
  { 350, 6, 12, 7, 1, -12 },
  { 359, 7, 15, 9, 1, -12 },
  { 373, 6, 12, 7, 1, -12 },
  { 382, 5, 12, 7, 1, -12 },
  { 390, 6, 12, 6, 0, -12 },
  { 399, 6, 12, 9, 1, -12 },
  { 408, 7, 12, 7, 0, -12 },
  { 419, 12, 12, 12, 0, -12 },
  { 437, 6, 12, 6, 0, -12 },
  { 446, 6, 12, 6, 0, -12 },
  { 455, 5, 12, 6, 0, -12 },
  { 463, 4, 15, 5, 1, -12 },
  { 471, 6, 12, 6, 0, -12 },
  { 480, 3, 15, 5, 1, -12 },
  { 486, 7, 6, 7, 0, -12 },
  { 492, 7, 1, 7, 0, 1 },
  { 493, 3, 3, 4, 1, -13 },
  { 495, 5, 9, 7, 1, -9 },
  { 501, 6, 13, 8, 1, -13 },
  { 511, 4, 9, 6, 1, -9 },
  { 516, 5, 13, 8, 1, -13 },
  { 525, 5, 9, 7, 1, -9 },
  { 531, 4, 13, 4, 0, -13 },
  { 538, 5, 13, 8, 1, -9 },
  { 547, 5, 13, 7, 1, -13 },
  { 556, 1, 12, 3, 1, -12 },
  { 558, 2, 16, 3, 0, -12 },
  { 562, 5, 13, 6, 1, -13 },
  { 571, 1, 13, 3, 1, -13 },
  { 573, 9, 9, 11, 1, -9 },
  { 584, 5, 9, 7, 1, -9 },
  { 590, 5, 9, 7, 1, -9 },
  { 596, 6, 13, 8, 1, -9 },
  { 606, 5, 13, 8, 1, -9 },
  { 615, 4, 9, 5, 1, -9 },
  { 620, 4, 9, 6, 1, -9 },
  { 625, 4, 11, 4, 0, -11 },
  { 631, 5, 9, 7, 1, -9 },
  { 637, 6, 9, 6, 0, -9 },
  { 644, 9, 9, 10, 0, -9 },
  { 655, 6, 9, 6, 0, -9 },
  { 662, 6, 13, 6, 0, -9 },
  { 672, 4, 9, 5, 0, -9 },
  { 677, 4, 15, 6, 1, -12 },
  { 685, 1, 17, 7, 3, -13 },
  { 688, 4, 15, 6, 1, -12 },
  { 696, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Light17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT17PT7B_H_
