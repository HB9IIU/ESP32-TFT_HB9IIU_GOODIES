#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x60, 0x00, 0x00, 0x7F, 0xF7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC1, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xC1, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x60, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0F, 0xF8, 0x1F, 0xFE, 0x79, 0x9E, 0x71, 0x82, 0xE1, 0x80, 0xC1, 0x80,
  0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xE1, 0x80, 0xE1, 0x80,
  0x71, 0x80, 0x3D, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xFC,
  0x01, 0x9E, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x87, 0x01, 0x83, 0x01, 0x83,
  0x01, 0x83, 0x01, 0x87, 0x01, 0x86, 0x81, 0x8E, 0xF1, 0xBC, 0xFF, 0xF8,
  0x3F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x03, 0x38, 0x06, 0x01, 0x86, 0x01,
  0x80, 0x61, 0xC0, 0xC0, 0x18, 0x30, 0x30, 0x0E, 0x0C, 0x0C, 0x03, 0x03,
  0x06, 0x00, 0xC0, 0xC1, 0x80, 0x30, 0x30, 0x60, 0x0C, 0x0C, 0x30, 0x03,
  0x03, 0x0C, 0x00, 0xC0, 0xC3, 0x00, 0x30, 0x31, 0x80, 0x0C, 0x0C, 0x63,
  0xE3, 0x83, 0x19, 0xFC, 0x60, 0xCC, 0x63, 0x18, 0x63, 0x38, 0xE6, 0x19,
  0xCC, 0x18, 0xCE, 0x63, 0x06, 0x3F, 0x18, 0xC1, 0x83, 0x0E, 0x30, 0x60,
  0x03, 0x1C, 0x1C, 0x00, 0xC7, 0x07, 0x00, 0x71, 0xC1, 0xC0, 0x18, 0x70,
  0x70, 0x06, 0x1C, 0x1C, 0x03, 0x83, 0x07, 0x00, 0xC0, 0xC1, 0x80, 0x30,
  0x30, 0x60, 0x1C, 0x0C, 0x18, 0x06, 0x03, 0x06, 0x01, 0x80, 0x63, 0x00,
  0xE0, 0x1F, 0xC0, 0x30, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0x70, 0x00, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x18, 0x01,
  0x81, 0x80, 0x1C, 0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x80,
  0x0E, 0x30, 0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xCC, 0x0E, 0x38, 0xE0, 0xE7, 0x07,
  0x0C, 0x70, 0x70, 0xC6, 0x03, 0x8C, 0x60, 0x19, 0xCE, 0x01, 0xDC, 0xE0,
  0x0D, 0x86, 0x00, 0xF8, 0x60, 0x07, 0x06, 0x00, 0x70, 0x70, 0x0F, 0x87,
  0x01, 0xDC, 0x38, 0x39, 0xC1, 0xFF, 0x0E, 0x0F, 0xE0, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x03, 0x8C, 0x6F, 0xFF, 0xCF, 0xFC, 0x07, 0x00,
  0x3E, 0x00, 0xCC, 0x06, 0x38, 0x38, 0x71, 0xC1, 0xC1, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x39, 0xCE,
  0x67, 0x39, 0xCC, 0x67, 0x30, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1C, 0x38, 0x38, 0x1C,
  0x30, 0x1C, 0x70, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x06,
  0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06,
  0xE0, 0x06, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x0F, 0xF0, 0x07, 0xE0,
  0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x3D, 0xDE, 0x7F, 0x1D, 0x87, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x07, 0x80, 0x3F, 0xF0, 0xFF,
  0xF8, 0x60, 0x38, 0x40, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x7F, 0xE1, 0xFF, 0xE7, 0x01,
  0xE4, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x79, 0xFF, 0xE1, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C,
  0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x03,
  0x06, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x67, 0x80, 0x7F, 0xF0,
  0x7F, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x80, 0x3C, 0xE0, 0x78, 0xFF, 0xF0,
  0x7F, 0xE0, 0x00, 0x78, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE3, 0xF0, 0xEF, 0xF8, 0xEC, 0x3C,
  0xF8, 0x1C, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x70, 0x06,
  0x70, 0x0E, 0x30, 0x0E, 0x38, 0x1C, 0x1C, 0x3C, 0x1F, 0xF8, 0x07, 0xF0,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x0F, 0xF0, 0x3F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06,
  0xE0, 0x06, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x30, 0x1C,
  0x38, 0x1C, 0x1C, 0x78, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xF0,
  0x1C, 0x78, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0x70, 0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0x80, 0x1F, 0xC0,
  0xFF, 0xC1, 0xC1, 0xC7, 0x01, 0xCC, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0E, 0xE0, 0x3D, 0xC0, 0x59, 0xE3, 0xB1, 0xFE, 0x61,
  0xF8, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x41, 0xE0, 0xFF, 0x81,
  0xFE, 0x00, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x33, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xE7, 0x33, 0x9C, 0xE6, 0x73, 0x98, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x07, 0xF8, 0xFF, 0xCC, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x18, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xE3, 0x00, 0xF8, 0x18, 0xC0, 0xFF, 0x06, 0x70,
  0x30, 0xC1, 0x98, 0x18, 0x30, 0x66, 0x06, 0x0C, 0x1D, 0x83, 0x83, 0x07,
  0x60, 0xC0, 0xC0, 0xD8, 0x30, 0x30, 0x3E, 0x0C, 0x1C, 0x0F, 0x83, 0x07,
  0x03, 0xE0, 0xC1, 0xC1, 0xF8, 0x30, 0x70, 0x7E, 0x0C, 0x1C, 0x1D, 0x83,
  0x07, 0x06, 0x60, 0xC1, 0xC1, 0x98, 0x30, 0xF0, 0x66, 0x0E, 0x34, 0x31,
  0x81, 0xD9, 0xFC, 0x70, 0x3E, 0x7E, 0x1C, 0x02, 0x02, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xB8, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x39, 0x80, 0x03,
  0x9C, 0x00, 0x31, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00,
  0x60, 0xE0, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x0C, 0x03, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1C, 0x03,
  0x81, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x00,
  0x0C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x7C, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xE0,
  0xFF, 0xF0, 0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1C, 0x02, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x81, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0x30,
  0x3E, 0x18, 0x07, 0x8C, 0x01, 0xE6, 0x00, 0x73, 0x00, 0x1D, 0x80, 0x0E,
  0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0x60, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0xE3, 0x00,
  0xF1, 0x87, 0xF0, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFE, 0xFF, 0xF6,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0x00, 0xE0, 0xF0,
  0x01, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x01, 0xFE, 0xC0, 0x0F, 0xF6, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x78, 0x00, 0xE1, 0xE0, 0x07,
  0x07, 0xC0, 0x78, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0xFF, 0x7E, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0xFE,
  0xFE, 0x78, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x38,
  0xC0, 0x70, 0xC0, 0x70, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1, 0xC0, 0xC3, 0x80,
  0xC3, 0x80, 0xC7, 0x00, 0xC7, 0x00, 0xCE, 0x00, 0xDE, 0x00, 0xDF, 0x00,
  0xFF, 0x00, 0xF3, 0x80, 0xE3, 0x80, 0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x38,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xDE, 0xC0, 0x00, 0x6F, 0x60, 0x00, 0x77, 0xB8,
  0x00, 0x3B, 0xCC, 0x00, 0x19, 0xE6, 0x00, 0x0C, 0xF3, 0x80, 0x0E, 0x79,
  0xC0, 0x06, 0x3C, 0x60, 0x03, 0x1E, 0x30, 0x03, 0x8F, 0x1C, 0x01, 0xC7,
  0x86, 0x00, 0xC3, 0xC3, 0x00, 0x61, 0xE1, 0xC0, 0x70, 0xF0, 0x60, 0x30,
  0x78, 0x30, 0x18, 0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0C, 0x0F, 0x03, 0x06,
  0x07, 0x81, 0x87, 0x03, 0xC0, 0xE3, 0x81, 0xE0, 0x31, 0x80, 0xF0, 0x18,
  0xC0, 0x78, 0x0E, 0xE0, 0x3C, 0x07, 0x60, 0x1E, 0x01, 0xB0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xC0,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xF6,
  0x00, 0x3D, 0xC0, 0x0F, 0x30, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0x60,
  0x0F, 0x1C, 0x03, 0xC3, 0x00, 0xF0, 0xE0, 0x3C, 0x18, 0x0F, 0x07, 0x03,
  0xC1, 0xC0, 0xF0, 0x38, 0x3C, 0x0E, 0x0F, 0x01, 0x83, 0xC0, 0x70, 0xF0,
  0x0C, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x00,
  0xCF, 0x00, 0x3B, 0xC0, 0x06, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xE0, 0x1E, 0x07, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x0C, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03,
  0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70,
  0x70, 0x03, 0x83, 0xC0, 0x38, 0x0F, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0x03, 0xE6, 0x01, 0xCC, 0x01, 0xD8, 0x03,
  0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x6C,
  0x00, 0xD8, 0x03, 0xB0, 0x07, 0x60, 0x1C, 0xC0, 0x79, 0x87, 0xE3, 0xFF,
  0x87, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xE0, 0x1E, 0x07, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x0C, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03,
  0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70,
  0x70, 0x03, 0x83, 0xC0, 0x38, 0x0F, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0xFF, 0xC0,
  0xFF, 0xF0, 0xC0, 0xF8, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0C,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x38, 0xC1, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0xC1, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70,
  0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0x03, 0xE0, 0x1F, 0xF8, 0x7F, 0xF9,
  0xE0, 0x27, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x40, 0x0E, 0xE0, 0x79, 0xFF, 0xE1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76,
  0x00, 0x1D, 0x80, 0x07, 0x70, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x70, 0xF8,
  0x3C, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x0C, 0xE0, 0x03, 0x8C, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0xC1, 0xC0,
  0x30, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x06, 0x01, 0xC0,
  0xC0, 0x38, 0x38, 0x03, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x01, 0xC7,
  0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x00, 0xDC,
  0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xB0, 0x00, 0xE0, 0x01, 0x98,
  0x00, 0x70, 0x01, 0xCE, 0x00, 0x78, 0x00, 0xE7, 0x00, 0x3E, 0x00, 0x73,
  0x80, 0x1B, 0x00, 0x30, 0xC0, 0x0D, 0x80, 0x38, 0x70, 0x06, 0xC0, 0x1C,
  0x38, 0x07, 0x60, 0x0E, 0x1C, 0x03, 0xB8, 0x07, 0x0E, 0x01, 0x9C, 0x03,
  0x03, 0x00, 0xC6, 0x03, 0x81, 0xC0, 0x63, 0x01, 0xC0, 0xE0, 0x71, 0x80,
  0xE0, 0x70, 0x38, 0xE0, 0x60, 0x18, 0x18, 0x70, 0x30, 0x0C, 0x0C, 0x18,
  0x38, 0x07, 0x06, 0x0C, 0x1C, 0x03, 0x87, 0x06, 0x0E, 0x01, 0xC3, 0x83,
  0x86, 0x00, 0x61, 0x81, 0xC3, 0x00, 0x30, 0xC0, 0x63, 0x80, 0x1C, 0x60,
  0x31, 0xC0, 0x0E, 0x70, 0x18, 0xE0, 0x07, 0x38, 0x0E, 0x60, 0x01, 0x98,
  0x07, 0x70, 0x00, 0xCC, 0x01, 0xB8, 0x00, 0x76, 0x00, 0xDC, 0x00, 0x3F,
  0x00, 0x6E, 0x00, 0x1F, 0x80, 0x36, 0x00, 0x07, 0x80, 0x1B, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0x9C, 0x01, 0x8E, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x30, 0x1C, 0x38, 0x06, 0x1C, 0x03, 0x8C, 0x00, 0xCE, 0x00,
  0x66, 0x00, 0x3B, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x33, 0x00, 0x39, 0xC0, 0x1C,
  0xE0, 0x0C, 0x30, 0x0E, 0x1C, 0x06, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC1,
  0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0xF0, 0x01,
  0xC0, 0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x00, 0x61,
  0xC0, 0x70, 0xE0, 0x38, 0x30, 0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x03, 0x06,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0x31, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x03,
  0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00, 0x71, 0x80, 0x18, 0x70,
  0x0E, 0x0C, 0x03, 0x03, 0x81, 0xC0, 0x60, 0x60, 0x1C, 0x38, 0x03, 0x0C,
  0x00, 0xE7, 0x00, 0x39, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x0F, 0xC1,
  0xFF, 0xC3, 0x87, 0x08, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0x1F, 0xFC, 0xF0, 0x77, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x80,
  0xFE, 0x03, 0xDC, 0x1F, 0x7F, 0xDC, 0xFE, 0x30, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xE7, 0xF8, 0xEE, 0x3C, 0xF8, 0x1C,
  0xF0, 0x0E, 0xF0, 0x06, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x06, 0xF0, 0x0E,
  0xF8, 0x0E, 0xEC, 0x1C, 0xEF, 0xF8, 0xC7, 0xF0, 0x03, 0xF0, 0x7F, 0xC7,
  0xCC, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x81, 0x1F,
  0xF8, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07,
  0xC7, 0x0F, 0xE7, 0x1E, 0x73, 0x38, 0x1B, 0x70, 0x0F, 0x70, 0x0F, 0x70,
  0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x0B, 0x3C, 0x3B, 0x1F,
  0xF3, 0x0F, 0xE3, 0x07, 0xC0, 0x1F, 0xE0, 0x71, 0xE1, 0xC0, 0xC3, 0x01,
  0xCE, 0x01, 0x98, 0x03, 0xB0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x8E, 0x06,
  0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xFC, 0xFF, 0xCF,
  0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x07, 0xC3, 0x0F, 0xF3, 0x1E, 0x73, 0x38, 0x1B, 0x70, 0x0F, 0x70, 0x07,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x1B, 0x3C, 0x3F,
  0x1F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x60, 0x3C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x02, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8F,
  0x87, 0x3F, 0xCE, 0xE7, 0x9F, 0x03, 0xBC, 0x07, 0x78, 0x06, 0xF0, 0x0D,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1C, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0xFB,
  0xC4, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xF8, 0x0E, 0xE0,
  0x33, 0x81, 0xCE, 0x0E, 0x38, 0x30, 0xE1, 0xC3, 0x86, 0x0E, 0x38, 0x39,
  0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xF8, 0x3E, 0xE0, 0xF1, 0x83, 0xC7, 0x0E,
  0x0C, 0x38, 0x38, 0xE0, 0xE3, 0x81, 0x8E, 0x07, 0x38, 0x0C, 0xE0, 0x3B,
  0x80, 0xEE, 0x01, 0xB8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xE0, 0x7C, 0x63, 0xF8,
  0xFF, 0x33, 0x1E, 0x67, 0xDB, 0x07, 0x60, 0xEF, 0x01, 0xA0, 0x37, 0x80,
  0xF0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0xF0,
  0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x3F,
  0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03,
  0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x7E, 0x01, 0xC0,
  0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x07, 0xE0, 0x1C,
  0x03, 0xF0, 0x0E, 0x01, 0xC0, 0xC3, 0xE1, 0x8F, 0xF3, 0x39, 0xE6, 0xC0,
  0xEF, 0x01, 0xDE, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x07, 0xE0, 0x0F, 0xF8, 0x1E, 0x7C,
  0x38, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x70, 0x06,
  0x70, 0x0E, 0x38, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0xC3, 0xE0,
  0xC7, 0xF8, 0xCE, 0x3C, 0xD8, 0x1C, 0xF0, 0x0E, 0xF0, 0x06, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x06, 0xF0, 0x0E, 0xF8, 0x0E, 0xEC, 0x1C, 0xEF, 0xF8,
  0xE3, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0xC3, 0x0F, 0xF3, 0x1E, 0x73, 0x38, 0x1B, 0x30, 0x0B, 0x70, 0x0F,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x1B, 0x3C, 0x3F,
  0x1F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0xB0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0F,
  0xC3, 0xFF, 0x78, 0xEE, 0x02, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x0E, 0xFF,
  0xC7, 0xF8, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0xFB, 0xFE,
  0xFF, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0xDE, 0x1B,
  0x3F, 0xCC, 0x7E, 0x30, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x06, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x0E, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x0E, 0x00, 0xD8,
  0x03, 0x80, 0x36, 0x00, 0xE0, 0x1D, 0xC0, 0x7C, 0x07, 0x70, 0x1B, 0x01,
  0x8C, 0x06, 0xC0, 0x63, 0x01, 0xB0, 0x18, 0xE0, 0x6C, 0x0E, 0x38, 0x3B,
  0x83, 0x8E, 0x0C, 0x60, 0xC1, 0x83, 0x18, 0x30, 0x60, 0xC6, 0x1C, 0x1C,
  0x31, 0x87, 0x07, 0x1C, 0x71, 0xC0, 0xC6, 0x0C, 0x60, 0x31, 0x83, 0x18,
  0x0C, 0x60, 0xCE, 0x03, 0xB8, 0x33, 0x80, 0xEE, 0x0E, 0xC0, 0x1B, 0x01,
  0xB0, 0x06, 0xC0, 0x6C, 0x01, 0xB0, 0x1B, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xC0,
  0x39, 0xC0, 0x71, 0x81, 0xC3, 0x83, 0x87, 0x06, 0x07, 0x1C, 0x0E, 0x30,
  0x0C, 0xE0, 0x1D, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x71, 0x80, 0xC3, 0x83, 0x83,
  0x06, 0x07, 0x1C, 0x0E, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x1C, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x66, 0x00, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0C, 0x30, 0x18, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0x81, 0x83, 0x03, 0x0E,
  0x07, 0x1C, 0x06, 0x30, 0x0C, 0x60, 0x19, 0xC0, 0x3B, 0x80, 0x36, 0x00,
  0x6C, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x07, 0xC0, 0x0F, 0x80, 0x0C, 0x00, 0x00, 0x7F, 0xEF,
  0xFD, 0xFF, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xF8,
  0x0F, 0xC0, 0xF0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0xF8, 0x0F, 0x00, 0x7E, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0x80,
  0xFC, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x1F, 0xC0, 0xF8, 0x06, 0x00, 0x00, 0x3F, 0x80,
  0x5F, 0xF0, 0x3E, 0x0F, 0xFA, 0x01, 0xFC, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 34, 10, 3, -34 },
  { 18, 10, 12, 16, 3, -34 },
  { 33, 19, 34, 21, 1, -34 },
  { 114, 16, 39, 20, 2, -36 },
  { 192, 26, 35, 30, 2, -35 },
  { 306, 20, 35, 21, 1, -35 },
  { 394, 3, 12, 9, 3, -34 },
  { 399, 10, 42, 13, 2, -34 },
  { 452, 9, 42, 13, 2, -34 },
  { 500, 14, 15, 18, 2, -37 },
  { 527, 17, 22, 20, 1, -28 },
  { 574, 5, 11, 10, 2, -5 },
  { 581, 11, 2, 13, 1, -14 },
  { 584, 4, 4, 10, 3, -4 },
  { 586, 15, 34, 17, 1, -34 },
  { 650, 16, 35, 20, 2, -35 },
  { 720, 10, 34, 20, 3, -34 },
  { 763, 16, 35, 20, 2, -35 },
  { 833, 15, 35, 20, 2, -35 },
  { 899, 18, 35, 20, 1, -35 },
  { 978, 16, 34, 20, 2, -34 },
  { 1046, 16, 36, 20, 2, -35 },
  { 1118, 16, 34, 20, 2, -34 },
  { 1186, 16, 35, 20, 2, -35 },
  { 1256, 15, 35, 20, 2, -35 },
  { 1322, 4, 26, 10, 3, -26 },
  { 1335, 5, 32, 10, 2, -26 },
  { 1355, 17, 20, 20, 1, -27 },
  { 1398, 17, 12, 20, 1, -23 },
  { 1424, 17, 20, 20, 1, -27 },
  { 1467, 12, 35, 14, 1, -35 },
  { 1520, 26, 39, 30, 2, -35 },
  { 1647, 20, 34, 20, 0, -34 },
  { 1732, 16, 34, 22, 4, -34 },
  { 1800, 18, 35, 21, 2, -35 },
  { 1879, 17, 34, 24, 4, -34 },
  { 1952, 13, 34, 19, 4, -34 },
  { 2008, 13, 34, 18, 4, -34 },
  { 2064, 21, 35, 26, 2, -35 },
  { 2156, 17, 34, 24, 4, -34 },
  { 2229, 8, 34, 12, 2, -34 },
  { 2263, 8, 43, 10, -2, -34 },
  { 2306, 16, 34, 20, 4, -34 },
  { 2374, 12, 34, 17, 4, -34 },
  { 2425, 25, 34, 33, 4, -34 },
  { 2532, 18, 34, 26, 4, -34 },
  { 2609, 21, 35, 25, 2, -35 },
  { 2701, 15, 34, 20, 4, -34 },
  { 2765, 21, 43, 25, 2, -35 },
  { 2878, 16, 34, 21, 4, -34 },
  { 2946, 15, 35, 19, 2, -35 },
  { 3012, 17, 34, 17, 0, -34 },
  { 3085, 18, 34, 24, 3, -34 },
  { 3162, 19, 34, 19, 0, -34 },
  { 3243, 33, 34, 33, 0, -34 },
  { 3384, 17, 34, 18, 0, -34 },
  { 3457, 17, 34, 17, 0, -34 },
  { 3530, 14, 34, 16, 1, -34 },
  { 3590, 9, 42, 15, 4, -34 },
  { 3638, 15, 34, 17, 1, -34 },
  { 3702, 9, 42, 15, 2, -34 },
  { 3750, 18, 17, 20, 1, -34 },
  { 3789, 20, 2, 20, 0, 4 },
  { 3794, 8, 8, 12, 2, -37 },
  { 3802, 14, 26, 19, 2, -26 },
  { 3848, 16, 36, 21, 3, -36 },
  { 3920, 13, 26, 16, 2, -26 },
  { 3963, 16, 36, 21, 2, -36 },
  { 4035, 15, 26, 19, 2, -26 },
  { 4084, 12, 37, 11, 0, -37 },
  { 4140, 16, 38, 21, 2, -26 },
  { 4216, 15, 36, 21, 3, -36 },
  { 4284, 3, 35, 9, 3, -35 },
  { 4298, 6, 47, 9, 0, -35 },
  { 4334, 14, 36, 17, 3, -36 },
  { 4397, 3, 36, 9, 3, -36 },
  { 4411, 25, 26, 31, 3, -26 },
  { 4493, 15, 26, 21, 3, -26 },
  { 4542, 16, 26, 20, 2, -26 },
  { 4594, 16, 37, 21, 3, -26 },
  { 4668, 16, 37, 21, 2, -26 },
  { 4742, 10, 26, 14, 3, -26 },
  { 4775, 12, 26, 16, 2, -26 },
  { 4814, 10, 32, 11, 1, -32 },
  { 4854, 14, 26, 21, 3, -26 },
  { 4900, 16, 26, 16, 0, -26 },
  { 4952, 26, 26, 27, 0, -26 },
  { 5037, 15, 26, 17, 1, -26 },
  { 5086, 15, 38, 16, 1, -26 },
  { 5158, 11, 26, 13, 1, -26 },
  { 5194, 13, 42, 17, 2, -34 },
  { 5263, 3, 48, 19, 8, -37 },
  { 5281, 13, 42, 17, 2, -34 },
  { 5350, 18, 5, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Light48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT48PT7B_H_
