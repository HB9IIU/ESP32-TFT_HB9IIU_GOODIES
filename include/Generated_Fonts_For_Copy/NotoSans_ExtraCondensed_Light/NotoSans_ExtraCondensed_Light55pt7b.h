#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0xEF, 0xFF, 0xF0, 0xF0, 0x7F, 0x07,
  0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x76, 0x07,
  0x60, 0x76, 0x07, 0x60, 0x76, 0x07, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80,
  0x0C, 0x0E, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x1C,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0E, 0x06, 0x00, 0x38, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x81, 0x81, 0xC0, 0x06,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xE6,
  0x0C, 0x70, 0xC0, 0x0E, 0x18, 0x03, 0x83, 0x00, 0x70, 0x60, 0x0E, 0x0C,
  0x01, 0xC1, 0x80, 0x38, 0x30, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x0E, 0x18,
  0x00, 0xE3, 0x00, 0x1F, 0x60, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0xDF, 0x00, 0x18, 0xF0, 0x03, 0x0F, 0x00, 0x60,
  0xE0, 0x0C, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x38, 0x06, 0x07, 0x00, 0xC0,
  0xE0, 0x18, 0x18, 0x03, 0x07, 0x40, 0x61, 0xEE, 0x0C, 0x79, 0xFF, 0xFE,
  0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0x03, 0xDC, 0x00, 0xC0, 0x0C, 0x38, 0x07, 0x00, 0x70, 0x60, 0x1C, 0x01,
  0xC1, 0x80, 0x60, 0x06, 0x07, 0x03, 0x80, 0x18, 0x1C, 0x0E, 0x00, 0x60,
  0x70, 0x30, 0x03, 0x81, 0xC1, 0xC0, 0x0E, 0x07, 0x07, 0x00, 0x38, 0x0C,
  0x18, 0x00, 0xE0, 0x30, 0xE0, 0x03, 0x80, 0xC3, 0x80, 0x0E, 0x07, 0x0C,
  0x00, 0x38, 0x1C, 0x70, 0x00, 0x60, 0x71, 0xC7, 0xC1, 0x81, 0xC6, 0x3F,
  0x86, 0x07, 0x38, 0xE7, 0x1C, 0x18, 0xE7, 0x0C, 0x70, 0x63, 0x18, 0x38,
  0xC3, 0x9C, 0x60, 0xE3, 0xFC, 0x73, 0x81, 0x87, 0xE1, 0x8E, 0x06, 0x0F,
  0x0E, 0x38, 0x1C, 0x00, 0x38, 0xE0, 0x70, 0x00, 0xC3, 0x81, 0xC0, 0x07,
  0x0E, 0x07, 0x00, 0x18, 0x38, 0x1C, 0x00, 0x60, 0xE0, 0x70, 0x03, 0x83,
  0x81, 0xC0, 0x0C, 0x0E, 0x07, 0x00, 0x30, 0x38, 0x18, 0x01, 0xC0, 0xE0,
  0x60, 0x06, 0x01, 0x81, 0x80, 0x18, 0x06, 0x0E, 0x00, 0xE0, 0x1C, 0x38,
  0x03, 0x00, 0x31, 0xC0, 0x0C, 0x00, 0xFF, 0x00, 0x70, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0x8F, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xC0, 0x06, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x07,
  0x70, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x73, 0x80, 0x03, 0x8E, 0x03, 0x9E, 0x1C, 0x0C, 0x70, 0x70, 0x73,
  0x80, 0xE1, 0xCE, 0x03, 0xC7, 0x38, 0x07, 0x1C, 0xE0, 0x0E, 0x63, 0x80,
  0x3B, 0x8E, 0x00, 0x7E, 0x38, 0x01, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F,
  0x0E, 0x00, 0x7C, 0x1C, 0x03, 0xF8, 0x78, 0x1E, 0xF0, 0xF0, 0xF1, 0xC3,
  0xFF, 0x83, 0x83, 0xFC, 0x0F, 0x01, 0x80, 0x00, 0xFF, 0x77, 0x77, 0x77,
  0x77, 0x66, 0x66, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x41, 0x83, 0x79, 0x9F, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xC0, 0x07,
  0xE0, 0x06, 0x70, 0x0E, 0x30, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x18, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x73, 0xCE, 0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x38, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x73, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x38, 0x78, 0x1C, 0x0F, 0x07, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x0E, 0x38,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70,
  0x70, 0x1C, 0x1E, 0x0F, 0x03, 0xCF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01,
  0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xEE, 0x79, 0xDE, 0x3F, 0x87, 0x60, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xE1,
  0xE0, 0x78, 0x20, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xE0, 0x7C, 0x60, 0x0F, 0x10, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x80, 0x0F, 0x3E, 0x0F,
  0x8F, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80,
  0x00, 0xEC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x38,
  0xC0, 0x01, 0xC6, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x0E, 0x0C, 0x00,
  0x70, 0x60, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x06,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x30,
  0x03, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xC1, 0xC0, 0x06, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x7F, 0xFE, 0x3F, 0xFF, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xCF, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x18, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x90, 0x03, 0xCF, 0x0F, 0xC7,
  0xFF, 0xC1, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFF,
  0x81, 0xF0, 0x21, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE3, 0xF8, 0x77, 0xFE, 0x3B, 0x8F, 0x9F, 0x01,
  0xEF, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCF, 0x00, 0xE3, 0x80,
  0xE0, 0xF1, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0x07, 0x83,
  0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xF3, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0x70, 0x07, 0x0F,
  0x01, 0xE0, 0xE0, 0x78, 0x0E, 0x1E, 0x00, 0xF7, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x80, 0x1E, 0x78, 0x07, 0x83, 0x81, 0xE0, 0x38, 0x78,
  0x03, 0x8E, 0x00, 0x79, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x39, 0xC0,
  0x07, 0x38, 0x01, 0xE7, 0x80, 0x78, 0x7C, 0x1E, 0x07, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xF8,
  0x78, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC0,
  0x0F, 0x78, 0x07, 0xCF, 0x03, 0x71, 0xFF, 0xDC, 0x7F, 0xE7, 0x07, 0xE1,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x08, 0x3E, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x04, 0x00,
  0x00, 0x77, 0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x73, 0xFE, 0xF7, 0x00, 0x3C, 0xF3, 0xCF, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x1C, 0xF3, 0xCE, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x38, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x0F, 0x01, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0x40, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x18, 0x60, 0x03, 0x00, 0xE7, 0x00, 0xFF, 0x07, 0x38, 0x0F,
  0xF8, 0x19, 0x80, 0xE1, 0xC0, 0xCC, 0x0E, 0x0E, 0x07, 0xE0, 0x70, 0x70,
  0x3F, 0x03, 0x03, 0x81, 0xF8, 0x38, 0x1C, 0x0F, 0xC1, 0xC0, 0xE0, 0x7E,
  0x0E, 0x07, 0x03, 0xE0, 0x70, 0x38, 0x1F, 0x03, 0x81, 0xC0, 0xF8, 0x1C,
  0x0E, 0x07, 0xC0, 0xE0, 0x70, 0x3E, 0x07, 0x03, 0x81, 0xF0, 0x38, 0x1C,
  0x0D, 0xC1, 0xC1, 0xE0, 0x6E, 0x0E, 0x0F, 0x07, 0x70, 0x30, 0x78, 0x3B,
  0x81, 0xC6, 0xE3, 0x9C, 0x0F, 0xF3, 0xFC, 0x60, 0x3F, 0x1F, 0xC3, 0x80,
  0x70, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x67, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x80,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x81, 0xFC, 0x70, 0x03, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00, 0xE7,
  0x00, 0x38, 0xE0, 0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFF, 0x0E,
  0x00, 0xF1, 0xC0, 0x07, 0x38, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x70,
  0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0x70, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x02, 0x0F, 0xC3, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x18, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xE1, 0xFE, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x8E,
  0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x38,
  0xE0, 0x07, 0x8E, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x3F, 0x01, 0xE0, 0xF8, 0x00, 0xC1, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x38, 0x78, 0x00,
  0x70, 0xF8, 0x00, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x05, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x3F, 0xFF, 0xFC, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0xE0, 0x01, 0xDC, 0x00,
  0x73, 0x80, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x78,
  0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x80,
  0x1C, 0xF0, 0x03, 0xBE, 0x00, 0x77, 0xE0, 0x0F, 0xDC, 0x01, 0xF3, 0x80,
  0x3C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x87, 0x00, 0x70,
  0xE0, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x1E, 0x70, 0x01, 0xCE, 0x00, 0x3D,
  0xC0, 0x03, 0xB8, 0x00, 0x78, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0x7E, 0xC0, 0x00, 0x1D, 0xFB, 0x80, 0x00,
  0x77, 0xEE, 0x00, 0x01, 0x9F, 0x98, 0x00, 0x0E, 0x7E, 0x70, 0x00, 0x39,
  0xF9, 0xC0, 0x00, 0xE7, 0xE3, 0x00, 0x07, 0x1F, 0x8E, 0x00, 0x1C, 0x7E,
  0x38, 0x00, 0x71, 0xF8, 0xE0, 0x01, 0x87, 0xE1, 0x80, 0x0E, 0x1F, 0x87,
  0x00, 0x38, 0x7E, 0x1C, 0x00, 0xC1, 0xF8, 0x30, 0x07, 0x07, 0xE0, 0xE0,
  0x1C, 0x1F, 0x83, 0x80, 0x70, 0x7E, 0x0E, 0x03, 0x81, 0xF8, 0x1C, 0x0E,
  0x07, 0xE0, 0x70, 0x38, 0x1F, 0x81, 0xC0, 0xC0, 0x7E, 0x03, 0x07, 0x01,
  0xF8, 0x0E, 0x1C, 0x07, 0xE0, 0x38, 0x70, 0x1F, 0x80, 0xE3, 0x80, 0x7E,
  0x01, 0xCE, 0x01, 0xF8, 0x07, 0x38, 0x07, 0xE0, 0x1D, 0xC0, 0x1F, 0x80,
  0x37, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xC0, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xB8, 0x00, 0xFD, 0xC0, 0x07, 0xE7, 0x00, 0x3F, 0x38, 0x01,
  0xF8, 0xE0, 0x0F, 0xC7, 0x00, 0x7E, 0x38, 0x03, 0xF0, 0xE0, 0x1F, 0x87,
  0x00, 0xFC, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F,
  0xC0, 0xE0, 0x7E, 0x03, 0x83, 0xF0, 0x1C, 0x1F, 0x80, 0x70, 0xFC, 0x03,
  0x87, 0xE0, 0x0E, 0x3F, 0x00, 0x71, 0xF8, 0x03, 0x8F, 0xC0, 0x0E, 0x7E,
  0x00, 0x71, 0xF0, 0x01, 0xCF, 0x80, 0x0E, 0x7C, 0x00, 0x3B, 0xE0, 0x01,
  0xDF, 0x00, 0x0E, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7C, 0x1F, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0x80, 0xF0, 0x0F, 0x01, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x7F, 0x9C, 0x03, 0xEE,
  0x00, 0xF7, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x07, 0xCF, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7C,
  0x1F, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x3C, 0x70, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0x80, 0xF0, 0x0F,
  0x01, 0xF8, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0x8F, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0xF1, 0xC0,
  0x0F, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00,
  0x3C, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x78, 0x7F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x38, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7C, 0x1E, 0x3C, 0x00, 0x9E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0xC0, 0x0F, 0x3F, 0x1F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F, 0x0F, 0x81, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77,
  0x00, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xE0, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x60, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x61, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3B, 0x80,
  0x03, 0xC0, 0x01, 0xDC, 0x00, 0x1E, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0x00,
  0xF7, 0x00, 0x0F, 0x80, 0x07, 0x3C, 0x00, 0x7C, 0x00, 0x38, 0xE0, 0x03,
  0x70, 0x01, 0xC7, 0x00, 0x1B, 0x80, 0x0E, 0x38, 0x00, 0xDC, 0x00, 0xF1,
  0xC0, 0x0E, 0xE0, 0x07, 0x07, 0x00, 0x73, 0x00, 0x38, 0x38, 0x03, 0x9C,
  0x01, 0xC1, 0xC0, 0x18, 0xE0, 0x0E, 0x0E, 0x00, 0xC7, 0x00, 0xE0, 0x70,
  0x0E, 0x38, 0x07, 0x01, 0xC0, 0x70, 0xC0, 0x38, 0x0E, 0x03, 0x87, 0x01,
  0xC0, 0x70, 0x1C, 0x38, 0x0E, 0x03, 0x80, 0xC1, 0xC0, 0xE0, 0x1C, 0x0E,
  0x0E, 0x07, 0x00, 0x70, 0x70, 0x30, 0x38, 0x03, 0x83, 0x81, 0xC1, 0xC0,
  0x1C, 0x1C, 0x0E, 0x1E, 0x00, 0xE0, 0xC0, 0x70, 0xE0, 0x07, 0x0E, 0x03,
  0x87, 0x00, 0x1C, 0x70, 0x0C, 0x38, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x07,
  0x1C, 0x03, 0x9C, 0x00, 0x38, 0xC0, 0x1C, 0xE0, 0x00, 0xCE, 0x00, 0xE7,
  0x00, 0x07, 0x70, 0x03, 0x38, 0x00, 0x3B, 0x80, 0x19, 0xC0, 0x01, 0xDC,
  0x00, 0xFC, 0x00, 0x0E, 0xC0, 0x07, 0xE0, 0x00, 0x36, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x0D, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0xE0,
  0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x8E,
  0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x03,
  0x9C, 0x00, 0x73, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xE6, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0xC0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x00,
  0x73, 0x80, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x18, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0x07, 0x3C, 0x07,
  0x78, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x70, 0x1F, 0x78, 0x37, 0x3F, 0xE7,
  0x1F, 0xC3, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE1, 0xF0, 0x38, 0xFF, 0x0E,
  0xFF, 0xE3, 0xB0, 0x3C, 0xF8, 0x07, 0x3C, 0x01, 0xEF, 0x00, 0x3B, 0xC0,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0xC0,
  0x0E, 0xF0, 0x03, 0xBE, 0x01, 0xCF, 0x80, 0xF3, 0x38, 0x78, 0xC7, 0xFC,
  0x30, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xF8, 0xF8,
  0x21, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x30, 0xFF, 0xE0,
  0x7F, 0x80, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x1E, 0x0E, 0x0F,
  0xF1, 0xC3, 0xFF, 0x38, 0xF0, 0x77, 0x3C, 0x06, 0xE7, 0x00, 0x7C, 0xE0,
  0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00,
  0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xF3, 0x80, 0x3E, 0x70, 0x07, 0xCF, 0x01,
  0xB8, 0xF0, 0x77, 0x0F, 0xFC, 0xE0, 0xFF, 0x1C, 0x02, 0x00, 0x00, 0x01,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x78, 0x38, 0x1C, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x67, 0x00, 0x19,
  0xC0, 0x07, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x08,
  0x3C, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x00, 0x03, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xF3, 0xFF, 0x83, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x1C, 0x3F,
  0xF3, 0x8F, 0x07, 0x73, 0xC0, 0x6E, 0x70, 0x07, 0xCE, 0x00, 0x7B, 0x80,
  0x0F, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00,
  0x7B, 0x80, 0x0F, 0x38, 0x03, 0xE7, 0x00, 0x5C, 0xF0, 0x1B, 0x8F, 0x0E,
  0x70, 0xFF, 0xCE, 0x0F, 0xE1, 0xC0, 0x20, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE1, 0x00, 0x3C, 0x3F, 0x7F, 0x07, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE1, 0xF0, 0xE7, 0xF8, 0xEF, 0xFC, 0xEE, 0x1E, 0xF8, 0x0E, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x7F, 0xF7, 0x60, 0x00, 0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x0E, 0x3C, 0x78,
  0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x3B, 0xF7, 0xCF, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E,
  0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE1, 0xC0, 0xE3, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xE7, 0x00, 0xEF, 0x80,
  0xFF, 0x80, 0xF9, 0xC0, 0xF9, 0xC0, 0xF1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x1E, 0x0C, 0x7F, 0x87, 0xF8, 0xCF, 0xF8, 0x7F, 0xCD, 0xC3,
  0xCC, 0x1E, 0xD8, 0x1D, 0x80, 0xEF, 0x00, 0xF8, 0x0E, 0xF0, 0x0F, 0x00,
  0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0,
  0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07,
  0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00,
  0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0x01, 0xF0, 0xC7,
  0xF8, 0xCF, 0xFC, 0xCC, 0x1E, 0xD8, 0x0E, 0xD0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x70, 0x07, 0x0E,
  0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x03, 0xB8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0x70,
  0x1E, 0x0F, 0x87, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x10, 0x00, 0x01,
  0xF0, 0x30, 0xFF, 0x0C, 0x7F, 0xE3, 0x30, 0x3C, 0xD8, 0x07, 0x34, 0x01,
  0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xEE, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBE, 0x01, 0xCF, 0xC0, 0xF3,
  0xB8, 0x78, 0xE7, 0xFC, 0x38, 0xFE, 0x0E, 0x06, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0x1C, 0x3F, 0xF3, 0x8F, 0x07, 0x73, 0xC0, 0x6E,
  0x70, 0x07, 0xCE, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x3D,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77,
  0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x38, 0x03, 0xE7,
  0x00, 0x5C, 0xF0, 0x1B, 0x8F, 0x8E, 0x70, 0xFF, 0xCE, 0x0F, 0xE1, 0xC0,
  0x20, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xD8, 0xFF, 0x1F, 0xE7,
  0x1D, 0xC1, 0xB0, 0x34, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0xC0, 0x7F, 0xE3, 0xFF, 0xDE, 0x06, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x03,
  0xBC, 0x3E, 0xFF, 0xF1, 0xFF, 0x80, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x07, 0xFF, 0xFF, 0xE3, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC4, 0x3F, 0x83, 0xF0, 0x10, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0x70, 0x3B, 0x78, 0x73, 0x3F, 0xE3, 0x1F, 0xC3, 0x02, 0x00, 0xE0,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x03, 0x03, 0x80, 0xE0, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x01, 0x87, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00, 0xCE,
  0x00, 0x33, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x78, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x66, 0x00, 0xD8, 0x07, 0x38,
  0x06, 0xC0, 0x39, 0xC0, 0x77, 0x01, 0xCE, 0x03, 0xB8, 0x0C, 0x70, 0x1D,
  0xC0, 0xE1, 0xC0, 0xC6, 0x07, 0x0E, 0x06, 0x30, 0x38, 0x70, 0x71, 0xC1,
  0xC3, 0x83, 0x8E, 0x0C, 0x0C, 0x1C, 0x70, 0xE0, 0x70, 0xC1, 0x87, 0x03,
  0x8E, 0x0C, 0x38, 0x1C, 0x70, 0x71, 0xC0, 0xE3, 0x83, 0x8C, 0x03, 0x18,
  0x1C, 0xE0, 0x1C, 0xC0, 0x67, 0x00, 0xEE, 0x03, 0x38, 0x07, 0x70, 0x1D,
  0x80, 0x1B, 0x80, 0xEC, 0x00, 0xD8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0xB8, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC1,
  0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x03, 0xB8,
  0x01, 0xDC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x9C, 0x01,
  0xCE, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x0E,
  0x1C, 0x07, 0x06, 0x03, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x30,
  0x70, 0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0xE6, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x07, 0xF0, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F,
  0xC0, 0x1F, 0x00, 0xFC, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x1E, 0x03, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x07, 0x8F, 0xE3, 0xC0, 0x3F, 0xF8, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Light55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 39, 12, 4, -39 },
  { 21, 12, 14, 18, 3, -39 },
  { 42, 22, 39, 24, 1, -39 },
  { 150, 19, 45, 23, 2, -42 },
  { 257, 30, 41, 34, 2, -40 },
  { 411, 22, 41, 24, 2, -40 },
  { 524, 4, 14, 10, 3, -39 },
  { 531, 10, 48, 15, 3, -39 },
  { 591, 10, 48, 15, 2, -39 },
  { 651, 16, 16, 20, 2, -42 },
  { 683, 19, 25, 23, 2, -32 },
  { 743, 6, 13, 11, 2, -6 },
  { 753, 12, 3, 15, 1, -16 },
  { 758, 5, 5, 11, 3, -5 },
  { 762, 17, 39, 19, 1, -39 },
  { 845, 18, 40, 23, 2, -40 },
  { 935, 11, 39, 23, 4, -39 },
  { 989, 18, 40, 23, 2, -40 },
  { 1079, 18, 41, 23, 2, -40 },
  { 1172, 21, 40, 23, 1, -40 },
  { 1277, 17, 40, 23, 3, -39 },
  { 1362, 17, 41, 23, 3, -40 },
  { 1450, 18, 39, 23, 2, -39 },
  { 1538, 19, 41, 23, 2, -40 },
  { 1636, 18, 41, 23, 2, -40 },
  { 1729, 5, 29, 11, 3, -29 },
  { 1748, 6, 36, 11, 2, -29 },
  { 1775, 19, 23, 23, 2, -31 },
  { 1830, 19, 15, 23, 2, -27 },
  { 1866, 19, 23, 23, 2, -31 },
  { 1921, 14, 40, 16, 1, -40 },
  { 1991, 29, 45, 34, 3, -40 },
  { 2155, 23, 39, 23, 0, -39 },
  { 2268, 19, 39, 25, 4, -39 },
  { 2361, 19, 41, 24, 3, -40 },
  { 2459, 20, 39, 27, 4, -39 },
  { 2557, 15, 39, 22, 4, -39 },
  { 2631, 15, 39, 20, 4, -39 },
  { 2705, 23, 41, 29, 3, -40 },
  { 2823, 20, 39, 28, 4, -39 },
  { 2921, 10, 39, 14, 2, -39 },
  { 2970, 10, 49, 11, -3, -39 },
  { 3032, 19, 39, 23, 4, -39 },
  { 3125, 15, 39, 20, 4, -39 },
  { 3199, 30, 39, 38, 4, -39 },
  { 3346, 21, 39, 30, 4, -39 },
  { 3449, 23, 41, 29, 3, -40 },
  { 3567, 17, 39, 23, 4, -39 },
  { 3650, 23, 49, 29, 3, -40 },
  { 3791, 19, 39, 24, 4, -39 },
  { 3884, 18, 41, 22, 2, -40 },
  { 3977, 19, 39, 20, 0, -39 },
  { 4070, 20, 40, 28, 4, -39 },
  { 4170, 22, 39, 22, 0, -39 },
  { 4278, 37, 39, 38, 0, -39 },
  { 4459, 20, 39, 20, 0, -39 },
  { 4557, 19, 39, 19, 0, -39 },
  { 4650, 17, 39, 19, 1, -39 },
  { 4733, 11, 48, 17, 4, -39 },
  { 4799, 17, 39, 19, 1, -39 },
  { 4882, 11, 48, 17, 2, -39 },
  { 4948, 21, 20, 23, 1, -39 },
  { 5001, 23, 2, 23, 0, 5 },
  { 5007, 9, 9, 14, 2, -42 },
  { 5018, 16, 31, 22, 2, -30 },
  { 5080, 18, 43, 24, 4, -42 },
  { 5177, 15, 31, 18, 2, -30 },
  { 5236, 19, 43, 24, 2, -42 },
  { 5339, 18, 31, 22, 2, -30 },
  { 5409, 13, 42, 13, 1, -42 },
  { 5478, 19, 43, 24, 2, -30 },
  { 5581, 16, 42, 24, 4, -42 },
  { 5665, 4, 40, 11, 3, -40 },
  { 5685, 7, 53, 11, 0, -40 },
  { 5732, 16, 42, 20, 4, -42 },
  { 5816, 3, 42, 10, 4, -42 },
  { 5832, 28, 30, 35, 4, -30 },
  { 5937, 16, 30, 24, 4, -30 },
  { 5997, 19, 31, 23, 2, -30 },
  { 6071, 18, 43, 24, 4, -30 },
  { 6168, 19, 43, 24, 2, -30 },
  { 6271, 11, 30, 16, 4, -30 },
  { 6313, 14, 31, 18, 2, -30 },
  { 6368, 11, 37, 13, 1, -36 },
  { 6419, 16, 30, 24, 4, -29 },
  { 6479, 18, 29, 18, 0, -29 },
  { 6545, 29, 29, 31, 1, -29 },
  { 6651, 17, 29, 19, 1, -29 },
  { 6713, 17, 42, 19, 1, -29 },
  { 6803, 13, 29, 15, 1, -29 },
  { 6851, 14, 48, 19, 3, -39 },
  { 6935, 3, 55, 22, 9, -42 },
  { 6956, 14, 48, 19, 3, -39 },
  { 7040, 19, 5, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Light55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT55PT7B_H_
