#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x50, 0xF0, 0x99, 0x99, 0x90, 0x12, 0x12, 0x12, 0x12,
  0x7F, 0x24, 0x24, 0x24, 0x24, 0xFF, 0x24, 0x24, 0x24, 0x48, 0x21, 0xFA,
  0x28, 0xA2, 0x86, 0x0E, 0x2C, 0x92, 0x49, 0xF8, 0x82, 0x00, 0x61, 0x28,
  0x89, 0x22, 0x48, 0x94, 0x25, 0x09, 0x5A, 0xA9, 0x6A, 0x42, 0x91, 0x24,
  0x49, 0x12, 0x48, 0x60, 0x30, 0xA1, 0x22, 0x45, 0x0A, 0x08, 0x30, 0x93,
  0x26, 0x34, 0x28, 0xCE, 0x40, 0xF8, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88,
  0x84, 0x42, 0x30, 0x91, 0x22, 0x49, 0x24, 0x92, 0xD2, 0x80, 0x25, 0x5C,
  0xAD, 0x80, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x6A, 0xF0, 0xF0,
  0x04, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x10, 0x43, 0x00, 0x31,
  0x28, 0xA1, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x49, 0xE0, 0x13, 0x59,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x72, 0x20, 0x81, 0x04, 0x20, 0x82, 0x10,
  0x82, 0x10, 0x83, 0xF0, 0x72, 0x20, 0xC1, 0x04, 0x27, 0x06, 0x0C, 0x10,
  0x41, 0x0B, 0xE0, 0x04, 0x0C, 0x0C, 0x14, 0x14, 0x24, 0x24, 0x44, 0x44,
  0x84, 0xFF, 0x04, 0x04, 0x04, 0xFA, 0x08, 0x20, 0x82, 0x0F, 0x83, 0x04,
  0x10, 0x41, 0x0B, 0xC0, 0x19, 0x84, 0x20, 0x82, 0x0F, 0xA1, 0x86, 0x18,
  0x61, 0x4D, 0xE0, 0xFC, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08,
  0x41, 0x00, 0x33, 0x28, 0x61, 0x85, 0x23, 0x1E, 0x8A, 0x18, 0x61, 0x85,
  0xE0, 0x33, 0x28, 0xA1, 0x86, 0x18, 0x73, 0x74, 0x10, 0x82, 0x1B, 0xC0,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7A, 0x04, 0x33, 0x30, 0x81, 0x81, 0x81,
  0xFC, 0x00, 0x00, 0xFC, 0x83, 0x03, 0x03, 0x04, 0x66, 0x20, 0x74, 0xC2,
  0x10, 0x84, 0x44, 0x21, 0x00, 0x02, 0x30, 0x0E, 0x0C, 0x44, 0x09, 0x02,
  0x8E, 0x64, 0x99, 0x26, 0x49, 0x92, 0x64, 0x99, 0x66, 0x36, 0x40, 0x10,
  0x02, 0x20, 0x70, 0x18, 0x18, 0x18, 0x18, 0x24, 0x24, 0x24, 0x24, 0x7E,
  0x42, 0x42, 0x42, 0x82, 0x81, 0xF1, 0x1A, 0x14, 0x18, 0x70, 0xBE, 0x46,
  0x87, 0x06, 0x0C, 0x18, 0x5F, 0x00, 0x1C, 0x45, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x03, 0x02, 0x06, 0x07, 0xC0, 0xF1, 0x1A, 0x1C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x5F, 0x00, 0xFE, 0x08, 0x20, 0x82,
  0x0F, 0xA0, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x3E, 0x82, 0x08, 0x20, 0x82, 0x00, 0x1E, 0x31, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x87, 0x81, 0x81, 0xC1, 0x41, 0x61, 0x3F, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xE9, 0x24, 0x92,
  0x49, 0x25, 0xC0, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x32, 0xE4,
  0x83, 0x0A, 0x34, 0x49, 0x12, 0x28, 0x68, 0xD1, 0x12, 0x24, 0x28, 0x50,
  0x40, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0xC0, 0x78,
  0x0E, 0x82, 0xD0, 0x5A, 0x0B, 0x41, 0x64, 0x4C, 0x89, 0x91, 0x31, 0x46,
  0x28, 0xC5, 0x18, 0x43, 0x08, 0x40, 0xC1, 0xC1, 0xA1, 0xA1, 0xA1, 0x91,
  0x91, 0x89, 0x89, 0x85, 0x85, 0x87, 0x83, 0x83, 0x18, 0x66, 0x42, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x42, 0x3C, 0xF2, 0x38,
  0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x20, 0x82, 0x00, 0x18, 0x66, 0x42,
  0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x42, 0x3C, 0x04,
  0x04, 0x02, 0xE1, 0x3A, 0x14, 0x28, 0x50, 0xA1, 0x7C, 0x91, 0x12, 0x24,
  0x28, 0x50, 0x40, 0x3B, 0x18, 0x20, 0x83, 0x06, 0x06, 0x08, 0x10, 0x41,
  0x0B, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0E, 0x14, 0x27, 0x80, 0x81, 0x82, 0xC2, 0x42, 0x42, 0x44, 0x44, 0x24,
  0x24, 0x24, 0x28, 0x18, 0x18, 0x18, 0x82, 0x0C, 0x10, 0x51, 0x84, 0x8A,
  0x24, 0x51, 0x22, 0x89, 0x14, 0x44, 0xA4, 0x28, 0xA1, 0x45, 0x0A, 0x28,
  0x51, 0x41, 0x8C, 0x08, 0x20, 0x42, 0x89, 0x11, 0x22, 0x85, 0x04, 0x08,
  0x28, 0x50, 0xB2, 0x24, 0x50, 0x40, 0x83, 0x09, 0x12, 0x24, 0x85, 0x0A,
  0x18, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0xF8, 0x46, 0x21, 0x10, 0x84,
  0x42, 0x31, 0x08, 0x7C, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10,
  0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x08, 0x18, 0x18, 0x24, 0x24,
  0x42, 0xC3, 0xFF, 0x99, 0x80, 0xF8, 0x42, 0x17, 0xC6, 0x31, 0x8F, 0xC0,
  0x81, 0x02, 0x04, 0x0B, 0xD8, 0xB1, 0x41, 0x83, 0x06, 0x1E, 0x2C, 0x57,
  0x00, 0x7A, 0x21, 0x08, 0x42, 0x10, 0xC3, 0xC0, 0x04, 0x10, 0x41, 0x7F,
  0x18, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xD0, 0x7A, 0x28, 0x61, 0xFE, 0x08,
  0x20, 0x41, 0xE0, 0x11, 0x48, 0x84, 0x79, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x00, 0x7F, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xD0, 0x41, 0x06, 0x27,
  0x00, 0x82, 0x08, 0x20, 0xBB, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10,
  0xE0, 0xAA, 0xAA, 0xA0, 0x68, 0x04, 0x92, 0x49, 0x24, 0x92, 0x5A, 0x00,
  0x82, 0x08, 0x21, 0x8A, 0x69, 0x28, 0xB3, 0x49, 0x22, 0x8A, 0x30, 0xFF,
  0xFC, 0xBB, 0xB3, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84,
  0x61, 0x10, 0xBB, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x7A, 0x18,
  0x61, 0x86, 0x18, 0x61, 0xC5, 0xE0, 0xB9, 0x8B, 0x14, 0x18, 0x30, 0x61,
  0xE2, 0xC5, 0x72, 0x04, 0x08, 0x10, 0x00, 0x7F, 0x18, 0x61, 0x86, 0x18,
  0x61, 0xCD, 0xD0, 0x41, 0x04, 0x10, 0xBC, 0xC8, 0x88, 0x88, 0x88, 0xFC,
  0x21, 0x06, 0x18, 0x41, 0x17, 0x80, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x43,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xD0, 0x87, 0x14, 0x52, 0x49,
  0x22, 0x8C, 0x30, 0xC0, 0x84, 0x53, 0x14, 0xA5, 0x29, 0x4A, 0x92, 0xA3,
  0x28, 0xC6, 0x31, 0x8C, 0x40, 0xC5, 0x22, 0x8A, 0x10, 0xC2, 0x92, 0x47,
  0x10, 0x85, 0x14, 0x52, 0x48, 0xA2, 0x8C, 0x30, 0x41, 0x08, 0x23, 0x8C,
  0x00, 0xF3, 0x22, 0x44, 0x48, 0x8F, 0x09, 0x88, 0x42, 0x10, 0x84, 0xC2,
  0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xE0, 0x83, 0x08, 0x42, 0x10,
  0x84, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0xC6, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 6, 1, -14 },
  { 8, 8, 14, 8, 0, -14 },
  { 22, 6, 15, 8, 1, -14 },
  { 34, 10, 14, 12, 1, -14 },
  { 52, 7, 14, 8, 1, -14 },
  { 65, 1, 5, 4, 1, -14 },
  { 66, 4, 17, 5, 1, -14 },
  { 75, 3, 17, 5, 1, -14 },
  { 82, 5, 5, 7, 1, -14 },
  { 86, 6, 9, 8, 1, -11 },
  { 93, 2, 4, 4, 1, -2 },
  { 94, 4, 1, 5, 1, -6 },
  { 95, 2, 2, 4, 1, -2 },
  { 96, 6, 14, 7, 0, -14 },
  { 107, 6, 14, 8, 1, -14 },
  { 118, 4, 14, 8, 1, -14 },
  { 125, 6, 14, 8, 1, -14 },
  { 136, 6, 14, 8, 1, -14 },
  { 147, 8, 14, 8, 0, -14 },
  { 161, 6, 14, 8, 1, -14 },
  { 172, 6, 14, 8, 1, -14 },
  { 183, 6, 14, 8, 1, -14 },
  { 194, 6, 14, 8, 1, -14 },
  { 205, 6, 14, 8, 1, -14 },
  { 216, 2, 10, 4, 1, -10 },
  { 219, 2, 12, 4, 1, -10 },
  { 222, 6, 8, 8, 1, -11 },
  { 228, 6, 5, 8, 1, -9 },
  { 232, 6, 8, 8, 1, -11 },
  { 238, 5, 14, 6, 0, -14 },
  { 247, 10, 16, 12, 1, -14 },
  { 267, 8, 14, 8, 0, -14 },
  { 281, 7, 14, 9, 1, -14 },
  { 294, 7, 14, 8, 1, -14 },
  { 307, 7, 14, 9, 1, -14 },
  { 320, 6, 14, 7, 1, -14 },
  { 331, 6, 14, 7, 1, -14 },
  { 342, 8, 14, 10, 1, -14 },
  { 356, 7, 14, 10, 1, -14 },
  { 369, 3, 14, 5, 1, -14 },
  { 375, 4, 18, 4, -1, -14 },
  { 384, 7, 14, 8, 1, -14 },
  { 397, 5, 14, 7, 1, -14 },
  { 406, 11, 14, 13, 1, -14 },
  { 426, 8, 14, 10, 1, -14 },
  { 440, 8, 14, 10, 1, -14 },
  { 454, 6, 14, 8, 1, -14 },
  { 465, 8, 17, 10, 1, -14 },
  { 482, 7, 14, 8, 1, -14 },
  { 495, 6, 14, 8, 1, -14 },
  { 506, 7, 14, 7, 0, -14 },
  { 519, 7, 14, 10, 1, -14 },
  { 532, 8, 14, 8, 0, -14 },
  { 546, 13, 14, 13, 0, -14 },
  { 569, 7, 14, 7, 0, -14 },
  { 582, 7, 14, 7, 0, -14 },
  { 595, 5, 14, 7, 1, -14 },
  { 604, 4, 17, 6, 1, -14 },
  { 613, 6, 14, 7, 0, -14 },
  { 624, 3, 17, 6, 1, -14 },
  { 631, 8, 7, 8, 0, -14 },
  { 638, 8, 1, 8, 0, 2 },
  { 639, 3, 3, 5, 1, -15 },
  { 641, 5, 10, 7, 1, -10 },
  { 648, 7, 14, 8, 1, -14 },
  { 661, 5, 10, 6, 1, -10 },
  { 668, 6, 14, 8, 1, -14 },
  { 679, 6, 10, 8, 1, -10 },
  { 687, 5, 15, 4, 0, -15 },
  { 697, 6, 15, 8, 1, -10 },
  { 709, 6, 14, 8, 1, -14 },
  { 720, 2, 14, 4, 1, -14 },
  { 724, 3, 19, 4, 0, -14 },
  { 732, 6, 14, 7, 1, -14 },
  { 743, 1, 14, 4, 1, -14 },
  { 745, 10, 10, 12, 1, -10 },
  { 758, 6, 10, 8, 1, -10 },
  { 766, 6, 10, 8, 1, -10 },
  { 774, 7, 14, 8, 1, -10 },
  { 787, 6, 14, 8, 1, -10 },
  { 798, 4, 10, 5, 1, -10 },
  { 803, 5, 10, 6, 1, -10 },
  { 810, 4, 12, 4, 0, -12 },
  { 816, 6, 10, 8, 1, -10 },
  { 824, 6, 10, 6, 0, -10 },
  { 832, 10, 10, 11, 0, -10 },
  { 845, 6, 10, 7, 0, -10 },
  { 853, 6, 15, 7, 0, -10 },
  { 865, 4, 10, 5, 1, -10 },
  { 870, 5, 17, 7, 1, -14 },
  { 881, 1, 19, 7, 3, -14 },
  { 884, 5, 17, 7, 1, -14 },
  { 895, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Light19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT19PT7B_H_
