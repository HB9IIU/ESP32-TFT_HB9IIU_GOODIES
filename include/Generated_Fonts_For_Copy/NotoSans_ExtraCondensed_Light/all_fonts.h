#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_Light
// Headers: 67

#include "NotoSans_ExtraCondensed_Light6pt7b.h"
#include "NotoSans_ExtraCondensed_Light7pt7b.h"
#include "NotoSans_ExtraCondensed_Light8pt7b.h"
#include "NotoSans_ExtraCondensed_Light9pt7b.h"
#include "NotoSans_ExtraCondensed_Light10pt7b.h"
#include "NotoSans_ExtraCondensed_Light11pt7b.h"
#include "NotoSans_ExtraCondensed_Light12pt7b.h"
#include "NotoSans_ExtraCondensed_Light13pt7b.h"
#include "NotoSans_ExtraCondensed_Light14pt7b.h"
#include "NotoSans_ExtraCondensed_Light15pt7b.h"
#include "NotoSans_ExtraCondensed_Light16pt7b.h"
#include "NotoSans_ExtraCondensed_Light17pt7b.h"
#include "NotoSans_ExtraCondensed_Light18pt7b.h"
#include "NotoSans_ExtraCondensed_Light19pt7b.h"
#include "NotoSans_ExtraCondensed_Light20pt7b.h"
#include "NotoSans_ExtraCondensed_Light21pt7b.h"
#include "NotoSans_ExtraCondensed_Light22pt7b.h"
#include "NotoSans_ExtraCondensed_Light23pt7b.h"
#include "NotoSans_ExtraCondensed_Light24pt7b.h"
#include "NotoSans_ExtraCondensed_Light25pt7b.h"
#include "NotoSans_ExtraCondensed_Light26pt7b.h"
#include "NotoSans_ExtraCondensed_Light27pt7b.h"
#include "NotoSans_ExtraCondensed_Light28pt7b.h"
#include "NotoSans_ExtraCondensed_Light29pt7b.h"
#include "NotoSans_ExtraCondensed_Light30pt7b.h"
#include "NotoSans_ExtraCondensed_Light31pt7b.h"
#include "NotoSans_ExtraCondensed_Light32pt7b.h"
#include "NotoSans_ExtraCondensed_Light33pt7b.h"
#include "NotoSans_ExtraCondensed_Light34pt7b.h"
#include "NotoSans_ExtraCondensed_Light35pt7b.h"
#include "NotoSans_ExtraCondensed_Light36pt7b.h"
#include "NotoSans_ExtraCondensed_Light37pt7b.h"
#include "NotoSans_ExtraCondensed_Light38pt7b.h"
#include "NotoSans_ExtraCondensed_Light39pt7b.h"
#include "NotoSans_ExtraCondensed_Light40pt7b.h"
#include "NotoSans_ExtraCondensed_Light41pt7b.h"
#include "NotoSans_ExtraCondensed_Light42pt7b.h"
#include "NotoSans_ExtraCondensed_Light43pt7b.h"
#include "NotoSans_ExtraCondensed_Light44pt7b.h"
#include "NotoSans_ExtraCondensed_Light45pt7b.h"
#include "NotoSans_ExtraCondensed_Light46pt7b.h"
#include "NotoSans_ExtraCondensed_Light47pt7b.h"
#include "NotoSans_ExtraCondensed_Light48pt7b.h"
#include "NotoSans_ExtraCondensed_Light49pt7b.h"
#include "NotoSans_ExtraCondensed_Light50pt7b.h"
#include "NotoSans_ExtraCondensed_Light51pt7b.h"
#include "NotoSans_ExtraCondensed_Light52pt7b.h"
#include "NotoSans_ExtraCondensed_Light53pt7b.h"
#include "NotoSans_ExtraCondensed_Light54pt7b.h"
#include "NotoSans_ExtraCondensed_Light55pt7b.h"
#include "NotoSans_ExtraCondensed_Light56pt7b.h"
#include "NotoSans_ExtraCondensed_Light57pt7b.h"
#include "NotoSans_ExtraCondensed_Light58pt7b.h"
#include "NotoSans_ExtraCondensed_Light59pt7b.h"
#include "NotoSans_ExtraCondensed_Light60pt7b.h"
#include "NotoSans_ExtraCondensed_Light61pt7b.h"
#include "NotoSans_ExtraCondensed_Light62pt7b.h"
#include "NotoSans_ExtraCondensed_Light63pt7b.h"
#include "NotoSans_ExtraCondensed_Light64pt7b.h"
#include "NotoSans_ExtraCondensed_Light65pt7b.h"
#include "NotoSans_ExtraCondensed_Light66pt7b.h"
#include "NotoSans_ExtraCondensed_Light67pt7b.h"
#include "NotoSans_ExtraCondensed_Light68pt7b.h"
#include "NotoSans_ExtraCondensed_Light69pt7b.h"
#include "NotoSans_ExtraCondensed_Light70pt7b.h"
#include "NotoSans_ExtraCondensed_Light71pt7b.h"
#include "NotoSans_ExtraCondensed_Light72pt7b.h"
