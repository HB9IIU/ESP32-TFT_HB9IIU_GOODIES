#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x03, 0xEC, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x43, 0x43, 0x04, 0x30, 0x10,
  0xC0, 0x43, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0x80, 0xC2, 0x03, 0x08, 0x7F,
  0xFC, 0x21, 0x80, 0x86, 0x06, 0x18, 0x18, 0x60, 0x61, 0x81, 0x84, 0x06,
  0x10, 0xFF, 0xFB, 0xFF, 0xE1, 0x0C, 0x04, 0x30, 0x30, 0xC0, 0xC3, 0x03,
  0x08, 0x0C, 0x20, 0x30, 0x80, 0x86, 0x00, 0x02, 0x00, 0x10, 0x03, 0xF0,
  0x7F, 0xE7, 0x22, 0x31, 0x03, 0x08, 0x18, 0x40, 0xC2, 0x06, 0x10, 0x18,
  0x80, 0xE4, 0x03, 0xA0, 0x07, 0x00, 0x1E, 0x00, 0x5C, 0x02, 0x70, 0x11,
  0x80, 0x84, 0x04, 0x30, 0x21, 0x81, 0x18, 0x08, 0xDC, 0x5C, 0xFF, 0xC0,
  0x70, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x38, 0x04, 0x0D, 0x81, 0x83,
  0x10, 0x30, 0x63, 0x04, 0x08, 0x61, 0x81, 0x0C, 0x30, 0x20, 0x84, 0x04,
  0x11, 0x80, 0x82, 0x30, 0x10, 0x44, 0x02, 0x19, 0x8C, 0x43, 0x37, 0xCC,
  0x64, 0xCD, 0x89, 0x90, 0x9F, 0x26, 0x11, 0xCC, 0xC3, 0x01, 0x98, 0x60,
  0x23, 0x0C, 0x0C, 0x61, 0x81, 0x8C, 0x30, 0x21, 0x86, 0x0C, 0x30, 0xC1,
  0x86, 0x10, 0x20, 0x46, 0x0C, 0x0C, 0xC1, 0x80, 0xF0, 0x0F, 0x00, 0x3F,
  0x00, 0xC6, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x40,
  0x11, 0x80, 0x33, 0x00, 0x6C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xC0, 0x0C,
  0xC3, 0x31, 0x86, 0x61, 0x8D, 0x83, 0x33, 0x03, 0x66, 0x03, 0xCC, 0x07,
  0x18, 0x06, 0x38, 0x1C, 0x30, 0x6C, 0x7B, 0x8C, 0x7E, 0x1C, 0xFB, 0x6D,
  0xB2, 0x48, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0xC0, 0xC1, 0x81, 0x83, 0x03, 0x03, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x03,
  0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x38, 0x60, 0xC3, 0x06, 0x18, 0x60, 0x06, 0x00,
  0xC0, 0x10, 0x32, 0x7F, 0xFE, 0x0C, 0x02, 0xC0, 0xD8, 0x31, 0x86, 0x18,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F,
  0xFF, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x33, 0x33, 0x66, 0x64, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x00, 0x1F, 0x07, 0xF1, 0xC6, 0x30, 0x66, 0x0D, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0x98, 0x33, 0x8E, 0x3F, 0x83,
  0xE0, 0x06, 0x1C, 0x79, 0xBE, 0x78, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x1F, 0x87, 0xFC, 0x60, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0x1F, 0x87, 0xFC, 0xE0, 0xE4, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x38, 0x1F, 0x01, 0xF8,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x68, 0x0E, 0xFB, 0xC7, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x02,
  0x80, 0x3C, 0x01, 0x60, 0x1B, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x06, 0x30,
  0x31, 0x83, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x7F, 0xCF, 0xF9, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x20, 0x7F, 0xCC, 0x3C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x0E, 0xFF, 0x9F,
  0xE0, 0x07, 0xC3, 0xF8, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x3C, 0x6F, 0xCF, 0x0D, 0xC1, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD8, 0x1B, 0x06, 0x3B, 0xC3,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0F, 0x81, 0xFE, 0x0C, 0x18, 0xC0, 0x66, 0x03,
  0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x71, 0x83, 0x06, 0x30, 0x1F, 0x00,
  0x70, 0x0F, 0xC0, 0xE3, 0x06, 0x0C, 0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80,
  0x3C, 0x01, 0xE0, 0x19, 0x80, 0xCE, 0x0E, 0x3D, 0xE0, 0xFE, 0x00, 0x0F,
  0x03, 0xFC, 0x30, 0xC6, 0x06, 0x60, 0x66, 0x02, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x60, 0x36, 0x03, 0x60, 0x77, 0x07, 0x3F, 0xB1, 0xF3, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x27,
  0x83, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x77, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x36, 0x66, 0x4C, 0x00, 0x18,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x20, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x02, 0x00, 0x00, 0x7C, 0x7F, 0x20, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x18, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x18,
  0x00, 0x33, 0x03, 0x86, 0x41, 0xF8, 0x58, 0x63, 0x0F, 0x0C, 0x61, 0xE1,
  0x0C, 0x3C, 0x61, 0x87, 0x8C, 0x30, 0xF1, 0x86, 0x1E, 0x30, 0xC3, 0xC6,
  0x18, 0x78, 0xC3, 0x0B, 0x18, 0xE1, 0x61, 0x94, 0x6C, 0x3E, 0xF9, 0x83,
  0x8E, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x10, 0x07, 0x9E, 0x00, 0x7F, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00,
  0x34, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x20, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0xC3, 0x01, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0F, 0xF8,
  0x3F, 0xF8, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC6, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0xC0, 0x0F, 0x80, 0x0C, 0xFE, 0x0F, 0xF8, 0xC1, 0xCC,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC,
  0x3C, 0xFF, 0x0C, 0x3C, 0xC0, 0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF0, 0x07, 0xF0,
  0x7F, 0xC7, 0x04, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xFC, 0x30, 0x71, 0x81, 0xCC,
  0x06, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0D,
  0x80, 0x6C, 0x03, 0x60, 0x33, 0x03, 0x98, 0x38, 0xFF, 0x87, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0F, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFF, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00,
  0x03, 0xF8, 0x1F, 0xFC, 0x70, 0x11, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0x6E, 0x00, 0xCE, 0x01, 0x8E, 0x03, 0x0F, 0xFE, 0x0F,
  0xF8, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0xFF, 0xFC, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x39, 0xFC, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xA7, 0x7C, 0x70,
  0xC0, 0x7C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x38, 0xC3, 0x0C, 0x60,
  0xC6, 0x0C, 0xC0, 0xCC, 0x0D, 0x80, 0xFC, 0x0F, 0xC0, 0xEC, 0x0C, 0x60,
  0xC6, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06,
  0xC0, 0x6C, 0x03, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x02, 0xF4,
  0x00, 0xDE, 0xC0, 0x1B, 0xD8, 0x03, 0x7B, 0x00, 0xCF, 0x30, 0x19, 0xE6,
  0x03, 0x3C, 0xC0, 0xC7, 0x88, 0x18, 0xF1, 0x83, 0x1E, 0x30, 0x43, 0xC2,
  0x18, 0x78, 0x63, 0x0F, 0x0C, 0x61, 0xE1, 0x98, 0x3C, 0x1B, 0x07, 0x83,
  0x60, 0xF0, 0x68, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0C, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3D, 0x80, 0xF6,
  0x03, 0xCC, 0x0F, 0x30, 0x3C, 0x60, 0xF1, 0x83, 0xC6, 0x0F, 0x0C, 0x3C,
  0x30, 0xF0, 0x63, 0xC1, 0x8F, 0x03, 0x3C, 0x0C, 0xF0, 0x33, 0xC0, 0x6F,
  0x01, 0xBC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x70, 0x07, 0xC0, 0x3F,
  0xE0, 0xE0, 0xE1, 0x80, 0xC6, 0x00, 0xCC, 0x01, 0x98, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1B, 0x00, 0x36, 0x00,
  0xCC, 0x01, 0x8C, 0x07, 0x1C, 0x1C, 0x1E, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F,
  0xF3, 0x0F, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x6C, 0x1D, 0x8F, 0x3F, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xE0, 0xE1, 0x80, 0xC6, 0x00, 0xCC, 0x01, 0x98, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1B, 0x00, 0x36,
  0x00, 0xCC, 0x01, 0x8C, 0x07, 0x1C, 0x1C, 0x1E, 0xF0, 0x1F, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0xFC, 0x0F,
  0xF8, 0xC3, 0xCC, 0x0C, 0xC0, 0xEC, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0x8F, 0xF0, 0xFE, 0x0C, 0x60, 0xC3, 0x0C,
  0x30, 0xC3, 0x8C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x6C,
  0x03, 0x0F, 0xC1, 0xFF, 0x30, 0x26, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x68,
  0x0E, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0x60, 0x1B, 0x00,
  0xCC, 0x0E, 0x7F, 0xE0, 0xFE, 0x00, 0xC0, 0x0F, 0x80, 0x19, 0x80, 0x33,
  0x00, 0x66, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60,
  0x60, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x0C, 0x06, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x19, 0x80, 0x33, 0x00, 0x26, 0x00, 0x6C, 0x00, 0xD0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0x60, 0x1C, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x3C, 0x03, 0x60, 0x34,
  0x06, 0x60, 0x34, 0x06, 0x30, 0x36, 0x06, 0x30, 0x26, 0x06, 0x30, 0x66,
  0x0E, 0x30, 0x66, 0x0C, 0x18, 0x62, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0x63,
  0x0C, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x0C, 0xC1, 0x18, 0x0C, 0xC1,
  0x98, 0x0C, 0xC1, 0x98, 0x0C, 0x81, 0xB0, 0x0D, 0x81, 0xB0, 0x07, 0x80,
  0xB0, 0x07, 0x80, 0xB0, 0x07, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x60, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0xE1, 0x86, 0x0C, 0x30, 0x63,
  0x01, 0x98, 0x0C, 0xC0, 0x2C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x03, 0x80,
  0x1E, 0x00, 0xB0, 0x0D, 0x80, 0x66, 0x06, 0x30, 0x30, 0x81, 0x86, 0x18,
  0x30, 0xC0, 0xCC, 0x06, 0x60, 0x37, 0x00, 0xC0, 0xC0, 0x1E, 0x01, 0x98,
  0x0C, 0xC0, 0x66, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x18, 0xC0, 0xC6,
  0x02, 0x60, 0x1B, 0x00, 0xD8, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x02,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x60, 0x0D, 0x80, 0x63, 0x01, 0x8C, 0x0C,
  0x18, 0x30, 0x61, 0x80, 0xC6, 0x03, 0x30, 0x06, 0xC0, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE1, 0x83, 0x06, 0x08, 0x30, 0x06, 0x07, 0xF0, 0xC7, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFC, 0xF1, 0xB8, 0x36,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xEC, 0x1D, 0xCD, 0x9F, 0x30, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x20, 0xCF,
  0xCD, 0x8E, 0xD0, 0x6E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xD0,
  0x6D, 0xDE, 0xCF, 0xC0, 0x06, 0x0F, 0xCE, 0x2C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x0E, 0x63, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x43, 0x3F, 0x37, 0x1B, 0x60, 0xBC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0x60, 0xB7, 0x3B, 0x3F, 0x30, 0x04, 0x07, 0xE1, 0xC6,
  0x30, 0x6C, 0x0D, 0x80, 0xB0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x04, 0xE7, 0x0F, 0xE0,
  0x03, 0x07, 0xC7, 0x23, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x7F, 0xBF,
  0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x04, 0x03, 0xF3, 0x71,
  0xB6, 0x0B, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x76, 0x0B, 0x7B,
  0xB3, 0xF3, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0E, 0xC1,
  0xCF, 0xF8, 0x1C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x10, 0xCF, 0xDB, 0x3B, 0x41, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0xFD, 0x80, 0x03, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6C, 0x39, 0xC6, 0x00, 0x00, 0x02, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xC6,
  0x37, 0xB0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0xD8, 0x33, 0x06, 0x61, 0x8C, 0x31, 0x8C, 0x33, 0x06, 0x60,
  0xDC, 0x1A, 0xC3, 0x98, 0x71, 0x8C, 0x31, 0x83, 0x30, 0x66, 0x0C, 0xC0,
  0xD8, 0x1B, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x02,
  0x02, 0x19, 0xF1, 0xF3, 0x67, 0x67, 0x78, 0x68, 0x6E, 0x0E, 0x07, 0xC0,
  0xC0, 0xF8, 0x18, 0x1E, 0x03, 0x03, 0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x01,
  0x81, 0xE0, 0x30, 0x3C, 0x06, 0x07, 0x80, 0xC0, 0xF0, 0x18, 0x1E, 0x03,
  0x03, 0xC0, 0x60, 0x78, 0x0C, 0x0F, 0x01, 0x81, 0xE0, 0x30, 0x30, 0x02,
  0x19, 0xFB, 0x63, 0x68, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x30, 0x04, 0x03, 0xF8, 0x71, 0xC6, 0x0C, 0xC0, 0x6C, 0x06,
  0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x6C, 0x06, 0xE0, 0x66, 0x0C, 0x3B, 0xC1, 0xF8, 0x02, 0x0C, 0xFC,
  0xD8, 0xED, 0x06, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7D, 0x06,
  0xDD, 0xCC, 0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x03, 0xF3, 0x71, 0xB6, 0x0B, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x76, 0x0B, 0x7B, 0xB3, 0xF3, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0xCF, 0xDF, 0xD0, 0xF0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x04, 0x0F, 0xE7, 0x19,
  0x80, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x01, 0xA0, 0x6F, 0x79, 0xFC, 0x20, 0x40, 0x81,
  0x02, 0x1F, 0xFF, 0xB0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x02, 0x06, 0x0E, 0x9F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1B, 0x07, 0x60, 0xEF, 0x64, 0xF8, 0x80, 0xC0, 0x36, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x62, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x08,
  0x19, 0x81, 0x98, 0x19, 0x80, 0x90, 0x0B, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x06, 0x00, 0xC0, 0x60, 0x36, 0x07, 0x02, 0x60, 0xF0, 0x66, 0x0F, 0x06,
  0x60, 0xD0, 0x62, 0x0D, 0x06, 0x30, 0x98, 0xC3, 0x19, 0x8C, 0x31, 0x98,
  0xC3, 0x19, 0x8C, 0x19, 0x88, 0x81, 0x90, 0xD8, 0x1B, 0x0D, 0x81, 0xB0,
  0xD8, 0x0B, 0x0D, 0x80, 0xA0, 0x50, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xC0, 0xEC, 0x19, 0x86, 0x18, 0xC3, 0x18, 0x66, 0x06, 0xC0,
  0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x66, 0x0C, 0x63, 0x0C,
  0x60, 0xD8, 0x1B, 0x01, 0x80, 0xE0, 0x36, 0x03, 0x60, 0x66, 0x06, 0x30,
  0x63, 0x06, 0x30, 0x43, 0x0C, 0x18, 0xC1, 0x8C, 0x18, 0x81, 0x98, 0x0D,
  0x80, 0xD8, 0x0D, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF8, 0x06, 0x00, 0xFF,
  0xFF, 0x03, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0x01, 0x83, 0xC3, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE1, 0xE0,
  0xF0, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x0E, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x0F, 0x07, 0x86, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x81,
  0xC3, 0xC1, 0x80, 0x10, 0x03, 0xF0, 0x71, 0xFF, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 26, 8, 2, -26 },
  { 11, 8, 10, 12, 2, -26 },
  { 21, 14, 26, 16, 1, -26 },
  { 67, 13, 29, 15, 1, -27 },
  { 115, 19, 26, 22, 2, -26 },
  { 177, 15, 26, 16, 1, -26 },
  { 226, 3, 10, 7, 2, -26 },
  { 230, 7, 32, 10, 2, -26 },
  { 258, 7, 32, 10, 1, -26 },
  { 286, 11, 10, 13, 1, -27 },
  { 300, 13, 17, 15, 1, -21 },
  { 328, 4, 9, 7, 1, -4 },
  { 333, 8, 2, 10, 1, -11 },
  { 335, 3, 3, 7, 2, -3 },
  { 337, 11, 26, 13, 1, -26 },
  { 373, 11, 26, 15, 2, -26 },
  { 409, 7, 26, 15, 3, -26 },
  { 432, 12, 26, 15, 1, -26 },
  { 471, 12, 26, 15, 1, -26 },
  { 510, 13, 26, 15, 1, -26 },
  { 553, 11, 26, 15, 2, -26 },
  { 589, 11, 26, 15, 2, -26 },
  { 625, 12, 26, 15, 1, -26 },
  { 664, 13, 26, 15, 1, -26 },
  { 707, 12, 26, 15, 1, -26 },
  { 746, 3, 19, 7, 2, -19 },
  { 754, 4, 24, 7, 1, -19 },
  { 766, 13, 15, 15, 1, -20 },
  { 791, 13, 9, 15, 1, -17 },
  { 806, 13, 15, 15, 1, -20 },
  { 831, 9, 26, 10, 1, -26 },
  { 861, 19, 29, 23, 2, -26 },
  { 930, 15, 26, 15, 0, -26 },
  { 979, 12, 26, 16, 3, -26 },
  { 1018, 13, 26, 16, 2, -26 },
  { 1061, 13, 26, 18, 3, -26 },
  { 1104, 9, 26, 14, 3, -26 },
  { 1134, 9, 26, 13, 3, -26 },
  { 1164, 15, 26, 19, 2, -26 },
  { 1213, 13, 26, 18, 3, -26 },
  { 1256, 7, 26, 9, 1, -26 },
  { 1279, 7, 33, 7, -2, -26 },
  { 1308, 12, 26, 15, 3, -26 },
  { 1347, 9, 26, 13, 3, -26 },
  { 1377, 19, 26, 25, 3, -26 },
  { 1439, 14, 26, 19, 3, -26 },
  { 1485, 15, 26, 19, 2, -26 },
  { 1534, 11, 26, 15, 3, -26 },
  { 1570, 15, 32, 19, 2, -26 },
  { 1630, 12, 26, 16, 3, -26 },
  { 1669, 12, 26, 14, 1, -26 },
  { 1708, 13, 26, 13, 0, -26 },
  { 1751, 13, 26, 18, 3, -26 },
  { 1794, 15, 26, 15, 0, -26 },
  { 1843, 24, 26, 25, 0, -26 },
  { 1921, 13, 26, 13, 0, -26 },
  { 1964, 13, 26, 13, 0, -26 },
  { 2007, 11, 26, 12, 1, -26 },
  { 2043, 7, 32, 11, 3, -26 },
  { 2071, 11, 26, 13, 1, -26 },
  { 2107, 7, 32, 11, 1, -26 },
  { 2135, 14, 13, 15, 1, -26 },
  { 2158, 15, 2, 15, 0, 3 },
  { 2162, 6, 6, 9, 1, -28 },
  { 2167, 11, 20, 14, 1, -20 },
  { 2195, 12, 27, 16, 2, -27 },
  { 2236, 9, 20, 12, 2, -20 },
  { 2259, 12, 27, 16, 2, -27 },
  { 2300, 11, 20, 14, 2, -20 },
  { 2328, 9, 28, 8, 0, -28 },
  { 2360, 12, 29, 16, 2, -20 },
  { 2404, 11, 27, 16, 2, -27 },
  { 2442, 3, 26, 7, 2, -26 },
  { 2452, 5, 35, 7, 0, -26 },
  { 2474, 11, 27, 13, 2, -27 },
  { 2512, 2, 27, 7, 2, -27 },
  { 2519, 19, 20, 23, 2, -20 },
  { 2567, 11, 20, 16, 2, -20 },
  { 2595, 12, 20, 15, 2, -20 },
  { 2625, 12, 29, 16, 2, -20 },
  { 2669, 12, 29, 16, 2, -20 },
  { 2713, 8, 19, 10, 2, -19 },
  { 2732, 10, 20, 12, 1, -20 },
  { 2757, 7, 24, 8, 1, -24 },
  { 2778, 11, 19, 16, 2, -19 },
  { 2805, 12, 19, 12, 0, -19 },
  { 2834, 20, 19, 20, 0, -19 },
  { 2882, 11, 19, 12, 1, -19 },
  { 2909, 12, 28, 12, 0, -19 },
  { 2951, 8, 19, 10, 1, -19 },
  { 2970, 9, 32, 13, 2, -26 },
  { 3006, 2, 36, 14, 6, -27 },
  { 3015, 9, 32, 13, 2, -26 },
  { 3051, 13, 4, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Light36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT36PT7B_H_
