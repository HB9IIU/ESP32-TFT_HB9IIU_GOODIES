#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x00, 0x00, 0xEF, 0xFF, 0xE0, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xD8, 0x3B, 0x07, 0x60, 0xEC, 0x1D, 0x83, 0xB0,
  0x36, 0x06, 0x01, 0xC0, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x81, 0x80, 0x1C, 0x0C, 0x00, 0xC0, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x81, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x03, 0x00, 0x38,
  0x18, 0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x03, 0x00,
  0x18, 0x18, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x70, 0x30, 0x03, 0x81,
  0x80, 0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x30, 0x38,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xE2, 0x0C, 0x70, 0x80,
  0x38, 0x20, 0x0E, 0x08, 0x03, 0x82, 0x00, 0xC0, 0x80, 0x30, 0x20, 0x0E,
  0x08, 0x03, 0x82, 0x00, 0x70, 0x80, 0x1E, 0x20, 0x03, 0xC8, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x02, 0x78, 0x00, 0x8F,
  0x00, 0x21, 0xE0, 0x08, 0x38, 0x02, 0x06, 0x00, 0x81, 0xC0, 0x20, 0x70,
  0x08, 0x1C, 0x02, 0x06, 0x00, 0x83, 0x80, 0x20, 0xEC, 0x08, 0xF3, 0xF2,
  0xF8, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x04, 0x01, 0xF8, 0x01, 0x80,
  0x3B, 0x80, 0x18, 0x03, 0x1C, 0x03, 0x80, 0x70, 0xC0, 0x30, 0x06, 0x0E,
  0x03, 0x00, 0x60, 0x60, 0x70, 0x0E, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x60,
  0x0E, 0x06, 0x0E, 0x00, 0xE0, 0x60, 0xC0, 0x0E, 0x06, 0x0C, 0x00, 0xE0,
  0x61, 0xC0, 0x0E, 0x06, 0x18, 0x00, 0xE0, 0x61, 0x80, 0x0E, 0x06, 0x38,
  0x70, 0x60, 0x63, 0x1F, 0x86, 0x0E, 0x31, 0xDC, 0x60, 0xE7, 0x38, 0xE7,
  0x0C, 0x63, 0x06, 0x31, 0xCE, 0x70, 0x63, 0xF8, 0xE7, 0x07, 0x1F, 0x8C,
  0x60, 0x70, 0x61, 0xC6, 0x07, 0x00, 0x1C, 0x60, 0x70, 0x01, 0x86, 0x07,
  0x00, 0x38, 0x60, 0x30, 0x03, 0x86, 0x07, 0x00, 0x30, 0x60, 0x70, 0x07,
  0x06, 0x07, 0x00, 0x70, 0x60, 0x70, 0x06, 0x07, 0x07, 0x00, 0xE0, 0x70,
  0x60, 0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x1C, 0x03, 0x8E, 0x01,
  0x80, 0x1F, 0xC0, 0x18, 0x00, 0xF8, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60,
  0x07, 0x03, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xDC,
  0x00, 0x1C, 0x70, 0x71, 0xC3, 0x83, 0x8E, 0x0E, 0x1C, 0xE0, 0x70, 0xE7,
  0x01, 0xC7, 0x38, 0x06, 0x31, 0x80, 0x3B, 0x8C, 0x00, 0xFC, 0x60, 0x07,
  0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x7E, 0x1C,
  0x07, 0x70, 0xF0, 0xF1, 0xC3, 0xFF, 0x0F, 0x0F, 0xF0, 0x3C, 0x0C, 0x00,
  0x00, 0xFE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x60, 0x03, 0xC0, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x08,
  0x30, 0xFE, 0x6F, 0xFF, 0xFF, 0x0F, 0xE0, 0x07, 0x80, 0x1B, 0x00, 0x73,
  0x01, 0xC7, 0x07, 0x07, 0x0E, 0x0E, 0x08, 0x08, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x38, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x86, 0x38, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0xC3, 0x81, 0xC0, 0xE1, 0xC0, 0x70, 0xE0,
  0x1C, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x00, 0xCE, 0x00, 0x77,
  0x00, 0x3B, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x33,
  0x80, 0x39, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x07, 0x07,
  0x83, 0xE7, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xC0, 0xF0, 0x7C, 0x3F,
  0x1D, 0xDE, 0x7F, 0x1F, 0x87, 0x41, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x0F, 0xF8, 0x1F, 0xFF,
  0x1F, 0x07, 0x86, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0x1E, 0x07, 0xC6,
  0x00, 0xE2, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0xA0, 0x07, 0x9E, 0x07, 0xCF, 0xFF, 0xC3, 0xFF, 0x80,
  0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x37, 0x00, 0x03, 0x70, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0xE7,
  0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x30,
  0x70, 0x07, 0x07, 0x00, 0x60, 0x70, 0x0E, 0x07, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x7F,
  0xFC, 0x7F, 0xFC, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x60, 0x7C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x80, 0x3C, 0xE0, 0xF8, 0xFF, 0xF0, 0x7F,
  0xE0, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF0, 0x20, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC3, 0xF0, 0x67,
  0xFC, 0x37, 0xFF, 0x3B, 0x03, 0xDF, 0x00, 0xEF, 0x00, 0x77, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xEE, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x38, 0x07, 0x1C,
  0x03, 0x87, 0x03, 0xC3, 0xC3, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0xF0, 0x78, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x39, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x07,
  0x0E, 0x01, 0xC3, 0xC0, 0xE0, 0x78, 0x70, 0x0F, 0x78, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0E, 0x78, 0x07, 0x07, 0x03, 0x80, 0xE1, 0xC0,
  0x1C, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x03, 0x9C, 0x00, 0xE7,
  0x80, 0x70, 0xF0, 0x78, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x87, 0x83, 0x80, 0xE3, 0x80, 0x71,
  0xC0, 0x18, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00,
  0x6E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0,
  0x03, 0xDC, 0x01, 0xEE, 0x01, 0xF3, 0x81, 0xB9, 0xFF, 0xDC, 0x7F, 0xCE,
  0x0F, 0x86, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x04, 0x1E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF7,
  0x38, 0xE7, 0xDE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x18,
  0x63, 0x8C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x03, 0xFE, 0x3F, 0xF9, 0xC1, 0xE8,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x39, 0xC0, 0x3F, 0x03, 0x30, 0x0F, 0xF0, 0x66,
  0x03, 0x8E, 0x0F, 0xC0, 0xE1, 0xC1, 0xF8, 0x38, 0x38, 0x3F, 0x07, 0x07,
  0x03, 0xC0, 0xC0, 0xE0, 0x78, 0x18, 0x1C, 0x0F, 0x03, 0x03, 0x81, 0xE0,
  0xE0, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x83, 0x81, 0x80, 0xF0, 0x70, 0x30,
  0x1E, 0x0E, 0x06, 0x07, 0xC1, 0xC1, 0xC0, 0xF8, 0x18, 0x38, 0x1B, 0x03,
  0x07, 0x83, 0x60, 0x71, 0xB0, 0xEE, 0x07, 0x37, 0x39, 0xC0, 0xFC, 0x7F,
  0x18, 0x0F, 0x07, 0x83, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x70, 0x00, 0x1C, 0xC0,
  0x00, 0x73, 0x00, 0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE1, 0x80, 0x03, 0x87, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC0,
  0xC0, 0x07, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0,
  0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0x60, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0E, 0x0F, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0xFF,
  0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0x80, 0x78, 0xE0, 0x07, 0x38, 0x01,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x07, 0x38, 0x03, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x3E, 0x06, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x04, 0x1F, 0x07, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0x87, 0xF0, 0x70, 0x0F,
  0x0E, 0x00, 0xF1, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x03, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x81, 0xF0, 0x1E, 0x0F, 0x00, 0x18, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x1D, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x78, 0x00, 0x70, 0xF0, 0x01, 0xC1, 0xF0, 0x1F, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xFF, 0xFF, 0xC7,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x1F, 0xFF, 0xF8, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xD1, 0xEF, 0xE7, 0xE0, 0x80, 0xE0, 0x03, 0xB8, 0x01,
  0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1,
  0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0xC0,
  0x0F, 0xF8, 0x03, 0xEE, 0x00, 0xF1, 0xC0, 0x3C, 0x70, 0x0E, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE0, 0xE0,
  0x3C, 0x38, 0x07, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0x7E, 0xC0, 0x00, 0x77, 0xEE, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x67,
  0xE6, 0x00, 0x0E, 0x7E, 0x60, 0x00, 0xE7, 0xE7, 0x00, 0x0E, 0x7E, 0x70,
  0x00, 0xC7, 0xE3, 0x00, 0x1C, 0x7E, 0x38, 0x01, 0xC7, 0xE3, 0x80, 0x18,
  0x7E, 0x18, 0x03, 0x87, 0xE1, 0xC0, 0x38, 0x7E, 0x1C, 0x03, 0x07, 0xE1,
  0xC0, 0x70, 0x7E, 0x0C, 0x07, 0x07, 0xE0, 0xE0, 0x70, 0x7E, 0x0E, 0x06,
  0x07, 0xE0, 0x60, 0xE0, 0x7E, 0x07, 0x0E, 0x07, 0xE0, 0x70, 0xC0, 0x7E,
  0x03, 0x1C, 0x07, 0xE0, 0x31, 0xC0, 0x7E, 0x03, 0x9C, 0x07, 0xE0, 0x39,
  0x80, 0x7E, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0E, 0x00, 0x70, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7E, 0xE0, 0x07, 0xEE, 0x00, 0x7E, 0x70, 0x07,
  0xE7, 0x00, 0x7E, 0x30, 0x07, 0xE3, 0x80, 0x7E, 0x38, 0x07, 0xE1, 0xC0,
  0x7E, 0x1C, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0x60, 0x7E, 0x07,
  0x07, 0xE0, 0x70, 0x7E, 0x03, 0x87, 0xE0, 0x38, 0x7E, 0x01, 0xC7, 0xE0,
  0x1C, 0x7E, 0x00, 0xE7, 0xE0, 0x0E, 0x7E, 0x00, 0xE7, 0xE0, 0x07, 0x7E,
  0x00, 0x77, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x03,
  0x83, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF8,
  0xE3, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xE0,
  0xF0, 0x03, 0x83, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x79, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x1E, 0x03, 0xE1,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x02, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xFF, 0xC0, 0x3F, 0xFE,
  0x0E, 0x3F, 0xC3, 0x80, 0xF8, 0xE0, 0x0E, 0x38, 0x03, 0xCE, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x0F,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x38, 0x38, 0x0E, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0F, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFF,
  0x07, 0xFF, 0xC7, 0xC0, 0xE3, 0x80, 0x13, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xA0, 0x07, 0x9F, 0x0F,
  0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x80, 0x0E, 0x70,
  0x03, 0x8F, 0x00, 0xF0, 0xF8, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xDC, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x38, 0xC0, 0x01, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0x00,
  0x1D, 0xC0, 0x03, 0xC0, 0x03, 0xB8, 0x00, 0x78, 0x00, 0x77, 0x00, 0x1F,
  0x00, 0x1C, 0xE0, 0x03, 0xE0, 0x03, 0x8E, 0x00, 0x6C, 0x00, 0x71, 0xC0,
  0x0D, 0xC0, 0x0E, 0x38, 0x01, 0xB8, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x70,
  0xE0, 0x0E, 0x60, 0x0E, 0x0E, 0x01, 0xCC, 0x01, 0xC1, 0xC0, 0x31, 0xC0,
  0x38, 0x38, 0x06, 0x38, 0x06, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x60, 0x38,
  0x60, 0x38, 0x0E, 0x07, 0x0C, 0x07, 0x01, 0xC0, 0xC1, 0xC0, 0xE0, 0x38,
  0x18, 0x38, 0x38, 0x07, 0x07, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x60, 0xE0,
  0x0E, 0x1C, 0x0C, 0x1C, 0x01, 0xC3, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x38,
  0xE0, 0x07, 0x1C, 0x07, 0x1C, 0x00, 0x63, 0x80, 0x63, 0x80, 0x0E, 0x70,
  0x0C, 0x70, 0x01, 0xCC, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x3B, 0x80, 0x07,
  0x30, 0x07, 0x70, 0x00, 0x6E, 0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x0D, 0xC0,
  0x01, 0xF0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0x60, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x0C, 0x70,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x03, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0x70, 0x00, 0xE6, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0x80,
  0x1C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0xEF,
  0x00, 0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xC3, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x06, 0x07, 0x03,
  0x80, 0xC0, 0xE0, 0x38, 0x30, 0x0E, 0x1C, 0x01, 0x87, 0x00, 0x71, 0x80,
  0x1C, 0xE0, 0x03, 0x38, 0x00, 0xEC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xD8,
  0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0,
  0x70, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x18, 0x38,
  0x01, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x0F, 0xE0, 0x7F, 0xF0, 0xF1, 0xF1, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x3F, 0xE3, 0xFF, 0xCF, 0x83, 0xBC, 0x07, 0x70, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xF0, 0x3E, 0xF0, 0xCC, 0xFF, 0x98, 0xFE, 0x30, 0x60, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x3F, 0x06, 0x7F, 0xC3, 0x38, 0xF1, 0xB0, 0x3C, 0xD0, 0x0E, 0x78, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01,
  0xDE, 0x01, 0xCD, 0x80, 0xE6, 0xE1, 0xE3, 0x3F, 0xF1, 0x8F, 0xE0, 0x00,
  0x80, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xF9, 0xC7, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x30,
  0xFF, 0xC1, 0xFF, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x07, 0xE1, 0xC3, 0xFE,
  0x71, 0xE3, 0xDC, 0xF0, 0x37, 0x38, 0x07, 0xDE, 0x00, 0xF7, 0x00, 0x3D,
  0xC0, 0x0F, 0x70, 0x03, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1D, 0x80, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3C,
  0xE0, 0x1F, 0x38, 0x0D, 0xC7, 0x87, 0x71, 0xFF, 0x9C, 0x1F, 0xC7, 0x01,
  0x80, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0x8F, 0x03, 0x81, 0xC3, 0x80,
  0xE1, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xDC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x01, 0x0F, 0x03, 0x83, 0xFF, 0xC0,
  0xFF, 0x80, 0x06, 0x00, 0x01, 0xE0, 0x7F, 0x0F, 0xF0, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xCF,
  0xFC, 0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x07, 0xE1, 0xC3, 0xFE, 0x71, 0xF3, 0xDC, 0xF0,
  0x37, 0x38, 0x07, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03,
  0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80,
  0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x1F, 0x38, 0x0D,
  0xC7, 0x87, 0x71, 0xFF, 0x9C, 0x1F, 0xC7, 0x01, 0x81, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x40, 0x0F, 0x1C, 0x07, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x3F, 0x19, 0xFF, 0x33, 0x9F, 0x6C, 0x0E, 0xF0, 0x1D, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x0C,
  0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC3, 0x87, 0x0E, 0xF9, 0xF1, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x01, 0xD8, 0x07, 0x30, 0x0E,
  0x60, 0x38, 0xC0, 0xE1, 0x81, 0xC3, 0x07, 0x06, 0x0E, 0x0C, 0x38, 0x18,
  0xE0, 0x31, 0xC0, 0x67, 0x80, 0xCF, 0x01, 0xB7, 0x03, 0xEE, 0x07, 0x9C,
  0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x38, 0x60, 0x70, 0xC0, 0x61, 0x80, 0xE3,
  0x01, 0xC6, 0x01, 0xCC, 0x03, 0x98, 0x03, 0x30, 0x07, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x7E,
  0x33, 0xFC, 0x3F, 0xCD, 0xE7, 0x9C, 0xFB, 0x60, 0xEC, 0x0E, 0xF0, 0x1F,
  0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x07, 0xE0,
  0x1E, 0x01, 0xF0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x1F, 0x00, 0x70, 0x07,
  0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x1F, 0x00, 0x70,
  0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x1F, 0x00,
  0x70, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x1F,
  0x00, 0x70, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x7C, 0x01, 0xC0,
  0x1F, 0x00, 0x70, 0x07, 0xC3, 0xF1, 0x9F, 0xF3, 0x39, 0xF6, 0xC0, 0xEF,
  0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xF3, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x76, 0x00, 0x1D, 0xC0, 0x06, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00,
  0x38, 0xE0, 0x1C, 0x3C, 0x07, 0x07, 0x87, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x40, 0x00, 0xC3, 0xF0, 0x63, 0xFC, 0x33, 0x8F, 0x1B, 0x03, 0xCD,
  0x00, 0xE7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0x70, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x6E, 0x00, 0x77,
  0x00, 0x3B, 0xC0, 0x1D, 0xE0, 0x1C, 0xD8, 0x0E, 0x6E, 0x1E, 0x33, 0xFE,
  0x18, 0xFE, 0x0C, 0x08, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xE1, 0xC3, 0xFE, 0x71, 0xF3, 0xDC, 0xF0,
  0x37, 0x38, 0x07, 0xCE, 0x01, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03,
  0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0,
  0x0F, 0x70, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x1F, 0x3C, 0x0D,
  0xC7, 0x87, 0x71, 0xFF, 0x9C, 0x1F, 0xC7, 0x01, 0x81, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xC3, 0xF1,
  0xFC, 0xFF, 0x70, 0xD8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0xE1, 0xFF,
  0xDF, 0x1E, 0xE0, 0x2E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x7F, 0x07, 0xBF, 0xF8, 0xFF, 0x80, 0x60, 0x00, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0,
  0x71, 0x1F, 0xC3, 0xF0, 0x10, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60,
  0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x1B, 0x3C, 0x73, 0x3F, 0xE3, 0x1F,
  0xC3, 0x02, 0x00, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE7,
  0x00, 0x71, 0x80, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07,
  0x06, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x30, 0x70, 0x1C,
  0x30, 0x0E, 0x38, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x06, 0xE0, 0x0F,
  0x00, 0xEE, 0x01, 0xF0, 0x0E, 0xE0, 0x1F, 0x00, 0xE6, 0x01, 0xB0, 0x0C,
  0x70, 0x1B, 0x00, 0xC7, 0x01, 0xB8, 0x1C, 0x70, 0x3B, 0x81, 0xC3, 0x03,
  0x98, 0x1C, 0x30, 0x31, 0x81, 0x83, 0x83, 0x18, 0x38, 0x38, 0x71, 0xC3,
  0x83, 0x87, 0x1C, 0x38, 0x18, 0x70, 0xC3, 0x01, 0xC6, 0x0C, 0x30, 0x1C,
  0x60, 0xE7, 0x01, 0xCE, 0x0E, 0x70, 0x1C, 0xE0, 0xE7, 0x00, 0xCE, 0x06,
  0x60, 0x0E, 0xC0, 0x66, 0x00, 0xEC, 0x06, 0xE0, 0x0E, 0xC0, 0x7E, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80,
  0x3C, 0x00, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38,
  0x1C, 0x38, 0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C,
  0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x06, 0x70,
  0x0E, 0x70, 0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x18,
  0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x30, 0x0E,
  0x70, 0x0E, 0x70, 0x06, 0x70, 0x06, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xF0, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x03, 0xF8, 0x0F, 0x00, 0x3F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xF0, 0x03, 0xC0, 0x3F, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xE0,
  0x1E, 0x7E, 0x1E, 0x03, 0xFF, 0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 37, 11, 4, -37 },
  { 20, 11, 13, 17, 3, -37 },
  { 38, 21, 37, 23, 1, -37 },
  { 136, 18, 43, 21, 2, -40 },
  { 233, 28, 38, 32, 2, -38 },
  { 366, 21, 39, 22, 2, -38 },
  { 469, 4, 13, 10, 3, -37 },
  { 476, 10, 45, 14, 3, -37 },
  { 533, 10, 45, 14, 2, -37 },
  { 590, 15, 16, 19, 2, -40 },
  { 620, 18, 24, 22, 2, -30 },
  { 674, 6, 13, 10, 2, -6 },
  { 684, 12, 3, 14, 1, -16 },
  { 689, 4, 5, 11, 3, -5 },
  { 692, 16, 37, 18, 1, -37 },
  { 766, 17, 38, 21, 2, -38 },
  { 847, 10, 37, 21, 4, -37 },
  { 894, 17, 38, 21, 2, -38 },
  { 975, 17, 39, 21, 2, -38 },
  { 1058, 20, 37, 21, 1, -37 },
  { 1151, 16, 37, 21, 3, -37 },
  { 1225, 17, 39, 21, 2, -38 },
  { 1308, 17, 37, 21, 2, -37 },
  { 1387, 18, 39, 21, 2, -38 },
  { 1475, 17, 39, 21, 2, -38 },
  { 1558, 4, 28, 11, 3, -28 },
  { 1572, 6, 35, 11, 2, -28 },
  { 1599, 18, 23, 22, 2, -30 },
  { 1651, 18, 13, 22, 2, -25 },
  { 1681, 18, 23, 22, 2, -30 },
  { 1733, 13, 38, 15, 1, -38 },
  { 1795, 27, 42, 33, 3, -37 },
  { 1937, 22, 37, 22, 0, -37 },
  { 2039, 18, 37, 24, 4, -37 },
  { 2123, 18, 39, 22, 3, -38 },
  { 2211, 19, 37, 26, 4, -37 },
  { 2299, 14, 37, 20, 4, -37 },
  { 2364, 14, 37, 19, 4, -37 },
  { 2429, 22, 39, 28, 3, -38 },
  { 2537, 19, 37, 27, 4, -37 },
  { 2625, 9, 37, 13, 2, -37 },
  { 2667, 9, 47, 11, -2, -37 },
  { 2720, 18, 37, 21, 4, -37 },
  { 2804, 14, 37, 19, 4, -37 },
  { 2869, 28, 37, 36, 4, -37 },
  { 2999, 20, 37, 28, 4, -37 },
  { 3092, 22, 39, 28, 3, -38 },
  { 3200, 16, 37, 22, 4, -37 },
  { 3274, 22, 47, 28, 3, -38 },
  { 3404, 18, 37, 23, 4, -37 },
  { 3488, 17, 39, 21, 2, -38 },
  { 3571, 18, 37, 19, 0, -37 },
  { 3655, 19, 38, 26, 4, -37 },
  { 3746, 21, 37, 21, 0, -37 },
  { 3844, 35, 37, 36, 0, -37 },
  { 4006, 19, 37, 19, 0, -37 },
  { 4094, 18, 37, 18, 0, -37 },
  { 4178, 16, 37, 18, 1, -37 },
  { 4252, 10, 45, 16, 4, -37 },
  { 4309, 16, 37, 18, 1, -37 },
  { 4383, 10, 45, 16, 2, -37 },
  { 4440, 20, 19, 22, 1, -37 },
  { 4488, 22, 2, 22, 0, 5 },
  { 4494, 9, 8, 13, 2, -40 },
  { 4503, 15, 29, 20, 2, -28 },
  { 4558, 17, 41, 23, 4, -40 },
  { 4646, 14, 29, 17, 2, -28 },
  { 4697, 18, 41, 23, 2, -40 },
  { 4790, 17, 29, 21, 2, -28 },
  { 4852, 12, 40, 12, 1, -40 },
  { 4912, 18, 41, 23, 2, -28 },
  { 5005, 15, 40, 22, 4, -40 },
  { 5080, 4, 38, 10, 3, -38 },
  { 5099, 7, 51, 10, 0, -38 },
  { 5144, 15, 40, 19, 4, -40 },
  { 5219, 2, 40, 10, 4, -40 },
  { 5229, 26, 28, 34, 4, -28 },
  { 5320, 15, 28, 22, 4, -28 },
  { 5373, 18, 29, 22, 2, -28 },
  { 5439, 17, 40, 23, 4, -28 },
  { 5524, 18, 40, 23, 2, -28 },
  { 5614, 10, 28, 15, 4, -28 },
  { 5649, 13, 29, 17, 2, -28 },
  { 5697, 10, 35, 12, 1, -34 },
  { 5741, 16, 29, 22, 3, -28 },
  { 5799, 17, 28, 17, 0, -28 },
  { 5859, 28, 28, 29, 1, -28 },
  { 5957, 16, 28, 18, 1, -28 },
  { 6013, 16, 41, 18, 1, -28 },
  { 6095, 12, 28, 15, 1, -28 },
  { 6137, 14, 45, 18, 2, -37 },
  { 6216, 2, 52, 20, 9, -40 },
  { 6229, 14, 45, 18, 2, -37 },
  { 6308, 18, 5, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Light52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT52PT7B_H_
