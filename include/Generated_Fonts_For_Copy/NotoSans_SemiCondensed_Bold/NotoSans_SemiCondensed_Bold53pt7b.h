#ifndef _NOTOSANS_SEMICONDENSED_BOLD53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9,
  0xFE, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xF3, 0xF0, 0x70, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x1F, 0xBF,
  0x83, 0xF7, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0x9C, 0x3C, 0xFF, 0x1C,
  0x04, 0xFF, 0x1C, 0x00, 0xFF, 0x1C, 0x00, 0xFF, 0x1C, 0x00, 0x7F, 0x9C,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1D, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x1C,
  0x7F, 0x00, 0x1C, 0x7F, 0xC0, 0x1C, 0x7F, 0xF0, 0x1C, 0xFF, 0xFE, 0x1F,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x9F, 0xC0, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x0F,
  0xC3, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F,
  0x1F, 0x8F, 0xFC, 0x3F, 0x8F, 0xCF, 0xC7, 0xFF, 0x87, 0xFF, 0xE3, 0xF3,
  0xFF, 0xF1, 0xFF, 0xF9, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x7E, 0x3F, 0x1F,
  0x87, 0xFE, 0x3F, 0x1F, 0x87, 0xE0, 0xFF, 0x0F, 0xC7, 0xE1, 0xF8, 0x00,
  0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xF8, 0x7F, 0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC7, 0xFD, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xE7, 0xF8,
  0xFF, 0x07, 0xFD, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFF,
  0xC3, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xC0, 0x1F,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x70, 0x3E, 0x06, 0x7E, 0x3E, 0x3F,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xF7, 0xE0, 0x07, 0xF7, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xC1, 0xF8, 0x03, 0xC1, 0xE0, 0x00, 0x80, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x7F, 0xBF, 0xDF, 0xEF,
  0xFF, 0xFB, 0xFC, 0xFC, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xF8, 0xFF, 0x3C, 0x3F,
  0xC6, 0x0F, 0xF1, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0x83, 0xFE, 0x3E, 0x01, 0xFE, 0x18, 0x01, 0xFE,
  0x10, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3E, 0x03, 0xFE,
  0x18, 0x01, 0xFE, 0x10, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xDF, 0xC0,
  0x03, 0xF7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC,
  0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x07,
  0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xA0, 0x00, 0xFF, 0x78, 0x07, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x07, 0x00, 0xFE, 0x3F, 0xE0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFE, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC3, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x7F,
  0xC7, 0xFC, 0x7F, 0x83, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x28, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x0F,
  0xFE, 0x7F, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x02, 0x80, 0x00, 0x7E,
  0x7F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1,
  0xFD, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xE7, 0xE0, 0xE0, 0x3F, 0x1F, 0xE7,
  0xFD, 0xFF, 0x7F, 0xDF, 0xE3, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xE1,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0, 0x7F, 0xCE, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x7F, 0xF0, 0x7C, 0x1F, 0x81, 0xFF, 0xFC, 0x7E,
  0x3F, 0x03, 0xFF, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xF8, 0x3E, 0x7E, 0x0F,
  0xF0, 0xF8, 0x3E, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x7E, 0x1F, 0x80, 0xF8,
  0x3F, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x7C, 0x3F, 0x01, 0xF8, 0x3F, 0xFC,
  0x3F, 0x01, 0xF8, 0x3F, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0xFC, 0x3F, 0x01,
  0xF8, 0x3F, 0xFC, 0x3F, 0x01, 0xF8, 0x3E, 0xFC, 0x3F, 0x01, 0xF8, 0x3E,
  0xFC, 0x3F, 0x01, 0xF8, 0x3E, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x7C, 0x1F,
  0x83, 0xF8, 0x7C, 0x7C, 0x1F, 0xFF, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7E, 0x07, 0xFF, 0x3F, 0xF0, 0x3E, 0x03, 0xFE, 0x1F, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0x00,
  0x07, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xC1, 0xF8, 0xFF, 0xC0,
  0x0C, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x08, 0xFF, 0xF0, 0x3E, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xF8, 0xFF,
  0x00, 0x7F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFD, 0xFE, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x07, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x07, 0xE1, 0xFF,
  0x80, 0x0C, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F,
  0x7F, 0xC0, 0x07, 0xF3, 0xFE, 0x00, 0x7F, 0x3F, 0xF0, 0x07, 0xF1, 0xFF,
  0x80, 0x7F, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00,
  0x3F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0,
  0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xEF, 0xC0, 0x07, 0xFF,
  0xFF, 0xBF, 0x00, 0x3F, 0x7F, 0xFE, 0xFC, 0x00, 0xFD, 0xFF, 0xFB, 0xF8,
  0x03, 0xF7, 0xFF, 0xE7, 0xE0, 0x1F, 0x9F, 0xFF, 0x9F, 0x80, 0x7E, 0x7F,
  0xFE, 0x7F, 0x01, 0xF9, 0xFF, 0xF8, 0xFC, 0x0F, 0xE7, 0xFF, 0xE3, 0xF0,
  0x3F, 0x1F, 0xFF, 0x8F, 0xC0, 0xFC, 0x7F, 0xFE, 0x3F, 0x87, 0xF1, 0xFF,
  0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0x87, 0xF1,
  0xF8, 0x7F, 0xFE, 0x0F, 0xCF, 0xC1, 0xFF, 0xF8, 0x3F, 0x3F, 0x07, 0xFF,
  0xE0, 0xFE, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF,
  0xCF, 0xF0, 0x1F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0x1F, 0xE0, 0x7F, 0xFE,
  0x3F, 0xC0, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xF0,
  0x7F, 0x87, 0xFF, 0xE0, 0x7F, 0x8F, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0x80,
  0xFF, 0x3F, 0xFF, 0x01, 0xFE, 0x7F, 0xFE, 0x01, 0xFE, 0xFF, 0xFC, 0x03,
  0xFD, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x01, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xEF, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xF8, 0xFE,
  0x3F, 0xC0, 0x1C, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x7F, 0x03, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF7, 0xFE, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0B, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xE7, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x9F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0xE1, 0xFE, 0x03, 0xF7, 0xE0, 0x3F,
  0xC1, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0xFE,
  0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x7F, 0x07, 0xF8,
  0x0F, 0xE0, 0xFC, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0x00,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x01,
  0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x1F, 0x8F, 0xE0, 0x07,
  0xF3, 0xF8, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xE0, 0x3F, 0x7F, 0x00, 0x0F,
  0xEF, 0xC0, 0x7E, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0xFD, 0xFC, 0x00, 0x3F,
  0xBF, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xC3, 0xFE, 0x0E, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0x7F, 0x3F, 0xFE, 0x3F,
  0x0F, 0xF8, 0x3F, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xFC, 0x0F, 0xE7, 0xFF, 0x07, 0xF7,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x01,
  0xFF, 0x7F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xC7, 0xE7, 0xFF, 0xC3, 0xF1, 0xFF, 0xC1, 0xF8, 0x7F, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xF8,
  0x1C, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x8F, 0xF8, 0x0E, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x08, 0x0F, 0xE0, 0x7F, 0xC7, 0xF0, 0x7F, 0xF3, 0xF8, 0x7F, 0xFD,
  0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xF0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xE0, 0x7F, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFD, 0xFC, 0x1F, 0xFC, 0x7E, 0x07, 0xFC, 0x3F, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x18, 0x7F, 0xF0, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF,
  0x0F, 0xC1, 0xFF, 0xC7, 0xE1, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0x80, 0x7F, 0xBF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF8, 0x03,
  0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x81, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7, 0xF0, 0x7F,
  0xF3, 0xF8, 0x1F, 0xF1, 0xFC, 0x00, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xD0, 0x00, 0x1F, 0xE7, 0x00, 0x1F, 0xE3,
  0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x5F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0xFE, 0x7F,
  0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x3F,
  0xBF, 0xDF, 0xFF, 0xF3, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xE0, 0x3C, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0x80,
  0x7F, 0xCF, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F,
  0x83, 0xFC, 0x0F, 0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0x80, 0xFE, 0x3F, 0xC0,
  0x3F, 0x9F, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xDF, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xE3, 0xF8, 0x07,
  0xF8, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x03, 0x00, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFD, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x00, 0xFC, 0x3F,
  0xF0, 0xFC, 0x7F, 0xF8, 0xFC, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03,
  0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xFB, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x7E, 0x1F, 0xF0,
  0x3F, 0x1F, 0xFC, 0x1F, 0x9F, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x7F, 0x80,
  0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x07, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xDF, 0xFF, 0x0F, 0xE7, 0xFF,
  0x07, 0xF1, 0xFF, 0x03, 0xF8, 0x18, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x01, 0xFF, 0x0F, 0xC1, 0xFF, 0xC7, 0xE1, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0,
  0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7,
  0xF8, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x81, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xF7,
  0xF0, 0x7F, 0xF3, 0xF8, 0x1F, 0xF1, 0xFC, 0x00, 0x80, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x02, 0x7C, 0x0F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x87, 0xCF, 0xF0, 0x0C,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x02, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x08, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFF, 0x07, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF,
  0xE1, 0xFF, 0xE3, 0xF0, 0x7F, 0xC1, 0xF8, 0x02, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE,
  0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xFC, 0x03, 0xF9, 0xFE, 0x03, 0xFF, 0x01,
  0xFE, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xFF, 0x83, 0xFC, 0x1F, 0xC1,
  0xF3, 0xE0, 0xFE, 0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x3E,
  0x0F, 0xE0, 0x7F, 0x8F, 0xCF, 0xC7, 0xF8, 0x0F, 0xE3, 0xE3, 0xF1, 0xFC,
  0x03, 0xF8, 0xF8, 0x7C, 0x7F, 0x00, 0xFE, 0x3E, 0x1F, 0x1F, 0xC0, 0x3F,
  0xDF, 0x87, 0xEF, 0xE0, 0x07, 0xF7, 0xE1, 0xFB, 0xF8, 0x01, 0xFD, 0xF0,
  0x7E, 0xFE, 0x00, 0x7F, 0x7C, 0x0F, 0xBF, 0x80, 0x0F, 0xDF, 0x03, 0xEF,
  0xC0, 0x03, 0xF7, 0xC0, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xC0,
  0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xFC,
  0x80, 0x00, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_Bold53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 39, 14, 3, -38 },
  { 45, 19, 14, 25, 3, -38 },
  { 79, 29, 38, 31, 1, -38 },
  { 217, 24, 43, 28, 2, -40 },
  { 346, 42, 38, 45, 2, -38 },
  { 546, 34, 39, 36, 2, -38 },
  { 712, 8, 14, 13, 3, -38 },
  { 726, 14, 46, 17, 2, -38 },
  { 807, 14, 46, 17, 1, -38 },
  { 888, 24, 23, 27, 1, -40 },
  { 957, 24, 26, 28, 2, -32 },
  { 1035, 10, 13, 14, 2, -6 },
  { 1052, 14, 6, 17, 1, -17 },
  { 1063, 9, 9, 14, 3, -8 },
  { 1074, 21, 38, 22, 0, -38 },
  { 1174, 24, 39, 28, 2, -38 },
  { 1291, 18, 38, 28, 3, -38 },
  { 1377, 24, 38, 28, 2, -38 },
  { 1491, 24, 39, 28, 2, -38 },
  { 1608, 26, 38, 28, 1, -38 },
  { 1732, 23, 39, 28, 3, -38 },
  { 1845, 24, 39, 28, 2, -38 },
  { 1962, 25, 38, 28, 1, -38 },
  { 2081, 24, 39, 28, 2, -38 },
  { 2198, 24, 39, 28, 2, -38 },
  { 2315, 9, 30, 14, 3, -29 },
  { 2349, 10, 36, 15, 2, -29 },
  { 2394, 24, 27, 28, 2, -33 },
  { 2475, 24, 16, 28, 2, -27 },
  { 2523, 24, 27, 28, 2, -33 },
  { 2604, 22, 39, 23, 0, -38 },
  { 2712, 40, 42, 44, 2, -38 },
  { 2922, 33, 38, 33, 0, -38 },
  { 3079, 26, 38, 33, 4, -38 },
  { 3203, 26, 39, 31, 3, -38 },
  { 3330, 29, 38, 35, 4, -38 },
  { 3468, 20, 38, 27, 4, -38 },
  { 3563, 20, 38, 27, 4, -38 },
  { 3658, 28, 39, 35, 3, -38 },
  { 3795, 29, 38, 37, 4, -38 },
  { 3933, 16, 38, 19, 2, -38 },
  { 4009, 16, 49, 16, -4, -38 },
  { 4107, 28, 38, 32, 4, -38 },
  { 4240, 21, 38, 27, 4, -38 },
  { 4340, 38, 38, 47, 4, -38 },
  { 4521, 31, 38, 40, 4, -38 },
  { 4669, 32, 39, 38, 3, -38 },
  { 4825, 24, 38, 30, 4, -38 },
  { 4939, 32, 47, 38, 3, -38 },
  { 5127, 28, 38, 32, 4, -38 },
  { 5260, 23, 39, 27, 2, -38 },
  { 5373, 26, 38, 28, 1, -38 },
  { 5497, 28, 39, 36, 4, -38 },
  { 5634, 32, 38, 32, 0, -38 },
  { 5786, 47, 38, 47, 0, -38 },
  { 6010, 32, 38, 32, 0, -38 },
  { 6162, 30, 38, 30, 0, -38 },
  { 6305, 25, 38, 27, 1, -38 },
  { 6424, 13, 46, 17, 3, -38 },
  { 6499, 21, 38, 22, 0, -38 },
  { 6599, 13, 46, 17, 1, -38 },
  { 6674, 27, 24, 30, 1, -38 },
  { 6755, 22, 3, 22, 0, 5 },
  { 6764, 14, 9, 18, 2, -41 },
  { 6780, 24, 30, 29, 2, -29 },
  { 6870, 25, 41, 31, 4, -40 },
  { 6999, 22, 31, 25, 2, -30 },
  { 7085, 25, 41, 31, 2, -40 },
  { 7214, 25, 30, 29, 2, -29 },
  { 7308, 20, 41, 19, 1, -41 },
  { 7411, 25, 43, 31, 2, -30 },
  { 7546, 24, 40, 32, 4, -40 },
  { 7666, 9, 40, 15, 3, -40 },
  { 7711, 14, 53, 15, -2, -40 },
  { 7804, 26, 40, 30, 4, -40 },
  { 7934, 7, 40, 15, 4, -40 },
  { 7969, 40, 30, 47, 4, -30 },
  { 8119, 24, 30, 32, 4, -30 },
  { 8209, 26, 31, 30, 2, -30 },
  { 8310, 25, 43, 31, 4, -30 },
  { 8445, 25, 43, 31, 2, -30 },
  { 8580, 17, 30, 22, 4, -30 },
  { 8644, 20, 31, 24, 2, -30 },
  { 8722, 19, 36, 21, 1, -35 },
  { 8808, 25, 30, 32, 3, -29 },
  { 8902, 28, 29, 28, 0, -29 },
  { 9004, 42, 29, 42, 0, -29 },
  { 9157, 27, 29, 28, 0, -29 },
  { 9255, 28, 42, 28, 0, -29 },
  { 9402, 21, 29, 24, 1, -29 },
  { 9479, 17, 46, 20, 1, -38 },
  { 9577, 5, 52, 27, 11, -40 },
  { 9610, 17, 46, 20, 2, -38 },
  { 9708, 24, 9, 28, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Bold53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD53PT7B_H_
