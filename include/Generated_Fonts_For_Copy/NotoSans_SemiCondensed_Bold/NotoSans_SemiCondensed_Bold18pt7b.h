#ifndef _NOTOSANS_SEMICONDENSED_BOLD18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0x7E, 0xEF, 0x3C, 0xF3, 0xCC, 0x0D, 0x82,
  0x61, 0x98, 0x64, 0x7F, 0xDF, 0xF1, 0xB0, 0x4C, 0xFF, 0xCC, 0x83, 0x60,
  0xD8, 0x36, 0x00, 0x10, 0x10, 0x7F, 0xFE, 0xD0, 0xF0, 0xF0, 0x7C, 0x1E,
  0x17, 0x97, 0xFE, 0xFC, 0x10, 0x10, 0x70, 0x63, 0xE3, 0x0D, 0x8C, 0x36,
  0x60, 0xD9, 0x83, 0x6D, 0xCF, 0xB7, 0x9D, 0xB3, 0x06, 0xCC, 0x33, 0x30,
  0xCC, 0xC6, 0x1E, 0x38, 0x78, 0x3C, 0x0F, 0xC1, 0x98, 0x33, 0x06, 0xE0,
  0x78, 0x1E, 0x3F, 0xE6, 0xCF, 0xD8, 0xF3, 0x8E, 0x7F, 0xE7, 0xEE, 0xFB,
  0x6C, 0x3B, 0x98, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0xC6, 0x31, 0xC6, 0xE3,
  0x0C, 0x63, 0x8C, 0x63, 0x18, 0xC6, 0x73, 0x19, 0xDC, 0x1C, 0x06, 0x12,
  0x2F, 0xEF, 0xF8, 0xE0, 0xD8, 0xEE, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0xFF, 0x60, 0xFF, 0xC0, 0xDF, 0x80, 0x06, 0x1C, 0x30,
  0x61, 0xC3, 0x06, 0x1C, 0x30, 0xE1, 0x83, 0x0E, 0x00, 0x3C, 0x7E, 0xE6,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xE6, 0x7E, 0x3C, 0x1C, 0xF7,
  0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7C, 0xFE, 0xC7, 0x07,
  0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0xC6,
  0x07, 0x06, 0x7C, 0x7C, 0x1E, 0x07, 0x07, 0x87, 0xFE, 0xFC, 0x07, 0x03,
  0x83, 0xC3, 0xE1, 0xF1, 0xB8, 0xDC, 0xCE, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0,
  0x70, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFC, 0xFE, 0x07, 0x07, 0x07, 0x86,
  0xFE, 0xFC, 0x1E, 0x7E, 0x70, 0xE0, 0xC0, 0xDE, 0xFF, 0xC7, 0xC7, 0xC7,
  0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x07, 0x07, 0x03, 0x80, 0x3C, 0xFE, 0xE7, 0xC7, 0xE6, 0x7E,
  0x7C, 0xFE, 0xC7, 0xC3, 0xC7, 0xFE, 0x7C, 0x7C, 0xFE, 0xE6, 0xC7, 0xC7,
  0xC7, 0xFF, 0xFB, 0x37, 0x06, 0x0E, 0xFC, 0xF8, 0xFF, 0x80, 0x02, 0xFC,
  0xFF, 0x80, 0x00, 0xFF, 0x60, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0xF0, 0x3E,
  0x0F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x1E, 0x78, 0xE0, 0x80, 0x7C, 0xFE, 0x46, 0x07, 0x06, 0x0E, 0x1C, 0x38,
  0x30, 0x00, 0x30, 0x38, 0x38, 0x0F, 0xC1, 0xFF, 0x1C, 0x0C, 0xC6, 0x3C,
  0xFD, 0xE6, 0x6F, 0x63, 0x7B, 0x1B, 0xD9, 0xDE, 0x7F, 0xB3, 0x9C, 0xC0,
  0x07, 0x04, 0x0F, 0xE0, 0x0E, 0x01, 0xE0, 0x7C, 0x0D, 0x81, 0xB8, 0x73,
  0x0E, 0x61, 0x8E, 0x7F, 0xCF, 0xF9, 0xC3, 0xF0, 0x7E, 0x0E, 0xFE, 0x7F,
  0xB8, 0xFC, 0x7E, 0x3F, 0xFB, 0xFD, 0xCF, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF,
  0xE0, 0x1F, 0x1F, 0xDC, 0x5C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x1C, 0x2F, 0xF1, 0xF8, 0xFE, 0x3F, 0xCE, 0x7B, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x7B, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0x87,
  0x0E, 0x1F, 0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x1F, 0xCF, 0xE7,
  0x8B, 0xC0, 0xE0, 0x38, 0x0E, 0x7F, 0x9F, 0xE1, 0xF8, 0x77, 0x1D, 0xFF,
  0x1F, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xC0, 0xFF, 0xDC, 0xE7, 0x39, 0xCE,
  0x73, 0x9D, 0xFF, 0x80, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xFE, 0xE0, 0xE1, 0xF8, 0xEE, 0x73, 0x9C, 0xEE, 0x3F, 0x0F, 0xC3,
  0xF8, 0xE6, 0x39, 0xCE, 0x3B, 0x8E, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0x83,
  0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xFE, 0x6F, 0xB3, 0x7D, 0x9B, 0xED, 0x9F,
  0x3C, 0xF9, 0xE7, 0xCE, 0x3E, 0x71, 0x80, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC,
  0x3F, 0xC7, 0xDC, 0xFB, 0x9F, 0x3B, 0xE7, 0x7C, 0x7F, 0x8F, 0xF0, 0xFE,
  0x1E, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1D, 0xC7, 0x3F, 0xE1, 0xF0, 0xFC, 0x7F, 0xB9, 0xDC, 0x7E,
  0x3F, 0x1B, 0xFD, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x1F, 0x0F,
  0xF1, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D,
  0xC7, 0x3F, 0xE1, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0xFC, 0x3F, 0xCE, 0x7B,
  0x8E, 0xE3, 0xB9, 0xCF, 0xF3, 0xF8, 0xE6, 0x39, 0xCE, 0x33, 0x8E, 0xE1,
  0xC0, 0x3F, 0xFF, 0x9E, 0x0E, 0x1E, 0x1F, 0x0F, 0x0E, 0x0E, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x77, 0x1D, 0xFE, 0x3F, 0x00, 0xE0, 0xFC, 0x19,
  0x87, 0x38, 0xE7, 0x18, 0x63, 0x0C, 0xE1, 0xD8, 0x1B, 0x03, 0x60, 0x7C,
  0x0F, 0x00, 0xE0, 0xE1, 0x87, 0xE3, 0x87, 0xE3, 0xC6, 0x63, 0xC6, 0x63,
  0xCE, 0x73, 0xCE, 0x76, 0x6E, 0x36, 0x6C, 0x36, 0x6C, 0x36, 0x6C, 0x3C,
  0x7C, 0x1C, 0x38, 0x1C, 0x38, 0xE1, 0xCE, 0x38, 0xCE, 0x1D, 0xC1, 0xF0,
  0x3C, 0x03, 0x80, 0xF0, 0x1F, 0x07, 0x71, 0xCE, 0x38, 0xEE, 0x1E, 0xE1,
  0xD8, 0x77, 0x38, 0xCE, 0x3B, 0x07, 0xC1, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70,
  0x30, 0x38, 0x38, 0x1C, 0x1F, 0xFF, 0xF8, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xFF, 0xE0, 0xC1, 0x83, 0x83, 0x06, 0x06, 0x0C, 0x1C, 0x18,
  0x30, 0x70, 0x60, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F,
  0xFF, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x33, 0x0C, 0xC6, 0x1B, 0x87, 0xFE,
  0xE6, 0x30, 0x7C, 0x7E, 0x47, 0x07, 0x7F, 0xF7, 0xC7, 0xC7, 0xFF, 0x7B,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0x9D, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x6F, 0xF6, 0xF0, 0x3E, 0xFF, 0x8F, 0x0C, 0x18, 0x38, 0x71, 0x7E,
  0x7C, 0x03, 0x03, 0x03, 0x03, 0x7B, 0x7F, 0xE7, 0xE3, 0xC3, 0xC3, 0xE3,
  0xE7, 0xFF, 0x7B, 0x3C, 0x7E, 0xE7, 0xC3, 0xFF, 0xFF, 0xC0, 0xE1, 0x7F,
  0x3F, 0x1E, 0x7C, 0xE9, 0x87, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x00, 0x7B, 0x7F, 0xE7, 0xE3, 0xC3, 0xC3, 0xE3, 0xE7, 0xFF, 0x7B,
  0x03, 0x87, 0xFF, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE7, 0xFB, 0xCD,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C, 0x5F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x11, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0xFF, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0x3B, 0xB9, 0xD8, 0xFC,
  0x7E, 0x3B, 0x9C, 0xEE, 0x77, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xDE, 0x7B, 0xFF, 0xFE, 0x79, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31,
  0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x70, 0xCE, 0x7F, 0xB8, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x3C, 0x3F, 0xB9, 0xDC, 0x6C, 0x3E,
  0x1F, 0x8D, 0xCE, 0x7F, 0x1F, 0x00, 0xCE, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC6, 0xFF, 0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x7B, 0x7F,
  0xE7, 0xE3, 0xC3, 0xC3, 0xE3, 0xE7, 0xFF, 0x7B, 0x03, 0x03, 0x03, 0x03,
  0xCF, 0x7F, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x7D, 0xFB, 0x17, 0x0F,
  0x87, 0x83, 0xC7, 0xFD, 0xF0, 0x30, 0x61, 0xFF, 0xF3, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xF9, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xCF, 0x7F, 0xBD, 0xC0, 0xE1, 0xF1, 0xD8, 0xEE, 0x67, 0x71, 0xB8, 0xD8,
  0x3C, 0x1E, 0x0E, 0x00, 0xE3, 0x8F, 0x9E, 0x76, 0x79, 0x99, 0xE6, 0x76,
  0xD8, 0xD3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x71, 0xC0, 0xE3, 0xB9,
  0x8D, 0xC7, 0xC1, 0xE0, 0xF0, 0xF8, 0x6E, 0x73, 0x71, 0xC0, 0xE1, 0xB1,
  0xD8, 0xEE, 0x63, 0x71, 0xB8, 0xF8, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x87,
  0x83, 0x80, 0x7E, 0x7E, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0x70, 0xFF, 0xFF,
  0x1C, 0x73, 0x8E, 0x38, 0xE3, 0xBC, 0xF0, 0xE3, 0x8E, 0x38, 0xE1, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x86, 0x18, 0x61, 0x87, 0x0F, 0x3D,
  0xC6, 0x18, 0x61, 0x8E, 0x30, 0xF1, 0xFF, 0x9F,
};

const GFXglyph NotoSans_SemiCondensed_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 6, 5, 8, 1, -13 },
  { 10, 10, 13, 11, 0, -13 },
  { 27, 8, 15, 10, 1, -14 },
  { 42, 14, 13, 15, 1, -13 },
  { 65, 11, 13, 12, 1, -13 },
  { 83, 3, 5, 5, 1, -13 },
  { 85, 5, 16, 6, 1, -13 },
  { 95, 5, 16, 6, 0, -13 },
  { 105, 9, 8, 9, 0, -14 },
  { 114, 8, 9, 10, 1, -11 },
  { 123, 3, 4, 5, 1, -2 },
  { 125, 5, 2, 6, 0, -6 },
  { 127, 3, 3, 5, 1, -3 },
  { 129, 7, 13, 7, 0, -13 },
  { 141, 8, 13, 10, 1, -13 },
  { 154, 6, 13, 10, 1, -13 },
  { 164, 8, 13, 10, 1, -13 },
  { 177, 8, 13, 10, 1, -13 },
  { 190, 9, 13, 10, 0, -13 },
  { 205, 8, 13, 10, 1, -13 },
  { 218, 8, 13, 10, 1, -13 },
  { 231, 9, 13, 10, 0, -13 },
  { 246, 8, 13, 10, 1, -13 },
  { 259, 8, 13, 10, 1, -13 },
  { 272, 3, 10, 5, 1, -10 },
  { 276, 3, 12, 5, 1, -10 },
  { 281, 8, 9, 10, 1, -11 },
  { 290, 8, 5, 10, 1, -9 },
  { 295, 8, 9, 10, 1, -11 },
  { 304, 8, 13, 8, 0, -13 },
  { 317, 13, 14, 15, 1, -13 },
  { 340, 11, 13, 11, 0, -13 },
  { 358, 9, 13, 11, 1, -13 },
  { 373, 9, 13, 11, 1, -13 },
  { 388, 10, 13, 12, 1, -13 },
  { 405, 7, 13, 9, 1, -13 },
  { 417, 7, 13, 9, 1, -13 },
  { 429, 10, 13, 12, 1, -13 },
  { 446, 10, 13, 13, 1, -13 },
  { 463, 5, 13, 7, 1, -13 },
  { 472, 5, 17, 6, -1, -13 },
  { 483, 10, 13, 11, 1, -13 },
  { 500, 8, 13, 9, 1, -13 },
  { 513, 13, 13, 16, 1, -13 },
  { 535, 11, 13, 13, 1, -13 },
  { 553, 11, 13, 13, 1, -13 },
  { 571, 9, 13, 10, 1, -13 },
  { 586, 11, 16, 13, 1, -13 },
  { 608, 10, 13, 11, 1, -13 },
  { 625, 7, 13, 9, 1, -13 },
  { 637, 9, 13, 9, 0, -13 },
  { 652, 10, 13, 12, 1, -13 },
  { 669, 11, 13, 11, 0, -13 },
  { 687, 16, 13, 16, 0, -13 },
  { 713, 11, 13, 11, 0, -13 },
  { 731, 10, 13, 10, 0, -13 },
  { 748, 9, 13, 9, 0, -13 },
  { 763, 4, 16, 6, 1, -13 },
  { 771, 7, 13, 7, 0, -13 },
  { 783, 5, 16, 6, 0, -13 },
  { 793, 10, 8, 10, 0, -13 },
  { 803, 7, 1, 7, 0, 2 },
  { 804, 4, 3, 6, 1, -14 },
  { 806, 8, 10, 10, 1, -10 },
  { 816, 9, 14, 11, 1, -14 },
  { 832, 7, 10, 9, 1, -10 },
  { 841, 8, 14, 11, 1, -14 },
  { 855, 8, 10, 10, 1, -10 },
  { 865, 7, 14, 6, 0, -14 },
  { 878, 8, 14, 11, 1, -10 },
  { 892, 9, 14, 11, 1, -14 },
  { 908, 3, 14, 5, 1, -14 },
  { 914, 5, 18, 5, -1, -14 },
  { 926, 9, 14, 10, 1, -14 },
  { 942, 3, 14, 5, 1, -14 },
  { 948, 14, 10, 16, 1, -10 },
  { 966, 9, 10, 11, 1, -10 },
  { 978, 9, 10, 10, 1, -10 },
  { 990, 9, 14, 11, 1, -10 },
  { 1006, 8, 14, 11, 1, -10 },
  { 1020, 6, 10, 7, 1, -10 },
  { 1028, 7, 10, 8, 1, -10 },
  { 1037, 7, 12, 7, 0, -12 },
  { 1048, 9, 10, 11, 1, -10 },
  { 1060, 9, 10, 9, 0, -10 },
  { 1072, 14, 10, 14, 0, -10 },
  { 1090, 9, 10, 9, 0, -10 },
  { 1102, 9, 14, 9, 0, -10 },
  { 1118, 8, 10, 8, 0, -10 },
  { 1128, 6, 16, 7, 0, -13 },
  { 1140, 2, 18, 9, 4, -14 },
  { 1145, 6, 16, 7, 1, -13 },
  { 1157, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Bold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD18PT7B_H_
