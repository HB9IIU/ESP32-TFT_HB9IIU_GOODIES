#ifndef _NOTOSANS_SEMICONDENSED_BOLD64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold64pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x7F, 0x9F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFC, 0x7F, 0x03, 0x80, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFE, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0xF0, 0x7C, 0xFF, 0x8F, 0x00,
  0x8F, 0xF8, 0xF0, 0x00, 0xFF, 0x8F, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0xFF,
  0xCF, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF7, 0xFF,
  0x00, 0x0F, 0x3F, 0xF0, 0x00, 0xF1, 0xFF, 0x00, 0x0F, 0x0F, 0xF8, 0x00,
  0xF0, 0xFF, 0xC0, 0x0F, 0x1F, 0xFF, 0x00, 0xF1, 0xFF, 0xFE, 0x0F, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0xFF, 0x0F, 0xFE, 0x07, 0xF0, 0xFF,
  0x1F, 0xC3, 0xFF, 0xE0, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC7, 0xF1, 0xFE, 0x3F, 0x83, 0xFF, 0xF0, 0xFE, 0x3F, 0x83, 0xF8,
  0x3F, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00,
  0x07, 0xFD, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFC, 0x03, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xFE, 0x7F, 0xF0,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x7F, 0xC3,
  0xFF, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xFF,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x1F, 0x80, 0x73, 0xF0,
  0xFC, 0x1F, 0x9F, 0xF7, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x03, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0x80, 0x70, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFF,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0xF8,
  0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x07, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F,
  0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFD, 0xFF, 0xFF, 0xE7,
  0xFD, 0xFF, 0x1F, 0xF3, 0xF8, 0x7F, 0xC7, 0xC1, 0xFF, 0x0E, 0x07, 0xFC,
  0x10, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x7F, 0xFC, 0x3F, 0xC0, 0x3F, 0xF0, 0x7C, 0x00, 0x7F, 0xC0, 0xE0, 0x01,
  0xFF, 0x81, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0xFE, 0x1F, 0x00, 0x3F, 0xF0, 0x60, 0x01,
  0xFF, 0x82, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0xE0,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0xFE, 0x3F, 0xE0,
  0x00, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0,
  0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0x00, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0x00, 0x0F, 0xFE, 0xFE, 0x03, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x18, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x81, 0xF0, 0x01, 0xFE, 0x1F, 0xFC,
  0x07, 0xF9, 0xFF, 0xF8, 0x1F, 0xEF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F,
  0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x7F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF,
  0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF,
  0x80, 0xFF, 0xF7, 0xFF, 0x8F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xF9,
  0xFE, 0x07, 0xFF, 0xC7, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x04, 0x07, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xE7, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x1F, 0xE7, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFD,
  0xFF, 0x1F, 0xE0, 0xE0, 0x02, 0x01, 0xFC, 0x3F, 0xE3, 0xFF, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F,
  0xFE, 0x1E, 0x00, 0x7F, 0xE3, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xE1,
  0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xE0,
  0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0x03, 0xFF, 0x0F, 0xE0,
  0xFE, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0x7E, 0x7E, 0x07, 0xF8, 0x0F, 0xE0,
  0x7E, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7E, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7E, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7E, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7E, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFC, 0xFE, 0x07, 0xF8, 0x7F, 0xE1, 0xF8, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0x03, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xF9, 0xFF,
  0xF0, 0x7F, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0x00, 0x3F, 0xFB,
  0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x07, 0xFE, 0xFF,
  0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x07, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xF7, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3C, 0x0F, 0xFF, 0x00,
  0x06, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x70, 0x3F, 0xFF, 0x83,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xC0,
  0x01, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0x8F,
  0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0x81,
  0xFF, 0xE0, 0x00, 0x20, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xEF, 0xF8, 0x07,
  0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF7, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0xC0,
  0x03, 0xFE, 0x3F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xF0, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xC0, 0x00,
  0xFE, 0xFF, 0xFF, 0x7F, 0x80, 0x03, 0xFB, 0xFF, 0xFD, 0xFE, 0x00, 0x1F,
  0xEF, 0xFF, 0xF7, 0xF8, 0x00, 0x7F, 0x3F, 0xFF, 0xCF, 0xE0, 0x01, 0xFC,
  0xFF, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0x9F,
  0xFF, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0x07, 0xF9, 0xFF,
  0xFF, 0x9F, 0xE0, 0x1F, 0xE7, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xFF,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0xFF, 0xE3, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF,
  0x8F, 0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x83,
  0xF8, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xCF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F, 0x81, 0xFF, 0xFF, 0x81, 0xFD,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFC,
  0xFF, 0x80, 0x1F, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0x1F, 0xF0, 0x07,
  0xFF, 0xF8, 0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0x87, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0xFF,
  0x01, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xE0, 0x1F, 0x9F, 0xF8, 0x00, 0x63, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xBF,
  0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF7, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xF3, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xF9, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x81,
  0xFE, 0x3F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0x87, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x00,
  0x7F, 0xC7, 0xF0, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x0F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFE,
  0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xBF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xFE,
  0x03, 0x80, 0x3F, 0xF8, 0x10, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xBF,
  0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xF7, 0xFE, 0x07, 0xFF, 0xBF, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF,
  0xF0, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x04, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xC0,
  0xFF, 0x9F, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0x3F,
  0xF8, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF,
  0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xF8, 0x00,
  0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xF0, 0x1F,
  0xF9, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xF0,
  0x7F, 0x87, 0xFF, 0xC0, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF8, 0x1E, 0x1F, 0xFC, 0x00, 0x87, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x09, 0xFF, 0xC0, 0x06, 0x7F, 0xF8, 0x0F, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x70, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xF1,
  0xFF, 0x0F, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xF7,
  0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF,
  0xC0, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0xF0,
  0xFF, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0x0F, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x23, 0xFF, 0x80, 0x0E, 0x1F, 0xFF, 0x8F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x3F,
  0xFE, 0x3F, 0xC3, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0x9F, 0xF0, 0x7F,
  0xFC, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x00, 0x18, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFD, 0x00, 0x00, 0x3F, 0xE3, 0x80, 0x03, 0xFF, 0x8F, 0xE0, 0x3F, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0,
  0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x1C, 0x1F, 0xEF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x87, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0xC7, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x1F, 0xF8,
  0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE,
  0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x7F, 0x83, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xFC, 0x1F,
  0xFC, 0x0F, 0xF0, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1,
  0xFF, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x01,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xFE, 0x07, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFB, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xF0,
  0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80,
  0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0x83,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xBF, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0x83, 0xFE, 0x3F, 0xFE,
  0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x3F,
  0xFE, 0x3F, 0xC3, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF,
  0x7F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0x9F, 0xF0, 0x7F,
  0xFC, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x00, 0x38, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x73, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xBF,
  0xC7, 0xFE, 0xFF, 0x1F, 0xFB, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x6F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFC, 0x7F, 0xC0, 0x1C, 0x7F, 0xC0,
  0x02, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xEC, 0x00, 0x1F, 0xF7, 0x80, 0x1F,
  0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x18, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF,
  0xFC, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0x3F, 0xFF,
  0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xE7, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF9, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0x7E, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xBF, 0x01, 0xFF, 0x0F,
  0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xCF, 0xE0, 0xFF, 0x81,
  0xFF, 0x0F, 0xE3, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xF1, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC3, 0xF8, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xF8, 0x7F, 0x1F, 0xF0,
  0x0F, 0xF8, 0xFC, 0x3F, 0x8F, 0xF8, 0x07, 0xFC, 0xFE, 0x0F, 0xC7, 0xFC,
  0x03, 0xFE, 0x7F, 0x07, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0x83, 0xF9, 0xFE,
  0x00, 0x7F, 0x9F, 0x81, 0xFD, 0xFF, 0x00, 0x3F, 0xCF, 0xC0, 0xFE, 0xFF,
  0x00, 0x1F, 0xE7, 0xE0, 0x3F, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xBF,
  0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xDF, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xEF,
  0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x08, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x04, 0x7F, 0xF8, 0x00,
  0x37, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xF3, 0x00, 0x03, 0xFF, 0x88, 0x00, 0x00, 0x70, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 47, 17, 3, -46 },
  { 66, 22, 17, 30, 4, -46 },
  { 113, 36, 46, 38, 1, -46 },
  { 320, 28, 53, 34, 3, -49 },
  { 506, 51, 47, 55, 2, -46 },
  { 806, 41, 47, 43, 2, -46 },
  { 1047, 9, 17, 16, 4, -46 },
  { 1067, 17, 56, 21, 3, -46 },
  { 1186, 16, 56, 21, 2, -46 },
  { 1298, 29, 29, 32, 2, -49 },
  { 1404, 30, 31, 34, 2, -38 },
  { 1521, 12, 15, 17, 2, -7 },
  { 1544, 16, 8, 20, 2, -21 },
  { 1560, 11, 11, 17, 3, -10 },
  { 1576, 25, 46, 26, 1, -46 },
  { 1720, 30, 47, 34, 2, -46 },
  { 1897, 22, 46, 34, 3, -46 },
  { 2024, 30, 46, 34, 2, -46 },
  { 2197, 29, 47, 34, 2, -46 },
  { 2368, 32, 46, 34, 1, -46 },
  { 2552, 28, 47, 34, 3, -46 },
  { 2717, 30, 47, 34, 2, -46 },
  { 2894, 30, 46, 34, 2, -46 },
  { 3067, 30, 47, 34, 2, -46 },
  { 3244, 30, 47, 34, 2, -46 },
  { 3421, 11, 37, 17, 3, -36 },
  { 3472, 12, 44, 18, 2, -36 },
  { 3538, 30, 32, 34, 2, -39 },
  { 3658, 30, 19, 34, 2, -32 },
  { 3730, 30, 32, 34, 2, -39 },
  { 3850, 27, 47, 28, 0, -46 },
  { 4009, 48, 51, 53, 3, -46 },
  { 4315, 40, 46, 40, 0, -46 },
  { 4545, 31, 46, 39, 5, -46 },
  { 4724, 33, 47, 37, 3, -46 },
  { 4918, 35, 46, 43, 5, -46 },
  { 5120, 24, 46, 33, 5, -46 },
  { 5258, 24, 46, 32, 5, -46 },
  { 5396, 35, 47, 43, 3, -46 },
  { 5602, 35, 46, 45, 5, -46 },
  { 5804, 19, 46, 23, 2, -46 },
  { 5914, 19, 59, 20, -4, -46 },
  { 6055, 34, 46, 39, 5, -46 },
  { 6251, 26, 46, 32, 5, -46 },
  { 6401, 46, 46, 56, 5, -46 },
  { 6666, 37, 46, 48, 5, -46 },
  { 6879, 40, 47, 46, 3, -46 },
  { 7114, 29, 46, 37, 5, -46 },
  { 7281, 40, 57, 46, 3, -46 },
  { 7566, 34, 46, 39, 5, -46 },
  { 7762, 27, 47, 32, 3, -46 },
  { 7921, 31, 46, 33, 1, -46 },
  { 8100, 34, 47, 44, 5, -46 },
  { 8300, 38, 46, 38, 0, -46 },
  { 8519, 57, 46, 57, 0, -46 },
  { 8847, 38, 46, 38, 0, -46 },
  { 9066, 36, 46, 36, 0, -46 },
  { 9273, 31, 46, 33, 1, -46 },
  { 9452, 15, 56, 21, 4, -46 },
  { 9557, 26, 46, 26, 0, -46 },
  { 9707, 15, 56, 21, 2, -46 },
  { 9812, 33, 29, 36, 1, -46 },
  { 9932, 26, 4, 26, 0, 6 },
  { 9945, 17, 10, 22, 3, -49 },
  { 9967, 29, 37, 35, 2, -36 },
  { 10102, 31, 50, 37, 4, -49 },
  { 10296, 26, 37, 30, 3, -36 },
  { 10417, 30, 50, 37, 3, -49 },
  { 10605, 29, 37, 35, 3, -36 },
  { 10740, 24, 49, 23, 1, -49 },
  { 10887, 30, 51, 37, 3, -36 },
  { 11079, 30, 49, 38, 4, -49 },
  { 11263, 10, 49, 18, 4, -49 },
  { 11325, 17, 64, 18, -3, -49 },
  { 11461, 32, 49, 36, 5, -49 },
  { 11657, 9, 49, 18, 4, -49 },
  { 11713, 49, 36, 57, 4, -36 },
  { 11934, 30, 36, 38, 4, -36 },
  { 12069, 31, 37, 37, 3, -36 },
  { 12213, 31, 51, 37, 4, -36 },
  { 12411, 30, 51, 37, 3, -36 },
  { 12603, 22, 36, 26, 4, -36 },
  { 12702, 25, 37, 29, 2, -36 },
  { 12818, 23, 43, 25, 1, -42 },
  { 12942, 30, 36, 38, 4, -35 },
  { 13077, 33, 35, 34, 0, -35 },
  { 13222, 49, 35, 51, 1, -35 },
  { 13437, 33, 35, 33, 0, -35 },
  { 13582, 33, 50, 34, 0, -35 },
  { 13789, 25, 35, 28, 2, -35 },
  { 13899, 21, 56, 24, 1, -46 },
  { 14046, 7, 64, 33, 13, -49 },
  { 14102, 21, 56, 24, 2, -46 },
  { 14249, 30, 11, 34, 2, -28 },
};

const GFXfont NotoSans_SemiCondensed_Bold64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD64PT7B_H_
