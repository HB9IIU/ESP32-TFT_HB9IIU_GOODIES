#ifndef _NOTOSANS_SEMICONDENSED_BOLD30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x78, 0x00, 0x67,
  0xBF, 0xFF, 0x00, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x07,
  0xFF, 0x3F, 0xF9, 0xFF, 0xEF, 0xB1, 0x3C, 0xC0, 0xFB, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xDF, 0x03, 0x3F,
  0x0D, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xE0, 0x3E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x3F, 0x01, 0xC0, 0x7F, 0x03, 0xC0, 0xF7,
  0x83, 0x80, 0xE3, 0x87, 0x80, 0xE3, 0x87, 0x00, 0xE3, 0xCF, 0x00, 0xE3,
  0x8E, 0x00, 0xE3, 0x9E, 0x00, 0xE3, 0x9C, 0xF8, 0xF7, 0xBD, 0xFC, 0x7F,
  0xB9, 0xFE, 0x3F, 0x7B, 0xCE, 0x0C, 0x73, 0xCF, 0x00, 0xF3, 0xCF, 0x00,
  0xE3, 0xCF, 0x00, 0xE3, 0xCF, 0x01, 0xC3, 0xCF, 0x01, 0xC3, 0xCE, 0x03,
  0x81, 0xFE, 0x03, 0x81, 0xFC, 0x07, 0x00, 0xF8, 0x03, 0x80, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE7, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x9F, 0xE1,
  0xE7, 0xFE, 0x3D, 0xF3, 0xEF, 0xBE, 0x3F, 0xE7, 0xC7, 0xFC, 0xF8, 0x7F,
  0x1F, 0x07, 0xE3, 0xFB, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xC7,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78,
  0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F, 0x80,
  0xEE, 0x0F, 0x78, 0xF1, 0xE1, 0x8C, 0x00, 0x40, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x7D,
  0xE7, 0x9C, 0xF3, 0xCE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x67, 0xBF, 0xFF,
  0x00, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0x7C, 0xF9, 0xE1, 0xEF, 0x87, 0xBE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xFE, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0xCF, 0x8F, 0xFC, 0x3F, 0xE0, 0x3F,
  0x00, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x7B, 0xFD, 0xF6, 0x7D, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC0, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x3F, 0xFE, 0x70,
  0xF8, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x60, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x7F,
  0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xFE, 0x1F, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xDE, 0x07,
  0xBC, 0x0E, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xC3, 0xC7, 0x87, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7B, 0xCF, 0xEF, 0xFF, 0x3F,
  0xF8, 0x7F, 0xC0, 0x00, 0xF0, 0x1F, 0xE1, 0xFF, 0x8F, 0xFE, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE,
  0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xE1, 0xF7, 0xCF,
  0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x7D, 0xF0, 0xFF,
  0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0xF1, 0xF3, 0xEF, 0x87, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFE, 0x7F, 0xF0, 0x7F, 0x80, 0x07, 0x00,
  0x7F, 0x83, 0xFF, 0x1F, 0xFC, 0xF8, 0xFB, 0xC1, 0xEF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFF, 0x8F, 0xDF, 0xFF, 0x7F, 0xBC, 0xFE, 0xF0, 0x43,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC,
  0x00, 0x67, 0xBF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7B, 0xFF, 0xF0,
  0x31, 0xE7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0x9E,
  0x79, 0xEF, 0x3C, 0xE0, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x3E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x01, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x08,
  0x00, 0x00, 0x07, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xE6, 0x0F, 0x00, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7C,
  0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E, 0x1F, 0xC7, 0x3C, 0x7F,
  0xCE, 0x71, 0xFF, 0x9C, 0xE3, 0x8F, 0x1D, 0xCF, 0x1E, 0x3F, 0x9C, 0x3C,
  0x7E, 0x38, 0x78, 0xFC, 0x70, 0xF3, 0xBC, 0xE1, 0xE7, 0x79, 0xE7, 0xCE,
  0x71, 0xFF, 0xF8, 0xE1, 0xF3, 0xE1, 0xE0, 0x81, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x04, 0x03, 0xF0, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x03, 0xEF, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x7C,
  0x7C, 0x0F, 0x07, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80,
  0x3E, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xEF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0x7C, 0x3E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFE, 0x00, 0x01, 0xE0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xE7, 0xE0, 0xCF, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x09, 0xFE, 0xF1, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x1F, 0xCF, 0x83, 0xF7, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xEF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x7E, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF,
  0xEF, 0xFE, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x06, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F,
  0x7F, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xF8, 0xFF, 0xFF, 0xDF, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x7E, 0xFF, 0x7F, 0x3F, 0x00,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0,
  0xF9, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFD, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x3C,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xDC, 0x0F, 0xFF, 0x70, 0x3B, 0xFD, 0xE0, 0xEF,
  0xF7, 0x87, 0xBF, 0xCE, 0x1C, 0xFF, 0x3C, 0x73, 0xFC, 0xF3, 0xCF, 0xF1,
  0xCE, 0x3F, 0xC7, 0x38, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFC,
  0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3C,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0x78, 0x3F, 0xDF, 0x0F, 0xF3, 0xE3, 0xFC, 0x78, 0xFF, 0x1F,
  0x3F, 0xC3, 0xCF, 0xF0, 0xFB, 0xFC, 0x1E, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xC0,
  0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xE7, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xF8, 0xFC,
  0xF8, 0x7C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8,
  0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0x07, 0x80,
  0xFF, 0x8F, 0xFE, 0xFF, 0xE7, 0xC3, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x0F,
  0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F, 0x7F, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0x77, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xFF, 0x03, 0xE0, 0x79,
  0xE0, 0x7C, 0x0F, 0x3C, 0x1F, 0x81, 0xE7, 0x83, 0xF0, 0x7C, 0xF0, 0x7F,
  0x0F, 0x0F, 0x0F, 0xE1, 0xE1, 0xE3, 0xDC, 0x3C, 0x3C, 0x7B, 0x8F, 0x87,
  0x8F, 0x79, 0xE0, 0xF1, 0xCF, 0x3C, 0x0F, 0x79, 0xE7, 0x81, 0xEF, 0x1C,
  0xF0, 0x3D, 0xE3, 0xBC, 0x07, 0xB8, 0x7F, 0x80, 0x77, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x78,
  0x78, 0x1F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xF7, 0xC0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0xC7, 0xC0, 0xF1, 0xF0,
  0x3E, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xBE, 0x07, 0x9F, 0x07, 0xC7, 0x83,
  0xC3, 0xE3, 0xE0, 0xF1, 0xE0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF,
  0xFC, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0x3C, 0x1E, 0x38,
  0x38, 0x78, 0xF0, 0x71, 0xC0, 0xF7, 0x80, 0xEE, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7C, 0x3E, 0x0E, 0x07, 0x03, 0xC0, 0xFF, 0xC3, 0xFF, 0x8F,
  0xFE, 0x10, 0x78, 0x01, 0xF0, 0x07, 0xC7, 0xFF, 0x3F, 0xFD, 0xFD, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xDF, 0xEF, 0x3F, 0x3C,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x1C,
  0x3D, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0x87, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0x3E, 0xFF,
  0xFB, 0xDF, 0xCF, 0x3E, 0x00, 0x03, 0xC1, 0xFF, 0x3F, 0xF3, 0xFF, 0x7C,
  0x27, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78,
  0x17, 0xE7, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0x8F, 0x8F, 0xDF, 0x3F, 0xFE,
  0xFF, 0xFD, 0xF1, 0xFB, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xFB, 0xE3, 0xF7, 0xFF, 0xE7, 0xFB,
  0xC7, 0xE7, 0x80, 0x03, 0x80, 0x7F, 0x83, 0xFF, 0x9F, 0xBE, 0x78, 0x7D,
  0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF0, 0x23, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xFC, 0xFF, 0xCF, 0xFC,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0x3F, 0x3C,
  0xFF, 0xFB, 0xFF, 0xF7, 0xC7, 0xEF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xEF, 0x8F, 0xDF, 0xFF,
  0x9F, 0xFF, 0x1F, 0xBE, 0x00, 0x7C, 0x00, 0xF2, 0x01, 0xE7, 0x8F, 0xCF,
  0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x1C, 0x3D, 0xFC, 0xFF, 0xFB, 0xFF, 0xEF, 0xC7,
  0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x77, 0xBF,
  0xE2, 0x00, 0x1E, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xC0, 0x0E, 0x1E, 0x1F, 0x1E, 0x04, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0xBE, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x3E, 0xF0, 0x79,
  0xE1, 0xE3, 0xC7, 0xC7, 0x9F, 0x0F, 0x7C, 0x1E, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xE1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0xCF, 0x07, 0xDE, 0x0F,
  0xBC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xE1, 0xEF, 0xE7, 0xF3, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0x87, 0xE3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x0F, 0xF8,
  0x3E, 0x1F, 0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xFF, 0x83,
  0xE1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F, 0xF8, 0x3E,
  0x1F, 0xF0, 0x7C, 0x3E, 0x01, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x03, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xCF, 0x8F,
  0x8F, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0, 0x01, 0xC3, 0xDF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xF3, 0xEF, 0xFF, 0xBD, 0xFC, 0xF3, 0xE3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x3F, 0x3C, 0xFF, 0xFB, 0xFF, 0xF7, 0xC7, 0xEF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83,
  0xEF, 0x8F, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xBE, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xFD, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0xFE, 0x7F, 0xEF,
  0xFE, 0xF0, 0x2F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xE0,
  0x1F, 0x01, 0xFE, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x4F, 0xF3, 0xFC, 0x7F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0xFD, 0xFF, 0xF7, 0xFB,
  0xCF, 0xCF, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x7C,
  0x1E, 0xF0, 0xFC, 0x3D, 0xE1, 0xF8, 0x7B, 0xC3, 0xF1, 0xE3, 0xCF, 0xE3,
  0xC7, 0x9D, 0xE7, 0x8F, 0x39, 0xCF, 0x1E, 0x73, 0xBC, 0x1E, 0xE7, 0x78,
  0x3F, 0x8E, 0xF0, 0x7F, 0x1D, 0xE0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x7C, 0x3C,
  0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0x78, 0x3C, 0x7C,
  0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x5F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xC3, 0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF3, 0xF8, 0xF8, 0x3F, 0x83, 0xE0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFC, 0x3F, 0x07, 0xC0, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x3F, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81,
  0xE0, 0x7F, 0x07, 0xC3, 0xF1, 0xF8, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x0F, 0xC3, 0xF0, 0xFC, 0x30, 0x00, 0x7E, 0x07, 0xFE, 0x7F,
  0xFF, 0xF1, 0xFF, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Bold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 21, 8, 2, -21 },
  { 15, 10, 7, 14, 2, -21 },
  { 24, 16, 21, 18, 1, -21 },
  { 66, 14, 25, 16, 1, -23 },
  { 110, 24, 22, 26, 1, -22 },
  { 176, 19, 22, 20, 1, -22 },
  { 229, 4, 7, 8, 2, -21 },
  { 233, 8, 26, 10, 1, -21 },
  { 259, 8, 26, 10, 1, -21 },
  { 285, 13, 14, 15, 1, -23 },
  { 308, 14, 15, 16, 1, -18 },
  { 335, 6, 7, 8, 1, -3 },
  { 341, 8, 4, 9, 1, -10 },
  { 345, 5, 5, 8, 2, -5 },
  { 349, 12, 22, 12, 0, -22 },
  { 382, 14, 22, 16, 1, -22 },
  { 421, 10, 21, 16, 2, -21 },
  { 448, 14, 22, 16, 1, -22 },
  { 487, 14, 22, 16, 1, -22 },
  { 526, 15, 21, 16, 0, -21 },
  { 566, 14, 21, 16, 1, -21 },
  { 603, 14, 22, 16, 1, -22 },
  { 642, 14, 21, 16, 1, -21 },
  { 679, 14, 22, 16, 1, -22 },
  { 718, 14, 22, 16, 1, -22 },
  { 757, 5, 17, 8, 2, -17 },
  { 768, 6, 21, 8, 1, -17 },
  { 784, 14, 15, 16, 1, -18 },
  { 811, 14, 9, 16, 1, -15 },
  { 827, 14, 15, 16, 1, -18 },
  { 854, 13, 22, 13, 0, -22 },
  { 890, 23, 24, 25, 1, -22 },
  { 959, 19, 21, 19, 0, -21 },
  { 1009, 15, 21, 18, 2, -21 },
  { 1049, 15, 22, 18, 2, -22 },
  { 1091, 17, 21, 20, 2, -21 },
  { 1136, 12, 21, 15, 2, -21 },
  { 1168, 12, 21, 15, 2, -21 },
  { 1200, 16, 22, 20, 2, -22 },
  { 1244, 17, 21, 21, 2, -21 },
  { 1289, 9, 21, 11, 1, -21 },
  { 1313, 9, 27, 9, -2, -21 },
  { 1344, 16, 21, 18, 2, -21 },
  { 1386, 12, 21, 15, 2, -21 },
  { 1418, 22, 21, 26, 2, -21 },
  { 1476, 18, 21, 22, 2, -21 },
  { 1524, 18, 22, 22, 2, -22 },
  { 1574, 14, 21, 17, 2, -21 },
  { 1611, 18, 27, 22, 2, -22 },
  { 1672, 16, 21, 18, 2, -21 },
  { 1714, 13, 22, 15, 1, -22 },
  { 1750, 14, 21, 16, 1, -21 },
  { 1787, 16, 21, 21, 2, -21 },
  { 1829, 18, 21, 18, 0, -21 },
  { 1877, 27, 21, 27, 0, -21 },
  { 1948, 18, 21, 18, 0, -21 },
  { 1996, 17, 21, 17, 0, -21 },
  { 2041, 14, 21, 16, 1, -21 },
  { 2078, 7, 26, 10, 2, -21 },
  { 2101, 12, 22, 12, 0, -22 },
  { 2134, 7, 26, 10, 1, -21 },
  { 2157, 15, 13, 17, 1, -21 },
  { 2182, 12, 2, 12, 0, 3 },
  { 2185, 8, 5, 10, 1, -23 },
  { 2190, 14, 17, 16, 1, -17 },
  { 2220, 14, 23, 18, 2, -23 },
  { 2261, 12, 17, 14, 1, -17 },
  { 2287, 15, 23, 18, 1, -23 },
  { 2331, 14, 17, 16, 1, -17 },
  { 2361, 12, 23, 11, 0, -23 },
  { 2396, 15, 24, 18, 1, -17 },
  { 2441, 14, 23, 18, 2, -23 },
  { 2482, 5, 23, 8, 2, -23 },
  { 2497, 8, 30, 8, -1, -23 },
  { 2527, 15, 23, 17, 2, -23 },
  { 2571, 4, 23, 8, 2, -23 },
  { 2583, 23, 17, 27, 2, -17 },
  { 2632, 14, 17, 18, 2, -17 },
  { 2662, 15, 17, 17, 1, -17 },
  { 2694, 14, 24, 18, 2, -17 },
  { 2736, 15, 24, 18, 1, -17 },
  { 2781, 10, 17, 12, 2, -17 },
  { 2803, 12, 17, 14, 1, -17 },
  { 2829, 10, 20, 12, 1, -20 },
  { 2854, 14, 16, 18, 2, -16 },
  { 2882, 16, 16, 16, 0, -16 },
  { 2914, 23, 16, 24, 0, -16 },
  { 2960, 16, 16, 16, 0, -16 },
  { 2992, 16, 23, 16, 0, -16 },
  { 3038, 12, 16, 13, 1, -16 },
  { 3062, 10, 26, 11, 0, -21 },
  { 3095, 3, 30, 15, 6, -23 },
  { 3107, 10, 26, 11, 1, -21 },
  { 3140, 14, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Bold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD30PT7B_H_
