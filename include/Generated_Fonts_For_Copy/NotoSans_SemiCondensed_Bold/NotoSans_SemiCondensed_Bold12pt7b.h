#ifndef _NOTOSANS_SEMICONDENSED_BOLD12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA2, 0xC0, 0xBB, 0xBB, 0x14, 0x68, 0xB3, 0xF2, 0x9F, 0xFF,
  0xB4, 0x58, 0x27, 0xEB, 0xCF, 0x1E, 0xFF, 0x21, 0x00, 0x61, 0x1C, 0x8D,
  0x23, 0x50, 0x77, 0x9A, 0xB0, 0xA4, 0x4F, 0x31, 0x80, 0x30, 0x7C, 0x6C,
  0x78, 0x33, 0x7B, 0xCE, 0x6E, 0x7B, 0xF0, 0x6B, 0x49, 0x24, 0x99, 0x80,
  0xC9, 0x92, 0x49, 0x6F, 0x00, 0x32, 0xDF, 0xCC, 0x68, 0x10, 0x4F, 0xC4,
  0x10, 0x40, 0x6B, 0x00, 0xFC, 0xB0, 0x18, 0x84, 0x62, 0x31, 0x88, 0xC0,
  0x31, 0xE4, 0xF3, 0xCF, 0x34, 0xDB, 0x78, 0x37, 0xFB, 0x33, 0x33, 0x30,
  0x33, 0xE4, 0xC3, 0x18, 0xC2, 0x18, 0xFC, 0x33, 0xF0, 0xC2, 0x30, 0x30,
  0xE3, 0xF8, 0x08, 0x63, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF7, 0xA1, 0x0F,
  0x0C, 0x77, 0xF0, 0x19, 0xE6, 0x14, 0xFF, 0x3C, 0xDB, 0x38, 0xFF, 0xF0,
  0xC2, 0x18, 0x43, 0x0C, 0x60, 0x31, 0xF4, 0xDA, 0x31, 0xFC, 0xF3, 0x78,
  0x31, 0xEC, 0xF3, 0x6D, 0xF0, 0xC6, 0x70, 0xB0, 0x2C, 0x4C, 0x00, 0x52,
  0xC0, 0x0C, 0xEE, 0x1C, 0x1C, 0x10, 0xFC, 0x0F, 0xFF, 0xC1, 0xC0, 0xCE,
  0xE2, 0x00, 0x77, 0xC6, 0x33, 0x10, 0x0C, 0x60, 0x18, 0x66, 0xC1, 0xBD,
  0xA5, 0xA5, 0xAD, 0x92, 0xC2, 0x3C, 0x18, 0x38, 0x3C, 0x2C, 0x6C, 0x7C,
  0x7E, 0xC6, 0xC3, 0xF3, 0xEC, 0xF2, 0xF3, 0x3C, 0xF7, 0xF8, 0x39, 0xFC,
  0x30, 0x82, 0x0C, 0x3A, 0x78, 0xE3, 0xEC, 0xF3, 0xC7, 0x1C, 0xF7, 0xF8,
  0xFF, 0xF1, 0x8F, 0x63, 0x18, 0xF8, 0xFF, 0xCC, 0xFF, 0xCC, 0xC0, 0x39,
  0xFC, 0x30, 0x9E, 0x7C, 0xFB, 0x7C, 0xC7, 0x1C, 0x71, 0xFF, 0x1C, 0x71,
  0xC4, 0xF7, 0x66, 0x66, 0x66, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE4,
  0xCF, 0x3D, 0xBC, 0xF3, 0xCD, 0xB2, 0xCC, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xF8, 0xC3, 0xF1, 0xE8, 0xFC, 0xFF, 0x5F, 0xAF, 0x77, 0xB3, 0xD9, 0x80,
  0xC7, 0xCF, 0x9F, 0xBF, 0x7B, 0xF3, 0xE7, 0xC6, 0x38, 0xFB, 0x1E, 0x38,
  0x70, 0xF1, 0xF6, 0x7C, 0xE7, 0xF3, 0x9F, 0xFB, 0x18, 0xC0, 0x38, 0xFB,
  0x1E, 0x38, 0x70, 0xF1, 0xF6, 0x7C, 0x18, 0x38, 0xE3, 0xEC, 0xB2, 0xFB,
  0xCD, 0xB6, 0xCC, 0x39, 0xF4, 0x18, 0x70, 0x60, 0xF6, 0xF8, 0xFF, 0xF3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x78,
  0xC7, 0x8D, 0x1B, 0x26, 0xC5, 0x8A, 0x1C, 0x38, 0xC4, 0x79, 0x8B, 0x39,
  0x27, 0x66, 0xAC, 0xF5, 0x9E, 0xA1, 0x9C, 0x31, 0x80, 0xC6, 0xD9, 0xB1,
  0xC3, 0x87, 0x1B, 0x36, 0xC6, 0xC6, 0x89, 0xB3, 0x43, 0x86, 0x04, 0x08,
  0x10, 0xFF, 0xF0, 0x86, 0x30, 0x86, 0x30, 0xFC, 0xFE, 0x49, 0x24, 0x93,
  0x80, 0xC2, 0x10, 0xC2, 0x18, 0xC2, 0x18, 0xFC, 0x92, 0x49, 0x27, 0x80,
  0x10, 0xC3, 0x9A, 0x4F, 0x10, 0xF8, 0xE3, 0x39, 0xF0, 0xDF, 0xCF, 0x37,
  0xC0, 0xC6, 0x3D, 0xFC, 0xE7, 0x3B, 0xB8, 0x7F, 0x88, 0x8D, 0xF0, 0x18,
  0xDF, 0xF9, 0xC6, 0x3B, 0xE8, 0x67, 0xE7, 0xF8, 0x65, 0xE0, 0x7B, 0x1D,
  0xE6, 0x31, 0x8C, 0x60, 0x6F, 0xE7, 0x18, 0xEF, 0xA3, 0xFF, 0x80, 0xC6,
  0x2D, 0xFC, 0xE7, 0x39, 0xC8, 0xEF, 0xFF, 0xC0, 0x32, 0x33, 0x33, 0x33,
  0x33, 0xEE, 0xC3, 0x0C, 0xF6, 0xF3, 0xCF, 0x36, 0xCC, 0xFF, 0xFF, 0xC0,
  0xB3, 0x7F, 0xF6, 0x7B, 0x3D, 0x9E, 0xCF, 0x66, 0xB7, 0xF3, 0x9C, 0xE7,
  0x20, 0x77, 0xE7, 0x18, 0xED, 0xC0, 0xB7, 0xF3, 0x9C, 0xEE, 0xF8, 0xC6,
  0x00, 0x6F, 0xE7, 0x18, 0xEF, 0xA3, 0x18, 0xC0, 0xBF, 0xCC, 0xCC, 0xC0,
  0x33, 0xF0, 0xE1, 0xCF, 0xC0, 0x67, 0xF6, 0x66, 0x67, 0xCE, 0x73, 0x9C,
  0xEF, 0xA0, 0xCF, 0x34, 0xDA, 0x78, 0xE3, 0x00, 0xCC, 0xE6, 0xD7, 0x6E,
  0xB7, 0x73, 0x98, 0xCC, 0xCD, 0xB7, 0x8C, 0x39, 0xAC, 0xC0, 0xCF, 0x34,
  0xDA, 0x78, 0xE3, 0x0C, 0xE3, 0x80, 0xFF, 0xC4, 0x66, 0x23, 0xE0, 0x13,
  0x22, 0x6C, 0x62, 0x22, 0x30, 0xFF, 0xFF, 0xFF, 0xCE, 0x66, 0x63, 0x26,
  0x66, 0xC0, 0xFE, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_Bold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 6, 1, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 10, 6, 1, -9 },
  { 21, 10, 9, 10, 0, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 1, 4, 3, 1, -9 },
  { 43, 3, 11, 4, 1, -9 },
  { 48, 3, 11, 4, 0, -9 },
  { 53, 6, 5, 6, 0, -9 },
  { 57, 6, 6, 6, 0, -7 },
  { 62, 3, 3, 3, 0, -1 },
  { 64, 3, 2, 4, 0, -4 },
  { 65, 2, 2, 3, 1, -2 },
  { 66, 5, 9, 5, 0, -9 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 4, 9, 6, 1, -9 },
  { 84, 6, 9, 6, 0, -9 },
  { 91, 6, 9, 6, 0, -9 },
  { 98, 6, 9, 6, 0, -9 },
  { 105, 5, 9, 6, 1, -9 },
  { 111, 6, 9, 6, 0, -9 },
  { 118, 6, 9, 6, 0, -9 },
  { 125, 6, 9, 6, 0, -9 },
  { 132, 6, 9, 6, 0, -9 },
  { 139, 2, 7, 3, 1, -7 },
  { 141, 3, 9, 3, 0, -7 },
  { 145, 6, 6, 6, 0, -7 },
  { 150, 6, 4, 6, 0, -6 },
  { 153, 6, 6, 6, 0, -7 },
  { 158, 5, 9, 5, 0, -9 },
  { 164, 8, 10, 10, 1, -9 },
  { 174, 8, 9, 8, 0, -9 },
  { 183, 6, 9, 7, 1, -9 },
  { 190, 6, 9, 7, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 5, 9, 6, 1, -9 },
  { 210, 4, 9, 6, 1, -9 },
  { 215, 6, 9, 8, 1, -9 },
  { 222, 6, 9, 8, 1, -9 },
  { 229, 4, 9, 4, 0, -9 },
  { 234, 4, 12, 4, -1, -9 },
  { 240, 6, 9, 7, 1, -9 },
  { 247, 5, 9, 6, 1, -9 },
  { 253, 9, 9, 11, 1, -9 },
  { 264, 7, 9, 9, 1, -9 },
  { 272, 7, 9, 9, 1, -9 },
  { 280, 5, 9, 7, 1, -9 },
  { 286, 7, 11, 9, 1, -9 },
  { 296, 6, 9, 7, 1, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 6, 9, 6, 0, -9 },
  { 317, 6, 9, 8, 1, -9 },
  { 324, 7, 9, 7, 0, -9 },
  { 332, 11, 9, 11, 0, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 7, 9, 7, 0, -9 },
  { 361, 6, 9, 6, 0, -9 },
  { 368, 3, 11, 4, 1, -9 },
  { 373, 5, 9, 5, 0, -9 },
  { 379, 3, 11, 4, 0, -9 },
  { 384, 6, 6, 7, 0, -9 },
  { 389, 5, 1, 5, 0, 1 },
  { 390, 4, 2, 4, 0, -9 },
  { 391, 6, 7, 7, 0, -7 },
  { 397, 5, 9, 7, 1, -9 },
  { 403, 4, 7, 6, 1, -7 },
  { 407, 5, 9, 7, 1, -9 },
  { 413, 5, 7, 7, 1, -7 },
  { 418, 5, 9, 4, 0, -9 },
  { 424, 5, 10, 7, 1, -7 },
  { 431, 5, 9, 7, 1, -9 },
  { 437, 2, 9, 3, 1, -9 },
  { 440, 4, 12, 3, -1, -9 },
  { 446, 6, 9, 7, 1, -9 },
  { 453, 2, 9, 3, 1, -9 },
  { 456, 9, 7, 11, 1, -7 },
  { 464, 5, 7, 7, 1, -7 },
  { 469, 5, 7, 7, 1, -7 },
  { 474, 5, 10, 7, 1, -7 },
  { 481, 5, 10, 7, 1, -7 },
  { 488, 4, 7, 5, 1, -7 },
  { 492, 5, 7, 5, 0, -7 },
  { 497, 4, 8, 5, 0, -8 },
  { 501, 5, 7, 7, 1, -7 },
  { 506, 6, 7, 6, 0, -7 },
  { 512, 9, 7, 9, 0, -7 },
  { 520, 6, 7, 6, 0, -7 },
  { 526, 6, 10, 6, 0, -7 },
  { 534, 5, 7, 5, 0, -7 },
  { 539, 4, 11, 5, 0, -9 },
  { 545, 2, 12, 6, 2, -9 },
  { 548, 4, 11, 5, 0, -9 },
  { 554, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Bold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD12PT7B_H_
