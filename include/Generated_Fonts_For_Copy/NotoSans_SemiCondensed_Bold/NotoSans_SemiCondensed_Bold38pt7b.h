#ifndef _NOTOSANS_SEMICONDENSED_BOLD38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xE0, 0x00, 0x00, 0xEF, 0xFF, 0xFF, 0xF7, 0xC0, 0xFC, 0xFF,
  0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xF9, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x07, 0x87, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xC0, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x0F, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x03,
  0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0x7C, 0xF9, 0x82, 0x7C, 0xC0,
  0x3E, 0x60, 0x1F, 0xB0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x6F, 0xC0, 0x33, 0xF0, 0x19, 0xFC,
  0x0C, 0xFF, 0x86, 0x7D, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFE,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x7C, 0x03, 0xFC, 0x01, 0xE0, 0x1F, 0xF8, 0x0F, 0x80,
  0x79, 0xF0, 0x3C, 0x03, 0xE3, 0xC1, 0xF0, 0x0F, 0x8F, 0x07, 0x80, 0x3C,
  0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xC3, 0xC7, 0xC0, 0x0F, 0x0F,
  0x1E, 0x00, 0x3E, 0x3C, 0xF8, 0x70, 0x78, 0xF3, 0xC7, 0xF1, 0xE7, 0xCF,
  0x3F, 0xE7, 0xFE, 0x79, 0xFF, 0x8F, 0xF9, 0xE7, 0x9F, 0x1F, 0xCF, 0x3E,
  0x3C, 0x18, 0x3C, 0xF8, 0xF0, 0x01, 0xE3, 0xC3, 0xC0, 0x07, 0x8F, 0x0F,
  0x00, 0x3C, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0xF0, 0x07, 0x83, 0xE3, 0xC0,
  0x1E, 0x07, 0x8F, 0x00, 0xF0, 0x1F, 0x7C, 0x03, 0xC0, 0x7F, 0xE0, 0x1E,
  0x00, 0xFF, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0xFC, 0x7F, 0xF0, 0x7C, 0x7F, 0xFC, 0x7E, 0x3F,
  0x3F, 0x3F, 0x3F, 0x0F, 0xDF, 0x1F, 0x83, 0xFF, 0x8F, 0xC0, 0xFF, 0x87,
  0xE0, 0x7F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x80, 0xFF, 0x87, 0xF0, 0xFF, 0xEF,
  0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE0, 0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x0B, 0x8E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0xC0, 0xF9, 0xF0,
  0xF8, 0xF8, 0x3C, 0x38, 0x04, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0x9E, 0x7C, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x40, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x0F, 0xCF, 0xC7, 0xE1, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x03, 0xE7, 0xE1, 0xF8, 0xFC, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF,
  0x9F, 0xFD, 0xFF, 0xFF, 0xBF, 0x79, 0xF9, 0x8F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0x40, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0x8F, 0xE3, 0x81, 0xF8, 0x40, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8E, 0x0F, 0xE1, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFB, 0xC0, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xBF, 0x00, 0xF7, 0xE0, 0x3C, 0xFC, 0x0F, 0x9F, 0x81, 0xE3,
  0xF0, 0x78, 0x7E, 0x1F, 0x0F, 0xC3, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFF, 0xF8, 0xC3, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF4, 0x01, 0xFB, 0xC3, 0xFD,
  0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0E, 0x07, 0xDF, 0xE3, 0xEF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F, 0xDF, 0x83, 0xE3, 0xF1,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x8F, 0xCF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFD, 0xFC, 0x7E,
  0x1F, 0x9F, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xF7, 0xE0, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x3F, 0x9F,
  0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF,
  0x1F, 0xE7, 0x80, 0xC3, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0x7C, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFB, 0xF7, 0xCF,
  0x9F, 0x3C, 0x79, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x03,
  0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x7F,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x78, 0x7F, 0x20, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE7, 0xC1, 0xFF, 0x1E, 0x78, 0x7F, 0xF9, 0xE7, 0x87,
  0xFF, 0x8F, 0xF0, 0xF8, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F, 0xF1, 0xE0, 0xF0,
  0xFF, 0x1E, 0x0F, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x0F, 0xF1,
  0xE0, 0xF0, 0xFF, 0x1E, 0x0F, 0x1E, 0xF1, 0xF1, 0xF1, 0xEF, 0x1F, 0xFF,
  0xFE, 0xF0, 0xFF, 0xBF, 0xCF, 0x87, 0xF3, 0xF8, 0x78, 0x0C, 0x0E, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xC3, 0xFD, 0xF8, 0x1F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF0, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE0, 0xFE, 0xFC,
  0x0F, 0xDF, 0x80, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF8,
  0x1F, 0xBF, 0x1F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0x87, 0x8F, 0xC0, 0x13, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x11, 0xFF, 0x3E, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC,
  0x0F, 0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF0, 0x70, 0xFE, 0x00, 0x8F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xF8, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x87, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F,
  0xDF, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFB, 0xC0, 0x7F, 0xFF, 0x78, 0x0F, 0x7F, 0xEF, 0x83,
  0xEF, 0xFC, 0xF0, 0x7D, 0xFF, 0x9E, 0x0F, 0x3F, 0xF3, 0xE1, 0xE7, 0xFE,
  0x7C, 0x7C, 0xFF, 0xC7, 0x8F, 0x1F, 0xF8, 0xF1, 0xE3, 0xFF, 0x1F, 0x7C,
  0x7F, 0xE1, 0xEF, 0x0F, 0xFC, 0x3D, 0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xF0,
  0xFF, 0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x3F, 0x83,
  0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0x80, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFB, 0xE0, 0x7F, 0xEF, 0xC1, 0xFF,
  0x9F, 0x87, 0xFE, 0x7E, 0x1F, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xFF, 0x87,
  0xE7, 0xFE, 0x1F, 0x9F, 0xF8, 0x3F, 0x7F, 0xE0, 0xFD, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x10, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF,
  0xC0, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x1F,
  0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7F,
  0x1F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0xFF, 0x8F, 0xC1, 0xF8, 0xFC,
  0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xC7, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7E, 0xFC, 0x07, 0xF0, 0x00, 0x80, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFE, 0x3C, 0xFC, 0x04, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x3F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x8F, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xEF,
  0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x1F, 0xC0, 0x3E, 0x7C, 0x07, 0xF0, 0x1F,
  0x9F, 0x01, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x1F, 0xE0,
  0x7C, 0x3E, 0x0F, 0xF8, 0x3F, 0x0F, 0x83, 0xDF, 0x0F, 0xC3, 0xF0, 0xF7,
  0xC3, 0xE0, 0x7C, 0x3C, 0xF0, 0xF8, 0x1F, 0x1F, 0x3C, 0x3E, 0x07, 0xC7,
  0xCF, 0x9F, 0x81, 0xF1, 0xE3, 0xE7, 0xC0, 0x3E, 0x78, 0xF9, 0xF0, 0x0F,
  0xBE, 0x1E, 0x7C, 0x03, 0xEF, 0x87, 0x9F, 0x00, 0xFB, 0xC1, 0xFF, 0xC0,
  0x3E, 0xF0, 0x7F, 0xE0, 0x07, 0xBC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x01,
  0xFB, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0x03,
  0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x1E,
  0x03, 0xE3, 0xC0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0x78, 0xF8, 0x0F,
  0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x07, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xC1, 0xF8, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x03, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xF9, 0xF7,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF,
  0xDF, 0xFD, 0xE7, 0xFC, 0xF1, 0xFC, 0x78, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF9, 0xF8, 0x3E, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x7F,
  0xBF, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xFB, 0xF0,
  0x7E, 0xFE, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xCF, 0xF8, 0xF1, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE7, 0xF3, 0xDF, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0x7F, 0x0C, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F,
  0xCF, 0xC7, 0xFB, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0x9F, 0x0F, 0xC7, 0xC0, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xF7, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xF8, 0x3F, 0xF1,
  0xFF, 0x87, 0xFE, 0x1F, 0x98, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xF3,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x0F,
  0xC7, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE,
  0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x40, 0x1F, 0x9F, 0x1F, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF9, 0xFC, 0x7D, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xF7, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF8, 0x39, 0xFF, 0xFF,
  0x7C, 0xC0, 0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x03, 0x81, 0xF0, 0xFC, 0x3F,
  0x07, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F,
  0xE7, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0xDF, 0x03, 0xF3, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F,
  0x87, 0xE1, 0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xF9, 0xF8, 0x3E,
  0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0x7E, 0x7C,
  0x07, 0xEF, 0x80, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1,
  0xFC, 0x1F, 0x8F, 0x3F, 0xE7, 0xFE, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0xC1, 0xFC, 0x3F, 0xFC, 0x1F, 0x81, 0xFF,
  0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F,
  0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F,
  0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81,
  0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81,
  0xF0, 0xF1, 0xFC, 0x79, 0xFF, 0x3D, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF8, 0x07, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x3F, 0xBF, 0x03, 0xEF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E, 0x7E, 0x1F,
  0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xF1, 0xF8,
  0x3C, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFE, 0x7F, 0xBF, 0x07, 0xEF,
  0xC1, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xFB, 0xF0, 0x7E, 0xFE, 0x3F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xEF, 0xF8, 0xF9, 0xFC, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC7, 0xC7, 0xF9, 0xF3, 0xFF,
  0x7D, 0xFF, 0xFF, 0x7F, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xBF, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xC1, 0x9F, 0x80, 0x1F, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x60, 0x7E, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x9F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xF8, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x3F, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xE3, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F,
  0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x9F, 0x00, 0xF9,
  0xF0, 0x0F, 0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFE, 0x0F, 0x9F,
  0x07, 0xF8, 0x3E, 0x7E, 0x1F, 0xE1, 0xF8, 0xF8, 0x7F, 0x87, 0xC3, 0xE1,
  0xFE, 0x1F, 0x0F, 0x8F, 0x3C, 0x7C, 0x3F, 0x3C, 0xF3, 0xF0, 0x7C, 0xF3,
  0xCF, 0x81, 0xF3, 0xCF, 0x3E, 0x07, 0xCE, 0x1C, 0xF8, 0x0F, 0x78, 0x7B,
  0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE7, 0xE0, 0x7E,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF9, 0xF0, 0x1F,
  0x9F, 0x83, 0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0x7E, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x04, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE3, 0xFE, 0x1F, 0xE0, 0xFC, 0x07, 0xF8,
  0x3F, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xF8,
  0x3F, 0xC3, 0xFE, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0,
  0xF8, 0x00, 0x08, 0x00, 0x4F, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE8, 0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 14, 10, 18, 2, -27 },
  { 40, 21, 27, 23, 1, -27 },
  { 111, 17, 31, 20, 2, -29 },
  { 177, 30, 28, 32, 1, -28 },
  { 282, 25, 28, 26, 1, -28 },
  { 370, 6, 10, 10, 2, -27 },
  { 378, 10, 33, 13, 2, -27 },
  { 420, 10, 33, 13, 1, -27 },
  { 462, 17, 17, 19, 1, -29 },
  { 499, 18, 19, 20, 1, -23 },
  { 542, 7, 9, 10, 1, -4 },
  { 550, 10, 5, 12, 1, -13 },
  { 557, 6, 6, 10, 2, -6 },
  { 562, 15, 27, 16, 0, -27 },
  { 613, 18, 28, 20, 1, -28 },
  { 676, 13, 27, 20, 2, -27 },
  { 720, 18, 28, 20, 1, -28 },
  { 783, 18, 28, 20, 1, -28 },
  { 846, 19, 27, 20, 1, -27 },
  { 911, 17, 27, 20, 2, -27 },
  { 969, 18, 27, 20, 1, -27 },
  { 1030, 18, 27, 20, 1, -27 },
  { 1091, 18, 27, 20, 1, -27 },
  { 1152, 18, 27, 20, 1, -27 },
  { 1213, 6, 21, 10, 2, -21 },
  { 1229, 7, 26, 10, 1, -21 },
  { 1252, 18, 19, 20, 1, -23 },
  { 1295, 18, 11, 20, 1, -19 },
  { 1320, 18, 19, 20, 1, -23 },
  { 1363, 16, 28, 17, 0, -28 },
  { 1419, 28, 30, 32, 2, -27 },
  { 1524, 24, 27, 24, 0, -27 },
  { 1605, 19, 27, 23, 3, -27 },
  { 1670, 19, 28, 22, 2, -28 },
  { 1737, 20, 27, 25, 3, -27 },
  { 1805, 14, 27, 20, 3, -27 },
  { 1853, 14, 27, 19, 3, -27 },
  { 1901, 21, 28, 25, 2, -28 },
  { 1975, 20, 27, 27, 3, -27 },
  { 2043, 12, 27, 14, 1, -27 },
  { 2084, 12, 35, 12, -3, -27 },
  { 2137, 20, 27, 23, 3, -27 },
  { 2205, 15, 27, 19, 3, -27 },
  { 2256, 27, 27, 33, 3, -27 },
  { 2348, 22, 27, 28, 3, -27 },
  { 2423, 23, 28, 27, 2, -28 },
  { 2504, 17, 27, 22, 3, -27 },
  { 2562, 23, 34, 27, 2, -28 },
  { 2660, 20, 27, 23, 3, -27 },
  { 2728, 16, 28, 19, 2, -28 },
  { 2784, 18, 27, 20, 1, -27 },
  { 2845, 20, 27, 26, 3, -27 },
  { 2913, 23, 27, 23, 0, -27 },
  { 2991, 34, 27, 34, 0, -27 },
  { 3106, 23, 27, 23, 0, -27 },
  { 3184, 22, 27, 22, 0, -27 },
  { 3259, 18, 27, 20, 1, -27 },
  { 3320, 9, 33, 12, 2, -27 },
  { 3358, 15, 27, 16, 0, -27 },
  { 3409, 9, 33, 12, 1, -27 },
  { 3447, 19, 17, 21, 1, -27 },
  { 3488, 16, 3, 16, 0, 3 },
  { 3494, 10, 6, 13, 2, -29 },
  { 3502, 17, 21, 21, 1, -21 },
  { 3547, 18, 29, 22, 3, -29 },
  { 3613, 15, 21, 18, 2, -21 },
  { 3653, 18, 29, 22, 2, -29 },
  { 3719, 17, 21, 21, 2, -21 },
  { 3764, 14, 29, 13, 1, -29 },
  { 3815, 18, 30, 22, 2, -21 },
  { 3883, 17, 29, 23, 3, -29 },
  { 3945, 6, 29, 11, 2, -29 },
  { 3967, 10, 38, 11, -2, -29 },
  { 4015, 19, 29, 22, 3, -29 },
  { 4084, 5, 29, 11, 3, -29 },
  { 4103, 28, 21, 34, 3, -21 },
  { 4177, 17, 21, 23, 3, -21 },
  { 4222, 18, 21, 22, 2, -21 },
  { 4270, 18, 30, 22, 3, -21 },
  { 4338, 18, 30, 22, 2, -21 },
  { 4406, 12, 21, 16, 3, -21 },
  { 4438, 15, 21, 17, 1, -21 },
  { 4478, 13, 25, 15, 1, -25 },
  { 4519, 18, 21, 23, 2, -21 },
  { 4567, 20, 21, 20, 0, -21 },
  { 4620, 30, 21, 30, 0, -21 },
  { 4699, 20, 21, 20, 0, -21 },
  { 4752, 20, 30, 20, 0, -21 },
  { 4827, 15, 21, 17, 1, -21 },
  { 4867, 13, 33, 14, 0, -27 },
  { 4921, 4, 38, 19, 8, -29 },
  { 4940, 13, 33, 14, 1, -27 },
  { 4994, 18, 7, 20, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_Bold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD38PT7B_H_
