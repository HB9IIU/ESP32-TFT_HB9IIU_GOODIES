#ifndef _NOTOSANS_SEMICONDENSED_BOLD6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0x5F, 0x3C, 0xD7, 0x8E, 0xB0, 0xE4, 0xBF,
  0x80, 0x6A, 0x40, 0x95, 0x80, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x5A, 0xF6, 0xB0, 0xD5, 0xE5, 0x70, 0xE8, 0xF0, 0x6F, 0x90, 0xF8, 0xF0,
  0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xE9, 0x20, 0x77, 0xF7, 0xE0, 0x66, 0xE9, 0xFE, 0xF0,
  0x72, 0x30, 0xE9, 0x9E, 0xFE, 0x70, 0xFE, 0x40, 0x7A, 0x97, 0x9F, 0x99,
  0xD7, 0xF8, 0xBC, 0xAB, 0x92, 0x70, 0xDE, 0xEB, 0x50, 0xDB, 0xB9, 0x79,
  0x97, 0xF7, 0x40, 0x79, 0x97, 0x10, 0xEA, 0xEB, 0xF8, 0xF0, 0xE9, 0x20,
  0x99, 0x96, 0xBA, 0x64, 0xAD, 0x56, 0xA0, 0xA4, 0x6B, 0xAD, 0x20, 0xE9,
  0x70, 0xEA, 0xC0, 0x95, 0xD5, 0xC0, 0x54, 0xC0, 0xC0, 0xFF, 0x80, 0x93,
  0xDE, 0xF1, 0x80, 0x27, 0xDE, 0xFD, 0x80, 0x6E, 0x80, 0xF7, 0xF0, 0x93,
  0xDA, 0xB8, 0xBC, 0x92, 0xEA, 0xF8, 0xFD, 0x6A, 0xF6, 0x80, 0xF5, 0x80,
  0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xEB, 0x80, 0xB9, 0xB5, 0x80, 0xB5, 0x00,
  0xAE, 0x94, 0xAA, 0x80, 0xAD, 0x60, 0xCB, 0x80, 0x59, 0x40, 0xFC, 0xD5,
  0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 2, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 5, 4, 5, 0, -4 },
  { 56, 4, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 2, 4, 2, 0, -4 },
  { 73, 1, 5, 2, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 5, 4, 5, 0, -4 },
  { 81, 4, 4, 4, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 4, 5, 4, 0, -4 },
  { 90, 4, 4, 4, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 5, 4, 5, 0, -4 },
  { 103, 4, 4, 4, 0, -4 },
  { 105, 3, 4, 3, 0, -4 },
  { 107, 3, 4, 3, 0, -4 },
  { 109, 2, 5, 2, 0, -4 },
  { 111, 2, 4, 2, 0, -4 },
  { 112, 2, 5, 2, 0, -4 },
  { 114, 3, 2, 3, 0, -4 },
  { 115, 2, 1, 2, 0, 0 },
  { 116, 2, 1, 2, 0, -5 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 5, 4, 0, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 3, 5, 4, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 2, 5, 2, 0, -5 },
  { 129, 3, 4, 4, 0, -3 },
  { 131, 3, 5, 4, 0, -5 },
  { 133, 1, 5, 2, 0, -5 },
  { 134, 1, 6, 2, 0, -5 },
  { 135, 3, 5, 3, 0, -5 },
  { 137, 1, 5, 2, 0, -5 },
  { 138, 5, 3, 5, 0, -3 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 3, 3, 0, -3 },
  { 144, 3, 4, 4, 0, -3 },
  { 146, 3, 4, 4, 0, -3 },
  { 148, 2, 3, 2, 0, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 2, 4, 2, 0, -4 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 5, 3, 5, 0, -3 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 3, 4, 3, 0, -3 },
  { 162, 3, 3, 3, 0, -3 },
  { 164, 2, 5, 2, 0, -4 },
  { 166, 1, 6, 3, 1, -5 },
  { 167, 2, 5, 2, 0, -4 },
  { 169, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Bold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD6PT7B_H_
