#ifndef _NOTOSANS_SEMICONDENSED_BOLD52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x18, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7E, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFD, 0xF0, 0x3E, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0x3C, 0x18, 0xFF, 0x3C, 0x00,
  0xFE, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0x7F, 0x3C, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFE, 0x00, 0x3C, 0xFF, 0x00, 0x3C, 0xFF,
  0x80, 0x3C, 0xFF, 0xE0, 0x3C, 0xFE, 0xFE, 0x3D, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xC0, 0x03, 0xF7, 0xF0, 0x07, 0xE0,
  0x03, 0xF1, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x3E, 0x00, 0x01, 0xF8,
  0x7E, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x1F, 0x0F, 0xF8, 0x7E, 0x1F, 0x1F,
  0x8F, 0xFE, 0x1F, 0x9F, 0x8F, 0x8F, 0xFF, 0x8F, 0xFF, 0xCF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC7, 0xC7, 0xE3, 0xF0, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0x3F,
  0xC3, 0xF1, 0xF0, 0x7C, 0x07, 0x83, 0xF1, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xBF,
  0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xC3, 0xFF, 0xE0, 0x1F, 0xE3, 0xFF, 0xF8, 0x0F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x7F, 0x87, 0xF9, 0xFF, 0x3F, 0xE3, 0xF8,
  0xFF, 0x0F, 0xFB, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFE,
  0x1F, 0xE0, 0x3F, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0xF8, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB,
  0xE7, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x02, 0x78, 0x3E, 0x0E, 0x7F, 0x3E, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xC1, 0xE0, 0x01, 0x81,
  0xC0, 0x00, 0x81, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x9F, 0xCF, 0xEF, 0xF7,
  0xF3, 0xF9, 0xFC, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0x81, 0xFC, 0x7F,
  0x01, 0xFE, 0x7F, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xCF, 0xEF, 0xC7, 0xF3, 0xC3, 0xF8, 0x81, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x03, 0xFE,
  0x3C, 0x01, 0xFE, 0x18, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3C, 0x03, 0xFC, 0x10, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x80, 0x01, 0xFE, 0xE0, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x7F, 0x00,
  0x0F, 0xDF, 0xC0, 0x03, 0xEF, 0xF0, 0x01, 0xFB, 0xFC, 0x00, 0xFC, 0xFF,
  0x00, 0x3F, 0x3F, 0xC0, 0x1F, 0x8F, 0xF0, 0x0F, 0xC3, 0xFC, 0x03, 0xF0,
  0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F, 0xF0, 0x3F, 0x03, 0xFC, 0x1F,
  0x80, 0xFF, 0x07, 0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE7, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0xFE, 0x7F, 0xF0, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFE,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF,
  0x7F, 0x80, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xCF, 0xFC, 0x7F, 0x83, 0xFC, 0xFF,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF,
  0x83, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFF, 0x01, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0x7F, 0x1F, 0xFE, 0x7E, 0x0F, 0xFE, 0x7E, 0x07, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x1E,
  0x1F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x3F, 0x9F, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0x00, 0xFF, 0x10,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x01, 0xF0, 0x7E, 0x07, 0xFF, 0xE3, 0xF1, 0xF8, 0x1F, 0xFF, 0xC3, 0xE3,
  0xF0, 0x7F, 0xFF, 0x87, 0xCF, 0xC1, 0xFF, 0xFF, 0x0F, 0xDF, 0x87, 0xF0,
  0x7E, 0x1F, 0xBF, 0x0F, 0xC0, 0xFC, 0x1F, 0x7C, 0x1F, 0x81, 0xF8, 0x3E,
  0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xF0, 0xFC, 0x07, 0xE0, 0xFF, 0xE1, 0xF8,
  0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0x1F, 0x03, 0xFF, 0x87, 0xE0, 0x3E, 0x0F,
  0xFF, 0x0F, 0xC0, 0x7C, 0x1F, 0xFE, 0x1F, 0x81, 0xF8, 0x3E, 0xFC, 0x3F,
  0x03, 0xF0, 0x7D, 0xF8, 0x3F, 0x0F, 0xF1, 0xF9, 0xF0, 0x7F, 0x3F, 0xF7,
  0xE3, 0xF0, 0xFF, 0xFB, 0xFF, 0xC7, 0xE0, 0xFF, 0xF7, 0xFF, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFC, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8,
  0x07, 0xFB, 0xFC, 0x0F, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7,
  0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3C, 0x3F, 0xE0, 0x01, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x18, 0xFF, 0xE0, 0x1E, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x0F,
  0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x1F, 0xF8, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3C, 0x3F, 0xF0, 0x00, 0x43, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF3, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1,
  0xFF, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xEF, 0xC0, 0x0F, 0xDF,
  0xFF, 0xBF, 0x00, 0x3F, 0x7F, 0xFE, 0xFC, 0x01, 0xF9, 0xFF, 0xFB, 0xF8,
  0x07, 0xE7, 0xFF, 0xE7, 0xE0, 0x1F, 0xBF, 0xFF, 0x9F, 0x80, 0xFC, 0xFF,
  0xFE, 0x7E, 0x03, 0xF3, 0xFF, 0xF8, 0xFC, 0x0F, 0xCF, 0xFF, 0xE3, 0xF0,
  0x7E, 0x3F, 0xFF, 0x8F, 0xC1, 0xF8, 0xFF, 0xFE, 0x3F, 0x87, 0xE3, 0xFF,
  0xF8, 0x7E, 0x3F, 0x8F, 0xFF, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0x87, 0xE3,
  0xF0, 0xFF, 0xFE, 0x0F, 0xCF, 0xC3, 0xFF, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF,
  0xE0, 0xFD, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xC0,
  0x3F, 0xFE, 0xFF, 0x00, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xE7, 0xF8, 0x0F,
  0xFF, 0x8F, 0xF0, 0x3F, 0xFE, 0x3F, 0xC0, 0xFF, 0xF8, 0x7F, 0x83, 0xFF,
  0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xFC, 0x3F, 0xFE, 0x07, 0xF0, 0xFF, 0xF8,
  0x1F, 0xE3, 0xFF, 0xE0, 0x3F, 0xCF, 0xFF, 0x80, 0xFF, 0x3F, 0xFE, 0x01,
  0xFE, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFF,
  0x03, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0x87, 0xF8, 0x0F,
  0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xF0,
  0x3C, 0x7F, 0x80, 0x11, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0xE0, 0x7F, 0xE3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x7F,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE7, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x3F, 0x80,
  0x3F, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xC3, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF3, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x3F, 0x07, 0xF8, 0x0F, 0xE0, 0xFC, 0xFC,
  0x1F, 0xC0, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x87, 0xE1,
  0xFC, 0x03, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0x07, 0xF1, 0xF8, 0x7E, 0x3F,
  0xC0, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x03, 0xF3, 0xF8,
  0x01, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x80,
  0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x01, 0xF7, 0xF0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x83,
  0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xC0, 0xFF,
  0x84, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFD, 0xFF, 0xF9, 0xF9, 0xFF, 0xE3,
  0xF0, 0xFF, 0x83, 0xE0, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xF8, 0x0F, 0xF3, 0xFF, 0x07,
  0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xF1, 0xFF, 0xBF, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xF7, 0xFF, 0xE3, 0xF9, 0xFF, 0xE1, 0xFC, 0x3F, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xC7, 0xCF, 0xF8,
  0x04, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x05, 0xFF, 0x80, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0x0F,
  0xF0, 0x7F, 0xE7, 0xF8, 0x7F, 0xF9, 0xFC, 0x7F, 0xFE, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0xDF, 0xF0, 0x3F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xE0, 0x7F, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFD, 0xFC, 0x3F, 0xFC,
  0xFE, 0x07, 0xF8, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x06, 0x3F, 0xF0, 0x7E, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xF8, 0xC0, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x1F,
  0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0x87, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xFC, 0x03, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xDF, 0xC7, 0xFF, 0xEF, 0xE1, 0xFF, 0xEF, 0xF0, 0x3F, 0xC7,
  0xF8, 0x01, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xA0, 0x00, 0x7F, 0x8E, 0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE1, 0xF8, 0x0F, 0xF3, 0xFF, 0x87, 0xFB, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xBF,
  0xF0, 0x3F, 0xDF, 0xF0, 0x0F, 0xEF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x08, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x00, 0x40, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x7F, 0xCF, 0xE0,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x0F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0,
  0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xE7, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFE, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xFB, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x3F, 0xF8, 0x3F,
  0xF8, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x1F, 0xFC, 0x3F, 0x9F,
  0xFF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF,
  0x8F, 0xFD, 0xFF, 0x81, 0xFE, 0xFF, 0x80, 0x7F, 0x7F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF0, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x1F, 0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xDF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0x8F, 0xFD, 0xFF,
  0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xF7, 0xFC, 0x07, 0xFB, 0xFF, 0x07,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xDF,
  0xFF, 0x1F, 0xE7, 0xFF, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x18, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xF7, 0xF1, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x87, 0xFE, 0xFF, 0x81, 0xFF, 0x7F,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xDF, 0xC7, 0xFF, 0xEF, 0xE1, 0xFF,
  0xEF, 0xF0, 0x3F, 0xC7, 0xF8, 0x01, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xE2, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0x01, 0xCF, 0xE0, 0x04, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xE3,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xBF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x07, 0xFC, 0x1F, 0x00,
  0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xCF, 0xF0, 0x1F, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F,
  0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xDF, 0x03,
  0xF8, 0x7F, 0x83, 0xEF, 0x81, 0xFC, 0x1F, 0xC3, 0xF7, 0xE1, 0xFC, 0x0F,
  0xE1, 0xFB, 0xF0, 0xFE, 0x07, 0xF0, 0xF8, 0xF8, 0x7F, 0x01, 0xFC, 0x7C,
  0x7C, 0x3F, 0x80, 0xFE, 0x3E, 0x3F, 0x3F, 0x80, 0x7F, 0x3F, 0x1F, 0x9F,
  0xC0, 0x3F, 0x9F, 0x87, 0xCF, 0xE0, 0x0F, 0xCF, 0x83, 0xE7, 0xF0, 0x07,
  0xF7, 0xC1, 0xF3, 0xF0, 0x03, 0xFB, 0xE0, 0xFB, 0xF8, 0x01, 0xFD, 0xF0,
  0x7D, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F,
  0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0xC0,
  0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC3, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x01, 0x3F,
  0xF0, 0x01, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 38, 14, 3, -37 },
  { 39, 18, 13, 24, 3, -37 },
  { 69, 29, 37, 31, 1, -37 },
  { 204, 24, 42, 28, 2, -39 },
  { 330, 41, 38, 44, 2, -38 },
  { 525, 33, 39, 35, 2, -38 },
  { 686, 7, 13, 13, 3, -37 },
  { 698, 14, 45, 17, 2, -37 },
  { 777, 14, 45, 17, 1, -37 },
  { 856, 24, 24, 26, 1, -40 },
  { 928, 24, 25, 28, 2, -31 },
  { 1003, 9, 13, 14, 2, -6 },
  { 1018, 14, 6, 16, 1, -17 },
  { 1029, 8, 9, 14, 3, -8 },
  { 1038, 21, 37, 21, 0, -37 },
  { 1136, 24, 39, 28, 2, -38 },
  { 1253, 17, 37, 28, 3, -37 },
  { 1332, 24, 38, 28, 2, -38 },
  { 1446, 24, 39, 28, 2, -38 },
  { 1563, 26, 37, 28, 1, -37 },
  { 1684, 23, 38, 28, 2, -37 },
  { 1794, 24, 39, 28, 2, -38 },
  { 1911, 25, 37, 28, 1, -37 },
  { 2027, 24, 39, 28, 2, -38 },
  { 2144, 24, 39, 28, 2, -38 },
  { 2261, 8, 30, 14, 3, -29 },
  { 2291, 9, 36, 14, 2, -29 },
  { 2332, 24, 26, 28, 2, -32 },
  { 2410, 24, 15, 28, 2, -26 },
  { 2455, 24, 26, 28, 2, -32 },
  { 2533, 22, 39, 23, 0, -38 },
  { 2641, 39, 41, 43, 2, -37 },
  { 2841, 33, 37, 33, 0, -37 },
  { 2994, 25, 37, 32, 4, -37 },
  { 3110, 26, 39, 30, 3, -38 },
  { 3237, 28, 37, 35, 4, -37 },
  { 3367, 20, 37, 27, 4, -37 },
  { 3460, 20, 37, 26, 4, -37 },
  { 3553, 28, 39, 35, 3, -38 },
  { 3690, 28, 37, 36, 4, -37 },
  { 3820, 15, 37, 19, 2, -37 },
  { 3890, 15, 48, 16, -3, -37 },
  { 3980, 28, 37, 32, 4, -37 },
  { 4110, 21, 37, 26, 4, -37 },
  { 4208, 38, 37, 46, 4, -37 },
  { 4384, 30, 37, 39, 4, -37 },
  { 4523, 32, 39, 37, 3, -38 },
  { 4679, 24, 37, 30, 4, -37 },
  { 4790, 32, 47, 37, 3, -38 },
  { 4978, 27, 37, 31, 4, -37 },
  { 5103, 22, 39, 26, 2, -38 },
  { 5211, 25, 37, 27, 1, -37 },
  { 5327, 28, 38, 36, 4, -37 },
  { 5460, 31, 37, 31, 0, -37 },
  { 5604, 46, 37, 46, 0, -37 },
  { 5817, 31, 37, 31, 0, -37 },
  { 5961, 30, 37, 30, 0, -37 },
  { 6100, 25, 37, 27, 1, -37 },
  { 6216, 13, 45, 17, 3, -37 },
  { 6290, 21, 37, 21, 0, -37 },
  { 6388, 12, 45, 17, 1, -37 },
  { 6456, 27, 23, 29, 1, -37 },
  { 6534, 21, 3, 21, 0, 5 },
  { 6542, 14, 8, 18, 2, -40 },
  { 6556, 23, 30, 29, 2, -29 },
  { 6643, 25, 41, 30, 3, -40 },
  { 6772, 21, 30, 25, 2, -29 },
  { 6851, 25, 41, 30, 2, -40 },
  { 6980, 24, 30, 28, 2, -29 },
  { 7070, 20, 40, 18, 1, -40 },
  { 7170, 25, 41, 30, 2, -29 },
  { 7299, 25, 40, 31, 3, -40 },
  { 7424, 8, 40, 15, 3, -40 },
  { 7464, 13, 52, 14, -2, -40 },
  { 7549, 26, 40, 30, 4, -40 },
  { 7679, 8, 40, 14, 3, -40 },
  { 7719, 40, 29, 46, 3, -29 },
  { 7864, 25, 29, 31, 3, -29 },
  { 7955, 26, 30, 30, 2, -29 },
  { 8053, 25, 41, 30, 3, -29 },
  { 8182, 25, 41, 30, 2, -29 },
  { 8311, 18, 29, 21, 3, -29 },
  { 8377, 20, 30, 24, 2, -29 },
  { 8452, 18, 35, 21, 1, -34 },
  { 8531, 24, 29, 31, 3, -28 },
  { 8618, 27, 28, 27, 0, -28 },
  { 8713, 41, 28, 41, 0, -28 },
  { 8857, 27, 28, 27, 0, -28 },
  { 8952, 27, 40, 27, 0, -28 },
  { 9087, 21, 28, 23, 1, -28 },
  { 9161, 17, 45, 20, 1, -37 },
  { 9257, 6, 52, 27, 10, -40 },
  { 9296, 17, 45, 20, 2, -37 },
  { 9392, 24, 9, 28, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Bold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD52PT7B_H_
