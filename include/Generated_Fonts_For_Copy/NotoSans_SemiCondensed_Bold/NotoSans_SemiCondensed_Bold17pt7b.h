#ifndef _NOTOSANS_SEMICONDENSED_BOLD17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0x0B, 0xF0, 0xCF, 0x3C, 0xF3, 0x09, 0x86, 0x41,
  0xB1, 0xFF, 0x7F, 0xC4, 0xC3, 0x23, 0xFE, 0xFF, 0x8D, 0x83, 0x60, 0x98,
  0x10, 0x7B, 0xFF, 0xBD, 0x1E, 0x1E, 0x0F, 0x17, 0x2F, 0xFF, 0xE1, 0x02,
  0x00, 0xF0, 0xC6, 0xCC, 0x26, 0x61, 0x36, 0x09, 0xB0, 0x6D, 0x7B, 0xDB,
  0x60, 0x9B, 0x0C, 0x98, 0x46, 0xC6, 0x36, 0x60, 0xE0, 0x7C, 0x0F, 0xC1,
  0x98, 0x37, 0x07, 0xC0, 0xF0, 0x3F, 0x76, 0x6C, 0xC7, 0x98, 0xE3, 0xFE,
  0x3E, 0xF0, 0xFF, 0x36, 0x6C, 0xCC, 0xCC, 0xCC, 0xCE, 0x66, 0x30, 0xE3,
  0x8C, 0x63, 0x8C, 0x63, 0x18, 0xCC, 0x63, 0x33, 0x80, 0x18, 0x18, 0x4B,
  0xFF, 0x1C, 0x3E, 0x76, 0x14, 0x10, 0x20, 0x47, 0xFF, 0xE2, 0x04, 0x08,
  0xFB, 0x60, 0xFF, 0xFE, 0x5F, 0x80, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0C,
  0x18, 0x70, 0xC1, 0x87, 0x00, 0x7D, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xDF, 0xFB, 0xE0, 0x1C, 0xF7, 0xF7, 0x5C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x7D, 0xFE, 0x18, 0x30, 0xE1, 0x87, 0x1C, 0x71, 0xC3, 0xFF, 0xF0,
  0xFD, 0xFE, 0x18, 0x30, 0xCF, 0x1F, 0x83, 0x07, 0x1F, 0xFF, 0xE0, 0x06,
  0x07, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0x99, 0x8C, 0xFF, 0xFF, 0xC1, 0x80,
  0xC0, 0xFF, 0xFF, 0x86, 0x0F, 0x9F, 0xE3, 0x83, 0x07, 0x1F, 0xFF, 0xE0,
  0x3E, 0xFF, 0x86, 0x0D, 0xDF, 0xF9, 0xE3, 0xC7, 0x8F, 0xFB, 0xE0, 0xFF,
  0xFF, 0x03, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x7D,
  0xFF, 0x1E, 0x3E, 0xC7, 0x1F, 0x67, 0xC7, 0x8F, 0xFB, 0xE0, 0x7D, 0xFF,
  0x1E, 0x3C, 0x79, 0xFF, 0xBB, 0x06, 0x1F, 0xF7, 0xC0, 0xFC, 0x00, 0x17,
  0xE0, 0xFC, 0x00, 0x07, 0xDB, 0x00, 0x02, 0x3D, 0xE7, 0x0E, 0x07, 0x83,
  0x81, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0xC1, 0xE0, 0xF0, 0x70, 0xEF,
  0x38, 0x40, 0xFD, 0xFE, 0x18, 0x30, 0xE3, 0x8E, 0x18, 0x00, 0x20, 0xE1,
  0x80, 0x1F, 0xC3, 0x8E, 0x60, 0x3C, 0xFB, 0xDD, 0x9D, 0x99, 0xD9, 0x9D,
  0x9B, 0xDB, 0xBC, 0xEE, 0x60, 0x07, 0x0C, 0x3F, 0xC0, 0x0E, 0x03, 0xC0,
  0x6C, 0x0D, 0x83, 0xB0, 0x67, 0x0C, 0x63, 0xFC, 0x7F, 0xCC, 0x3B, 0x83,
  0x70, 0x70, 0xFE, 0x7F, 0xB8, 0xDC, 0x6E, 0x77, 0xF3, 0xFD, 0xC7, 0xE3,
  0xF1, 0xFF, 0xDF, 0xC0, 0x3F, 0x7F, 0x71, 0xE0, 0xE0, 0xC0, 0xC0, 0xE0,
  0xE0, 0x71, 0x7F, 0x3F, 0xFE, 0x3F, 0xCE, 0x3B, 0x86, 0xE1, 0xB8, 0x7E,
  0x1B, 0x86, 0xE3, 0xB9, 0xEF, 0xF3, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F,
  0xFF, 0xF0, 0xE1, 0xC3, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF,
  0xF0, 0xE1, 0xC3, 0x87, 0x00, 0x1F, 0xBF, 0xDC, 0x1C, 0x0E, 0x06, 0x3F,
  0x1F, 0xC3, 0xE1, 0xB8, 0xDF, 0xE7, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFD, 0xE3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0xBF, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0xFF, 0xD8, 0xE3, 0xF3, 0xB9, 0xDD, 0xCF, 0xC7, 0xE3,
  0xF1, 0xDC, 0xE6, 0x73, 0xB8, 0xFC, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xF1,
  0xFF, 0x8F, 0xFC, 0xDF, 0xB6, 0xFD, 0xB7, 0xED, 0x3F, 0x39, 0xF9, 0xCF,
  0xCE, 0x70, 0xF0, 0xFC, 0x3F, 0x8F, 0xE3, 0xFC, 0xFB, 0x3E, 0xEF, 0x9B,
  0xE7, 0xF8, 0xFE, 0x3F, 0x87, 0x3F, 0x1F, 0xEE, 0x1F, 0x87, 0xE0, 0xF0,
  0x3C, 0x0F, 0x83, 0xE1, 0xDC, 0x77, 0xF8, 0xFC, 0xFE, 0xFF, 0xE7, 0xE3,
  0xE7, 0xEF, 0xFE, 0xF8, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x1F, 0xEE, 0x1F,
  0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x83, 0xE1, 0xDC, 0x77, 0xF8, 0xFC, 0x07,
  0x00, 0xE0, 0x1C, 0xFE, 0x7F, 0xB9, 0xDC, 0x6E, 0x77, 0xFB, 0xF1, 0xDC,
  0xE6, 0x73, 0xB8, 0xDC, 0x70, 0x7F, 0xFF, 0x0E, 0x0E, 0x0F, 0x0F, 0x07,
  0x0F, 0x1F, 0xF7, 0xC0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xB1, 0xDF, 0xE7, 0xE0, 0xE0, 0xD8, 0x76, 0x19,
  0x86, 0x73, 0x8C, 0xC3, 0x30, 0xEC, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0xC3,
  0x87, 0xC7, 0x1D, 0x8E, 0x3B, 0x16, 0x66, 0x6C, 0xCE, 0xDB, 0x9D, 0xB7,
  0x1B, 0x6C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0xE3, 0x80, 0xE1, 0xDC,
  0xE3, 0x30, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x1C, 0xE7, 0x1B,
  0x87, 0xE1, 0xD8, 0xE7, 0x30, 0xDC, 0x3E, 0x07, 0x81, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38,
  0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0,
  0xE0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xF0, 0x0C, 0x0E, 0x07, 0x86, 0xC3,
  0x33, 0x19, 0x87, 0x83, 0xFE, 0xE6, 0x30, 0xFE, 0xDC, 0x19, 0xFF, 0xF8,
  0xF1, 0xFF, 0xF6, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3,
  0xE3, 0xE7, 0xFF, 0xDE, 0x7F, 0xFB, 0x86, 0x0C, 0x18, 0x38, 0xFE, 0x7C,
  0x07, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF,
  0x7B, 0x7C, 0xE6, 0xC6, 0xFF, 0xFF, 0xC0, 0xE0, 0x7E, 0x3E, 0x1E, 0x78,
  0xC1, 0x8F, 0xDF, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x7B, 0xFF,
  0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x07, 0x87, 0xFE, 0xFC, 0xE0,
  0xE0, 0xE0, 0xE0, 0xDE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xDD, 0x0F, 0xFF, 0xFF, 0xFE, 0x31, 0xC4, 0x03, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFE, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x77, 0x73, 0xB1,
  0xF0, 0xFC, 0x76, 0x3B, 0x9C, 0xEE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xDE, 0xF7, 0xFF, 0xF9, 0xC7, 0xCE, 0x3E, 0x71, 0xF3, 0x8F, 0x9C, 0x7C,
  0xE3, 0xE7, 0x18, 0xDE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0x7E, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xE7, 0x7E, 0x3C, 0xDE, 0xFF, 0xE7,
  0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x7B, 0xFF,
  0xC7, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xDF,
  0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0xFF, 0x3C, 0x3C, 0x7C, 0x78, 0xFF,
  0xF8, 0x30, 0xCF, 0xFF, 0x71, 0xC7, 0x1C, 0x70, 0xF3, 0xC0, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0xFF, 0x7B, 0xE3, 0xB1, 0x98, 0xCE, 0xE3,
  0x61, 0xB0, 0xF8, 0x38, 0x1C, 0x00, 0xE7, 0x1B, 0x38, 0xD9, 0xEE, 0xCB,
  0x67, 0xDB, 0x1E, 0x58, 0xF3, 0xC7, 0x1C, 0x38, 0xE0, 0xE3, 0xBB, 0x8F,
  0x87, 0x81, 0xC1, 0xF0, 0xD8, 0xEE, 0xE3, 0x80, 0xE3, 0xB1, 0x98, 0xCE,
  0xE3, 0x61, 0xB0, 0xF8, 0x38, 0x1C, 0x0E, 0x06, 0x0F, 0x07, 0x00, 0x7E,
  0xFC, 0x30, 0xE3, 0x86, 0x1C, 0x7F, 0xFE, 0x1C, 0xF3, 0x0C, 0x30, 0xCF,
  0x38, 0x30, 0xC3, 0x0C, 0x38, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE7, 0x18, 0xC6, 0x31, 0xE7, 0x73, 0x18, 0xC6, 0x73, 0x00, 0xFB, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 6, 4, 8, 1, -12 },
  { 9, 10, 12, 10, 0, -12 },
  { 24, 7, 14, 9, 1, -13 },
  { 37, 13, 12, 15, 1, -12 },
  { 57, 11, 12, 12, 1, -12 },
  { 74, 2, 4, 4, 1, -12 },
  { 75, 4, 15, 6, 1, -12 },
  { 83, 5, 15, 6, 0, -12 },
  { 93, 8, 8, 9, 0, -13 },
  { 101, 7, 8, 9, 1, -10 },
  { 108, 3, 4, 5, 1, -2 },
  { 110, 5, 3, 5, 0, -6 },
  { 112, 3, 3, 5, 1, -3 },
  { 114, 7, 12, 7, 0, -12 },
  { 125, 7, 12, 9, 1, -12 },
  { 136, 6, 12, 9, 1, -12 },
  { 145, 7, 12, 9, 1, -12 },
  { 156, 7, 12, 9, 1, -12 },
  { 167, 9, 12, 9, 0, -12 },
  { 181, 7, 12, 9, 1, -12 },
  { 192, 7, 12, 9, 1, -12 },
  { 203, 8, 12, 9, 0, -12 },
  { 215, 7, 12, 9, 1, -12 },
  { 226, 7, 12, 9, 1, -12 },
  { 237, 3, 9, 5, 1, -9 },
  { 241, 3, 11, 5, 1, -9 },
  { 246, 7, 8, 9, 1, -10 },
  { 253, 7, 6, 9, 1, -9 },
  { 259, 7, 8, 9, 1, -10 },
  { 266, 7, 12, 7, 0, -12 },
  { 277, 12, 13, 14, 1, -12 },
  { 297, 11, 12, 11, 0, -12 },
  { 314, 9, 12, 10, 1, -12 },
  { 328, 8, 12, 10, 1, -12 },
  { 340, 10, 12, 11, 1, -12 },
  { 355, 7, 12, 9, 1, -12 },
  { 366, 7, 12, 9, 1, -12 },
  { 377, 9, 12, 11, 1, -12 },
  { 391, 10, 12, 12, 1, -12 },
  { 406, 6, 12, 6, 0, -12 },
  { 415, 5, 16, 5, -1, -12 },
  { 425, 9, 12, 10, 1, -12 },
  { 439, 7, 12, 9, 1, -12 },
  { 450, 13, 12, 15, 1, -12 },
  { 470, 10, 12, 13, 1, -12 },
  { 485, 10, 12, 12, 1, -12 },
  { 500, 8, 12, 10, 1, -12 },
  { 512, 10, 15, 12, 1, -12 },
  { 531, 9, 12, 10, 1, -12 },
  { 545, 7, 12, 9, 1, -12 },
  { 556, 9, 12, 9, 0, -12 },
  { 570, 9, 12, 12, 1, -12 },
  { 584, 10, 12, 10, 0, -12 },
  { 599, 15, 12, 15, 0, -12 },
  { 622, 10, 12, 10, 0, -12 },
  { 637, 10, 12, 10, 0, -12 },
  { 652, 8, 12, 9, 0, -12 },
  { 664, 4, 15, 6, 1, -12 },
  { 672, 7, 12, 7, 0, -12 },
  { 683, 4, 15, 6, 0, -12 },
  { 691, 9, 8, 9, 0, -12 },
  { 700, 7, 1, 7, 0, 2 },
  { 701, 4, 3, 6, 1, -13 },
  { 703, 7, 9, 9, 1, -9 },
  { 711, 8, 13, 10, 1, -13 },
  { 724, 7, 9, 8, 1, -9 },
  { 732, 8, 13, 10, 1, -13 },
  { 745, 8, 9, 9, 1, -9 },
  { 754, 7, 13, 6, 0, -13 },
  { 766, 8, 13, 10, 1, -9 },
  { 779, 8, 13, 10, 1, -13 },
  { 792, 3, 13, 5, 1, -13 },
  { 797, 5, 17, 5, -1, -13 },
  { 808, 9, 13, 10, 1, -13 },
  { 823, 3, 13, 5, 1, -13 },
  { 828, 13, 9, 15, 1, -9 },
  { 843, 8, 9, 10, 1, -9 },
  { 852, 8, 9, 10, 1, -9 },
  { 861, 8, 13, 10, 1, -9 },
  { 874, 8, 13, 10, 1, -9 },
  { 887, 6, 9, 7, 1, -9 },
  { 894, 6, 9, 8, 1, -9 },
  { 901, 6, 11, 7, 0, -11 },
  { 910, 8, 9, 10, 1, -9 },
  { 919, 9, 9, 9, 0, -9 },
  { 930, 13, 9, 13, 0, -9 },
  { 945, 9, 9, 9, 0, -9 },
  { 956, 9, 13, 9, 0, -9 },
  { 971, 7, 9, 8, 0, -9 },
  { 979, 6, 15, 6, 0, -12 },
  { 991, 2, 17, 9, 3, -13 },
  { 996, 5, 15, 6, 1, -12 },
  { 1006, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Bold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD17PT7B_H_
