#ifndef _NOTOSANS_SEMICONDENSED_BOLD15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF7, 0xB0, 0x1B, 0x0D, 0x04, 0x8F, 0xF7,
  0xF9, 0xB0, 0xD1, 0xFE, 0x24, 0x16, 0x1B, 0x00, 0x11, 0xFE, 0xF4, 0xE1,
  0xE1, 0xC7, 0x9F, 0xF1, 0x04, 0x30, 0xC7, 0x88, 0x59, 0x8C, 0x90, 0x5B,
  0x67, 0xAF, 0x36, 0x90, 0x49, 0x0C, 0x90, 0x8F, 0x18, 0xF0, 0x38, 0x3E,
  0x33, 0x1D, 0x87, 0x83, 0x8F, 0x6D, 0xBE, 0xCE, 0x7F, 0x9E, 0xE0, 0xFF,
  0x36, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x70, 0xC6, 0x23, 0x33, 0x33, 0x33,
  0x36, 0xE0, 0x19, 0x37, 0xF8, 0xC3, 0xCD, 0x80, 0x30, 0xC3, 0x3F, 0xFC,
  0xC3, 0x00, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x31, 0x86, 0x10, 0xC3, 0x18,
  0x61, 0x8C, 0x00, 0x7B, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xF7, 0x80,
  0x19, 0xDF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x7B, 0xF8, 0xC3, 0x0C, 0x63,
  0x9C, 0xE3, 0xFF, 0xC0, 0x7B, 0xF8, 0xC3, 0x19, 0xC1, 0xC3, 0x0F, 0xFF,
  0x80, 0x0E, 0x0E, 0x1E, 0x1E, 0x3E, 0x6E, 0x4E, 0xFF, 0xFF, 0x0E, 0x0E,
  0xFF, 0xFC, 0x30, 0xFB, 0xF0, 0xC3, 0x0F, 0xFF, 0x80, 0x1E, 0x7D, 0xC3,
  0x07, 0xCF, 0xF9, 0xB3, 0x66, 0xFC, 0xF0, 0xFF, 0xFC, 0x18, 0x30, 0xC1,
  0x87, 0x0C, 0x18, 0x60, 0xC0, 0x3C, 0xFD, 0x9B, 0x37, 0xE7, 0x9F, 0xB3,
  0xE6, 0xFC, 0xF0, 0x38, 0xFD, 0x9F, 0x3E, 0x6D, 0xDF, 0x83, 0x06, 0xF9,
  0xE0, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x78, 0x04, 0x77, 0x30, 0xF0, 0xF0,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x83, 0x83, 0x3F, 0xCC, 0x00, 0x7B,
  0xF8, 0xC3, 0x1C, 0xE3, 0x0C, 0x00, 0xC3, 0x00, 0x0F, 0x07, 0xF1, 0x83,
  0x67, 0xBD, 0xB7, 0x26, 0xEC, 0xDC, 0x9B, 0xDD, 0xD8, 0x01, 0x84, 0x1F,
  0x80, 0x1C, 0x0E, 0x07, 0x86, 0xC3, 0x61, 0x99, 0xCC, 0xFE, 0x63, 0xF0,
  0xF8, 0x60, 0xF8, 0xFE, 0xC6, 0xC6, 0xCE, 0xFC, 0xC6, 0xC7, 0xC6, 0xFE,
  0xFC, 0x1E, 0xFF, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xFC, 0xF8, 0xF8,
  0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xFF, 0xFC,
  0x30, 0xC3, 0xFC, 0x30, 0xC3, 0xFF, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0xFF,
  0xF0, 0xC3, 0x0C, 0x00, 0x1E, 0x7F, 0x61, 0xE0, 0xC0, 0xCF, 0xCF, 0xC3,
  0xE3, 0x7F, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFF, 0xCC, 0x63, 0x18, 0xC6, 0x33, 0xBE, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFE, 0xC3, 0xC6, 0xCE, 0xDC, 0xD8, 0xF8, 0xFC, 0xCC,
  0xCE, 0xC6, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0,
  0xE0, 0xFE, 0x1F, 0xC7, 0xF8, 0xFD, 0x17, 0xB6, 0xF6, 0xDE, 0x53, 0xCE,
  0x79, 0xCF, 0x39, 0x80, 0xE1, 0xF8, 0xFC, 0x7F, 0x3D, 0x9E, 0xEF, 0x37,
  0x9F, 0xC7, 0xE3, 0xF0, 0xE0, 0x3C, 0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F,
  0x07, 0x87, 0xE3, 0xBF, 0x8F, 0x80, 0xF9, 0xFB, 0x3E, 0x3C, 0x7F, 0xFF,
  0x60, 0xC1, 0x83, 0x00, 0x3C, 0x3F, 0xB8, 0xD8, 0x7C, 0x1E, 0x0F, 0x07,
  0x87, 0xE3, 0xBF, 0x8F, 0x80, 0xC0, 0x70, 0x1C, 0xF8, 0xFE, 0xC6, 0xC6,
  0xC6, 0xFC, 0xF8, 0xCC, 0xCE, 0xC6, 0xC7, 0x7B, 0xFC, 0x70, 0xE1, 0xE3,
  0xC3, 0x8F, 0xFF, 0x80, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3,
  0x7F, 0x3E, 0xC1, 0xE1, 0xD8, 0xCC, 0x66, 0x31, 0xB0, 0xD8, 0x6C, 0x14,
  0x0E, 0x07, 0x00, 0xC3, 0x1E, 0x38, 0xF9, 0xC6, 0xCE, 0x76, 0x5B, 0x36,
  0xD9, 0xB6, 0xC7, 0x96, 0x3C, 0xA1, 0xC7, 0x0E, 0x38, 0xE3, 0xB1, 0x9D,
  0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x6C, 0x76, 0x31, 0xB8, 0xE0, 0xC3, 0xB1,
  0x99, 0x86, 0xC3, 0xE1, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x00, 0xFF,
  0xFC, 0x18, 0x61, 0xC3, 0x0C, 0x18, 0x61, 0xFF, 0xF8, 0xFF, 0x6D, 0xB6,
  0xDB, 0x6E, 0xC1, 0x86, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x20, 0xC0, 0xFF,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x18, 0x3C, 0x3C, 0x26, 0x66,
  0xC3, 0xFC, 0xE3, 0xFD, 0x30, 0xDF, 0xCF, 0x3D, 0xFD, 0xC1, 0x83, 0x07,
  0xEE, 0xF8, 0xF1, 0xE3, 0xC7, 0xFF, 0x70, 0x7F, 0xAC, 0x30, 0xC3, 0x0F,
  0xDF, 0x06, 0x0C, 0x1B, 0xBE, 0xF8, 0xF1, 0xE3, 0xC7, 0xFD, 0xD8, 0x7D,
  0x9B, 0x1F, 0xFC, 0x18, 0x3F, 0x3E, 0x3D, 0xC6, 0x3E, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x00, 0x77, 0xDF, 0x1E, 0x3C, 0x78, 0xFF, 0xBB, 0x07, 0x1F,
  0xF1, 0x80, 0xC1, 0x83, 0x07, 0xEE, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x18,
  0xF3, 0xFF, 0xFC, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x40, 0xC0,
  0xC0, 0xC0, 0xCE, 0xCC, 0xD8, 0xF8, 0xF8, 0xCC, 0xCE, 0xC7, 0xFF, 0xFF,
  0xFC, 0xFD, 0xFD, 0xEF, 0x19, 0xE3, 0x3C, 0x67, 0x8C, 0xF1, 0x9E, 0x33,
  0xFD, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D, 0xDB, 0x1E, 0x3C, 0x78,
  0xFF, 0x3C, 0xFD, 0xDF, 0x1E, 0x3C, 0x78, 0xFF, 0xEE, 0xC1, 0x83, 0x06,
  0x00, 0x77, 0xDF, 0x1E, 0x3C, 0x78, 0xFF, 0xBB, 0x06, 0x0C, 0x18, 0x30,
  0xDF, 0xF9, 0x8C, 0x63, 0x18, 0xFE, 0x71, 0xE3, 0x8F, 0xFE, 0x20, 0x8F,
  0x98, 0x61, 0x86, 0x18, 0x7C, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF,
  0xBB, 0xC7, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C, 0x18, 0xC6, 0x76, 0xE6,
  0x6F, 0x66, 0xB6, 0x69, 0x62, 0x9C, 0x39, 0xC3, 0x9C, 0xE7, 0x6E, 0x3C,
  0x38, 0x3C, 0x3C, 0x66, 0xE7, 0xC7, 0x66, 0x66, 0x66, 0x3C, 0x3C, 0x3C,
  0x18, 0x18, 0x38, 0x70, 0x40, 0x7D, 0xF1, 0x8E, 0x31, 0x87, 0xFF, 0x19,
  0xCC, 0x63, 0x1B, 0x9E, 0x31, 0x8C, 0x63, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0xCE, 0x66, 0x66, 0x77, 0x66, 0x66, 0xC0, 0x47, 0xF9, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Bold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 9, 11, 9, 0, -11 },
  { 20, 6, 12, 8, 1, -11 },
  { 29, 12, 11, 13, 0, -11 },
  { 46, 9, 11, 10, 1, -11 },
  { 59, 2, 4, 4, 1, -11 },
  { 60, 4, 13, 5, 1, -11 },
  { 67, 4, 13, 5, 0, -11 },
  { 74, 7, 6, 8, 0, -11 },
  { 80, 6, 7, 8, 1, -9 },
  { 86, 3, 4, 4, 0, -2 },
  { 88, 4, 2, 5, 0, -5 },
  { 89, 2, 2, 4, 1, -2 },
  { 90, 6, 11, 6, 0, -11 },
  { 99, 6, 11, 8, 1, -11 },
  { 108, 5, 11, 8, 1, -11 },
  { 115, 6, 11, 8, 1, -11 },
  { 124, 6, 11, 8, 1, -11 },
  { 133, 8, 11, 8, 0, -11 },
  { 144, 6, 11, 8, 1, -11 },
  { 153, 7, 11, 8, 0, -11 },
  { 163, 7, 11, 8, 0, -11 },
  { 173, 7, 11, 8, 0, -11 },
  { 183, 7, 11, 8, 0, -11 },
  { 193, 2, 8, 4, 1, -8 },
  { 195, 3, 10, 4, 0, -8 },
  { 199, 6, 7, 8, 1, -9 },
  { 205, 6, 5, 8, 1, -8 },
  { 209, 6, 7, 8, 1, -9 },
  { 215, 6, 11, 7, 0, -11 },
  { 224, 11, 12, 13, 1, -11 },
  { 241, 9, 11, 9, 0, -11 },
  { 254, 8, 11, 9, 1, -11 },
  { 265, 7, 11, 9, 1, -11 },
  { 275, 8, 11, 10, 1, -11 },
  { 286, 6, 11, 8, 1, -11 },
  { 295, 6, 11, 8, 1, -11 },
  { 304, 8, 11, 10, 1, -11 },
  { 315, 8, 11, 11, 1, -11 },
  { 326, 5, 11, 5, 0, -11 },
  { 333, 4, 14, 5, -1, -11 },
  { 340, 8, 11, 9, 1, -11 },
  { 351, 6, 11, 8, 1, -11 },
  { 360, 11, 11, 13, 1, -11 },
  { 376, 9, 11, 11, 1, -11 },
  { 389, 9, 11, 11, 1, -11 },
  { 402, 7, 11, 9, 1, -11 },
  { 412, 9, 14, 11, 1, -11 },
  { 428, 8, 11, 9, 1, -11 },
  { 439, 6, 11, 8, 1, -11 },
  { 448, 8, 11, 8, 0, -11 },
  { 459, 8, 11, 10, 1, -11 },
  { 470, 9, 11, 9, 0, -11 },
  { 483, 13, 11, 13, 0, -11 },
  { 501, 9, 11, 9, 0, -11 },
  { 514, 9, 11, 9, 0, -11 },
  { 527, 7, 11, 8, 0, -11 },
  { 537, 3, 13, 5, 1, -11 },
  { 542, 6, 11, 6, 0, -11 },
  { 551, 4, 13, 5, 0, -11 },
  { 558, 8, 7, 8, 0, -11 },
  { 565, 6, 1, 6, 0, 1 },
  { 566, 4, 2, 5, 1, -11 },
  { 567, 6, 8, 8, 1, -8 },
  { 573, 7, 11, 9, 1, -11 },
  { 583, 6, 8, 7, 1, -8 },
  { 589, 7, 11, 9, 1, -11 },
  { 599, 7, 8, 8, 1, -8 },
  { 606, 6, 11, 5, 0, -11 },
  { 615, 7, 12, 9, 1, -8 },
  { 626, 7, 11, 9, 1, -11 },
  { 636, 2, 11, 4, 1, -11 },
  { 639, 4, 15, 4, -1, -11 },
  { 647, 8, 11, 9, 1, -11 },
  { 658, 2, 11, 4, 1, -11 },
  { 661, 11, 8, 13, 1, -8 },
  { 672, 7, 8, 9, 1, -8 },
  { 679, 7, 8, 9, 1, -8 },
  { 686, 7, 12, 9, 1, -8 },
  { 697, 7, 12, 9, 1, -8 },
  { 708, 5, 8, 6, 1, -8 },
  { 713, 5, 8, 7, 1, -8 },
  { 718, 6, 10, 6, 0, -10 },
  { 726, 7, 8, 9, 1, -8 },
  { 733, 8, 8, 8, 0, -8 },
  { 741, 12, 8, 12, 0, -8 },
  { 753, 8, 8, 8, 0, -8 },
  { 761, 8, 12, 8, 0, -8 },
  { 773, 6, 8, 7, 0, -8 },
  { 779, 5, 13, 6, 0, -11 },
  { 788, 2, 14, 8, 3, -11 },
  { 792, 4, 13, 6, 1, -11 },
  { 799, 6, 3, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Bold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD15PT7B_H_
