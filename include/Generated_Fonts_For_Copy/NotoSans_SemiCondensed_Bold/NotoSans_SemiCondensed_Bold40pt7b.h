#ifndef _NOTOSANS_SEMICONDENSED_BOLD40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xFD, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0x7C, 0x7D,
  0xF1, 0xF7, 0xC7, 0xDE, 0x1F, 0x78, 0x7D, 0xE1, 0xF7, 0x87, 0xC0, 0x01,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x03, 0xC7, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x03, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x3F, 0xF8, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0xFB,
  0x3C, 0xFC, 0xC1, 0x3E, 0x30, 0x0F, 0xCC, 0x03, 0xFB, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0x7F, 0x00, 0xCF, 0xC0, 0x33, 0xFC, 0x0C, 0xFF, 0xE3,
  0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F,
  0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x7F, 0xF0, 0x1F, 0x00, 0x78,
  0xF0, 0x1E, 0x00, 0x78, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x3C, 0x00, 0xF8,
  0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0xF0, 0x00, 0xF8, 0xF9, 0xF0, 0x40, 0x78, 0xF9, 0xE3, 0xF8, 0x78,
  0xF3, 0xE7, 0xFC, 0x7F, 0xF3, 0xCF, 0xFE, 0x3F, 0xE7, 0xCF, 0xBE, 0x1F,
  0xE7, 0x8F, 0x1E, 0x0F, 0x8F, 0x9F, 0x1F, 0x00, 0x0F, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1F, 0x00,
  0x3C, 0x1F, 0x1F, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x78, 0x0F, 0x1E, 0x00,
  0xF8, 0x0F, 0xBE, 0x00, 0xF0, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x01,
  0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x81, 0xF8, 0xFF, 0xF0, 0x7E, 0x3F, 0xFE, 0x3F, 0x1F, 0xDF,
  0xCF, 0xC7, 0xE3, 0xFB, 0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFE, 0x3F,
  0x01, 0xFF, 0x0F, 0xE0, 0x7F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xFE, 0x07, 0xFE,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x80, 0x07,
  0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x41, 0xE0, 0x9E, 0x79, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xBC, 0x07, 0xCF, 0x83, 0xF1,
  0xF0, 0x78, 0x78, 0x06, 0x08, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFB, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7E, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7,
  0xC0, 0x7C, 0xFC, 0x1F, 0x9F, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0xBF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x03,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xBF, 0xFC,
  0xFD, 0xE3, 0xF3, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x7C, 0x3F, 0x8E, 0x03, 0xF0, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x07,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x3F, 0x84,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFE, 0xFC, 0x7F, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0x9F, 0x00, 0xF9, 0xF0,
  0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFB, 0x00,
  0xFE, 0xFD, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x40, 0x3E, 0x7F, 0x87, 0xDF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xF8, 0x7E, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x3F, 0xBF,
  0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xFC, 0xFC, 0x1F, 0x9F, 0x81, 0xF3,
  0xF0, 0x3E, 0x7E, 0x0F, 0xC7, 0xC1, 0xF8, 0xFC, 0x7E, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xE3, 0xF9, 0xF8, 0x3F, 0x3E, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFC, 0x3F, 0x9F, 0x83, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xDF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC,
  0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFE, 0xFC, 0x3F,
  0x9F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x20, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x3E, 0x7F, 0x7F,
  0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF1, 0xC1, 0xFC, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x3C, 0x3C, 0x0F, 0xF8, 0xF9, 0xF0, 0xFF, 0xF1, 0xE7, 0x87,
  0xFF, 0xC7, 0x9E, 0x3F, 0x1F, 0x1E, 0xF8, 0xF8, 0x7C, 0x7B, 0xC3, 0xC1,
  0xF1, 0xFF, 0x1F, 0x07, 0xC7, 0xFC, 0x7C, 0x1E, 0x1F, 0xF1, 0xF0, 0x78,
  0x7B, 0xC7, 0xC1, 0xE1, 0xEF, 0x1F, 0x07, 0x87, 0xBC, 0x7C, 0x3E, 0x1E,
  0xF0, 0xF8, 0xFC, 0xF3, 0xC3, 0xFF, 0xFF, 0xCF, 0x87, 0xFD, 0xFE, 0x1E,
  0x0F, 0xE3, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0x80, 0x0F, 0xF8, 0x7E, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7,
  0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC0, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xF8, 0xFF, 0xA0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFC, 0x7F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x0E, 0x3F, 0x80, 0x27, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x02, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0xFF, 0xCF, 0xC0,
  0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F, 0x07, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x81, 0xC3, 0xF8, 0x01, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xE0,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0,
  0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFB, 0xF0, 0x3F,
  0x9F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0x00, 0xFD, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x78, 0x03, 0xDF, 0xFB, 0xE0, 0x3E, 0xFF,
  0xDF, 0x01, 0xF7, 0xFE, 0xF8, 0x0F, 0xBF, 0xF3, 0xC0, 0x79, 0xFF, 0x9F,
  0x07, 0xDF, 0xFE, 0xF8, 0x3E, 0xFF, 0xF3, 0xC1, 0xE7, 0xFF, 0x9F, 0x1F,
  0x3F, 0xFC, 0xF8, 0xF9, 0xFF, 0xE7, 0xC7, 0x8F, 0xFF, 0x1E, 0x7C, 0x7F,
  0xF8, 0xFB, 0xE3, 0xFF, 0xC7, 0xDE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF, 0xF0,
  0xFF, 0x87, 0xFF, 0x87, 0xF8, 0x3F, 0xFC, 0x3F, 0xC1, 0xFF, 0xE0, 0xFE,
  0x0F, 0xFF, 0x07, 0xF0, 0x7F, 0xF8, 0x3F, 0x03, 0xFF, 0xC0, 0xF8, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFB, 0xF0, 0x3F, 0xFB, 0xF0, 0x3F, 0xF9, 0xF8, 0x3F, 0xF9, 0xF8,
  0x3F, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x3F, 0x3F, 0xFC, 0x1F, 0xBF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF,
  0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03,
  0xF9, 0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF1,
  0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0,
  0x03, 0xF9, 0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E,
  0x1F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x81,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xE7,
  0xFF, 0xF7, 0xF0, 0x73, 0xF0, 0x09, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7E, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3E, 0xFC, 0x01, 0xF8, 0x07, 0xE7,
  0xC0, 0x3F, 0x80, 0x7E, 0x7C, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0xC0,
  0x7C, 0x7E, 0x03, 0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0xC0, 0xFC, 0x3E, 0x07,
  0xFC, 0x0F, 0xC3, 0xE0, 0x7B, 0xE0, 0xFC, 0x3F, 0x07, 0xBE, 0x0F, 0x83,
  0xF0, 0xFB, 0xE1, 0xF8, 0x1F, 0x0F, 0xBE, 0x1F, 0x81, 0xF0, 0xF9, 0xE1,
  0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x01, 0xF9, 0xF1, 0xF1, 0xF0, 0x0F, 0x9F,
  0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0xF3, 0xF0, 0x0F, 0x9F, 0x0F, 0xBE, 0x00,
  0xFD, 0xE0, 0xFB, 0xE0, 0x07, 0xFE, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x7B,
  0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E,
  0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xE7, 0xE0,
  0x0F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x07,
  0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83,
  0xE0, 0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0E, 0x1F,
  0xC2, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7F, 0xC3, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x07, 0xDF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xDF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xF3,
  0xC7, 0xF8, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFC,
  0x1F, 0x3F, 0xE3, 0xEF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x3F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFE, 0x0F, 0xDF, 0xE7, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xBF, 0xF1,
  0xE3, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F,
  0xFE, 0x7E, 0x02, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x02, 0x7F, 0x9E, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xE3,
  0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0x3E, 0x1F, 0xC7, 0xC0, 0x07,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x9F, 0xC0, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x60, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xF0,
  0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x0F, 0xE3, 0xE3, 0xFE, 0x7C, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFB, 0xFF,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1,
  0xFF, 0x7E, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC8,
  0x01, 0xF9, 0xC0, 0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0xFE,
  0x3E, 0xFF, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0,
  0x7C, 0xFF, 0xFB, 0xF7, 0xC0, 0x00, 0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x80, 0x07, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xFA, 0x3F, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xC1, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC,
  0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x0F,
  0x9F, 0x80, 0xFB, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xFE, 0x0F, 0xE3,
  0xCF, 0xFC, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0x80, 0xFC,
  0x0F, 0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0x03,
  0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF,
  0xE0, 0x3F, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x3F, 0xF8,
  0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0xF0, 0xFE, 0x3C, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xF9, 0xFC, 0xFC, 0x1F, 0xBF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7E,
  0x0F, 0xCF, 0xE3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0xF0, 0xFC, 0x1F, 0x3F, 0xE3, 0xEF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xF3, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x07, 0xDF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x0F, 0xDF, 0xE7, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xBF, 0xF1, 0xF1, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE3, 0xE3, 0xFE, 0x7C, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xE3,
  0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF, 0x7E, 0x1F, 0xCF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0xF0,
  0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xC3, 0x9F, 0x01, 0x3E, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xE1, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x31, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC,
  0x1F, 0xE0, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xDF, 0x3F,
  0xF7, 0xC7, 0xF0, 0xF0, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC,
  0xFC, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xFD, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0xF8, 0x1F, 0xC0, 0xFD, 0xF8, 0x3F,
  0xC1, 0xFB, 0xF0, 0x7F, 0x83, 0xE7, 0xE0, 0xFF, 0x07, 0xC7, 0xC3, 0xFE,
  0x1F, 0x8F, 0x87, 0xBC, 0x3F, 0x1F, 0x8F, 0x7C, 0x7C, 0x3F, 0x1E, 0x78,
  0xF8, 0x3E, 0x3C, 0xF3, 0xF0, 0x7C, 0xF1, 0xE7, 0xE0, 0xFD, 0xE3, 0xCF,
  0x80, 0xFB, 0xC3, 0xDF, 0x01, 0xF7, 0x87, 0xBE, 0x03, 0xEF, 0x0F, 0x7C,
  0x07, 0xDC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8,
  0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x3F, 0x7F,
  0x01, 0xFC, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x07,
  0xE3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F,
  0x87, 0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xFD, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x0F, 0xF0,
  0xFF, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1,
  0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3E, 0x00,
  0x3F, 0xC0, 0x2F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFD,
  0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 14, 11, 19, 2, -29 },
  { 47, 22, 29, 24, 1, -29 },
  { 127, 18, 32, 21, 2, -30 },
  { 199, 32, 29, 34, 1, -29 },
  { 315, 26, 29, 27, 1, -29 },
  { 410, 6, 11, 10, 2, -29 },
  { 419, 10, 35, 13, 2, -29 },
  { 463, 10, 35, 13, 1, -29 },
  { 507, 18, 17, 20, 1, -30 },
  { 546, 18, 20, 21, 2, -24 },
  { 591, 8, 10, 11, 1, -5 },
  { 601, 10, 5, 13, 1, -13 },
  { 608, 7, 6, 11, 2, -6 },
  { 614, 16, 29, 16, 0, -29 },
  { 672, 19, 29, 21, 1, -29 },
  { 741, 14, 29, 21, 2, -29 },
  { 792, 19, 29, 21, 1, -29 },
  { 861, 19, 29, 21, 1, -29 },
  { 930, 20, 29, 21, 1, -29 },
  { 1003, 18, 29, 21, 2, -29 },
  { 1069, 19, 29, 21, 1, -29 },
  { 1138, 19, 29, 21, 1, -29 },
  { 1207, 19, 29, 21, 1, -29 },
  { 1276, 19, 29, 21, 1, -29 },
  { 1345, 7, 22, 11, 2, -22 },
  { 1365, 8, 27, 11, 1, -22 },
  { 1392, 19, 21, 21, 1, -25 },
  { 1442, 19, 12, 21, 1, -20 },
  { 1471, 18, 21, 21, 2, -25 },
  { 1519, 17, 29, 18, 0, -29 },
  { 1581, 30, 32, 33, 2, -29 },
  { 1701, 25, 29, 25, 0, -29 },
  { 1792, 20, 29, 25, 3, -29 },
  { 1865, 20, 29, 23, 2, -29 },
  { 1938, 22, 29, 27, 3, -29 },
  { 2018, 15, 29, 21, 3, -29 },
  { 2073, 15, 29, 20, 3, -29 },
  { 2128, 22, 29, 27, 2, -29 },
  { 2208, 22, 29, 28, 3, -29 },
  { 2288, 12, 29, 14, 1, -29 },
  { 2332, 12, 37, 12, -3, -29 },
  { 2388, 21, 29, 24, 3, -29 },
  { 2465, 16, 29, 20, 3, -29 },
  { 2523, 29, 29, 35, 3, -29 },
  { 2629, 24, 29, 30, 3, -29 },
  { 2716, 25, 29, 29, 2, -29 },
  { 2807, 18, 29, 23, 3, -29 },
  { 2873, 25, 36, 29, 2, -29 },
  { 2986, 21, 29, 24, 3, -29 },
  { 3063, 17, 29, 20, 2, -29 },
  { 3125, 19, 29, 21, 1, -29 },
  { 3194, 21, 29, 28, 3, -29 },
  { 3271, 24, 29, 24, 0, -29 },
  { 3358, 36, 29, 35, 0, -29 },
  { 3489, 24, 29, 24, 0, -29 },
  { 3576, 23, 29, 23, 0, -29 },
  { 3660, 19, 29, 21, 1, -29 },
  { 3729, 9, 35, 13, 3, -29 },
  { 3769, 16, 29, 16, 0, -29 },
  { 3827, 9, 35, 13, 1, -29 },
  { 3867, 20, 18, 22, 1, -29 },
  { 3912, 16, 2, 16, 0, 4 },
  { 3916, 10, 7, 14, 2, -31 },
  { 3925, 18, 22, 22, 1, -22 },
  { 3975, 19, 30, 23, 3, -30 },
  { 4047, 16, 22, 19, 2, -22 },
  { 4091, 19, 30, 23, 2, -30 },
  { 4163, 18, 22, 22, 2, -22 },
  { 4213, 15, 31, 14, 1, -31 },
  { 4272, 19, 32, 23, 2, -22 },
  { 4348, 18, 30, 24, 3, -30 },
  { 4416, 7, 30, 11, 2, -30 },
  { 4443, 11, 40, 11, -2, -30 },
  { 4498, 20, 30, 23, 3, -30 },
  { 4573, 5, 30, 11, 3, -30 },
  { 4592, 30, 22, 36, 3, -22 },
  { 4675, 18, 22, 24, 3, -22 },
  { 4725, 19, 22, 23, 2, -22 },
  { 4778, 19, 32, 23, 3, -22 },
  { 4854, 19, 32, 23, 2, -22 },
  { 4930, 13, 22, 16, 3, -22 },
  { 4966, 15, 22, 18, 2, -22 },
  { 5008, 14, 26, 16, 1, -26 },
  { 5054, 18, 22, 24, 3, -22 },
  { 5104, 21, 22, 21, 0, -22 },
  { 5162, 31, 22, 32, 0, -22 },
  { 5248, 21, 22, 21, 0, -22 },
  { 5306, 21, 32, 21, 0, -22 },
  { 5390, 16, 22, 18, 1, -22 },
  { 5434, 13, 35, 15, 1, -29 },
  { 5491, 4, 39, 20, 8, -30 },
  { 5511, 13, 35, 15, 2, -29 },
  { 5568, 19, 6, 21, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_Bold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD40PT7B_H_
