#ifndef _NOTOSANS_SEMICONDENSED_BOLD60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF3, 0xF8, 0x38, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F,
  0xE7, 0xF0, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFD, 0xE1, 0xF1, 0xFF, 0x3C,
  0x06, 0x3F, 0xC7, 0x80, 0x07, 0xF8, 0xF0, 0x00, 0xFF, 0x1E, 0x00, 0x1F,
  0xF3, 0xC0, 0x03, 0xFF, 0x78, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3D, 0xFF, 0x80, 0x07, 0x9F, 0xF0, 0x00,
  0xF1, 0xFE, 0x00, 0x1E, 0x3F, 0xF0, 0x03, 0xC7, 0xFB, 0x00, 0x78, 0xFF,
  0x7C, 0x0F, 0x3F, 0xEF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF7, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0x0F, 0xC3, 0xFF, 0x83, 0xF0, 0xFE, 0x3F, 0x8F, 0xFF, 0x87, 0xF3, 0xFC,
  0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xF1, 0xFE, 0xFF, 0x0F, 0xFF, 0x8F, 0xE3, 0xF8, 0x7F, 0x0F, 0xFE, 0x1F,
  0x87, 0xF0, 0xFE, 0x0F, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0x83, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFE, 0x1F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xCF, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xFC, 0xFF, 0x87, 0xFE, 0x0F, 0xFD, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x01, 0xF8,
  0x02, 0x78, 0x3F, 0x03, 0xCF, 0xE7, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8,
  0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x78,
  0x0E, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x83,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F,
  0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x01,
  0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8,
  0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF, 0x7F, 0x8F, 0xF3, 0xF0, 0xFF, 0x1E,
  0x0F, 0xF0, 0xC0, 0xFF, 0x08, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFC, 0x0F, 0xFC, 0x3F, 0x00, 0x7F, 0xC1, 0xE0, 0x03, 0xFE, 0x08,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xF0, 0x0F, 0xFC, 0x1C,
  0x00, 0x7F, 0xC0, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0xC0, 0x00, 0x7F, 0xEF, 0x00, 0x0F,
  0xFE, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x3F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x7F, 0x80,
  0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x80, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0x60, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFB, 0xE0, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x1F, 0xFC, 0x0F, 0xF3, 0xFF,
  0xF0, 0xFF, 0x7F, 0xFF, 0x8F, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xEF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x3F,
  0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x07, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8,
  0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xFF, 0x83,
  0xFF, 0x1F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x7F, 0xC0,
  0x7F, 0xCF, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFC,
  0xFE, 0x07, 0xFF, 0x9F, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x38, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x3F, 0x83, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x87, 0x80, 0x1F,
  0x87, 0xF8, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xCF, 0xF9, 0xFF, 0x1F, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x9F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7E,
  0x03, 0xFF, 0x18, 0x00, 0xFF, 0x88, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFF, 0x80,
  0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0x8F, 0xE3, 0xF8, 0x1F, 0xFF, 0xF8, 0x7E,
  0x3F, 0x03, 0xFF, 0xFF, 0x87, 0xF7, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x7E,
  0x07, 0xF8, 0x3F, 0x83, 0xF7, 0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0xFE, 0x0F,
  0xE0, 0x3F, 0x03, 0xFF, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0,
  0x3F, 0x03, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x3F,
  0x03, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0x03,
  0xFF, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0x03, 0xFF,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xEF, 0xC1,
  0xFC, 0x0F, 0xF0, 0x7E, 0xFC, 0x0F, 0xE1, 0xFF, 0x8F, 0xCF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0x87, 0xE0, 0x3F, 0xFC,
  0x7F, 0xF0, 0x7F, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0x3F,
  0xFE, 0xFF, 0x00, 0x3F, 0xF7, 0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x07, 0xFD,
  0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xFC,
  0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xE7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xBF, 0xC0, 0x07, 0xFD, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xC0, 0x7C, 0x1F, 0xFC, 0x00, 0x30, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0x87, 0xFF, 0xC0, 0x3E, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x7F,
  0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xF8, 0x1F, 0xFE, 0x00,
  0x0C, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF,
  0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F,
  0xE3, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x0F, 0xFA, 0x07, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x30,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xFF, 0xEF, 0xE0, 0x01, 0xFD, 0xFF,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0xDF, 0xC0, 0x07, 0xF7, 0xFF, 0xFB,
  0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0x9F, 0xFF, 0xE7, 0xF0,
  0x07, 0xF3, 0xFF, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0xFF, 0x9F, 0xC0, 0x3F,
  0x8F, 0xFF, 0xF1, 0xFC, 0x07, 0xF1, 0xFF, 0xFE, 0x3F, 0x81, 0xFC, 0x3F,
  0xFF, 0xC7, 0xF0, 0x3F, 0x87, 0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x3F,
  0xC7, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x3F,
  0x81, 0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xEF,
  0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF,
  0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xE3, 0xFE, 0x03,
  0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF,
  0xFC, 0x07, 0xFE, 0x7F, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xF0, 0x0F, 0xFD,
  0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xF8, 0x7F, 0xFE, 0xFF,
  0x00, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0x7F, 0x80, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0x81, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xC3, 0xFC,
  0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0x07, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x07,
  0xF8, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFE, 0x3F,
  0xC0, 0x07, 0xFE, 0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0x00, 0x0F, 0xFD, 0xFE,
  0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xC1, 0xFC, 0x7F, 0xE0, 0x07,
  0x1F, 0xF0, 0x00, 0x47, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xC0, 0x7F, 0x81, 0xFE,
  0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xF8, 0x03,
  0xFC, 0x1F, 0xC7, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x1F, 0xC3, 0xFC,
  0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0x07, 0xF0,
  0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x00, 0x07,
  0xFB, 0xF8, 0x07, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x38, 0x03, 0xFF, 0x04, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xBF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF,
  0xFF, 0xF3, 0xF8, 0xFF, 0xF8, 0x7F, 0x07, 0xFE, 0x07, 0xE0, 0x0C, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x9F, 0xFE, 0x0F, 0xF3, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0x8F, 0xF7, 0xFF, 0xF0, 0xFE,
  0x1F, 0xFE, 0x0F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xF0, 0x1C, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x02, 0x7F, 0xE0, 0x0E, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0xFF, 0xFC, 0xFF,
  0x1F, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xEF, 0xF0, 0xFF,
  0xFC, 0xFF, 0x07, 0xFF, 0x87, 0xF0, 0x3F, 0xF0, 0x7F, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x18, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x0C, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x07,
  0xF0, 0x7F, 0xF8, 0xFF, 0x0F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFE, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFE, 0x07,
  0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xF9,
  0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x60, 0x00,
  0x3F, 0xE7, 0x80, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x1F, 0xFF, 0x0F, 0xF3,
  0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x1C,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xBF,
  0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x1F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFE,
  0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0x07, 0xFE, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0xFE, 0x07,
  0xFC, 0x0F, 0xE1, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F,
  0xC0, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD, 0xFF, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x0F, 0xE1, 0xFF, 0xE0, 0xFF, 0x3F, 0xFF, 0x0F, 0xF7, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE,
  0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xF7, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0x0F, 0xF1,
  0xFF, 0xE0, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0x0E, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x7F,
  0xF8, 0xFF, 0x0F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFE, 0x07, 0xFF, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE,
  0x03, 0xFF, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xF9, 0xFF, 0x03,
  0xFF, 0x1F, 0xF0, 0x03, 0x81, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xF0, 0x3E, 0x7F,
  0xC0, 0x0C, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF3, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x0D, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0x1F, 0xFF, 0xCF, 0xF0, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0x07,
  0xF0, 0x0B, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFD,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF3, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x8F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xFE, 0x03, 0xFC, 0x1F,
  0xE0, 0x7E, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0xFD, 0xFC, 0x1F, 0xF0, 0x7F,
  0x81, 0xF9, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF3, 0xF0, 0x7F, 0x80, 0xFF,
  0x0F, 0xC7, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0x8F, 0xC3, 0xFE, 0x03, 0xFC,
  0x3F, 0x1F, 0xC7, 0xF8, 0x07, 0xFC, 0x7E, 0x1F, 0x8F, 0xF0, 0x07, 0xF9,
  0xFC, 0x3F, 0x1F, 0xE0, 0x0F, 0xF3, 0xF0, 0x7E, 0x7F, 0x80, 0x1F, 0xE7,
  0xE0, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xC0, 0xFD, 0xFE, 0x00, 0x3F, 0x9F,
  0x81, 0xFB, 0xFC, 0x00, 0x7F, 0xBE, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFC,
  0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x7F,
  0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x07,
  0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF,
  0xC0, 0x03, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0xC0,
  0x03, 0xFF, 0x88, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 44, 16, 3, -43 },
  { 56, 22, 16, 28, 3, -43 },
  { 100, 33, 43, 36, 1, -43 },
  { 278, 27, 49, 32, 3, -46 },
  { 444, 47, 44, 51, 2, -43 },
  { 703, 39, 44, 41, 2, -43 },
  { 918, 9, 16, 15, 3, -43 },
  { 936, 15, 52, 20, 3, -43 },
  { 1034, 16, 52, 20, 1, -43 },
  { 1138, 27, 27, 30, 2, -46 },
  { 1230, 28, 29, 32, 2, -36 },
  { 1332, 11, 15, 16, 2, -7 },
  { 1353, 15, 8, 19, 2, -20 },
  { 1368, 10, 10, 16, 3, -9 },
  { 1381, 24, 43, 25, 0, -43 },
  { 1510, 28, 45, 32, 2, -44 },
  { 1668, 20, 43, 32, 3, -43 },
  { 1776, 28, 43, 32, 2, -43 },
  { 1927, 28, 44, 32, 2, -43 },
  { 2081, 30, 43, 32, 1, -43 },
  { 2243, 26, 44, 32, 3, -43 },
  { 2386, 28, 44, 32, 2, -43 },
  { 2540, 29, 43, 32, 1, -43 },
  { 2696, 28, 44, 32, 2, -43 },
  { 2850, 28, 44, 32, 2, -43 },
  { 3004, 10, 34, 16, 3, -33 },
  { 3047, 11, 41, 17, 2, -33 },
  { 3104, 28, 31, 32, 2, -37 },
  { 3213, 28, 18, 32, 2, -30 },
  { 3276, 28, 31, 32, 2, -37 },
  { 3385, 25, 44, 26, 0, -43 },
  { 3523, 44, 48, 50, 3, -43 },
  { 3787, 38, 43, 38, 0, -43 },
  { 3992, 29, 43, 37, 5, -43 },
  { 4148, 30, 44, 35, 3, -43 },
  { 4313, 32, 43, 40, 5, -43 },
  { 4485, 23, 43, 31, 5, -43 },
  { 4609, 22, 43, 30, 5, -43 },
  { 4728, 33, 44, 40, 3, -43 },
  { 4910, 32, 43, 42, 5, -43 },
  { 5082, 18, 43, 22, 2, -43 },
  { 5179, 18, 56, 19, -4, -43 },
  { 5305, 32, 43, 37, 5, -43 },
  { 5477, 24, 43, 30, 5, -43 },
  { 5606, 43, 43, 53, 5, -43 },
  { 5838, 35, 43, 45, 5, -43 },
  { 6027, 37, 45, 43, 3, -44 },
  { 6236, 27, 43, 34, 5, -43 },
  { 6382, 37, 54, 43, 3, -44 },
  { 6632, 31, 43, 36, 5, -43 },
  { 6799, 26, 44, 30, 2, -43 },
  { 6942, 29, 43, 31, 1, -43 },
  { 7098, 32, 44, 41, 5, -43 },
  { 7274, 36, 43, 36, 0, -43 },
  { 7468, 53, 43, 53, 0, -43 },
  { 7753, 36, 43, 36, 0, -43 },
  { 7947, 34, 43, 34, 0, -43 },
  { 8130, 29, 43, 31, 1, -43 },
  { 8286, 14, 52, 19, 4, -43 },
  { 8377, 24, 43, 25, 0, -43 },
  { 8506, 15, 52, 19, 1, -43 },
  { 8604, 31, 27, 33, 1, -43 },
  { 8709, 25, 4, 25, 0, 5 },
  { 8722, 16, 10, 21, 2, -46 },
  { 8742, 27, 34, 33, 2, -33 },
  { 8857, 28, 47, 35, 4, -46 },
  { 9022, 24, 34, 28, 3, -33 },
  { 9124, 28, 47, 35, 3, -46 },
  { 9289, 27, 34, 33, 3, -33 },
  { 9404, 23, 46, 21, 1, -46 },
  { 9537, 28, 47, 35, 3, -33 },
  { 9702, 28, 46, 36, 4, -46 },
  { 9863, 9, 46, 17, 4, -46 },
  { 9915, 16, 60, 17, -3, -46 },
  { 10035, 30, 46, 34, 4, -46 },
  { 10208, 9, 46, 17, 4, -46 },
  { 10260, 46, 33, 53, 4, -33 },
  { 10450, 28, 33, 36, 4, -33 },
  { 10566, 29, 34, 35, 3, -33 },
  { 10690, 28, 47, 35, 4, -33 },
  { 10855, 28, 47, 35, 3, -33 },
  { 11020, 20, 33, 25, 4, -33 },
  { 11103, 23, 34, 27, 2, -33 },
  { 11201, 21, 41, 24, 1, -40 },
  { 11309, 28, 34, 36, 4, -33 },
  { 11428, 31, 33, 31, 0, -33 },
  { 11556, 47, 33, 47, 0, -33 },
  { 11750, 31, 33, 31, 0, -33 },
  { 11878, 31, 47, 31, 0, -33 },
  { 12061, 23, 33, 27, 2, -33 },
  { 12156, 19, 52, 23, 1, -43 },
  { 12280, 7, 60, 31, 12, -46 },
  { 12333, 20, 52, 23, 2, -43 },
  { 12463, 28, 10, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_Bold60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD60PT7B_H_
