#ifndef _NOTOSANS_SEMICONDENSED_BOLD25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x00, 0x6F, 0xF7, 0xF3, 0xB9,
  0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0x8E, 0x0E, 0x70, 0x73, 0x03, 0x98, 0x19,
  0xC0, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xCE, 0x06, 0x71,
  0xFF, 0xFF, 0xFF, 0x9C, 0xC0, 0xC6, 0x06, 0x70, 0x33, 0x83, 0x9C, 0x00,
  0x04, 0x00, 0x80, 0x7F, 0x3F, 0xFF, 0xFD, 0xE8, 0xBD, 0x07, 0xA0, 0x7C,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x5E, 0x09, 0xF1, 0x3F, 0xFF, 0xFF, 0xC7,
  0xE0, 0x10, 0x02, 0x00, 0x3C, 0x0E, 0x07, 0xE0, 0xE0, 0xEE, 0x1C, 0x0E,
  0x71, 0xC0, 0xE7, 0x38, 0x0E, 0x73, 0x80, 0xE7, 0x30, 0x0E, 0x77, 0x38,
  0xEE, 0x67, 0xE7, 0xEE, 0xEE, 0x3C, 0xCE, 0x60, 0x1C, 0xC7, 0x01, 0x8C,
  0x70, 0x38, 0xC7, 0x03, 0x0E, 0x60, 0x70, 0xEE, 0x06, 0x07, 0xE0, 0xE0,
  0x7C, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x79,
  0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x0E, 0x7F, 0x1E, 0xFF, 0x9E, 0xF3,
  0xDC, 0xF1, 0xFC, 0xF0, 0xF8, 0xF0, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F,
  0x9F, 0xF7, 0x77, 0x77, 0x60, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x1C, 0x78,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xE0, 0xE1, 0xC1, 0xC3,
  0xC0, 0xE3, 0xC7, 0x0E, 0x38, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xCF, 0x38, 0xE7, 0x9C, 0xF3, 0x80, 0x0E, 0x01, 0xC0, 0x38, 0x67, 0x7F,
  0xFF, 0xFF, 0xC7, 0x81, 0xF8, 0x3B, 0x8E, 0x78, 0x44, 0x00, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x77, 0xFF, 0xEE, 0xFF, 0xFF, 0xC0, 0x6F, 0xF7, 0x01,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x00, 0x1F, 0x07,
  0xF1, 0xFF, 0x38, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F,
  0x83, 0xF8, 0x7F, 0x0F, 0xE3, 0xDC, 0x7B, 0xFE, 0x3F, 0xC3, 0xF0, 0x07,
  0x87, 0xC7, 0xE7, 0xFF, 0xFB, 0xBC, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0xFB, 0xFF,
  0x30, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x70, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x1F, 0xFB,
  0xFF, 0x30, 0xF0, 0x1E, 0x03, 0xC0, 0x71, 0xFC, 0x3F, 0x07, 0xF8, 0x0F,
  0x80, 0xF0, 0x0E, 0x03, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xF0, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0x6E, 0x07, 0xF0, 0x37, 0x83, 0xBC, 0x39,
  0xE1, 0xCF, 0x1C, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xFC, 0x7F, 0xDF, 0xFC, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0xE0,
  0x7F, 0xFE, 0xFF, 0xCF, 0xE0, 0x07, 0xC3, 0xF8, 0xFF, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0xC7, 0x7E, 0xFF, 0xFF, 0x3F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE1,
  0xFC, 0x7B, 0xFF, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0x1F, 0x0F, 0xF9, 0xFF, 0xF8,
  0xFF, 0x0F, 0xE3, 0xDE, 0xF1, 0xFE, 0x1F, 0x07, 0xF1, 0xEF, 0x78, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0xDF, 0x7F, 0xC7, 0xF0, 0x1F, 0x0F, 0xF1, 0xFF,
  0x78, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF1, 0xFF, 0xFD, 0xFB, 0x8E,
  0x70, 0x0E, 0x03, 0xC0, 0xF3, 0xFC, 0x7F, 0x8F, 0xC0, 0x7F, 0xF7, 0x00,
  0x00, 0x00, 0x6F, 0xF7, 0x77, 0xBE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0x3B, 0xDC, 0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x78, 0x7F, 0x3F, 0x1F, 0x83, 0xC0, 0x60, 0x00,
  0x3F, 0x3F, 0xF7, 0xFD, 0x87, 0x01, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x07,
  0x81, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x7C, 0x3C, 0x1E, 0x01, 0xC3, 0x80, 0x1C, 0xE3,
  0xF9, 0x98, 0xFF, 0x37, 0x38, 0xE7, 0xE7, 0x1C, 0xFC, 0xE3, 0x9F, 0x98,
  0x73, 0xF3, 0x8E, 0x6E, 0x73, 0xDD, 0xCF, 0xFF, 0x18, 0xF9, 0xE3, 0x80,
  0x00, 0x38, 0x00, 0x07, 0xC1, 0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E,
  0x70, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x38, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7F, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFE, 0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0xFE, 0xFF,
  0x8F, 0xFE, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFE, 0xFF,
  0xEF, 0xF8, 0x07, 0xF0, 0xFF, 0xCF, 0xFC, 0x78, 0x27, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x47, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFE, 0x3F,
  0xF9, 0xE3, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC7, 0xDF, 0xFC, 0xFF, 0xC7,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x07, 0xF8, 0x3F, 0xF3,
  0xFF, 0x8F, 0x82, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF1, 0xFF,
  0xC7, 0xFF, 0x1F, 0xFC, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xC3, 0xCF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xE0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xC0, 0xFF, 0xFF,
  0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3E,
  0xFF, 0xFC, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0xFE, 0xFE,
  0xF8, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE3, 0xCF, 0x3C, 0x7B, 0xE3, 0xDE,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xE7, 0x8F, 0x3C, 0x78, 0xF3,
  0xC7, 0x9E, 0x1E, 0xF0, 0xF7, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFB, 0x87, 0x7E, 0xE1, 0xDF, 0xB8, 0x77,
  0xEE, 0x39, 0xF9, 0xCE, 0x7E, 0x73, 0x9F, 0x9D, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x70, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFD, 0xC3, 0xFB, 0xC7,
  0xF3, 0x8F, 0xE7, 0x9F, 0xC7, 0x3F, 0x8F, 0x7F, 0x0F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x1F, 0xFB,
  0xFF, 0xF9, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF7, 0xFF, 0xFB, 0xFE,
  0x7E, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E,
  0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xE3,
  0xCF, 0x0E, 0x78, 0x7B, 0xC3, 0x9E, 0x3C, 0xFF, 0xE7, 0xFE, 0x3F, 0xE1,
  0xE7, 0x0F, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x1E, 0xF0, 0xF7, 0x83, 0xC0,
  0x1F, 0x8F, 0xFD, 0xFF, 0x78, 0x6F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x1E, 0x03, 0xF0, 0x7F, 0xFE, 0xFF, 0x8F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xE1, 0xEF, 0xFE, 0x3F, 0xF0, 0xFE,
  0x00, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE7, 0x83, 0xC7, 0x07,
  0x0E, 0x0E, 0x1E, 0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x7B, 0xC0, 0xF7, 0x00,
  0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF0,
  0x78, 0x1F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xDC, 0x1F, 0x0E, 0x70, 0xFC,
  0x39, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x8E, 0x3B, 0x1E, 0x39, 0xCE, 0x70,
  0xE7, 0x39, 0xC3, 0xDC, 0xEF, 0x07, 0x73, 0xBC, 0x1D, 0xC7, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x83, 0xC0, 0x3C, 0x0F,
  0x00, 0xF8, 0x3C, 0xF0, 0x78, 0xF1, 0xE1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE,
  0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x01,
  0xEF, 0x03, 0x9E, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0x3D, 0xE0, 0x7C, 0xF0,
  0x3D, 0xE0, 0xF7, 0x87, 0x8E, 0x1E, 0x3C, 0xF0, 0x73, 0xC1, 0xEE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFC,
  0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0xFF,
  0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF,
  0xFC, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xB8, 0x39, 0xC7,
  0x1C, 0x70, 0xEE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x70,
  0x70, 0x1F, 0x8F, 0xF8, 0xFF, 0x90, 0xF0, 0x0E, 0x03, 0xCF, 0xFB, 0xFF,
  0xF0, 0xFE, 0x3F, 0xC7, 0xFF, 0xF7, 0xFE, 0xFD, 0xC0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xEF, 0xCF, 0xFE, 0xF1, 0xEF, 0x1E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xFE, 0x0E, 0xE0, 0xEF, 0x1E, 0xFF, 0xEF, 0xFC,
  0xEF, 0x80, 0x0F, 0x8F, 0xF7, 0xFD, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x85, 0xFF, 0x3F, 0xC7, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x3F, 0xF7, 0xFF, 0x79, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x7F, 0xF7, 0xF7, 0x3E,
  0x70, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xEF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x70, 0x27, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xC7,
  0xF3, 0xF8, 0xF0, 0x3C, 0x0F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1E, 0x73,
  0xF7, 0x7F, 0xF7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x41, 0xF7,
  0xFE, 0x7F, 0xC3, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF,
  0x3B, 0xF7, 0xFF, 0xF1, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x80, 0xFF, 0xA1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1C, 0x71, 0xC2, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xFE, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE1, 0xEE, 0x3C, 0xE7, 0x8E,
  0x78, 0xEF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF8, 0xF7, 0x8E, 0x3C, 0xE1, 0xEE,
  0x1E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7,
  0x8F, 0x9F, 0xFB, 0xFB, 0xFF, 0xFF, 0x78, 0xF9, 0xFF, 0x1E, 0x1F, 0xC3,
  0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE1, 0xE1, 0xFC, 0x3C, 0x3F, 0x87,
  0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xC0, 0xE7, 0x9D, 0xFB,
  0xFF, 0xF8, 0xFF, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x70, 0xF7, 0xFE, 0x3F,
  0xE1, 0xF8, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0F, 0xE0, 0xEE, 0x0E, 0xF1, 0xEF, 0xFE, 0xFF, 0xCE, 0xF8, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x73, 0xF7, 0x7F,
  0xF7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF7, 0xFF, 0x7F, 0xF3, 0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xC7, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0x3F, 0xFF, 0xFC, 0x1F, 0x07, 0xE1, 0xFC,
  0x7F, 0x0F, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x07,
  0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xFE, 0x3F, 0x1F, 0x80, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0xFE, 0xFD, 0xC0,
  0xF0, 0x7F, 0x83, 0xDC, 0x1C, 0xF1, 0xE7, 0x8F, 0x1C, 0x70, 0xF3, 0x87,
  0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF0,
  0xF0, 0xF7, 0x0F, 0x0E, 0x71, 0xF0, 0xE7, 0x1F, 0x9E, 0x79, 0xF9, 0xC3,
  0x9B, 0x9C, 0x39, 0x99, 0xC3, 0xB9, 0xBC, 0x3F, 0x9F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0xF0, 0x7B,
  0xC7, 0x8E, 0x38, 0x7B, 0xC1, 0xDC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0xC0, 0xEE, 0x0F, 0x78, 0x71, 0xC7, 0x8F, 0x78, 0x3C, 0xF0, 0x7F, 0x83,
  0xDC, 0x1C, 0xF1, 0xE3, 0x8F, 0x1C, 0x70, 0xF3, 0x83, 0xBC, 0x1D, 0xC0,
  0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0xF0,
  0x70, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0x0F,
  0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF8, 0x7C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xF8, 0xF8, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3E, 0x1F, 0x1F, 0x3F, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0xF8, 0xF8, 0xE0, 0x78, 0x3F, 0xEF, 0xFF, 0xC3, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Bold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 18, 7, 1, -18 },
  { 10, 9, 7, 12, 1, -18 },
  { 18, 13, 18, 15, 1, -18 },
  { 48, 11, 20, 13, 1, -19 },
  { 76, 20, 18, 21, 1, -18 },
  { 121, 16, 18, 17, 1, -18 },
  { 157, 4, 7, 6, 1, -18 },
  { 161, 7, 22, 8, 1, -18 },
  { 181, 6, 22, 8, 1, -18 },
  { 198, 11, 11, 13, 1, -19 },
  { 214, 11, 12, 13, 1, -15 },
  { 231, 4, 6, 7, 1, -3 },
  { 234, 6, 3, 8, 1, -8 },
  { 237, 4, 4, 7, 1, -4 },
  { 239, 10, 18, 10, 0, -18 },
  { 262, 11, 18, 13, 1, -18 },
  { 287, 9, 18, 13, 1, -18 },
  { 308, 11, 18, 13, 1, -18 },
  { 333, 11, 18, 13, 1, -18 },
  { 358, 13, 18, 13, 0, -18 },
  { 388, 11, 18, 13, 1, -18 },
  { 413, 11, 18, 13, 1, -18 },
  { 438, 11, 18, 13, 1, -18 },
  { 463, 11, 18, 13, 1, -18 },
  { 488, 11, 18, 13, 1, -18 },
  { 513, 4, 14, 7, 1, -14 },
  { 520, 5, 17, 7, 1, -14 },
  { 531, 11, 12, 13, 1, -15 },
  { 548, 11, 8, 13, 1, -13 },
  { 559, 11, 12, 13, 1, -15 },
  { 576, 10, 18, 11, 0, -18 },
  { 599, 19, 20, 21, 1, -18 },
  { 647, 16, 18, 16, 0, -18 },
  { 683, 12, 18, 15, 2, -18 },
  { 710, 13, 18, 15, 1, -18 },
  { 740, 13, 18, 17, 2, -18 },
  { 770, 9, 18, 13, 2, -18 },
  { 791, 9, 18, 13, 2, -18 },
  { 812, 14, 18, 17, 1, -18 },
  { 844, 13, 18, 18, 2, -18 },
  { 874, 7, 18, 9, 1, -18 },
  { 890, 8, 23, 8, -2, -18 },
  { 913, 13, 18, 15, 2, -18 },
  { 943, 10, 18, 13, 2, -18 },
  { 966, 18, 18, 22, 2, -18 },
  { 1007, 15, 18, 19, 2, -18 },
  { 1041, 16, 18, 18, 1, -18 },
  { 1077, 11, 18, 14, 2, -18 },
  { 1102, 16, 22, 18, 1, -18 },
  { 1146, 13, 18, 15, 2, -18 },
  { 1176, 11, 18, 13, 1, -18 },
  { 1201, 13, 18, 13, 0, -18 },
  { 1231, 13, 18, 17, 2, -18 },
  { 1261, 15, 18, 15, 0, -18 },
  { 1295, 22, 18, 22, 0, -18 },
  { 1345, 15, 18, 15, 0, -18 },
  { 1379, 14, 18, 14, 0, -18 },
  { 1411, 12, 18, 13, 0, -18 },
  { 1438, 5, 22, 8, 2, -18 },
  { 1452, 10, 18, 10, 0, -18 },
  { 1475, 5, 22, 8, 1, -18 },
  { 1489, 12, 11, 14, 1, -18 },
  { 1506, 10, 2, 10, 0, 2 },
  { 1509, 7, 4, 9, 1, -19 },
  { 1513, 11, 14, 14, 1, -14 },
  { 1533, 12, 19, 15, 2, -19 },
  { 1562, 10, 14, 12, 1, -14 },
  { 1580, 12, 19, 15, 1, -19 },
  { 1609, 12, 14, 14, 1, -14 },
  { 1630, 10, 19, 9, 0, -19 },
  { 1654, 12, 20, 15, 1, -14 },
  { 1684, 11, 19, 15, 2, -19 },
  { 1711, 3, 19, 7, 2, -19 },
  { 1719, 6, 25, 7, -1, -19 },
  { 1738, 12, 19, 14, 2, -19 },
  { 1767, 3, 19, 7, 2, -19 },
  { 1775, 19, 14, 22, 2, -14 },
  { 1809, 11, 14, 15, 2, -14 },
  { 1829, 12, 14, 14, 1, -14 },
  { 1850, 12, 20, 15, 2, -14 },
  { 1880, 12, 20, 15, 1, -14 },
  { 1910, 8, 14, 10, 2, -14 },
  { 1924, 9, 14, 11, 1, -14 },
  { 1940, 9, 17, 10, 0, -17 },
  { 1960, 11, 14, 15, 2, -14 },
  { 1980, 13, 14, 13, 0, -14 },
  { 2003, 20, 14, 20, 0, -14 },
  { 2038, 13, 14, 13, 0, -14 },
  { 2061, 13, 20, 13, 0, -14 },
  { 2094, 9, 14, 11, 1, -14 },
  { 2110, 8, 22, 9, 0, -18 },
  { 2132, 3, 25, 13, 5, -19 },
  { 2142, 8, 22, 9, 1, -18 },
  { 2164, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Bold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD25PT7B_H_
