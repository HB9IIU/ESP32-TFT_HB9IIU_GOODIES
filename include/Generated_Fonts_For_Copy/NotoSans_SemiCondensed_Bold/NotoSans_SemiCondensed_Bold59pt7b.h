#ifndef _NOTOSANS_SEMICONDENSED_BOLD59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0xE0, 0xC0, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFC,
  0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x3F, 0x9F, 0xC0, 0xFC,
  0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x9E, 0x0E, 0x3F,
  0xC7, 0x80, 0x8F, 0xF1, 0xE0, 0x03, 0xFC, 0x78, 0x00, 0xFF, 0x1E, 0x00,
  0x3F, 0xE7, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xBF, 0xF0, 0x01, 0xE7, 0xFC, 0x00, 0x78,
  0xFF, 0x00, 0x1E, 0x3F, 0xE0, 0x07, 0x8F, 0xFF, 0x01, 0xE7, 0xFF, 0xF8,
  0x7B, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x87,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x0F, 0xC3, 0xFF, 0x03, 0xF0, 0xFE, 0x3F,
  0x8F, 0xFF, 0x07, 0xF1, 0xFC, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE3, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x8F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0x0F, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0x07, 0x80, 0xFC, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x7F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8,
  0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0,
  0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x08, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF,
  0xBF, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xFE, 0x3F, 0xF0, 0xFF, 0xCF,
  0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x01, 0x80, 0xFC, 0x06, 0x7C, 0x3F, 0x0F, 0xBF, 0xEF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xF3, 0xFC,
  0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0x3F, 0x03, 0xF0, 0x03, 0xC0,
  0xF0, 0x00, 0x60, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7F, 0x83, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xDF, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x0F, 0xF9, 0xFF,
  0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFC, 0xFF,
  0x7F, 0x8F, 0xF3, 0xE0, 0xFF, 0x1C, 0x0F, 0xF0, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xC3, 0xC0, 0x0F,
  0xF8, 0x30, 0x01, 0xFF, 0x04, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x3F, 0xFE, 0x1E, 0x00, 0xFF, 0xC3,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x7F, 0x3F,
  0xC0, 0x03, 0xF3, 0xFE, 0x00, 0x3F, 0x9F, 0xF0, 0x01, 0xF8, 0xFF, 0x80,
  0x1F, 0xC7, 0xFC, 0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0xC1, 0xFF, 0x00, 0xFE,
  0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x1F,
  0xF0, 0x3F, 0x80, 0xFF, 0x83, 0xF8, 0x07, 0xFC, 0x3F, 0x80, 0x3F, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC1, 0xC0, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xA0, 0x00, 0x3F, 0xEF, 0x00, 0x3F,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xF8,
  0x1F, 0xE7, 0xFF, 0xC3, 0xFD, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF7, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07,
  0xFE, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xF7, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFE, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xDF, 0xE3, 0xFF, 0xFB, 0xFC, 0x3F, 0xFE, 0x7F, 0x81,
  0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x1E, 0x1F, 0xE7,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x87, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x3F, 0x83, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF9, 0xFF, 0x3F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x7F, 0x8F, 0xFE, 0x3E, 0x01, 0xFF, 0x08, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0x00, 0x1F, 0xC1, 0xF8, 0x03, 0xFF,
  0xE1, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xF0,
  0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0x07, 0xE7, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E,
  0x7E, 0x0F, 0xF0, 0x3F, 0x07, 0xEF, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0xFC, 0x1F,
  0x80, 0x7F, 0x03, 0xFF, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0x80,
  0x7F, 0x07, 0xEF, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0xFC, 0x1F, 0x80, 0x7F,
  0x07, 0xEF, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0x80, 0x7E, 0x07,
  0xEF, 0xC1, 0xF8, 0x0F, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xCF,
  0xC1, 0xFE, 0x1F, 0xF1, 0xFC, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7E, 0x07, 0xFF, 0xCF, 0xFF, 0x07, 0xE0, 0x3F,
  0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0xFE, 0xFF, 0x00,
  0x3F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0,
  0x07, 0xFC, 0xFF, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xFE, 0xFF, 0x00, 0x7F, 0xEF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xF0, 0x7F, 0xE0, 0x00, 0x83, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x07, 0xFF, 0x80, 0x3C,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0xFF,
  0xF8, 0xFF, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x3F,
  0xF7, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFF, 0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0x00,
  0x3F, 0xF9, 0xFE, 0x00, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x3C, 0x1F, 0xFC, 0x00, 0x08, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x01,
  0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0x01, 0xFF,
  0x81, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC7, 0xFE, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFE, 0xFF, 0xC0, 0x03,
  0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC1, 0xFE, 0x00,
  0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03,
  0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x07,
  0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x01, 0xFF, 0xFF, 0xFB, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0x9F, 0xC0, 0x0F, 0xEF, 0xFF,
  0xE7, 0xF0, 0x03, 0xFB, 0xFF, 0xF9, 0xFC, 0x00, 0xFC, 0xFF, 0xFE, 0x7F,
  0x00, 0x7F, 0x3F, 0xFF, 0xCF, 0xE0, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0x07,
  0xE3, 0xFF, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F,
  0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xFF, 0xF1, 0xFC, 0x1F, 0xC3, 0xFF, 0xFC,
  0x7F, 0x07, 0xF0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x83, 0xFF, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFF, 0xFF, 0x07, 0xF3, 0xF0, 0x3F, 0xFF, 0xC1, 0xFD, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xC0, 0x0F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0xFF, 0xFE,
  0x3F, 0xE0, 0x3F, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0x03, 0xFE,
  0x1F, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0xFC, 0x03,
  0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0xDF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x1F, 0xFE, 0xFF,
  0x00, 0xFF, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x03, 0xFF,
  0x7F, 0x81, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x17, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xE0,
  0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0x87,
  0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE,
  0x01, 0xFF, 0x83, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x1F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x00, 0xFF,
  0x81, 0xFE, 0x01, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFF,
  0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFE, 0x3F, 0xC0, 0x07, 0xFE,
  0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x7F, 0xE0, 0x3E, 0x1F, 0xF0, 0x01, 0x87, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xB0,
  0x00, 0x1F, 0xEF, 0x00, 0x0F, 0xFB, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xD0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0D, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x7E,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFC, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE, 0x00,
  0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x87, 0xF0, 0xFF,
  0x80, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0xFE,
  0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE7, 0xF0,
  0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0x81, 0xFC, 0xFF, 0x00, 0x07, 0xF9,
  0xFC, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x3F, 0xBF, 0xC0, 0x00,
  0xFE, 0xFE, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF0,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFB, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3C, 0x03, 0xFE, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xE0, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xCF, 0xFF, 0xE3, 0xF8, 0xFF, 0xF8,
  0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x03, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x3F, 0xFE,
  0x0F, 0xF7, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xF9, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0x7F, 0xFF, 0x0F, 0xE3, 0xFF, 0xE0, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xF8, 0x3C,
  0x7F, 0xE0, 0x08, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x02, 0xFF, 0xC0, 0x1D, 0xFF, 0xF7, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF1, 0xFF, 0x0F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFD, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x0F,
  0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF7, 0xFC, 0x07, 0xFF, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xF8,
  0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xE3, 0xFF, 0x03, 0xFC, 0x7F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x30,
  0xFF, 0xC0, 0x1E, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0x02, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0x0F, 0xFF, 0x8F, 0xF1, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xEF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC,
  0x07, 0xFF, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0xF0, 0x7F, 0xF9, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x02, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x60, 0x00, 0x7F, 0xE7,
  0xC0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0x01,
  0xFE, 0x1F, 0xF8, 0x3F, 0xCF, 0xFF, 0xC7, 0xFB, 0xFF, 0xFC, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFE,
  0x3E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF0, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x0F,
  0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC,
  0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE3, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xFF, 0x87, 0xFE, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC3, 0xFF, 0xC3,
  0xF8, 0xFF, 0xFC, 0x7F, 0x3F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xE0, 0xFF, 0xC0, 0xFE, 0x3F, 0xFE, 0x0F, 0xF7, 0xFF, 0xF0, 0xFF, 0x7F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF,
  0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF7, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0x0F, 0xF3, 0xFF, 0xE0,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0x0F, 0xFF, 0x8F, 0xF1, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xEF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x07, 0xFF,
  0x7F, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0xF0, 0x7F, 0xF9, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xEF, 0xE0, 0xFF, 0xFE, 0x1F, 0xEF, 0xE3, 0xFE,
  0xFE, 0x7F, 0xEF, 0xEF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xEF, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFD, 0xFE, 0x7F, 0xC0, 0x38,
  0xFF, 0x00, 0x11, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x78, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0x80,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xFF, 0xE3, 0xF8, 0x3F, 0xF0, 0x7F,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xF9,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x87,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8,
  0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xDF, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xF8, 0x07,
  0xF8, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0xBF, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFB, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xCF, 0xC1, 0xFE, 0x03,
  0xFC, 0x3F, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0xFC, 0x7E, 0x1F, 0xE0, 0x3F,
  0xC3, 0xF1, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0x87, 0xE3, 0xFC, 0x01, 0xFE,
  0x7E, 0x1F, 0x8F, 0xF0, 0x07, 0xF9, 0xF8, 0x3F, 0x3F, 0xC0, 0x1F, 0xE7,
  0xE0, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0x83, 0xF3, 0xF8, 0x00, 0xFE, 0x7C,
  0x0F, 0xDF, 0xE0, 0x03, 0xFB, 0xF0, 0x3F, 0x7F, 0x80, 0x0F, 0xEF, 0xC0,
  0x7D, 0xFC, 0x00, 0x3F, 0xFF, 0x01, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x07,
  0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xF9,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x87,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xE0,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x23, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x90, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Bold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 43, 16, 3, -42 },
  { 55, 21, 15, 28, 3, -42 },
  { 95, 33, 42, 35, 1, -42 },
  { 269, 26, 48, 31, 3, -45 },
  { 425, 47, 44, 50, 2, -43 },
  { 684, 38, 44, 40, 2, -43 },
  { 893, 9, 15, 15, 3, -42 },
  { 910, 15, 51, 19, 3, -42 },
  { 1006, 16, 51, 19, 1, -42 },
  { 1108, 26, 26, 30, 2, -45 },
  { 1193, 27, 28, 31, 2, -35 },
  { 1288, 11, 15, 16, 2, -7 },
  { 1309, 15, 7, 19, 2, -19 },
  { 1323, 10, 10, 16, 3, -9 },
  { 1336, 24, 43, 24, 0, -43 },
  { 1465, 27, 44, 31, 2, -43 },
  { 1614, 20, 42, 31, 3, -42 },
  { 1719, 27, 43, 31, 2, -43 },
  { 1865, 27, 44, 31, 2, -43 },
  { 2014, 29, 42, 31, 1, -42 },
  { 2167, 26, 43, 31, 3, -42 },
  { 2307, 27, 44, 31, 2, -43 },
  { 2456, 28, 42, 31, 1, -42 },
  { 2603, 27, 44, 31, 2, -43 },
  { 2752, 27, 44, 31, 2, -43 },
  { 2901, 10, 34, 16, 3, -33 },
  { 2944, 11, 41, 16, 2, -33 },
  { 3001, 27, 30, 31, 2, -36 },
  { 3103, 27, 18, 31, 2, -30 },
  { 3164, 27, 30, 31, 2, -36 },
  { 3266, 25, 44, 26, 0, -43 },
  { 3404, 44, 47, 49, 3, -42 },
  { 3663, 37, 42, 37, 0, -42 },
  { 3858, 28, 42, 36, 5, -42 },
  { 4005, 30, 44, 34, 3, -43 },
  { 4170, 31, 42, 39, 5, -42 },
  { 4333, 22, 42, 30, 5, -42 },
  { 4449, 22, 42, 30, 5, -42 },
  { 4565, 32, 44, 39, 3, -43 },
  { 4741, 31, 42, 41, 5, -42 },
  { 4904, 18, 42, 21, 2, -42 },
  { 4999, 17, 54, 18, -4, -42 },
  { 5114, 31, 42, 36, 5, -42 },
  { 5277, 23, 42, 30, 5, -42 },
  { 5398, 42, 42, 52, 5, -42 },
  { 5619, 34, 42, 44, 5, -42 },
  { 5798, 36, 44, 42, 3, -43 },
  { 5996, 27, 42, 34, 5, -42 },
  { 6138, 36, 53, 42, 3, -43 },
  { 6377, 31, 42, 36, 5, -42 },
  { 6540, 26, 44, 30, 2, -43 },
  { 6683, 29, 42, 31, 1, -42 },
  { 6836, 31, 43, 41, 5, -42 },
  { 7003, 35, 42, 35, 0, -42 },
  { 7187, 53, 42, 52, 0, -42 },
  { 7466, 35, 42, 35, 0, -42 },
  { 7650, 34, 42, 34, 0, -42 },
  { 7829, 28, 42, 31, 1, -42 },
  { 7976, 14, 51, 19, 4, -42 },
  { 8066, 24, 43, 24, 0, -43 },
  { 8195, 14, 51, 19, 1, -42 },
  { 8285, 30, 26, 33, 1, -42 },
  { 8383, 24, 4, 24, 0, 5 },
  { 8395, 16, 9, 20, 2, -45 },
  { 8413, 27, 34, 32, 2, -33 },
  { 8528, 28, 46, 34, 4, -45 },
  { 8689, 23, 34, 28, 3, -33 },
  { 8787, 28, 46, 34, 3, -45 },
  { 8948, 27, 34, 32, 3, -33 },
  { 9063, 22, 45, 21, 1, -45 },
  { 9187, 28, 47, 34, 3, -33 },
  { 9352, 27, 45, 35, 4, -45 },
  { 9504, 9, 45, 16, 4, -45 },
  { 9555, 16, 59, 16, -3, -45 },
  { 9673, 30, 45, 34, 4, -45 },
  { 9842, 8, 45, 16, 4, -45 },
  { 9887, 45, 33, 53, 4, -33 },
  { 10073, 27, 33, 35, 4, -33 },
  { 10185, 28, 34, 34, 3, -33 },
  { 10304, 28, 47, 34, 4, -33 },
  { 10469, 28, 47, 34, 3, -33 },
  { 10634, 20, 33, 24, 4, -33 },
  { 10717, 23, 34, 27, 2, -33 },
  { 10815, 21, 40, 23, 1, -39 },
  { 10920, 27, 33, 35, 4, -32 },
  { 11032, 31, 32, 31, 0, -32 },
  { 11156, 46, 32, 47, 0, -32 },
  { 11340, 31, 32, 31, 0, -32 },
  { 11464, 31, 46, 31, 0, -32 },
  { 11643, 23, 32, 26, 2, -32 },
  { 11735, 19, 51, 22, 1, -42 },
  { 11857, 6, 59, 30, 12, -45 },
  { 11902, 19, 51, 22, 2, -42 },
  { 12024, 27, 10, 31, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_Bold59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD59PT7B_H_
