#ifndef _NOTOSANS_SEMICONDENSED_BOLD20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x60, 0x7F, 0xC0, 0xEF, 0xDF, 0x9F, 0x3E, 0x60,
  0x0C, 0xC1, 0x98, 0x33, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xCC, 0xFF,
  0xFF, 0xFC, 0xCC, 0x19, 0x83, 0x30, 0x66, 0x00, 0x08, 0x0F, 0x1F, 0xFF,
  0xEE, 0x87, 0x43, 0xE0, 0xFC, 0x1F, 0x07, 0xC2, 0xF9, 0x7F, 0xF7, 0xF0,
  0x20, 0x10, 0x78, 0x31, 0xB8, 0xC3, 0x31, 0x86, 0x66, 0x0C, 0xCC, 0x19,
  0xB3, 0xB7, 0x6F, 0xBD, 0xBB, 0x03, 0x66, 0x0C, 0xCC, 0x19, 0x98, 0x63,
  0xB0, 0xC3, 0xE3, 0x07, 0x80, 0x3F, 0x03, 0xF8, 0x1C, 0xC0, 0xE6, 0x07,
  0x70, 0x1F, 0x00, 0xF1, 0xDF, 0xCE, 0xEF, 0xE7, 0x3F, 0x38, 0xF1, 0xE7,
  0x8F, 0xFE, 0x3F, 0x3C, 0xFF, 0xFE, 0x39, 0x9C, 0xCE, 0x73, 0x18, 0xC6,
  0x39, 0xCE, 0x31, 0xC6, 0x38, 0xE0, 0xC3, 0x8E, 0x18, 0x61, 0xC7, 0x1C,
  0x71, 0xC6, 0x18, 0xE3, 0x1C, 0xE0, 0x18, 0x0C, 0x26, 0x5F, 0xEF, 0xF9,
  0xE1, 0xF9, 0xCE, 0x24, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC,
  0x60, 0x30, 0x18, 0x0C, 0x00, 0xFF, 0xEC, 0xFF, 0xFE, 0xFF, 0x80, 0x07,
  0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60,
  0xE0, 0x08, 0x3F, 0x1F, 0xDC, 0xEE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x73, 0xF8, 0xF8, 0x0E, 0x7D, 0xFF, 0x74, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7E, 0x7F, 0x91, 0xC0, 0x70,
  0x30, 0x38, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0xFE,
  0x7F, 0x91, 0xC0, 0x60, 0x70, 0xF0, 0xF0, 0x7E, 0x07, 0x81, 0xC0, 0xF0,
  0xFF, 0xF7, 0xF0, 0x03, 0x81, 0xE0, 0xF8, 0x3E, 0x1B, 0x8E, 0xE3, 0x39,
  0xCE, 0x63, 0xBF, 0xFF, 0xFC, 0x0E, 0x03, 0x80, 0xE0, 0x7F, 0x3F, 0x98,
  0x1C, 0x0E, 0x07, 0xF3, 0xFC, 0x8F, 0x03, 0x81, 0xC0, 0xF0, 0xEF, 0xF7,
  0xF0, 0x1F, 0x3F, 0x9C, 0x1C, 0x0E, 0x06, 0xFB, 0xFD, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x7E,
  0x7F, 0xB8, 0xFC, 0x7E, 0x73, 0xF8, 0xF0, 0xFE, 0xE7, 0x61, 0xF0, 0xFC,
  0x7F, 0xF3, 0xF0, 0x7E, 0x7F, 0xB9, 0xDC, 0x7C, 0x3F, 0x1F, 0x9F, 0xFF,
  0x7B, 0x81, 0xC1, 0xC1, 0xEF, 0xE7, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x1F, 0xFD, 0x80, 0x01, 0x83, 0xC7, 0xCF, 0x8F, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0xF9, 0xF0, 0xE0, 0x40,
  0x00, 0xFE, 0xFF, 0x47, 0x03, 0x07, 0x0F, 0x1E, 0x18, 0x18, 0x00, 0x00,
  0x38, 0x38, 0x38, 0x0F, 0xF0, 0x38, 0xF0, 0xC0, 0x73, 0x1E, 0x66, 0x7E,
  0xF9, 0xCC, 0xF3, 0x19, 0xE6, 0x33, 0xCC, 0xE7, 0x99, 0xDB, 0x3F, 0xF7,
  0x39, 0xC7, 0x00, 0x07, 0x06, 0x07, 0xFC, 0x01, 0xC0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x3B, 0x01, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x1C, 0x3F, 0xE3,
  0xFF, 0x1F, 0xFC, 0xE0, 0xEF, 0x07, 0x70, 0x3C, 0xFF, 0x7F, 0xF0, 0xF8,
  0x7C, 0x3F, 0xFB, 0xF9, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0xFF, 0xF7, 0xF0,
  0x1F, 0xCF, 0xF7, 0x89, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x07, 0x01, 0xE3, 0x3F, 0xC7, 0xF0, 0xFE, 0x3F, 0xEC, 0x7B, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x3E, 0xFF, 0x3F, 0x00,
  0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE1, 0xC3, 0x87, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x00, 0x1F, 0xE7, 0xF9, 0xE1, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0xFF,
  0x1F, 0xE0, 0xFC, 0x1D, 0xC3, 0xBC, 0x73, 0xFE, 0x3F, 0x80, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xFF, 0xF0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xAE, 0xFB, 0xC0, 0xE3, 0xF8, 0xEE, 0x73, 0xBC, 0xEE, 0x3F,
  0x0F, 0xC3, 0xF8, 0xEE, 0x3B, 0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x70, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xD8, 0x7F, 0x63, 0xFD,
  0xCD, 0xF7, 0x37, 0xCD, 0xDF, 0x36, 0x7C, 0xF9, 0xF1, 0xE7, 0xC7, 0x1F,
  0x1C, 0x70, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3D, 0xC7, 0xB8, 0xF3, 0x9E,
  0x73, 0xC7, 0x78, 0xEF, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xC0, 0x02, 0x01,
  0xFC, 0x3F, 0xE7, 0x0E, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x77, 0x0F, 0x79, 0xE3, 0xFE, 0x1F, 0x80, 0xFE, 0x7F, 0xB1,
  0xD8, 0x7C, 0x3E, 0x3F, 0xFD, 0xFE, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x02, 0x01, 0xFC, 0x3F, 0xE7, 0x0E, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x79, 0xE3, 0xFE, 0x1F, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0xFE, 0x3F, 0xCC, 0x7B, 0x0E, 0xC3, 0xB1, 0xEF,
  0xF3, 0xF8, 0xCE, 0x33, 0x8C, 0x73, 0x1E, 0xC3, 0xB0, 0x70, 0x7F, 0xFF,
  0xE1, 0xE0, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x07, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0xCF, 0x7F, 0x8F, 0xC0,
  0xE0, 0x76, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xC3, 0x9C, 0x39, 0xC3, 0x9C,
  0x19, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0xE1, 0xC1, 0xF8,
  0x78, 0x66, 0x1E, 0x39, 0xC7, 0x8E, 0x73, 0xE3, 0x9C, 0xFC, 0xC3, 0x37,
  0x70, 0xCC, 0xDC, 0x3F, 0x37, 0x0F, 0xCD, 0xC3, 0xE3, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0xF7, 0x1E, 0x39, 0xC3, 0xB8, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0xC7, 0x9C, 0x70,
  0xEF, 0x0F, 0xE0, 0xEE, 0x1D, 0xC7, 0x1C, 0xE3, 0xB8, 0x3F, 0x07, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xDF,
  0xF0, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xF8, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C,
  0x0C, 0x0E, 0x06, 0x06, 0x07, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x7F, 0xF8, 0x0C, 0x01, 0xC0, 0x7C, 0x0D, 0x83, 0xB8, 0x63,
  0x1C, 0x73, 0x06, 0xE0, 0xE0, 0xFF, 0xF1, 0x86, 0x7E, 0x3F, 0x91, 0xE0,
  0x73, 0xFB, 0xFF, 0x8F, 0xC7, 0xE7, 0xFF, 0xDE, 0xE0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xEF, 0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xF3, 0xBF, 0xEE, 0xF0, 0x3F, 0x7F, 0xF2, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF1, 0x7F, 0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xDB, 0xFF, 0xCF, 0xC7,
  0xE1, 0xF0, 0xF8, 0x7C, 0x7F, 0x3B, 0xFC, 0xF6, 0x3E, 0x3F, 0xB8, 0xFC,
  0x7F, 0xFF, 0xFF, 0x81, 0xC0, 0xF0, 0xBF, 0xCF, 0xC0, 0x1F, 0x3E, 0x38,
  0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3D, 0xBF, 0xFC, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC7, 0xF3, 0xBF, 0xCF,
  0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF,
  0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1C, 0xFD, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xC6, 0x03, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE1, 0xF8, 0xEE, 0x73, 0xB8, 0xEE, 0x3F, 0x8F, 0xE3, 0x9C, 0xE3,
  0xB8, 0xEE, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF, 0x3C, 0xFF,
  0xFE, 0xF3, 0xCE, 0xE3, 0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xEF, 0x3F, 0xEF, 0x3B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x3E, 0x1F, 0xCF,
  0x3B, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xF3, 0x9F, 0xC3, 0xE0, 0xEF,
  0x3F, 0xEF, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xBF, 0xEE,
  0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x3D, 0xBF, 0xFC, 0xFC, 0x7E,
  0x1F, 0x0F, 0x87, 0xC7, 0xF3, 0xBF, 0xCF, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0xEF, 0xFF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x7F,
  0xFF, 0x8F, 0x0F, 0x8F, 0x87, 0x87, 0x8F, 0xFF, 0xF0, 0x38, 0x71, 0xFF,
  0xF3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xF1, 0xE0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xF3, 0xDF, 0xF3, 0xDC, 0xE1,
  0xD8, 0x77, 0x1D, 0xCE, 0x33, 0x8E, 0xE3, 0xB0, 0x7C, 0x1F, 0x07, 0x80,
  0xE0, 0xE3, 0xC7, 0x63, 0xC6, 0x73, 0xCE, 0x73, 0xCE, 0x76, 0xCC, 0x36,
  0x6C, 0x36, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1C, 0x78, 0x1C, 0x38, 0xF1,
  0xDC, 0xE3, 0xB8, 0xFC, 0x1F, 0x07, 0x81, 0xF0, 0xFC, 0x3B, 0x9C, 0xEE,
  0x1C, 0xE1, 0xD8, 0x77, 0x1D, 0xC6, 0x33, 0x8E, 0xE3, 0xB0, 0x7C, 0x1F,
  0x07, 0x80, 0xE0, 0x38, 0x1C, 0x1F, 0x07, 0x81, 0xC0, 0xFF, 0xFC, 0x38,
  0xE1, 0xC7, 0x1C, 0x38, 0xE1, 0xFF, 0xF8, 0x1E, 0x3C, 0x60, 0xC1, 0x83,
  0x0E, 0x7C, 0xE1, 0xF0, 0xE0, 0xC1, 0x83, 0x06, 0x0F, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x0F, 0x1C, 0xF7, 0x1C,
  0x71, 0xC7, 0x3C, 0xE0, 0x70, 0xFF, 0xE7, 0xF0, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_Bold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 9, 1, -14 },
  { 12, 11, 14, 12, 0, -14 },
  { 32, 9, 16, 11, 1, -15 },
  { 50, 15, 14, 17, 1, -14 },
  { 77, 13, 14, 14, 1, -14 },
  { 100, 3, 5, 5, 1, -14 },
  { 102, 5, 17, 7, 1, -14 },
  { 113, 6, 17, 7, 0, -14 },
  { 126, 9, 9, 10, 1, -15 },
  { 137, 9, 10, 11, 1, -12 },
  { 149, 3, 5, 5, 1, -2 },
  { 151, 5, 3, 6, 1, -7 },
  { 153, 3, 3, 5, 1, -3 },
  { 155, 8, 14, 8, 0, -14 },
  { 169, 9, 15, 11, 1, -15 },
  { 186, 7, 14, 11, 1, -14 },
  { 199, 9, 14, 11, 1, -14 },
  { 215, 9, 14, 11, 1, -14 },
  { 231, 10, 14, 11, 0, -14 },
  { 249, 9, 14, 11, 1, -14 },
  { 265, 9, 14, 11, 1, -14 },
  { 281, 10, 14, 11, 0, -14 },
  { 299, 9, 14, 11, 1, -14 },
  { 315, 9, 14, 11, 1, -14 },
  { 331, 3, 11, 5, 1, -11 },
  { 336, 3, 14, 6, 1, -11 },
  { 342, 9, 10, 11, 1, -12 },
  { 354, 9, 6, 11, 1, -10 },
  { 361, 9, 10, 11, 1, -12 },
  { 373, 8, 14, 9, 0, -14 },
  { 387, 15, 16, 17, 1, -14 },
  { 417, 13, 14, 13, 0, -14 },
  { 440, 9, 14, 12, 2, -14 },
  { 456, 10, 14, 12, 1, -14 },
  { 474, 10, 14, 13, 2, -14 },
  { 492, 7, 14, 10, 2, -14 },
  { 505, 7, 14, 10, 2, -14 },
  { 518, 11, 14, 13, 1, -14 },
  { 538, 10, 14, 14, 2, -14 },
  { 556, 6, 14, 7, 1, -14 },
  { 567, 6, 18, 6, -1, -14 },
  { 581, 10, 14, 12, 2, -14 },
  { 599, 8, 14, 10, 2, -14 },
  { 613, 14, 14, 18, 2, -14 },
  { 638, 11, 14, 15, 2, -14 },
  { 658, 12, 15, 14, 1, -15 },
  { 681, 9, 14, 11, 2, -14 },
  { 697, 12, 18, 14, 1, -15 },
  { 724, 10, 14, 12, 2, -14 },
  { 742, 8, 14, 10, 1, -14 },
  { 756, 10, 14, 10, 0, -14 },
  { 774, 10, 14, 14, 2, -14 },
  { 792, 12, 14, 12, 0, -14 },
  { 813, 18, 14, 18, 0, -14 },
  { 845, 12, 14, 12, 0, -14 },
  { 866, 11, 14, 11, 0, -14 },
  { 886, 10, 14, 10, 0, -14 },
  { 904, 5, 17, 6, 1, -14 },
  { 915, 8, 14, 8, 0, -14 },
  { 929, 5, 17, 6, 0, -14 },
  { 940, 11, 9, 11, 0, -14 },
  { 953, 8, 1, 8, 0, 2 },
  { 954, 5, 3, 7, 1, -15 },
  { 956, 9, 11, 11, 1, -11 },
  { 969, 10, 15, 12, 1, -15 },
  { 988, 8, 11, 9, 1, -11 },
  { 999, 9, 15, 12, 1, -15 },
  { 1016, 9, 11, 11, 1, -11 },
  { 1029, 8, 15, 7, 0, -15 },
  { 1044, 9, 16, 12, 1, -11 },
  { 1062, 10, 15, 12, 1, -15 },
  { 1081, 3, 15, 6, 1, -15 },
  { 1087, 5, 20, 6, -1, -15 },
  { 1100, 10, 15, 11, 1, -15 },
  { 1119, 3, 15, 6, 1, -15 },
  { 1125, 16, 11, 18, 1, -11 },
  { 1147, 10, 11, 12, 1, -11 },
  { 1161, 10, 11, 12, 1, -11 },
  { 1175, 10, 16, 12, 1, -11 },
  { 1195, 9, 16, 12, 1, -11 },
  { 1213, 7, 11, 8, 1, -11 },
  { 1223, 7, 11, 9, 1, -11 },
  { 1233, 7, 13, 8, 0, -13 },
  { 1245, 10, 11, 12, 1, -11 },
  { 1259, 10, 11, 10, 0, -11 },
  { 1273, 16, 11, 16, 0, -11 },
  { 1295, 10, 11, 10, 0, -11 },
  { 1309, 10, 16, 10, 0, -11 },
  { 1329, 7, 11, 9, 1, -11 },
  { 1339, 7, 17, 8, 0, -14 },
  { 1354, 2, 20, 10, 4, -15 },
  { 1359, 6, 17, 8, 1, -14 },
  { 1372, 9, 4, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Bold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD20PT7B_H_
