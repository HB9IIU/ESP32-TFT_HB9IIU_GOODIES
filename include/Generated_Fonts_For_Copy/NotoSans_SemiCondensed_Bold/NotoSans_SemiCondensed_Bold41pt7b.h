#ifndef _NOTOSANS_SEMICONDENSED_BOLD41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFB, 0xE3, 0xF7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x78, 0x00, 0xF1,
  0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x3C, 0x78, 0x00,
  0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x81, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x81, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x3E, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0xC3, 0x3F, 0x30, 0x0F, 0xCC, 0x03, 0xF3,
  0x00, 0xFE, 0xC0, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xCF, 0xC0, 0x33, 0xF8,
  0x0C, 0x7F, 0x03, 0x3F, 0xFC, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0xF8, 0x01,
  0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xDF, 0x80, 0xF0, 0x03, 0xC7, 0xC0,
  0xF8, 0x03, 0xE3, 0xE0, 0x78, 0x01, 0xF0, 0xF0, 0x7C, 0x00, 0xF8, 0x78,
  0x3C, 0x00, 0x7C, 0x3C, 0x3E, 0x00, 0x3E, 0x1E, 0x1E, 0x00, 0x1F, 0x0F,
  0x1F, 0x00, 0x0F, 0x8F, 0x8F, 0x0F, 0x83, 0xC7, 0xCF, 0x9F, 0xE1, 0xF3,
  0xE7, 0x9F, 0xF8, 0xFF, 0xE7, 0xCF, 0xFE, 0x3F, 0xE3, 0xCF, 0x9F, 0x0F,
  0xE3, 0xE7, 0xC7, 0x81, 0xC1, 0xE3, 0xC3, 0xE0, 0x01, 0xF1, 0xE1, 0xF0,
  0x00, 0xF0, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x7C, 0x00, 0x78, 0x3C, 0x3E,
  0x00, 0x7C, 0x1E, 0x1F, 0x00, 0x3C, 0x0F, 0x8F, 0x00, 0x3E, 0x07, 0xC7,
  0x80, 0x1E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0xFF, 0xC0, 0x0F, 0x00, 0x3F,
  0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xF0, 0xFF, 0xE0, 0xFE, 0x3F,
  0xFC, 0x1F, 0x8F, 0xFF, 0xC3, 0xF1, 0xFC, 0xFC, 0xFE, 0x3F, 0x1F, 0xDF,
  0x8F, 0xE1, 0xFF, 0xF1, 0xFC, 0x1F, 0xFC, 0x3F, 0x81, 0xFF, 0x87, 0xF0,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF,
  0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE0, 0x07, 0xE1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xE3, 0xC3, 0x9F,
  0xBB, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x0E,
  0x0E, 0x00, 0x41, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x3F, 0x8F, 0xC3, 0xF3, 0xF0, 0x3E, 0x7E,
  0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0,
  0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x7E, 0x3F, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xBF, 0x7C, 0xFC, 0xE3, 0xF1, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFE, 0x3F, 0x8F, 0x03, 0xF0,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C, 0x3F, 0x84, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xDF, 0x80, 0x7D, 0xF8, 0x07, 0x9F, 0x80, 0xF9,
  0xF8, 0x0F, 0x1F, 0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x83, 0xC1, 0xF8, 0x7C,
  0x1F, 0x8F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xDF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF8, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFF,
  0x00, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xC0, 0x8F, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x3F, 0x07, 0xDF, 0xF0, 0xFB, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE,
  0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x3F,
  0x0F, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE,
  0x1F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xF8, 0xFC,
  0x3F, 0x1F, 0xCF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xF7, 0xF1, 0xFC, 0x7F, 0x3F, 0x07, 0xF7, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xEF, 0xE1,
  0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF,
  0x3F, 0x9F, 0x83, 0xF3, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0x7C, 0x7F, 0xCF, 0x83, 0xE3, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x86, 0x1F,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x38,
  0xFB, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x1C, 0x3E, 0x7F, 0x7F,
  0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x30,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xE1, 0xFC, 0xC0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x3E, 0x07, 0xF0, 0x78, 0xF0, 0x7F,
  0xF1, 0xE7, 0xC3, 0xFF, 0xC7, 0xDE, 0x1F, 0xFF, 0x0F, 0xF8, 0xFC, 0x3C,
  0x3F, 0xE3, 0xE0, 0xF0, 0xFF, 0x0F, 0x03, 0xC3, 0xFC, 0x3C, 0x0F, 0x0F,
  0xF1, 0xF0, 0x3C, 0x3F, 0xC7, 0xC0, 0xF0, 0xFF, 0x1F, 0x07, 0xC3, 0xFC,
  0x3C, 0x1F, 0x0F, 0xF0, 0xF0, 0x7C, 0x7B, 0xC3, 0xE3, 0xFB, 0xEF, 0x87,
  0xFF, 0xFF, 0x3E, 0x1F, 0xF3, 0xFC, 0x78, 0x3F, 0x87, 0xC1, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0x00, 0x3F, 0xF1, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00,
  0x3F, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xF9, 0xF8, 0xFF, 0x00, 0x87, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x31, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF,
  0xC0, 0x7F, 0xBF, 0x07, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xE7, 0xE3, 0xFC, 0x01, 0x8F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xDF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF8, 0x03, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0xC0, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0xC3, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x83, 0xC0, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xEF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xF3, 0xF8, 0x0F, 0xCF,
  0xC0, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xBC, 0x01, 0xFF, 0xFE, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xDF, 0x03, 0xEF, 0xFF, 0x7C,
  0x0F, 0xBF, 0xFD, 0xF0, 0x3C, 0xFF, 0xF3, 0xE1, 0xF3, 0xFF, 0xCF, 0x87,
  0xCF, 0xFF, 0x3E, 0x1E, 0x3F, 0xFC, 0xF8, 0xF8, 0xFF, 0xF1, 0xF3, 0xE3,
  0xFF, 0xC7, 0xCF, 0x8F, 0xFF, 0x1F, 0x7C, 0x3F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xF0, 0xFF, 0xC3, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x3F, 0xFC,
  0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x03,
  0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFB, 0xF0, 0x1F, 0xFB, 0xF0, 0x1F, 0xFD, 0xF8, 0x1F,
  0xFD, 0xF8, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7E, 0x1F,
  0xFC, 0x7F, 0x1F, 0xFC, 0x3F, 0x1F, 0xFC, 0x3F, 0x9F, 0xFC, 0x1F, 0x9F,
  0xFC, 0x1F, 0xDF, 0xFC, 0x0F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFF, 0x9F, 0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7,
  0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFD, 0xF8, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0x83, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x9F, 0xF0, 0xFE,
  0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xFF,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0x09, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xC0,
  0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x7C, 0x01, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x3F, 0x7E, 0x03, 0xFC, 0x03, 0xE7, 0xE0,
  0x3F, 0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xE0, 0x7E,
  0x3F, 0x07, 0xFE, 0x07, 0xC3, 0xF0, 0x7F, 0xE0, 0xFC, 0x3F, 0x07, 0xDE,
  0x0F, 0xC1, 0xF0, 0x79, 0xF0, 0xFC, 0x1F, 0x0F, 0x9F, 0x0F, 0xC1, 0xF8,
  0xF9, 0xF0, 0xF8, 0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0xF8, 0xF8, 0xF9, 0xF8,
  0x0F, 0x9F, 0x0F, 0x9F, 0x80, 0xF9, 0xF0, 0xF9, 0xF0, 0x0F, 0xDF, 0x0F,
  0x9F, 0x00, 0xFD, 0xF0, 0x7B, 0xF0, 0x07, 0xDE, 0x07, 0xFF, 0x00, 0x7D,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0x81, 0xFC, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x03,
  0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F,
  0x81, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF1, 0xF8,
  0x0F, 0xE3, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x07, 0xE1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0,
  0x0F, 0x9F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xE0, 0x3E, 0x0F, 0x01, 0xE0,
  0x7C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xF7,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFE, 0x0F, 0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xEF, 0xC1, 0xFD,
  0xF8, 0x7F, 0xBF, 0xFF, 0xF7, 0xFF, 0xBE, 0x7F, 0xE7, 0xC7, 0xF8, 0x78,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x7C, 0x1F, 0xBF, 0xC3,
  0xEF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFE, 0x3F, 0xBF, 0x83, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFB, 0xFE, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xF7, 0xFE, 0x3E,
  0x3F, 0x80, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x7F, 0x06, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x01, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xC7, 0xE3, 0xFE, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFD, 0xFE, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xBE, 0x3F, 0xE7, 0xC3,
  0xF8, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x09, 0xFE, 0x0F, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xFD, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x83, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xFE,
  0x7C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC1, 0xFD, 0xFE, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xEF,
  0xC3, 0xF9, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFD, 0x00, 0x3F,
  0xB8, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x7C,
  0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFE, 0x3F,
  0xBF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0xFB, 0xFF, 0xFF, 0xFD, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xF8,
  0x7C, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x80, 0xFB,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x7E, 0x0F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC,
  0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xC1,
  0xF3, 0xFE, 0x3F, 0xE3, 0xEF, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE3, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE,
  0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0x80, 0xFF, 0xF0,
  0x3F, 0x01, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81,
  0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x0F,
  0xC0, 0x7F, 0xF8, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xE0, 0x7E,
  0x03, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFE, 0x3F, 0xBF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE,
  0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x3F, 0xE3,
  0xEF, 0xFE, 0x7D, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x3F, 0xBF, 0x83, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFB, 0xFE, 0xFF, 0x7F, 0xFF, 0xEF, 0xBF, 0xF9, 0xF3, 0xFE, 0x3F,
  0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x7C, 0xFF, 0xEF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFD, 0xFE, 0x7F, 0xBF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xEF, 0xC3, 0xF9, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x87,
  0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0x01, 0xBE, 0x00,
  0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0xC7,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0x3E, 0x3F, 0xC7, 0xC0,
  0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x87, 0xC0,
  0xFC, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x03, 0xEF,
  0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x07,
  0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x3E, 0x7E, 0x0F,
  0xF0, 0x7E, 0x3E, 0x0F, 0xF8, 0x7E, 0x3F, 0x0F, 0xF8, 0x7E, 0x3F, 0x1F,
  0x78, 0x7C, 0x3F, 0x1E, 0x78, 0xFC, 0x1F, 0x1E, 0x78, 0xFC, 0x1F, 0x9E,
  0x7C, 0xFC, 0x1F, 0x9E, 0x3C, 0xF8, 0x1F, 0xBE, 0x3C, 0xF8, 0x0F, 0xBC,
  0x3D, 0xF8, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xF9, 0xF8, 0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x1F,
  0xC1, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0xCF, 0xC0, 0xFC,
  0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFC,
  0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0,
  0x7C, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xEF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x1F, 0xF0, 0xFF, 0x07,
  0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xC1,
  0xFE, 0x1F, 0xF1, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x2F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 15, 10, 19, 2, -29 },
  { 46, 23, 29, 24, 1, -29 },
  { 130, 18, 33, 22, 2, -31 },
  { 205, 33, 30, 35, 1, -30 },
  { 329, 27, 30, 28, 1, -30 },
  { 431, 6, 10, 10, 2, -29 },
  { 439, 11, 35, 14, 2, -29 },
  { 488, 11, 35, 14, 1, -29 },
  { 537, 19, 18, 21, 1, -31 },
  { 580, 18, 19, 22, 2, -24 },
  { 623, 8, 10, 11, 1, -5 },
  { 633, 11, 6, 13, 1, -14 },
  { 642, 7, 6, 11, 2, -6 },
  { 648, 17, 30, 17, 0, -30 },
  { 712, 19, 30, 22, 1, -30 },
  { 784, 14, 29, 22, 2, -29 },
  { 835, 19, 30, 22, 1, -30 },
  { 907, 19, 30, 22, 1, -30 },
  { 979, 20, 29, 22, 1, -29 },
  { 1052, 18, 29, 22, 2, -29 },
  { 1118, 19, 30, 22, 1, -30 },
  { 1190, 19, 29, 22, 1, -29 },
  { 1259, 19, 30, 22, 1, -30 },
  { 1331, 19, 30, 22, 1, -30 },
  { 1403, 7, 23, 11, 2, -23 },
  { 1424, 8, 28, 11, 1, -23 },
  { 1452, 19, 21, 22, 1, -25 },
  { 1502, 18, 13, 22, 2, -21 },
  { 1532, 18, 21, 22, 2, -25 },
  { 1580, 17, 30, 18, 0, -30 },
  { 1644, 30, 33, 34, 2, -30 },
  { 1768, 26, 29, 26, 0, -29 },
  { 1863, 20, 29, 25, 3, -29 },
  { 1936, 21, 30, 24, 2, -30 },
  { 2015, 22, 29, 27, 3, -29 },
  { 2095, 16, 29, 21, 3, -29 },
  { 2153, 16, 29, 21, 3, -29 },
  { 2211, 22, 30, 27, 2, -30 },
  { 2294, 22, 29, 29, 3, -29 },
  { 2374, 13, 29, 15, 1, -29 },
  { 2422, 12, 38, 13, -3, -29 },
  { 2479, 22, 29, 25, 3, -29 },
  { 2559, 17, 29, 21, 3, -29 },
  { 2621, 30, 29, 36, 3, -29 },
  { 2730, 24, 29, 31, 3, -29 },
  { 2817, 25, 30, 29, 2, -30 },
  { 2911, 19, 29, 24, 3, -29 },
  { 2980, 25, 37, 29, 2, -30 },
  { 3096, 22, 29, 25, 3, -29 },
  { 3176, 17, 30, 21, 2, -30 },
  { 3240, 20, 29, 21, 1, -29 },
  { 3313, 22, 29, 28, 3, -29 },
  { 3393, 24, 29, 24, 0, -29 },
  { 3480, 36, 29, 36, 0, -29 },
  { 3611, 24, 29, 25, 0, -29 },
  { 3698, 23, 29, 23, 0, -29 },
  { 3782, 19, 29, 21, 1, -29 },
  { 3851, 9, 35, 13, 3, -29 },
  { 3891, 17, 30, 17, 0, -30 },
  { 3955, 10, 35, 13, 1, -29 },
  { 3999, 21, 18, 23, 1, -29 },
  { 4047, 17, 2, 17, 0, 4 },
  { 4052, 11, 6, 14, 2, -31 },
  { 4061, 19, 23, 23, 1, -23 },
  { 4116, 19, 31, 24, 3, -31 },
  { 4190, 16, 23, 19, 2, -23 },
  { 4236, 19, 31, 24, 2, -31 },
  { 4310, 19, 23, 22, 2, -23 },
  { 4365, 15, 31, 15, 1, -31 },
  { 4424, 19, 33, 24, 2, -23 },
  { 4503, 19, 31, 24, 3, -31 },
  { 4577, 6, 31, 11, 3, -31 },
  { 4601, 11, 41, 11, -2, -31 },
  { 4658, 20, 31, 23, 3, -31 },
  { 4736, 6, 31, 11, 3, -31 },
  { 4760, 31, 23, 37, 3, -23 },
  { 4850, 19, 23, 24, 3, -23 },
  { 4905, 20, 23, 24, 2, -23 },
  { 4963, 19, 33, 24, 3, -23 },
  { 5042, 19, 33, 24, 2, -23 },
  { 5121, 13, 23, 17, 3, -23 },
  { 5159, 15, 23, 19, 2, -23 },
  { 5203, 14, 27, 16, 1, -27 },
  { 5251, 19, 22, 24, 3, -22 },
  { 5304, 21, 22, 21, 0, -22 },
  { 5362, 32, 22, 32, 0, -22 },
  { 5450, 21, 22, 21, 0, -22 },
  { 5508, 21, 32, 21, 0, -22 },
  { 5592, 16, 22, 18, 1, -22 },
  { 5636, 13, 35, 15, 1, -29 },
  { 5693, 5, 40, 21, 8, -31 },
  { 5718, 13, 35, 15, 2, -29 },
  { 5775, 19, 7, 22, 1, -18 },
};

const GFXfont NotoSans_SemiCondensed_Bold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD41PT7B_H_
