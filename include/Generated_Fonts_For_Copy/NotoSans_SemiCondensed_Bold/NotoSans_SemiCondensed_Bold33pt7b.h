#ifndef _NOTOSANS_SEMICONDENSED_BOLD33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x00,
  0x00, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x71, 0xE1, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0xF1, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x03,
  0x8E, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x1E, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xE3, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0F, 0x00, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0x9F,
  0x67, 0x7C, 0xC0, 0xF9, 0x80, 0xFB, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xBE, 0x03, 0x3E, 0x06, 0x7F,
  0x8D, 0xFF, 0xFF, 0xDF, 0xFF, 0x9F, 0xFC, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1E, 0x00, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF8, 0x0F,
  0x01, 0xEF, 0x07, 0x80, 0xF3, 0xC1, 0xE0, 0x3C, 0x70, 0x70, 0x0F, 0x1E,
  0x3C, 0x03, 0xC7, 0x8E, 0x00, 0xF1, 0xE7, 0x80, 0x3C, 0x71, 0xC0, 0x0F,
  0x3C, 0xF3, 0xF1, 0xEF, 0x39, 0xFE, 0x7F, 0x9E, 0xFF, 0x8F, 0xE7, 0x3C,
  0xF1, 0xE3, 0xCF, 0x3C, 0x00, 0xE3, 0x8F, 0x00, 0x78, 0xE3, 0xC0, 0x1C,
  0x38, 0xF0, 0x0F, 0x0E, 0x3C, 0x03, 0x83, 0xCF, 0x01, 0xE0, 0xF3, 0xC0,
  0x70, 0x1F, 0xE0, 0x3C, 0x07, 0xF8, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC1, 0xF3, 0xFE, 0x1F, 0x3F, 0xF8, 0xF9, 0xF7, 0xE7,
  0xDF, 0x1F, 0xFC, 0xF8, 0x7F, 0xE7, 0xC1, 0xFE, 0x3E, 0x07, 0xF1, 0xF8,
  0x3F, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F,
  0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF0, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x0E, 0x38, 0xDF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xF7, 0x87, 0xC7, 0x83, 0x8E, 0x01, 0x10,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7D, 0xF7, 0xDE, 0x79, 0xEF,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xE7, 0xCF, 0x87, 0x9E,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3E, 0xF0, 0x7D, 0xF0, 0xFB,
  0xE3, 0xE3, 0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0x01, 0xE0, 0x7C,
  0x1F, 0x8F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x63, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xE7,
  0xFF, 0xE7, 0xC7, 0xE6, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE3, 0x87,
  0xC4, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x7F, 0xC0,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x38, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFB, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFE, 0xFF, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF0, 0x00, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE3, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF7,
  0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xE1, 0xF7, 0xFF, 0xE7, 0xFF, 0x87,
  0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC3, 0xEF, 0x07, 0xDE,
  0x0F, 0xBE, 0x1F, 0x7C, 0x7C, 0x7F, 0xF8, 0x7F, 0xC0, 0x7F, 0x01, 0xFF,
  0x07, 0xFF, 0x1F, 0x1F, 0x3C, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF,
  0xF7, 0x87, 0x8F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE7, 0xFF,
  0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xC0, 0x7D, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xDF, 0x7D, 0xE7, 0x9E, 0xF3, 0xC0, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8,
  0x1F, 0xC0, 0x3E, 0x00, 0x60, 0x00, 0x0F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFE, 0x70, 0xFD, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0x70, 0xF0, 0x38, 0x3C, 0x78, 0x7F,
  0xCE, 0x78, 0xFF, 0xE7, 0xBC, 0x78, 0xF3, 0xDC, 0x78, 0x70, 0xEE, 0x3C,
  0x38, 0x77, 0x1C, 0x1C, 0x3F, 0x8E, 0x0E, 0x1F, 0xC7, 0x07, 0x1F, 0xE3,
  0x87, 0x8F, 0x71, 0xE3, 0xC7, 0x38, 0xFF, 0xFF, 0x9E, 0x3F, 0xBF, 0x8F,
  0x0F, 0x8F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x40,
  0x1F, 0xC7, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0x9F,
  0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0x78, 0x0F,
  0x83, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0,
  0x07, 0xDF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF0, 0xFE, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x7C,
  0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x3F, 0x0E, 0x7E, 0x02, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x02, 0x3F, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFE, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0x81, 0xFB, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0xDE, 0x1F, 0xEF, 0xFF,
  0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x83, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xF7,
  0xC0, 0x7D, 0xF8, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFC, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0xE7, 0xFF, 0xFF, 0xF7, 0xF3, 0xE0, 0xF0, 0x0F, 0xF8,
  0x0F, 0xBC, 0x0F, 0xDE, 0x07, 0xCF, 0x07, 0xC7, 0x87, 0xE3, 0xC3, 0xE1,
  0xE3, 0xE0, 0xF3, 0xE0, 0x7B, 0xF0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xF7, 0xC1, 0xF3, 0xE0, 0xF0, 0xF8, 0x78, 0x7E, 0x3C,
  0x1F, 0x1E, 0x0F, 0xCF, 0x03, 0xE7, 0x81, 0xFB, 0xC0, 0x7D, 0xE0, 0x3F,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xEF, 0xF7, 0x83, 0xDF, 0xEF, 0x07, 0xBF, 0xDE, 0x0F, 0x7F, 0x9C,
  0x3C, 0xFF, 0x3C, 0x79, 0xFE, 0x78, 0xF3, 0xFC, 0xF3, 0xC7, 0xF8, 0xF7,
  0x8F, 0xF1, 0xEF, 0x1F, 0xE3, 0xDC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0,
  0xFF, 0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3C, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF7, 0xC1, 0xFE, 0xF8, 0x3F,
  0xCF, 0x87, 0xF9, 0xF0, 0xFF, 0x1F, 0x1F, 0xE3, 0xF3, 0xFC, 0x3E, 0x7F,
  0x83, 0xEF, 0xF0, 0x7D, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0x01, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7E,
  0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x3F, 0xDE, 0x0F, 0xBC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xF7, 0x9F, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F,
  0xF8, 0x7F, 0x80, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3E, 0x7C, 0x07, 0xE7, 0xE0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0x1F, 0xC7, 0x83, 0xF3, 0xC0, 0xF9,
  0xE0, 0x7C, 0xF0, 0x3E, 0x78, 0x3F, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0x81, 0xE3, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C,
  0x1F, 0x1E, 0x0F, 0x8F, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x7D, 0xE0, 0x3F,
  0x07, 0xE0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0x7E, 0x79, 0xF0, 0x27, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x9E, 0x00, 0x79,
  0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0x7F, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3E, 0xF0, 0x1F, 0x81, 0xF7,
  0x81, 0xFC, 0x0F, 0x3E, 0x0F, 0xE0, 0x79, 0xF0, 0x7F, 0x07, 0xC7, 0x83,
  0xB8, 0x3E, 0x3C, 0x1D, 0xE1, 0xF1, 0xF1, 0xEF, 0x0F, 0x0F, 0x8F, 0x78,
  0xF8, 0x7C, 0x7B, 0xC7, 0xC1, 0xE3, 0xCF, 0x3E, 0x0F, 0x3C, 0x79, 0xE0,
  0x7D, 0xE3, 0xCF, 0x03, 0xEF, 0x1E, 0xF8, 0x0F, 0x78, 0x77, 0xC0, 0x7B,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x01,
  0xF0, 0xF8, 0x3E, 0x0F, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xEF, 0xC0, 0x3F,
  0xF8, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3C, 0xF0,
  0x1E, 0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x03, 0xC7, 0x81, 0xE3, 0x80,
  0x7B, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0xE3, 0xF1, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x3F, 0xBF, 0xFF, 0x7F, 0xDE, 0x7F, 0x3C, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xF3,
  0xF0, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0x8F, 0xFE, 0x7E, 0x09, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x27, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F,
  0xDF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x1F, 0x7C, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0xCF, 0x07,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x02, 0x3F, 0x1E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x0F,
  0xF1, 0xFF, 0x3F, 0xE3, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xFC, 0xFF,
  0xCF, 0xFC, 0xFF, 0xC3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0xCF, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x1F, 0x7C,
  0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x60, 0x3E, 0x7F, 0xFE, 0x7F,
  0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xFC, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1E, 0x7F, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x1F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0xF8, 0x3E,
  0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x9F, 0x07, 0xDF, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0x3E, 0x1F, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF3, 0xF8, 0xFE, 0x7B, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0xF8,
  0x3F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x0F,
  0x81, 0xFF, 0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x7F, 0xC1, 0xF0, 0x3F, 0xE0,
  0xF8, 0x1F, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x03, 0xC0,
  0xF3, 0xF9, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3C, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xEF, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xCF, 0x03, 0xE7,
  0xC1, 0xF3, 0xE0, 0xF8, 0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0xF1, 0xF8, 0xF3, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1E, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xF9,
  0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xCF, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xDF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF1, 0xFE, 0x7F,
  0xDF, 0xFF, 0xFF, 0xF1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x1F, 0xE3,
  0xFF, 0xDF, 0xFD, 0xF0, 0xEF, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xE3, 0xFE, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xFF, 0x9F, 0xF1, 0xFE, 0x1F, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0xFF, 0xBF, 0xFF, 0x3F, 0xDE, 0x3F, 0x1C, 0xF8, 0x0F, 0xBC,
  0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8,
  0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x3F, 0x07, 0xDE, 0x0F, 0xC1, 0xE7, 0xC3, 0xF0, 0x79, 0xF0, 0xFC,
  0x3E, 0x7C, 0x7F, 0x8F, 0x8F, 0x1F, 0xE3, 0xC3, 0xE7, 0x38, 0xF0, 0xF9,
  0xCE, 0x7C, 0x1E, 0xF3, 0xDF, 0x07, 0xBC, 0xF7, 0x81, 0xEF, 0x1D, 0xE0,
  0x7B, 0x87, 0x78, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xFC,
  0x1F, 0xBE, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xF8, 0xF8, 0x7C, 0x7E, 0x7C, 0x1F, 0x7E,
  0x07, 0xC0, 0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE3, 0xC1,
  0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C, 0x1F, 0x3C, 0x0F, 0x9E, 0x03,
  0xDF, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x7C, 0x1F, 0x87, 0xF0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF1, 0xFE, 0x3F,
  0x07, 0xF0, 0xFF, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1F, 0x83,
  0xF8, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x3F, 0x1F, 0xE3, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F,
  0x80, 0x7F, 0x03, 0xFF, 0xDF, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 12, 9, 15, 2, -24 },
  { 30, 18, 24, 20, 1, -24 },
  { 84, 15, 27, 18, 1, -25 },
  { 135, 26, 24, 28, 1, -24 },
  { 213, 21, 24, 22, 1, -24 },
  { 276, 5, 9, 8, 2, -24 },
  { 282, 9, 29, 11, 1, -24 },
  { 315, 8, 29, 11, 1, -24 },
  { 344, 15, 15, 17, 1, -25 },
  { 373, 15, 16, 18, 1, -20 },
  { 403, 6, 8, 9, 1, -4 },
  { 409, 8, 4, 10, 1, -11 },
  { 413, 5, 5, 9, 2, -5 },
  { 417, 13, 24, 14, 0, -24 },
  { 456, 15, 24, 18, 1, -24 },
  { 501, 11, 24, 18, 2, -24 },
  { 534, 15, 24, 18, 1, -24 },
  { 579, 15, 24, 18, 1, -24 },
  { 624, 16, 24, 18, 1, -24 },
  { 672, 14, 24, 18, 2, -24 },
  { 714, 15, 24, 18, 1, -24 },
  { 759, 15, 24, 18, 1, -24 },
  { 804, 15, 24, 18, 1, -24 },
  { 849, 15, 24, 18, 1, -24 },
  { 894, 5, 18, 9, 2, -18 },
  { 906, 6, 22, 9, 1, -18 },
  { 923, 15, 16, 18, 1, -20 },
  { 953, 15, 10, 18, 1, -17 },
  { 972, 15, 16, 18, 1, -20 },
  { 1002, 14, 24, 14, 0, -24 },
  { 1044, 25, 27, 27, 1, -24 },
  { 1129, 21, 24, 21, 0, -24 },
  { 1192, 16, 24, 20, 3, -24 },
  { 1240, 16, 24, 19, 2, -24 },
  { 1288, 17, 24, 22, 3, -24 },
  { 1339, 12, 24, 17, 3, -24 },
  { 1375, 12, 24, 17, 3, -24 },
  { 1411, 18, 24, 22, 2, -24 },
  { 1465, 17, 24, 23, 3, -24 },
  { 1516, 10, 24, 12, 1, -24 },
  { 1546, 9, 31, 10, -2, -24 },
  { 1581, 17, 24, 20, 3, -24 },
  { 1632, 13, 24, 17, 3, -24 },
  { 1671, 23, 24, 29, 3, -24 },
  { 1740, 19, 24, 25, 3, -24 },
  { 1797, 20, 24, 24, 2, -24 },
  { 1857, 15, 24, 19, 3, -24 },
  { 1902, 20, 30, 24, 2, -24 },
  { 1977, 17, 24, 20, 3, -24 },
  { 2028, 14, 24, 17, 1, -24 },
  { 2070, 16, 24, 17, 1, -24 },
  { 2118, 17, 24, 23, 3, -24 },
  { 2169, 20, 24, 20, 0, -24 },
  { 2229, 29, 24, 29, 0, -24 },
  { 2316, 20, 24, 20, 0, -24 },
  { 2376, 19, 24, 19, 0, -24 },
  { 2433, 15, 24, 17, 1, -24 },
  { 2478, 8, 29, 11, 2, -24 },
  { 2507, 13, 24, 14, 0, -24 },
  { 2546, 8, 29, 11, 1, -24 },
  { 2575, 17, 15, 18, 1, -24 },
  { 2607, 14, 2, 14, 0, 3 },
  { 2611, 9, 5, 11, 1, -25 },
  { 2617, 15, 18, 18, 1, -18 },
  { 2651, 16, 25, 19, 2, -25 },
  { 2701, 14, 18, 16, 1, -18 },
  { 2733, 16, 25, 19, 1, -25 },
  { 2783, 16, 18, 18, 1, -18 },
  { 2819, 12, 25, 12, 1, -25 },
  { 2857, 16, 26, 19, 1, -18 },
  { 2909, 15, 25, 20, 2, -25 },
  { 2956, 5, 25, 9, 2, -25 },
  { 2972, 8, 33, 9, -1, -25 },
  { 3005, 17, 25, 19, 2, -25 },
  { 3059, 5, 25, 9, 2, -25 },
  { 3075, 25, 18, 29, 2, -18 },
  { 3132, 15, 18, 20, 2, -18 },
  { 3166, 17, 18, 19, 1, -18 },
  { 3205, 16, 26, 19, 2, -18 },
  { 3257, 16, 26, 19, 1, -18 },
  { 3309, 11, 18, 14, 2, -18 },
  { 3334, 13, 18, 15, 1, -18 },
  { 3364, 11, 22, 13, 1, -22 },
  { 3395, 15, 18, 20, 2, -18 },
  { 3429, 17, 18, 17, 0, -18 },
  { 3468, 26, 18, 26, 0, -18 },
  { 3527, 17, 18, 17, 0, -18 },
  { 3566, 17, 26, 17, 0, -18 },
  { 3622, 13, 18, 15, 1, -18 },
  { 3652, 11, 29, 12, 0, -24 },
  { 3692, 3, 33, 17, 7, -25 },
  { 3705, 11, 29, 12, 1, -24 },
  { 3745, 15, 5, 18, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Bold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD33PT7B_H_
