#ifndef _NOTOSANS_SEMICONDENSED_BOLD55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x38, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E,
  0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x0F,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xF3, 0x83, 0xCF, 0xF1, 0xC0, 0x47, 0xF8, 0xE0,
  0x03, 0xFC, 0x70, 0x00, 0xFF, 0x38, 0x00, 0x7F, 0xDC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0x7F, 0xE0, 0x03, 0x9F, 0xF0, 0x01, 0xC7, 0xF8,
  0x00, 0xE3, 0xFE, 0x00, 0x71, 0xFF, 0xC0, 0x38, 0xFF, 0xF8, 0x1C, 0xFF,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x8F,
  0xC0, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x1F, 0x87, 0xF1,
  0xF8, 0xFF, 0xC3, 0xF8, 0xFC, 0x7E, 0x3F, 0xFC, 0x3F, 0xBF, 0x8F, 0xC7,
  0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFC, 0x7E, 0x3F, 0x1F,
  0x87, 0xFF, 0x1F, 0x8F, 0xE3, 0xF8, 0x7F, 0xC3, 0xF1, 0xF8, 0x3F, 0x03,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF,
  0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xE3,
  0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x9F,
  0xE3, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F,
  0xFF, 0xC1, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x7E, 0x0E, 0x7F, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0x03, 0xC0, 0x03, 0x81, 0xC0,
  0x00, 0x40, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x9F,
  0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x18, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83,
  0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xE0,
  0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xF9, 0xFE, 0x03,
  0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFB, 0xFF, 0xFE, 0x7F, 0xBF,
  0x8F, 0xF3, 0xE1, 0xFE, 0x38, 0x3F, 0xC2, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0x0E, 0x00,
  0x7F, 0x82, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7C, 0x03, 0xFE,
  0x18, 0x00, 0xFF, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x7C, 0x03, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFF,
  0x00, 0x0F, 0xDF, 0xE0, 0x03, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F,
  0x8F, 0xF0, 0x07, 0xE1, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x3F, 0x07, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xC0,
  0x7F, 0x83, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x80, 0x01, 0xFE, 0xC0, 0x03, 0xFE, 0xF8, 0x0F, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0E, 0x01, 0xFC, 0x3F, 0xE0, 0xFE, 0x7F,
  0xF8, 0x7F, 0x7F, 0xFE, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF,
  0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0,
  0x0F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x87, 0xF8, 0x3F,
  0xEF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xCF, 0xFC, 0x7F, 0xC3, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0xFD,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0x87, 0xFC, 0xFF, 0x81,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0x7F,
  0x0F, 0xFF, 0x3F, 0x83, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x38, 0x04, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFC, 0xFF, 0x3F, 0x81, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0xFE, 0x3F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE3, 0xF8, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0x18, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x83, 0xF8, 0x0F, 0xFF, 0x07, 0xE1, 0xF8, 0x0F, 0xFF, 0xE3,
  0xF1, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x7E,
  0x0F, 0xF1, 0xFC, 0x3F, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xBF, 0x07, 0xE0,
  0x3E, 0x07, 0xDF, 0x87, 0xF0, 0x1F, 0x03, 0xEF, 0xC3, 0xF0, 0x1F, 0x81,
  0xF7, 0xC1, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0xF0,
  0x7E, 0x03, 0xF0, 0x3F, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xFC, 0x1F, 0x80,
  0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xDF, 0x07, 0xE0, 0x7F, 0x07,
  0xCF, 0x83, 0xF8, 0x3F, 0x87, 0xE7, 0xE0, 0xFC, 0x3F, 0xE3, 0xF3, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F, 0xFF, 0x7F, 0xF0, 0xFE, 0x0F, 0xFF,
  0x3F, 0xF8, 0x3F, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00,
  0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF,
  0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xE7, 0xF8, 0x3F,
  0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F,
  0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x7C, 0x3F,
  0xF0, 0x01, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0xC1, 0xFF, 0xF0, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x02, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F,
  0xF8, 0xFF, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF,
  0xF0, 0x07, 0xFE, 0x3F, 0xC0, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x7C, 0x1F, 0xF8, 0x00, 0x20,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F,
  0x80, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0xFF, 0x3F, 0xF0, 0x03, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x08, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF9, 0xFC, 0x00, 0xFF,
  0x8F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xFC, 0x1F,
  0xC0, 0x7F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x83,
  0xFE, 0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0xE1, 0xFF, 0x00, 0x7F, 0x1F, 0xF0,
  0x03, 0xF9, 0xFF, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x07,
  0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0x01,
  0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x01, 0xFF, 0x03, 0xF8,
  0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x87, 0xF0, 0x03,
  0xFE, 0x3F, 0x80, 0x1F, 0xF1, 0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x03, 0xFE,
  0x7F, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xF0, 0x00, 0xFD, 0xFF, 0xF7, 0xF0, 0x01,
  0xFB, 0xFF, 0xEF, 0xE0, 0x07, 0xF7, 0xFF, 0xEF, 0xC0, 0x0F, 0xCF, 0xFF,
  0xDF, 0x80, 0x1F, 0x9F, 0xFF, 0xBF, 0x80, 0x7F, 0x7F, 0xFF, 0x7F, 0x00,
  0xFC, 0xFF, 0xFE, 0x7E, 0x01, 0xF9, 0xFF, 0xFC, 0xFE, 0x07, 0xF3, 0xFF,
  0xF9, 0xFC, 0x0F, 0xE7, 0xFF, 0xF1, 0xF8, 0x1F, 0x8F, 0xFF, 0xE3, 0xF0,
  0x3F, 0x1F, 0xFF, 0xC7, 0xF0, 0xFE, 0x3F, 0xFF, 0x8F, 0xE1, 0xF8, 0x7F,
  0xFF, 0x0F, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0xFC, 0x3F,
  0x9F, 0x83, 0xFF, 0xF8, 0x3F, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xF8,
  0x03, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xCF, 0xF0, 0x0F, 0xFF, 0x9F, 0xF0,
  0x1F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0x3F, 0xE0, 0x7F, 0xFE, 0x3F, 0xC0,
  0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0x1F, 0xFF, 0x81, 0xFE, 0x3F,
  0xFF, 0x01, 0xFE, 0x7F, 0xFE, 0x03, 0xFC, 0xFF, 0xFC, 0x03, 0xFD, 0xFF,
  0xF8, 0x07, 0xFD, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xBF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0xCF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF,
  0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x87, 0xF8, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF9,
  0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFB, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xE0, 0xFC, 0x7F, 0x80, 0x18, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x01, 0xFE, 0xF8, 0x01, 0xFE, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xA0, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x81, 0xFC, 0x03, 0xF7, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFB, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFD, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFC, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x7F, 0x07,
  0xF8, 0x07, 0xF0, 0x7F, 0x1F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0x8F, 0xC1,
  0xFE, 0x01, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC3, 0xF8,
  0x7F, 0x00, 0x3F, 0x87, 0xE0, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x7E,
  0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xF8, 0x1F,
  0xCF, 0xE0, 0x01, 0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x03,
  0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x01, 0xFB, 0xFC, 0x00, 0x1F, 0xBF, 0x80,
  0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x8F, 0xFC, 0x0E, 0x01, 0xFE, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xF8,
  0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3, 0xFF, 0xF3, 0xF8,
  0xFF, 0xF0, 0xFC, 0x3F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x04, 0x00,
  0xFE, 0x1F, 0xF0, 0x3F, 0x9F, 0xFE, 0x0F, 0xEF, 0xFF, 0xC3, 0xFB, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFC, 0x1F, 0xF3, 0xFE,
  0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xEF,
  0xF8, 0x0F, 0xFB, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0xF0, 0xFC, 0x7F, 0xF8, 0x3F, 0x07,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xF8, 0x1C, 0x3F, 0xC0, 0x08, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x02, 0x3F, 0xF0, 0x3C, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0xE0, 0x7F, 0x03, 0xFE, 0x1F, 0xC1, 0xFF, 0xE7, 0xF0, 0xFF,
  0xFD, 0xFC, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFE, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF7, 0xFC, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0x7F, 0x07,
  0xFF, 0x8F, 0xC0, 0xFF, 0x83, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x04, 0x3F, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xF3, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xC3, 0xF0, 0x7F, 0xF9, 0xFC, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x7F,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFF,
  0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0x7F, 0x0F, 0xFF, 0xDF, 0xC1, 0xFF, 0xE7, 0xF0, 0x3F, 0xE1,
  0xFC, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x30, 0x00, 0x7F, 0xCF, 0xC0, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x20, 0x0F, 0xE1, 0xFF, 0x07,
  0xF3, 0xFF, 0xE3, 0xFB, 0xFF, 0xF9, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xC0, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFB, 0xFD, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xC0, 0x00, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x9F, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xE7, 0xF8,
  0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x87, 0xFC, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF3, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x7E, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0x1F,
  0xFF, 0x0F, 0xFF, 0x9F, 0x9F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xFF,
  0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xFC, 0x3F, 0x1F, 0xFF,
  0x1F, 0x9F, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x3F, 0x07, 0xFC, 0x0F, 0xC7,
  0xFF, 0x83, 0xF9, 0xFF, 0xF0, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0xC1,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0xF8, 0xFE,
  0xFF, 0xFC, 0x3F, 0x9F, 0xFE, 0x0F, 0xE1, 0xFF, 0x03, 0xFC, 0x04, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x7F, 0xF9,
  0xFC, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF,
  0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x7F, 0x0F, 0xFF,
  0xDF, 0xC1, 0xFF, 0xE7, 0xF0, 0x3F, 0xE1, 0xFC, 0x01, 0x80, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xBF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xF0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFB, 0xFE, 0x1F, 0x9F, 0xE0, 0x0C, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x28, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x43,
  0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xE7, 0xFF, 0xF7, 0xF1, 0xFF, 0xF1, 0xF8, 0x7F,
  0xE0, 0xFC, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x7F,
  0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00,
  0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x3F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFF,
  0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xDF, 0x81,
  0xFC, 0x1F, 0xC1, 0xFB, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x7E, 0x0F, 0xF0,
  0x7F, 0x87, 0xE7, 0xC1, 0xFC, 0x0F, 0xF0, 0xFC, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0x1F, 0x8F, 0xF0, 0x1F, 0xC7, 0xE3, 0xF1, 0xFE, 0x03, 0xFC, 0xFC,
  0x3E, 0x3F, 0x80, 0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0x07, 0xF3, 0xE0, 0xFD,
  0xFE, 0x00, 0xFE, 0x7C, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0x83, 0xF7, 0xF0,
  0x01, 0xFB, 0xF0, 0x3E, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xDF, 0xC0, 0x07,
  0xFF, 0x80, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0x7E, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0xFF,
  0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x02, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0x1F, 0xFE, 0x80, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 9, 40, 15, 3, -39 },
  { 46, 20, 14, 26, 3, -39 },
  { 81, 31, 39, 33, 1, -39 },
  { 233, 25, 45, 29, 2, -42 },
  { 374, 43, 41, 47, 2, -40 },
  { 595, 35, 41, 37, 2, -40 },
  { 775, 8, 14, 14, 3, -39 },
  { 789, 15, 48, 18, 2, -39 },
  { 879, 15, 48, 18, 1, -39 },
  { 969, 25, 25, 28, 1, -42 },
  { 1048, 25, 27, 29, 2, -33 },
  { 1133, 10, 13, 15, 2, -6 },
  { 1150, 14, 7, 17, 2, -18 },
  { 1163, 9, 9, 15, 3, -8 },
  { 1174, 22, 40, 23, 0, -40 },
  { 1284, 25, 41, 29, 2, -40 },
  { 1413, 19, 39, 29, 3, -39 },
  { 1506, 25, 40, 29, 2, -40 },
  { 1631, 25, 41, 29, 2, -40 },
  { 1760, 27, 39, 29, 1, -39 },
  { 1892, 24, 40, 29, 3, -39 },
  { 2012, 25, 41, 29, 2, -40 },
  { 2141, 26, 39, 29, 1, -39 },
  { 2268, 25, 41, 29, 2, -40 },
  { 2397, 25, 41, 29, 2, -40 },
  { 2526, 9, 32, 15, 3, -31 },
  { 2562, 10, 38, 15, 2, -31 },
  { 2610, 25, 28, 29, 2, -34 },
  { 2698, 25, 17, 29, 2, -28 },
  { 2752, 25, 28, 29, 2, -34 },
  { 2840, 23, 41, 24, 0, -40 },
  { 2958, 41, 44, 46, 2, -40 },
  { 3184, 35, 39, 35, 0, -39 },
  { 3355, 27, 39, 34, 4, -39 },
  { 3487, 28, 41, 32, 3, -40 },
  { 3631, 30, 39, 37, 4, -39 },
  { 3778, 20, 39, 28, 5, -39 },
  { 3876, 20, 39, 28, 5, -39 },
  { 3974, 30, 41, 37, 3, -40 },
  { 4128, 29, 39, 39, 5, -39 },
  { 4270, 16, 39, 20, 2, -39 },
  { 4348, 16, 51, 17, -4, -39 },
  { 4450, 29, 39, 34, 5, -39 },
  { 4592, 22, 39, 28, 4, -39 },
  { 4700, 39, 39, 48, 5, -39 },
  { 4891, 31, 39, 41, 5, -39 },
  { 5043, 34, 41, 39, 3, -40 },
  { 5218, 25, 39, 32, 4, -39 },
  { 5340, 34, 49, 39, 3, -40 },
  { 5549, 29, 39, 33, 4, -39 },
  { 5691, 24, 41, 28, 2, -40 },
  { 5814, 27, 39, 29, 1, -39 },
  { 5946, 30, 40, 38, 4, -39 },
  { 6096, 33, 39, 33, 0, -39 },
  { 6257, 49, 39, 49, 0, -39 },
  { 6496, 33, 39, 33, 0, -39 },
  { 6657, 31, 39, 31, 0, -39 },
  { 6809, 26, 39, 28, 1, -39 },
  { 6936, 12, 48, 18, 4, -39 },
  { 7008, 22, 40, 23, 0, -40 },
  { 7118, 13, 48, 18, 1, -39 },
  { 7196, 28, 25, 31, 1, -39 },
  { 7284, 23, 4, 23, 0, 5 },
  { 7296, 15, 9, 19, 2, -42 },
  { 7313, 25, 32, 30, 2, -31 },
  { 7413, 26, 43, 32, 4, -42 },
  { 7553, 23, 32, 26, 2, -31 },
  { 7645, 26, 43, 32, 2, -42 },
  { 7785, 26, 32, 30, 2, -31 },
  { 7889, 21, 42, 20, 1, -42 },
  { 8000, 26, 44, 32, 2, -31 },
  { 8143, 25, 42, 33, 4, -42 },
  { 8275, 9, 42, 15, 3, -42 },
  { 8323, 14, 55, 15, -2, -42 },
  { 8420, 27, 42, 31, 4, -42 },
  { 8562, 8, 42, 15, 4, -42 },
  { 8604, 41, 31, 49, 4, -31 },
  { 8763, 25, 31, 33, 4, -31 },
  { 8860, 27, 32, 32, 2, -31 },
  { 8968, 26, 44, 32, 4, -31 },
  { 9111, 26, 44, 32, 2, -31 },
  { 9254, 18, 31, 23, 4, -31 },
  { 9324, 21, 32, 25, 2, -31 },
  { 9408, 19, 37, 22, 1, -36 },
  { 9496, 25, 31, 33, 4, -30 },
  { 9593, 29, 30, 29, 0, -30 },
  { 9702, 43, 30, 44, 0, -30 },
  { 9864, 28, 30, 29, 0, -30 },
  { 9969, 29, 43, 29, 0, -30 },
  { 10125, 22, 30, 24, 1, -30 },
  { 10208, 18, 48, 21, 1, -39 },
  { 10316, 6, 55, 28, 11, -42 },
  { 10358, 18, 48, 21, 2, -39 },
  { 10466, 25, 9, 29, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_Bold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD55PT7B_H_
