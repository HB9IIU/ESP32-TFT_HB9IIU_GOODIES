#ifndef _NOTOSANS_SEMICONDENSED_BOLD21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xE6, 0x66, 0x00, 0xEF, 0xE0, 0xE7, 0xE7, 0xE6,
  0xE6, 0x66, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x1D,
  0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0xB8, 0x33, 0x03, 0x30, 0x33,
  0x00, 0x08, 0x04, 0x1F, 0xFF, 0xFE, 0x97, 0x43, 0xE0, 0xF8, 0x3F, 0x07,
  0xC2, 0xE1, 0x7C, 0xBF, 0xFD, 0xF8, 0x10, 0x08, 0x00, 0x78, 0x38, 0xFC,
  0x30, 0xCC, 0x70, 0xCC, 0x60, 0xCC, 0xE0, 0xCC, 0xC0, 0xCD, 0xDE, 0xFD,
  0xBF, 0x7B, 0xB3, 0x03, 0x33, 0x07, 0x33, 0x06, 0x33, 0x0E, 0x33, 0x0C,
  0x3F, 0x1C, 0x1E, 0x3F, 0x03, 0xF8, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3F,
  0x80, 0xF8, 0x0F, 0x87, 0xFE, 0x77, 0x3B, 0xB8, 0xF9, 0xC3, 0xCF, 0x3E,
  0x3F, 0xF8, 0xFD, 0xE0, 0xFF, 0xF6, 0x19, 0x9C, 0xE6, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x71, 0x8E, 0x31, 0xC0, 0xE1, 0xC3, 0x8E, 0x18, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x31, 0xC0, 0x1C, 0x0C, 0x26, 0x3F,
  0xFF, 0xF8, 0xE0, 0xF8, 0xEE, 0x66, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F,
  0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFE, 0xEC, 0xC0, 0xFF,
  0xFE, 0xEF, 0xE0, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x80, 0x3E, 0x3F, 0xBD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0x7B, 0xF8,
  0xF8, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x80, 0x3E, 0x7F, 0xB9, 0xE8, 0x70, 0x38, 0x1C, 0x1C, 0x1E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0xFF, 0xFF, 0xFE, 0x7E, 0x7F, 0x99, 0xE0,
  0x70, 0x38, 0x38, 0xF8, 0x7C, 0x1F, 0x81, 0xC0, 0xE0, 0x7C, 0x7F, 0xFB,
  0xF8, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x37, 0x0E, 0xE1, 0x9C,
  0x73, 0x8C, 0x73, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x7F, 0x3F,
  0x9F, 0xCC, 0x0E, 0x07, 0x63, 0xFD, 0xFF, 0x07, 0x81, 0xC0, 0xE0, 0x7C,
  0x7F, 0xFB, 0xF8, 0x1F, 0x9F, 0xDE, 0x0E, 0x0E, 0x07, 0x73, 0xFD, 0xFF,
  0xE3, 0xF0, 0xF8, 0x7C, 0x7F, 0x3B, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC1,
  0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x3B, 0xB8, 0xF8, 0x7C, 0x7F, 0x71,
  0xF8, 0x7C, 0x3E, 0x3F, 0xFD, 0xFC, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xFF, 0x7D, 0x9D, 0xC0, 0xE0, 0x70, 0xF3, 0xF1, 0xF0, 0x6F,
  0xF6, 0x00, 0x00, 0x0E, 0xFE, 0x6F, 0xF6, 0x00, 0x00, 0x01, 0xEE, 0xEC,
  0xC0, 0x00, 0x80, 0xC1, 0xE3, 0xC7, 0x87, 0x03, 0xE0, 0x7E, 0x0F, 0x80,
  0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x70,
  0x3E, 0x07, 0xC0, 0xF8, 0x1C, 0x3E, 0x7C, 0xF8, 0x70, 0x20, 0x00, 0x7E,
  0x7F, 0x99, 0xE0, 0x70, 0x38, 0x38, 0x3C, 0x38, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E,
  0x63, 0xF6, 0xE7, 0xE6, 0xCE, 0x67, 0xCC, 0x67, 0xCC, 0x66, 0xCC, 0x66,
  0xCE, 0xE6, 0xE7, 0xBC, 0x63, 0x18, 0x70, 0x00, 0x38, 0x30, 0x1F, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x81, 0xDC, 0x0E, 0xE0,
  0x73, 0x87, 0x1C, 0x38, 0xE1, 0xFF, 0x9F, 0xFC, 0xE0, 0xE7, 0x07, 0x78,
  0x1F, 0x80, 0xE0, 0xFE, 0x3F, 0xEE, 0x7B, 0x8F, 0xE3, 0xF8, 0xEF, 0xF3,
  0xFC, 0xE7, 0xB8, 0x7E, 0x1F, 0x87, 0xE7, 0xFF, 0xEF, 0xE0, 0x0F, 0xE7,
  0xF9, 0xF3, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0xCC, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xF3, 0xFF, 0x70,
  0xEE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF1, 0xEF,
  0xFD, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xFE, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xE7,
  0xFC, 0xF1, 0xBC, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x1F, 0xE3, 0xFC, 0x1F,
  0xC3, 0xB8, 0x77, 0xCE, 0x7F, 0xC7, 0xF8, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x38, 0xFF, 0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0xFF, 0xC0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x3B, 0xEF, 0x00, 0xE1, 0xFC, 0x7B, 0x8E, 0x73,
  0x8E, 0xF1, 0xDC, 0x3F, 0x07, 0xF0, 0xFE, 0x1D, 0xE3, 0x9C, 0x73, 0xCE,
  0x39, 0xC3, 0xB8, 0x78, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFD, 0x87, 0xFB, 0x0D, 0xF7, 0x1B, 0xE6, 0x77, 0xEC, 0xCF,
  0xDD, 0x9F, 0xBF, 0x3F, 0x3C, 0x7E, 0x78, 0xFC, 0xF1, 0xF8, 0xE3, 0x80,
  0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xDC, 0x7D, 0xC7, 0xCE, 0x7C, 0xE7,
  0xE7, 0x7E, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xF0, 0x1F,
  0xC1, 0xFF, 0x1F, 0x3C, 0xE0, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x1E, 0xE0, 0xE7, 0xDF, 0x1F, 0xF0, 0x7F, 0x00,
  0xFE, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0x7E, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F, 0xC1, 0xFF, 0x1F, 0x3C, 0xE0, 0xEF,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x1E, 0xE0,
  0xE7, 0xDF, 0x1F, 0xF0, 0x7F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0xFE, 0x1F, 0xE3, 0xBE, 0x71, 0xCE, 0x39, 0xC7, 0x39, 0xE7, 0xF8, 0xFE,
  0x1D, 0xC3, 0x9C, 0x73, 0xCE, 0x39, 0xC7, 0xB8, 0x78, 0x3F, 0x3F, 0xFD,
  0xDC, 0x0E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x7E, 0x7F,
  0xFB, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFF, 0x3C, 0xFF, 0x8F, 0xC0, 0xE0, 0x7F, 0x03, 0x9C,
  0x1C, 0xE0, 0xC7, 0x0E, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x19, 0xC0, 0xEE,
  0x07, 0x60, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0xE0, 0xFC,
  0x1C, 0x39, 0x87, 0x87, 0x38, 0xF8, 0xE7, 0x1F, 0x1C, 0xE3, 0x67, 0x1C,
  0xEC, 0xE1, 0xDD, 0x9C, 0x3B, 0x3B, 0x87, 0x67, 0x60, 0xEC, 0x7C, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x83, 0x80, 0xF0, 0xF3, 0x87,
  0x0E, 0x78, 0x73, 0x81, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80,
  0xFC, 0x07, 0x70, 0x73, 0x87, 0x8E, 0x38, 0x7B, 0xC1, 0xE0, 0xF0, 0xF7,
  0x0E, 0x70, 0xE3, 0x9C, 0x39, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xDF, 0xF7,
  0xFC, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFF, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C,
  0x1C, 0x0C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x33, 0xFF, 0x06, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xB8, 0x73,
  0x0C, 0x73, 0x86, 0xE0, 0xE0, 0xFF, 0x80, 0xF3, 0x8E, 0x1E, 0x3F, 0x9F,
  0xE0, 0x70, 0x39, 0xFF, 0xFF, 0xC7, 0xE3, 0xF3, 0xFF, 0xEF, 0x30, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE7, 0x3B, 0xEF, 0xFF, 0xC7, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xF1, 0xFC, 0xFF, 0xFB, 0xBC, 0x0E, 0x3F, 0x7F, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xF1, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x19, 0xDF, 0xF7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC,
  0xF7, 0xFC, 0xF7, 0x1C, 0x0F, 0xC7, 0xFB, 0x8E, 0xE1, 0xFF, 0xFF, 0xFF,
  0x80, 0xE0, 0x1C, 0x27, 0xF8, 0xFE, 0x1F, 0x3F, 0x39, 0x38, 0x38, 0xFE,
  0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1F,
  0xF7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xFC,
  0xF7, 0x01, 0xC0, 0x76, 0x79, 0xFE, 0x7E, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE7, 0x3B, 0xEF, 0xFF, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0x6F, 0x60, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x18, 0xF1, 0x80, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xEB, 0xBE, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0xEC,
  0x73, 0x38, 0xDC, 0x37, 0x0F, 0xC3, 0xB8, 0xCF, 0x31, 0xCC, 0x3B, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x1C, 0xEF, 0xBF, 0xFF, 0xFF,
  0xF1, 0xC7, 0xF1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7,
  0xE1, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0x07, 0x3B, 0xEF, 0xFF, 0xC7, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x1E, 0x0F, 0xC7,
  0xFB, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xDC, 0xF7, 0xF8, 0xFC,
  0x07, 0x3B, 0xEF, 0xFF, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC,
  0xFF, 0xFB, 0xBC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x1F,
  0xF7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xF7, 0xFC,
  0xF7, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x07, 0xDF, 0xFF, 0xCF,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x3C, 0x7F, 0xFE, 0xE0, 0xF0,
  0xFC, 0x3E, 0x0F, 0x07, 0x87, 0xFE, 0xFC, 0x18, 0x38, 0x38, 0xFF, 0xFF,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0x3F, 0x1F, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0x73, 0xDF, 0xF3, 0xCC, 0xE0,
  0xEE, 0x39, 0xC7, 0x38, 0xE3, 0xB8, 0x77, 0x0E, 0xE0, 0xD8, 0x1F, 0x03,
  0xE0, 0x38, 0x00, 0xE3, 0xC7, 0x73, 0xC7, 0x73, 0xE7, 0x73, 0x66, 0x73,
  0x6E, 0x3E, 0x6E, 0x3E, 0x6E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0xF1, 0xEF, 0x78, 0xEE, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xDC,
  0x3B, 0x8E, 0x3B, 0xC7, 0x80, 0xE0, 0xEE, 0x39, 0xC7, 0x38, 0xE3, 0xB8,
  0x77, 0x06, 0xE0, 0xD8, 0x1F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE1, 0x78,
  0x1F, 0x03, 0x80, 0xFF, 0xFF, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0,
  0xFF, 0xFF, 0x0E, 0x3C, 0x70, 0xC1, 0x83, 0x06, 0x1C, 0xF9, 0xE0, 0xE0,
  0xC1, 0x83, 0x06, 0x0E, 0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x3E, 0x3C, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xE0, 0xF8, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 10, 1, -15 },
  { 14, 12, 15, 12, 0, -15 },
  { 37, 9, 17, 11, 1, -16 },
  { 57, 16, 15, 18, 1, -15 },
  { 87, 13, 15, 14, 1, -15 },
  { 112, 3, 5, 5, 1, -15 },
  { 114, 5, 18, 7, 1, -15 },
  { 126, 6, 18, 7, 0, -15 },
  { 140, 9, 9, 11, 1, -16 },
  { 151, 9, 11, 11, 1, -13 },
  { 164, 4, 5, 6, 1, -2 },
  { 167, 5, 3, 7, 1, -7 },
  { 169, 4, 3, 6, 1, -3 },
  { 171, 9, 15, 9, 0, -15 },
  { 188, 9, 15, 11, 1, -15 },
  { 205, 7, 15, 11, 1, -15 },
  { 219, 9, 15, 11, 1, -15 },
  { 236, 9, 15, 11, 1, -15 },
  { 253, 11, 15, 11, 0, -15 },
  { 274, 9, 15, 11, 1, -15 },
  { 291, 9, 15, 11, 1, -15 },
  { 308, 9, 15, 11, 1, -15 },
  { 325, 9, 15, 11, 1, -15 },
  { 342, 9, 15, 11, 1, -15 },
  { 359, 4, 12, 6, 1, -12 },
  { 365, 4, 15, 6, 1, -12 },
  { 373, 9, 11, 11, 1, -13 },
  { 386, 9, 7, 11, 1, -11 },
  { 394, 9, 11, 11, 1, -13 },
  { 407, 9, 15, 9, 0, -15 },
  { 424, 16, 17, 18, 1, -15 },
  { 458, 13, 15, 13, 0, -15 },
  { 483, 10, 15, 13, 2, -15 },
  { 502, 11, 15, 12, 1, -15 },
  { 523, 11, 15, 14, 2, -15 },
  { 544, 8, 15, 11, 2, -15 },
  { 559, 8, 15, 11, 2, -15 },
  { 574, 11, 15, 14, 1, -15 },
  { 595, 11, 15, 15, 2, -15 },
  { 616, 6, 15, 8, 1, -15 },
  { 628, 6, 19, 7, -1, -15 },
  { 643, 11, 15, 13, 2, -15 },
  { 664, 8, 15, 11, 2, -15 },
  { 679, 15, 15, 18, 2, -15 },
  { 708, 12, 15, 16, 2, -15 },
  { 731, 13, 15, 15, 1, -15 },
  { 756, 9, 15, 12, 2, -15 },
  { 773, 13, 19, 15, 1, -15 },
  { 804, 11, 15, 13, 2, -15 },
  { 825, 9, 15, 11, 1, -15 },
  { 842, 11, 15, 11, 0, -15 },
  { 863, 11, 15, 14, 2, -15 },
  { 884, 13, 15, 13, 0, -15 },
  { 909, 19, 15, 19, 0, -15 },
  { 945, 13, 15, 13, 0, -15 },
  { 970, 12, 15, 12, 0, -15 },
  { 993, 10, 15, 11, 0, -15 },
  { 1012, 5, 18, 7, 1, -15 },
  { 1024, 8, 15, 9, 0, -15 },
  { 1039, 4, 18, 7, 1, -15 },
  { 1048, 11, 9, 12, 0, -15 },
  { 1061, 9, 1, 9, 0, 2 },
  { 1063, 5, 3, 7, 1, -16 },
  { 1065, 9, 12, 12, 1, -12 },
  { 1079, 10, 16, 12, 1, -16 },
  { 1099, 8, 12, 10, 1, -12 },
  { 1111, 10, 16, 12, 1, -16 },
  { 1131, 10, 12, 11, 1, -12 },
  { 1146, 8, 16, 7, 0, -16 },
  { 1162, 10, 17, 12, 1, -12 },
  { 1184, 10, 16, 13, 1, -16 },
  { 1204, 4, 16, 6, 1, -16 },
  { 1212, 6, 21, 6, -1, -16 },
  { 1228, 10, 16, 12, 2, -16 },
  { 1248, 3, 16, 6, 1, -16 },
  { 1254, 16, 12, 19, 1, -12 },
  { 1278, 10, 12, 13, 1, -12 },
  { 1293, 10, 12, 12, 1, -12 },
  { 1308, 10, 17, 12, 1, -12 },
  { 1330, 10, 17, 12, 1, -12 },
  { 1352, 7, 12, 9, 1, -12 },
  { 1363, 8, 12, 10, 1, -12 },
  { 1375, 8, 14, 8, 0, -14 },
  { 1389, 10, 11, 13, 1, -11 },
  { 1403, 11, 11, 11, 0, -11 },
  { 1419, 16, 11, 17, 0, -11 },
  { 1441, 11, 11, 11, 0, -11 },
  { 1457, 11, 16, 11, 0, -11 },
  { 1479, 8, 11, 9, 1, -11 },
  { 1490, 7, 18, 8, 0, -15 },
  { 1506, 3, 21, 11, 4, -16 },
  { 1514, 7, 18, 8, 1, -15 },
  { 1530, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Bold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD21PT7B_H_
