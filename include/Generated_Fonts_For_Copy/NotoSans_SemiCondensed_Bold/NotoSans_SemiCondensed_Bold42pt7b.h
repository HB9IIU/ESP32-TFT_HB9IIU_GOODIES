#ifndef _NOTOSANS_SEMICONDENSED_BOLD42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0x84, 0x00, 0xFC, 0x7F, 0xF8, 0xFD, 0xF1, 0xFB, 0xE3,
  0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xC0,
  0x07, 0x87, 0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x83, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFE, 0xE7, 0x9F, 0x9C, 0x13, 0xF3, 0x80, 0x7E, 0x70, 0x0F, 0xEE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xDF, 0xC0, 0x39, 0xFC,
  0x07, 0x3F, 0xE0, 0xEF, 0xDF, 0xDF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x78, 0x01, 0xFF, 0xE0, 0x3E, 0x00, 0x7C, 0xF8, 0x0F, 0x00, 0x1E,
  0x1E, 0x07, 0xC0, 0x0F, 0x87, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x3C, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC7, 0x80,
  0x03, 0xE1, 0xF3, 0xE0, 0x00, 0x78, 0x78, 0xF1, 0xFC, 0x1F, 0x3E, 0x7C,
  0xFF, 0x87, 0xFF, 0x9E, 0x3F, 0xF0, 0xFF, 0xCF, 0x9F, 0xFE, 0x3F, 0xF3,
  0xC7, 0xCF, 0x83, 0xF1, 0xF3, 0xE1, 0xE0, 0x00, 0x7C, 0xF8, 0x78, 0x00,
  0x3E, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x87, 0xC0, 0x07, 0xC3, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x1E, 0x00, 0x3E, 0x07, 0x87,
  0x80, 0x1F, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0x7F, 0xF8, 0x03, 0xE0, 0x0F,
  0xFC, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x0F, 0xE1, 0xFF, 0xC0, 0xFC, 0x3F, 0xFE, 0x0F, 0xC7, 0xF7, 0xF1,
  0xF8, 0x7F, 0x3F, 0x9F, 0x87, 0xE1, 0xFF, 0xF8, 0xFE, 0x0F, 0xFF, 0x0F,
  0xE0, 0x7F, 0xF0, 0xFE, 0x03, 0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x9F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xC1, 0xE1,
  0x9F, 0x3D, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x7C, 0x07, 0xEF, 0xC1, 0xF8, 0xFC,
  0x1F, 0x0F, 0x00, 0xC1, 0xC0, 0x08, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xF0, 0xFC, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFE, 0xFC, 0xF3, 0xF3, 0x8F, 0xC4, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xE0, 0xFE, 0x18,
  0x07, 0xE1, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xE0,
  0x3F, 0x88, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0xC0, 0x1F, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1E,
  0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0,
  0x7C, 0x7E, 0x07, 0xC3, 0xF0, 0x3C, 0x1F, 0x83, 0xE0, 0xFC, 0x3E, 0x07,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x20, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF4, 0x00, 0x7E, 0xC0, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x18, 0x07, 0xCF, 0xF0,
  0x7D, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0x07, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x8F,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0,
  0x7E, 0x3F, 0x8F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x7F, 0x0F, 0xE7,
  0xE0, 0x7E, 0x7C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7,
  0xE0, 0x7F, 0x7F, 0x1F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xBF,
  0x0F, 0xF3, 0xE0, 0x18, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x83, 0xBF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x08, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3F, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8E, 0x07, 0xE2,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x0F, 0xFE, 0x3C, 0xF8, 0x3F, 0xFC, 0x79, 0xF0,
  0xFF, 0xF8, 0xFB, 0xC3, 0xF1, 0xF0, 0xFF, 0x87, 0xC3, 0xE1, 0xFF, 0x1F,
  0x07, 0xC3, 0xFC, 0x3E, 0x0F, 0x87, 0xF8, 0x78, 0x1F, 0x0F, 0xF0, 0xF0,
  0x3E, 0x1F, 0xE1, 0xE0, 0x7C, 0x3F, 0xC3, 0xC0, 0xF8, 0xFF, 0x87, 0x83,
  0xF1, 0xEF, 0x0F, 0x87, 0xE3, 0xDF, 0x1F, 0xBF, 0xCF, 0xBE, 0x1F, 0xFB,
  0xFE, 0x3C, 0x1F, 0xE7, 0xF8, 0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x30,
  0x01, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7E,
  0x07, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xBF, 0x00, 0xFD,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xE0, 0x38, 0xFE, 0x00, 0x4F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x30, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0x81, 0xFF, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFC,
  0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x3F, 0xBF, 0x00, 0xFE, 0x7E, 0x03, 0xFC, 0xFC, 0x1F, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0x03, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0xC0, 0x7E, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF6, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xC1,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFD, 0xFC, 0x07, 0xF1, 0xFC, 0x0F,
  0xE1, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x7F, 0xFB, 0xE0, 0x3E, 0xFF,
  0xF7, 0xC0, 0x7D, 0xFF, 0xEF, 0x80, 0xFB, 0xFF, 0xDF, 0x03, 0xE7, 0xFF,
  0x9F, 0x07, 0xCF, 0xFF, 0x3E, 0x0F, 0x9F, 0xFE, 0x7C, 0x3E, 0x3F, 0xFC,
  0x7C, 0x7C, 0x7F, 0xF8, 0xF8, 0xF8, 0xFF, 0xF1, 0xF3, 0xE1, 0xFF, 0xE3,
  0xE7, 0xC3, 0xFF, 0xC3, 0xEF, 0x87, 0xFF, 0x87, 0xDE, 0x0F, 0xFF, 0x0F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x7F, 0xF8, 0x3F,
  0xC0, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0xFC,
  0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC,
  0x0F, 0xFF, 0x7F, 0x07, 0xFF, 0x9F, 0x83, 0xFF, 0xCF, 0xE1, 0xFF, 0xE3,
  0xF0, 0xFF, 0xF1, 0xFC, 0x7F, 0xF8, 0x7E, 0x3F, 0xFC, 0x3F, 0x9F, 0xFE,
  0x0F, 0xCF, 0xFF, 0x07, 0xF7, 0xFF, 0x81, 0xFB, 0xFF, 0xC0, 0xFE, 0xFF,
  0xE0, 0x3F, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3,
  0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xEF, 0xC1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF8,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xF0, 0x7F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F,
  0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0x81, 0xCF, 0xC0,
  0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x7E, 0xF0, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x83,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0xFC,
  0x03, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x3F, 0x3F, 0x00, 0xFF, 0x01,
  0xF9, 0xF8, 0x0F, 0xF8, 0x0F, 0xC7, 0xC0, 0x7F, 0xC0, 0x7E, 0x3F, 0x03,
  0xDE, 0x07, 0xE1, 0xF8, 0x1E, 0xF8, 0x3F, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8,
  0x3E, 0x0F, 0xBE, 0x0F, 0xC1, 0xF8, 0x7D, 0xF0, 0x7C, 0x0F, 0xC3, 0xE7,
  0xC7, 0xE0, 0x7E, 0x3E, 0x3E, 0x3F, 0x03, 0xF1, 0xF1, 0xF1, 0xF8, 0x0F,
  0x8F, 0x8F, 0x8F, 0xC0, 0x7E, 0x7C, 0x7C, 0x7C, 0x03, 0xF7, 0xC1, 0xF7,
  0xE0, 0x1F, 0xBE, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x7D, 0xF8, 0x03, 0xEF,
  0x83, 0xEF, 0x80, 0x1F, 0x7C, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x7B, 0xE0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0,
  0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0,
  0x7E, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07,
  0xFE, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x78, 0x0F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1E, 0x1F, 0xC4, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC3, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xDF, 0xF8, 0xF3, 0xFC, 0x3C,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xCF,
  0xE0, 0xFD, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xF9, 0xFF, 0x8F, 0x8F, 0xE0, 0x03, 0xFE, 0x07, 0xFF,
  0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF8, 0x13, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x9F, 0xFF,
  0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0xFE, 0x3F, 0x1F, 0xFB,
  0xF3, 0xFF, 0xBF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF,
  0x1F, 0xFB, 0xF0, 0xFE, 0x1F, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE7, 0xF0, 0xFC, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x09,
  0xFE, 0x0F, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xE3, 0xF1, 0xFF, 0xBF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xE0,
  0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0xBF, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x40, 0x07, 0xE7,
  0x00, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0x9F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0x01, 0xF9, 0xF8, 0x1F,
  0xCF, 0xC1, 0xFC, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC,
  0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x3F, 0x07, 0xE1,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0xF9, 0xFF, 0x9F,
  0xFC, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xF8, 0xFF, 0x1F, 0x3F, 0xF3, 0xEF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xDF, 0xE7, 0xE0, 0x7E, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xF8, 0xFE, 0x0F, 0x9F, 0xF8, 0xFB,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x07,
  0xEF, 0xE0, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xDF,
  0xF0, 0xFC, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF1, 0xFF, 0xBF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7,
  0xE0, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0xBF,
  0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x7F, 0xE7, 0xFF, 0xBF, 0xFE, 0xFE, 0xFF,
  0xFB, 0xFF, 0xEF, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x3F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFC, 0x3C, 0xF8, 0x04, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xBE, 0x7F, 0xE7,
  0xC7, 0xF8, 0xF8, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xBF,
  0x03, 0xF8, 0x0F, 0xDF, 0x81, 0xFC, 0x0F, 0xCF, 0xC0, 0xFF, 0x07, 0xE7,
  0xE0, 0xFF, 0x83, 0xF1, 0xF8, 0x7B, 0xC1, 0xF0, 0xFC, 0x3D, 0xE1, 0xF8,
  0x7E, 0x1E, 0xF8, 0xFC, 0x1F, 0x1F, 0x7C, 0x7E, 0x0F, 0xCF, 0x9E, 0x3E,
  0x07, 0xE7, 0x8F, 0x3F, 0x03, 0xF3, 0xC7, 0x9F, 0x80, 0xF9, 0xE3, 0xEF,
  0xC0, 0x7D, 0xF0, 0xF7, 0xC0, 0x3E, 0xF0, 0x7B, 0xE0, 0x1F, 0xF8, 0x3D,
  0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF9, 0xFC, 0x0F, 0xE3,
  0xF0, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xE1,
  0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E,
  0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0xFF, 0x87, 0xF8, 0x3F,
  0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x07,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x8F, 0xE0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x0E, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x00,
  0xFF, 0xA0, 0x01, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 31, 11, 2, -30 },
  { 29, 15, 11, 20, 2, -30 },
  { 50, 23, 30, 25, 1, -30 },
  { 137, 19, 34, 22, 2, -32 },
  { 218, 34, 30, 36, 1, -30 },
  { 346, 28, 30, 29, 1, -30 },
  { 451, 6, 11, 11, 2, -30 },
  { 460, 11, 37, 14, 2, -30 },
  { 511, 11, 37, 14, 1, -30 },
  { 562, 19, 19, 21, 1, -32 },
  { 608, 19, 20, 22, 2, -25 },
  { 656, 8, 10, 11, 1, -5 },
  { 666, 11, 5, 13, 1, -14 },
  { 673, 7, 7, 11, 2, -6 },
  { 680, 17, 30, 17, 0, -30 },
  { 744, 20, 30, 22, 1, -30 },
  { 819, 14, 30, 22, 2, -30 },
  { 872, 20, 30, 22, 1, -30 },
  { 947, 19, 30, 22, 2, -30 },
  { 1019, 21, 30, 22, 1, -30 },
  { 1098, 19, 30, 22, 2, -30 },
  { 1170, 20, 30, 22, 1, -30 },
  { 1245, 20, 30, 22, 1, -30 },
  { 1320, 20, 30, 22, 1, -30 },
  { 1395, 20, 30, 22, 1, -30 },
  { 1470, 7, 24, 11, 2, -23 },
  { 1491, 8, 28, 12, 1, -23 },
  { 1519, 19, 22, 22, 2, -26 },
  { 1572, 19, 12, 22, 2, -21 },
  { 1601, 19, 22, 22, 2, -26 },
  { 1654, 18, 31, 18, 0, -30 },
  { 1724, 31, 33, 35, 2, -30 },
  { 1852, 27, 30, 27, 0, -30 },
  { 1954, 21, 30, 26, 3, -30 },
  { 2033, 21, 30, 25, 2, -30 },
  { 2112, 23, 30, 28, 3, -30 },
  { 2199, 16, 30, 22, 3, -30 },
  { 2259, 16, 30, 21, 3, -30 },
  { 2319, 23, 30, 28, 2, -30 },
  { 2406, 23, 30, 29, 3, -30 },
  { 2493, 13, 30, 15, 1, -30 },
  { 2542, 13, 39, 13, -3, -30 },
  { 2606, 23, 30, 26, 3, -30 },
  { 2693, 17, 30, 21, 3, -30 },
  { 2757, 31, 30, 37, 3, -30 },
  { 2874, 25, 30, 31, 3, -30 },
  { 2968, 26, 30, 30, 2, -30 },
  { 3066, 20, 30, 24, 3, -30 },
  { 3141, 26, 37, 30, 2, -30 },
  { 3262, 22, 30, 25, 3, -30 },
  { 3345, 18, 30, 21, 2, -30 },
  { 3413, 20, 30, 22, 1, -30 },
  { 3488, 23, 30, 29, 3, -30 },
  { 3575, 25, 30, 25, 0, -30 },
  { 3669, 37, 30, 37, 0, -30 },
  { 3808, 25, 30, 25, 0, -30 },
  { 3902, 24, 30, 24, 0, -30 },
  { 3992, 20, 30, 22, 1, -30 },
  { 4067, 10, 37, 14, 3, -30 },
  { 4114, 17, 30, 17, 0, -30 },
  { 4178, 10, 37, 14, 1, -30 },
  { 4225, 21, 19, 23, 1, -30 },
  { 4275, 17, 3, 17, 0, 4 },
  { 4282, 11, 7, 14, 2, -32 },
  { 4292, 18, 23, 23, 2, -23 },
  { 4344, 20, 32, 25, 3, -32 },
  { 4424, 17, 23, 20, 2, -23 },
  { 4473, 20, 32, 25, 2, -32 },
  { 4553, 19, 23, 23, 2, -23 },
  { 4608, 16, 32, 15, 1, -32 },
  { 4672, 20, 33, 25, 2, -23 },
  { 4755, 19, 32, 25, 3, -32 },
  { 4831, 6, 32, 12, 3, -32 },
  { 4855, 11, 42, 12, -2, -32 },
  { 4913, 21, 32, 24, 3, -32 },
  { 4997, 6, 32, 12, 3, -32 },
  { 5021, 32, 23, 37, 3, -23 },
  { 5113, 19, 23, 25, 3, -23 },
  { 5168, 20, 23, 24, 2, -23 },
  { 5226, 20, 33, 25, 3, -23 },
  { 5309, 20, 33, 25, 2, -23 },
  { 5392, 14, 23, 17, 3, -23 },
  { 5433, 16, 23, 19, 2, -23 },
  { 5479, 14, 28, 17, 1, -28 },
  { 5528, 19, 23, 25, 3, -23 },
  { 5583, 22, 23, 22, 0, -23 },
  { 5647, 33, 23, 33, 0, -23 },
  { 5742, 22, 23, 22, 0, -23 },
  { 5806, 22, 33, 22, 0, -23 },
  { 5897, 17, 23, 19, 1, -23 },
  { 5946, 13, 37, 16, 1, -30 },
  { 6007, 5, 42, 21, 8, -32 },
  { 6034, 13, 37, 16, 2, -30 },
  { 6095, 19, 7, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Bold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD42PT7B_H_
