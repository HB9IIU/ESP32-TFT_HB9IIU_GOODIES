#ifndef _NOTOSANS_SEMICONDENSED_BOLD9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF5, 0x3F, 0xD5, 0xF5, 0x38, 0x27, 0xE6, 0x3B, 0x62,
  0x45, 0x52, 0xA5, 0xB5, 0x64, 0xC9, 0x80, 0x21, 0xC5, 0x18, 0xFF, 0x67,
  0xC0, 0xD0, 0x6B, 0x6C, 0x98, 0xC9, 0xB6, 0xB0, 0x2F, 0x25, 0x2F, 0x22,
  0x70, 0xE0, 0xC0, 0x32, 0x64, 0x48, 0x27, 0xDD, 0xD5, 0x70, 0x7F, 0x33,
  0x33, 0x2F, 0x11, 0x24, 0xF0, 0x2F, 0x16, 0x11, 0xF0, 0x31, 0x95, 0x2F,
  0x88, 0x74, 0x71, 0x1F, 0x17, 0x4F, 0xDD, 0x70, 0xF1, 0x32, 0x24, 0x25,
  0xD6, 0x5D, 0x70, 0x27, 0xDD, 0x71, 0x60, 0xD0, 0xC0, 0xC0, 0x70, 0x13,
  0xC6, 0x10, 0xF0, 0xF0, 0x8C, 0x37, 0xC0, 0x4F, 0x32, 0x40, 0x40, 0x7C,
  0xB6, 0xAD, 0x57, 0x68, 0x8E, 0x00, 0x31, 0xC5, 0x9E, 0xCB, 0x30, 0xF9,
  0xE9, 0x9F, 0x13, 0xD1, 0x8C, 0x21, 0xE0, 0xF4, 0xA7, 0x39, 0x70, 0xF3,
  0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x13, 0xD1, 0xB5, 0xA5, 0xE0, 0x9C, 0xFF,
  0x39, 0xCC, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x4E, 0xB5, 0x39, 0x4B, 0x4C,
  0x92, 0x49, 0xC0, 0xCF, 0x3D, 0xED, 0xB6, 0xD0, 0xCE, 0x6B, 0x59, 0xCC,
  0x11, 0xE4, 0xF1, 0xC5, 0x37, 0x80, 0xFB, 0xBE, 0x88, 0x11, 0xE4, 0xF1,
  0xC5, 0x37, 0x82, 0x0C, 0xF9, 0xFE, 0xB9, 0x27, 0xC6, 0x39, 0xF0, 0xF9,
  0x08, 0x42, 0x10, 0x9C, 0xE7, 0x39, 0x78, 0xCA, 0x54, 0xA3, 0x18, 0x99,
  0xDB, 0x5A, 0x7A, 0x66, 0x66, 0xDB, 0x8C, 0xE5, 0x64, 0xDA, 0x9C, 0x42,
  0x10, 0xF3, 0x26, 0x4F, 0xEA, 0xAC, 0xC4, 0x42, 0x23, 0xD5, 0x5C, 0x22,
  0x95, 0x10, 0xF0, 0xC4, 0x71, 0x7D, 0x70, 0x88, 0xEB, 0x9B, 0xE0, 0x74,
  0xCC, 0x70, 0x18, 0xDF, 0xBD, 0xED, 0xE0, 0x72, 0xBF, 0x87, 0x00, 0x74,
  0xE4, 0x44, 0x40, 0x7A, 0xF7, 0xB7, 0x8D, 0xC0, 0x88, 0xEB, 0xBB, 0xB0,
  0xBE, 0x45, 0x55, 0xC0, 0x88, 0xBE, 0xEA, 0xB0, 0xFE, 0xEE, 0xDB, 0x6D,
  0xB4, 0xEB, 0xBB, 0xB0, 0x72, 0xF6, 0xB7, 0x00, 0xEB, 0x9B, 0xE8, 0x80,
  0x7E, 0xF7, 0xB7, 0x8C, 0x60, 0xF2, 0x48, 0x7C, 0x61, 0xE0, 0x5D, 0x24,
  0xC0, 0xBB, 0xBB, 0xD0, 0x9E, 0x94, 0xE2, 0x00, 0x93, 0xDD, 0xB3, 0x66,
  0xC0, 0xDB, 0x88, 0xED, 0x80, 0x9A, 0x94, 0xE2, 0x13, 0x00, 0xF2, 0x64,
  0xF0, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF9,
};

const GFXglyph NotoSans_SemiCondensed_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 0, -7 },
  { 12, 7, 7, 8, 0, -7 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 2, 2, 2, 0, -6 },
  { 26, 3, 7, 3, 0, -6 },
  { 29, 3, 7, 3, 0, -6 },
  { 32, 4, 4, 5, 0, -7 },
  { 34, 4, 4, 5, 0, -5 },
  { 36, 2, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 1, 2, 0, -1 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 7, 5, 0, -7 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 7, 5, 0, -7 },
  { 53, 4, 7, 5, 0, -7 },
  { 57, 5, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 7, 5, 0, -7 },
  { 68, 4, 6, 5, 0, -6 },
  { 71, 4, 7, 5, 0, -7 },
  { 75, 4, 7, 5, 0, -7 },
  { 79, 2, 5, 2, 0, -5 },
  { 81, 2, 6, 2, 0, -5 },
  { 83, 4, 5, 5, 0, -6 },
  { 86, 4, 3, 5, 0, -5 },
  { 88, 4, 5, 5, 0, -6 },
  { 91, 4, 7, 4, 0, -7 },
  { 95, 7, 7, 8, 0, -6 },
  { 102, 6, 6, 6, 0, -6 },
  { 107, 4, 6, 6, 1, -6 },
  { 110, 5, 7, 5, 0, -7 },
  { 115, 5, 6, 6, 1, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 3, 6, 5, 1, -6 },
  { 125, 5, 7, 6, 0, -7 },
  { 130, 5, 6, 6, 1, -6 },
  { 134, 3, 6, 3, 0, -6 },
  { 137, 3, 8, 3, -1, -6 },
  { 140, 5, 6, 5, 1, -6 },
  { 144, 3, 6, 5, 1, -6 },
  { 147, 6, 6, 8, 1, -6 },
  { 152, 5, 6, 7, 1, -6 },
  { 156, 6, 7, 6, 0, -7 },
  { 162, 4, 6, 5, 1, -6 },
  { 165, 6, 9, 6, 0, -7 },
  { 172, 4, 6, 5, 1, -6 },
  { 175, 4, 7, 5, 0, -7 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 5, 6, 6, 1, -6 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 8, 6, 8, 0, -6 },
  { 197, 5, 6, 5, 0, -6 },
  { 201, 5, 6, 5, 0, -6 },
  { 205, 4, 6, 5, 0, -6 },
  { 208, 2, 7, 3, 1, -6 },
  { 210, 4, 6, 4, 0, -6 },
  { 213, 2, 7, 3, 0, -6 },
  { 215, 5, 4, 5, 0, -6 },
  { 218, 4, 1, 4, 0, 1 },
  { 219, 3, 2, 3, 0, -7 },
  { 220, 4, 5, 5, 0, -5 },
  { 223, 4, 7, 5, 1, -7 },
  { 227, 4, 5, 4, 0, -5 },
  { 230, 5, 7, 5, 0, -7 },
  { 235, 5, 5, 5, 0, -5 },
  { 239, 4, 7, 3, 0, -7 },
  { 243, 5, 7, 5, 0, -5 },
  { 248, 4, 7, 5, 1, -7 },
  { 252, 1, 7, 3, 1, -7 },
  { 253, 2, 9, 3, 0, -7 },
  { 256, 4, 7, 5, 1, -7 },
  { 260, 1, 7, 3, 1, -7 },
  { 261, 6, 5, 8, 1, -5 },
  { 265, 4, 5, 5, 1, -5 },
  { 268, 5, 5, 5, 0, -5 },
  { 272, 4, 7, 5, 1, -5 },
  { 276, 5, 7, 5, 0, -5 },
  { 281, 3, 5, 4, 1, -5 },
  { 283, 4, 5, 4, 0, -5 },
  { 286, 3, 6, 4, 0, -6 },
  { 289, 4, 5, 5, 1, -5 },
  { 292, 5, 5, 5, 0, -5 },
  { 296, 7, 5, 7, 0, -5 },
  { 301, 5, 5, 5, 0, -5 },
  { 305, 5, 7, 5, 0, -5 },
  { 310, 4, 5, 4, 0, -5 },
  { 313, 3, 7, 3, 0, -6 },
  { 316, 1, 9, 5, 2, -7 },
  { 318, 3, 7, 3, 0, -6 },
  { 321, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Bold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD9PT7B_H_
