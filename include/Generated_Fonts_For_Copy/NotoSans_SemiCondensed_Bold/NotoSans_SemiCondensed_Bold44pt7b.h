#ifndef _NOTOSANS_SEMICONDENSED_BOLD44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E, 0x08, 0xFE, 0x3F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x00, 0xF8, 0x78, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3,
  0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC3,
  0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x0F, 0x87, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFE, 0xE3, 0xCF, 0xCE, 0x04, 0xFC, 0xE0, 0x0F, 0xCE, 0x00, 0xFE, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0E, 0x7E, 0x00,
  0xE7, 0xF0, 0x0E, 0x3F, 0xC0, 0xE7, 0xFF, 0x0E, 0x7E, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x00, 0x10, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F,
  0xFC, 0x01, 0xE0, 0x07, 0xEF, 0x80, 0x7C, 0x00, 0xF8, 0xF8, 0x0F, 0x00,
  0x1F, 0x1F, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0xF8, 0x7C, 0x1F,
  0x00, 0x1F, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0xF8, 0xFC, 0x1F,
  0x1F, 0x3E, 0x3F, 0xE3, 0xF7, 0xE7, 0xCF, 0xFC, 0x3F, 0xF9, 0xF3, 0xFF,
  0xC7, 0xFE, 0x3E, 0x7C, 0xF8, 0x7F, 0x8F, 0x8F, 0x8F, 0x83, 0xC1, 0xF3,
  0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0xF8, 0x7C, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x1F, 0x01, 0xF3,
  0xF0, 0x07, 0xC0, 0x3F, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x00,
  0x3F, 0xE0, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0xFE, 0x1F, 0xFE, 0x07, 0xE1, 0xFF, 0xF8, 0x3F, 0x0F,
  0xFF, 0xE3, 0xF8, 0xFE, 0x7F, 0x1F, 0x87, 0xF1, 0xFC, 0xFC, 0x3F, 0x07,
  0xFF, 0xE1, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0x7F, 0xF0, 0x7E, 0x01, 0xFF,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xFE, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0,
  0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x0F, 0x0E, 0x7E, 0xF7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0x9F, 0x81, 0xF9, 0xF8, 0x3F, 0x0F, 0xC0, 0xF0, 0xF0, 0x02,
  0x04, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0x7E, 0x7E,
  0x10, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0x87, 0xFB, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFE, 0xFE, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0x1F, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0x7E, 0x7E, 0x78, 0xFC, 0x61, 0xF8, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7C,
  0x0F, 0xE3, 0x00, 0xFE, 0x20, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xF7, 0xFE, 0x30, 0x0F, 0xE2, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0xE0, 0x1F, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3C, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0,
  0x3E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0,
  0x3F, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x38, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFC, 0x30, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE7, 0xF8, 0x3E, 0x7F, 0xE1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xF8, 0x3F, 0xBF, 0xC0, 0xFF, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF8, 0x1F,
  0x8F, 0xE1, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0x1F, 0xC1, 0xFD, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x01, 0xFD,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80,
  0xFE, 0xFF, 0x9F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xEF, 0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFE,
  0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFD, 0xF8, 0x1F, 0xEF, 0xE1, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFF, 0x7E, 0x1F, 0xF3, 0xE0, 0x7F, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF,
  0x7E, 0x7E, 0x08, 0x3F, 0x1F, 0x9F, 0xEF, 0xF3, 0xF9, 0xF8, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF,
  0xDF, 0xF3, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x40, 0x3E, 0x1F, 0x03, 0xFF, 0x8F, 0x8F, 0x07, 0xFF, 0xC7,
  0xCF, 0x87, 0xFF, 0xE1, 0xE7, 0xC3, 0xF1, 0xF0, 0xF3, 0xC3, 0xE0, 0xF8,
  0x7F, 0xE1, 0xF0, 0x7C, 0x3F, 0xF1, 0xF0, 0x3E, 0x1F, 0xF8, 0xF8, 0x1F,
  0x0F, 0xFC, 0x7C, 0x0F, 0x87, 0xFE, 0x3E, 0x07, 0xC3, 0xFF, 0x1F, 0x03,
  0xE1, 0xEF, 0x8F, 0x81, 0xF0, 0xF7, 0xC7, 0xC1, 0xF8, 0xFB, 0xE1, 0xF0,
  0xFC, 0x79, 0xF0, 0xFF, 0xFF, 0xFC, 0x78, 0x3F, 0xF7, 0xFC, 0x3E, 0x0F,
  0xF1, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x00, 0x1F,
  0xFC, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xBF, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x9F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFE, 0x01,
  0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8,
  0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFE, 0x03, 0x8F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x23, 0xFF, 0x03, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xFC,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x3F, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xF0, 0x0C, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0x7E, 0x07, 0xFF, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0xC0,
  0x3F, 0x1F, 0xE0, 0x3F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xE3, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F,
  0xE0, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x7F, 0x81, 0xF8, 0xFE, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xF0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC3,
  0xF8, 0x1F, 0x87, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFC, 0x0F,
  0xE1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F,
  0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFB, 0xE0, 0x0F, 0xFF, 0xF7, 0xC0, 0x3E, 0xFF, 0xEF, 0xC0, 0x7D, 0xFF,
  0xCF, 0x80, 0xFB, 0xFF, 0x9F, 0x03, 0xE7, 0xFF, 0x3E, 0x07, 0xCF, 0xFE,
  0x7E, 0x0F, 0x9F, 0xFC, 0x7C, 0x3F, 0x3F, 0xF8, 0xF8, 0x7C, 0x7F, 0xF1,
  0xF8, 0xF8, 0xFF, 0xE1, 0xF1, 0xF1, 0xFF, 0xC3, 0xE7, 0xC3, 0xFF, 0x87,
  0xCF, 0x87, 0xFF, 0x0F, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x01, 0xF8,
  0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFB, 0xF0, 0x1F, 0xFD, 0xFC,
  0x0F, 0xFE, 0x7E, 0x07, 0xFF, 0x3F, 0x83, 0xFF, 0x8F, 0xC1, 0xFF, 0xC7,
  0xF0, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0, 0xFE, 0x3F, 0xF8, 0x3F, 0x1F, 0xFC,
  0x1F, 0xC7, 0xFE, 0x07, 0xF3, 0xFF, 0x03, 0xF9, 0xFF, 0x80, 0xFE, 0xFF,
  0xC0, 0x7F, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x07, 0xFB, 0xF8,
  0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xCF,
  0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x83, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE,
  0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x80, 0xE7, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xD8, 0x01, 0xFB, 0xE0, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0xE0, 0x1F, 0x9F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x3F, 0x03, 0xEF,
  0x81, 0xF8, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0xFC, 0x0F, 0xBE, 0x0F, 0xE0,
  0xFC, 0x1F, 0x7C, 0x1F, 0x81, 0xF8, 0x3E, 0xF8, 0x3F, 0x03, 0xF0, 0xF9,
  0xF8, 0x7E, 0x07, 0xE1, 0xF1, 0xF0, 0xFC, 0x07, 0xE3, 0xE3, 0xE3, 0xF0,
  0x0F, 0xC7, 0xC7, 0xC7, 0xE0, 0x1F, 0x9F, 0x8F, 0xCF, 0xC0, 0x3F, 0x3E,
  0x0F, 0x9F, 0x80, 0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x3E, 0xFC,
  0x00, 0xFD, 0xF0, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF1, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE1, 0xF1, 0xFE, 0x30, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xDF, 0xFC,
  0xF8, 0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x3F, 0x7F, 0xE1, 0xFB, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xBF,
  0x81, 0xFD, 0xFE, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0x3F, 0xF0, 0xF8, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0xFF,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF8, 0x11, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x05, 0xFE, 0x06, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x83, 0xF8, 0x7F, 0x9F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFB, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFE, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xF7,
  0xE3, 0xFF, 0x3F, 0x07, 0xF0, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x8F, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x63, 0xFE, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x78, 0x03, 0xFF, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xEE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x80, 0x00, 0x3F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFB,
  0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xF7, 0xE3, 0xFF, 0x7F, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x30, 0x03, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC7, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0xFD, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x01, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x0F, 0xE3, 0xF0,
  0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF8,
  0x0F, 0xDF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F,
  0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x40, 0x7C,
  0x7F, 0xC1, 0xFE, 0x3E, 0x7F, 0xF3, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x0F,
  0xFF, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x01,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xE0, 0x3F,
  0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xF8, 0x0F, 0xE0, 0x3F, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x08, 0x0F, 0x87, 0xF8, 0xF9, 0xFF, 0xCF, 0xBF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFC, 0x1F,
  0xCF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFE, 0x0F, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x08, 0x07, 0xC3, 0xF8, 0x3E, 0x7F, 0xF1, 0xFB, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xF7,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xBF,
  0x81, 0xFD, 0xFE, 0x1F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xBF, 0xF0, 0xFC, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFE, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xF7, 0xE3,
  0xFF, 0x7F, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x09,
  0xF0, 0xFF, 0xE3, 0xF7, 0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x1F,
  0xFC, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x02, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xDF, 0x3F, 0xF9, 0xF0, 0xFF, 0x1F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD,
  0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0x03, 0xF7,
  0xE0, 0x7F, 0x80, 0xFD, 0xF8, 0x1F, 0xF0, 0x7F, 0x3F, 0x07, 0xFC, 0x1F,
  0x8F, 0xC1, 0xEF, 0x07, 0xE3, 0xF0, 0xFB, 0xC1, 0xF8, 0xFC, 0x3E, 0xF8,
  0xFC, 0x1F, 0x8F, 0xBE, 0x3F, 0x07, 0xE3, 0xCF, 0x8F, 0xC1, 0xF8, 0xF1,
  0xE3, 0xF0, 0x7E, 0x7C, 0x79, 0xF8, 0x0F, 0xDF, 0x1F, 0x7E, 0x03, 0xF7,
  0x87, 0xDF, 0x80, 0xFD, 0xE0, 0xF7, 0xE0, 0x3F, 0x78, 0x3D, 0xF0, 0x07,
  0xDE, 0x0F, 0x7C, 0x01, 0xFF, 0x83, 0xDF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x7F, 0x01,
  0xF8, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFD,
  0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xFB,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x0F,
  0xFC, 0x3F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x80, 0x1F,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 16, 11, 21, 2, -31 },
  { 55, 24, 31, 26, 1, -31 },
  { 148, 20, 36, 23, 2, -33 },
  { 238, 35, 32, 38, 1, -32 },
  { 378, 29, 32, 30, 1, -32 },
  { 494, 7, 11, 11, 2, -31 },
  { 504, 11, 38, 15, 2, -31 },
  { 557, 12, 38, 15, 1, -31 },
  { 614, 20, 19, 22, 1, -33 },
  { 662, 20, 21, 23, 2, -26 },
  { 715, 9, 11, 12, 1, -5 },
  { 728, 12, 6, 14, 1, -15 },
  { 737, 8, 8, 12, 2, -7 },
  { 745, 18, 32, 18, 0, -32 },
  { 817, 20, 32, 23, 2, -32 },
  { 897, 15, 31, 23, 2, -31 },
  { 956, 20, 32, 23, 2, -32 },
  { 1036, 20, 32, 23, 2, -32 },
  { 1116, 22, 31, 23, 1, -31 },
  { 1202, 19, 31, 23, 2, -31 },
  { 1276, 21, 32, 23, 1, -32 },
  { 1360, 21, 31, 23, 1, -31 },
  { 1442, 21, 32, 23, 1, -32 },
  { 1526, 21, 32, 23, 1, -32 },
  { 1610, 8, 25, 12, 2, -24 },
  { 1635, 9, 30, 12, 1, -24 },
  { 1669, 20, 22, 23, 2, -27 },
  { 1724, 20, 13, 23, 2, -22 },
  { 1757, 20, 22, 23, 2, -27 },
  { 1812, 18, 33, 19, 0, -32 },
  { 1887, 33, 36, 37, 2, -32 },
  { 2036, 28, 32, 28, 0, -32 },
  { 2148, 22, 31, 27, 3, -31 },
  { 2234, 22, 32, 26, 2, -32 },
  { 2322, 24, 31, 29, 3, -31 },
  { 2415, 16, 31, 23, 4, -31 },
  { 2477, 16, 31, 22, 4, -31 },
  { 2539, 24, 32, 29, 2, -32 },
  { 2635, 23, 31, 31, 4, -31 },
  { 2725, 14, 31, 16, 1, -31 },
  { 2780, 13, 40, 14, -3, -31 },
  { 2845, 23, 31, 27, 4, -31 },
  { 2935, 18, 31, 22, 3, -31 },
  { 3005, 31, 31, 39, 4, -31 },
  { 3126, 25, 31, 33, 4, -31 },
  { 3223, 27, 32, 32, 2, -32 },
  { 3331, 21, 31, 25, 3, -31 },
  { 3413, 27, 39, 32, 2, -32 },
  { 3545, 24, 31, 27, 3, -31 },
  { 3638, 19, 32, 22, 2, -32 },
  { 3714, 21, 31, 23, 1, -31 },
  { 3796, 24, 31, 30, 3, -31 },
  { 3889, 26, 31, 26, 0, -31 },
  { 3990, 39, 31, 39, 0, -31 },
  { 4142, 26, 31, 26, 0, -31 },
  { 4243, 25, 31, 25, 0, -31 },
  { 4340, 21, 31, 23, 1, -31 },
  { 4422, 10, 38, 14, 3, -31 },
  { 4470, 18, 32, 18, 0, -32 },
  { 4542, 10, 38, 14, 1, -31 },
  { 4590, 22, 20, 25, 1, -32 },
  { 4645, 18, 3, 18, 0, 4 },
  { 4652, 11, 7, 15, 2, -34 },
  { 4662, 19, 24, 24, 2, -24 },
  { 4719, 21, 33, 26, 3, -33 },
  { 4806, 18, 25, 21, 2, -25 },
  { 4863, 21, 33, 26, 2, -33 },
  { 4950, 20, 24, 24, 2, -24 },
  { 5010, 16, 34, 16, 1, -34 },
  { 5078, 21, 36, 26, 2, -25 },
  { 5173, 20, 33, 26, 3, -33 },
  { 5256, 7, 33, 12, 3, -33 },
  { 5285, 12, 44, 12, -2, -33 },
  { 5351, 22, 33, 25, 3, -33 },
  { 5442, 6, 33, 12, 3, -33 },
  { 5467, 33, 25, 39, 3, -25 },
  { 5571, 20, 25, 26, 3, -25 },
  { 5634, 21, 25, 25, 2, -25 },
  { 5700, 21, 36, 26, 3, -25 },
  { 5795, 21, 36, 26, 2, -25 },
  { 5890, 15, 25, 18, 3, -25 },
  { 5937, 16, 25, 20, 2, -25 },
  { 5987, 15, 29, 17, 1, -29 },
  { 6042, 20, 24, 26, 3, -24 },
  { 6102, 23, 24, 23, 0, -24 },
  { 6171, 34, 24, 35, 0, -24 },
  { 6273, 23, 24, 23, 0, -24 },
  { 6342, 23, 35, 23, 0, -24 },
  { 6443, 17, 24, 20, 1, -24 },
  { 6494, 14, 38, 17, 1, -31 },
  { 6561, 5, 43, 22, 9, -33 },
  { 6588, 14, 38, 17, 2, -31 },
  { 6655, 20, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Bold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD44PT7B_H_
