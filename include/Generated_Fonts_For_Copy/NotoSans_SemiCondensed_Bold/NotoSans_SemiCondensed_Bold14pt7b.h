#ifndef _NOTOSANS_SEMICONDENSED_BOLD14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF7, 0xA0, 0x12, 0x16, 0x16, 0x7F, 0x34,
  0x24, 0xFF, 0x2C, 0x2C, 0x68, 0x20, 0xCF, 0xF9, 0xE3, 0xC3, 0x8B, 0xAF,
  0xE2, 0x08, 0x71, 0x85, 0x90, 0xDB, 0x0D, 0xA0, 0x5E, 0xE7, 0x5A, 0x0D,
  0xB0, 0xDB, 0x19, 0xA1, 0x8E, 0x3C, 0x1F, 0x86, 0x60, 0xF0, 0x38, 0x1E,
  0x66, 0xFB, 0x9C, 0x7F, 0x0F, 0x70, 0xFF, 0x6B, 0x69, 0x24, 0xD9, 0x30,
  0xC6, 0x23, 0x33, 0x33, 0x32, 0x6E, 0x10, 0x21, 0x5F, 0xF3, 0x8D, 0x8A,
  0x00, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0x6D, 0x60, 0xFF, 0xF0, 0x0C, 0x61,
  0x84, 0x30, 0xC6, 0x18, 0x63, 0x00, 0x3C, 0xF9, 0x9B, 0x3E, 0x7C, 0xD9,
  0xB3, 0x7C, 0x78, 0x37, 0xDB, 0x33, 0x33, 0x33, 0x7D, 0xFD, 0x18, 0x30,
  0xC3, 0x0E, 0x38, 0x7E, 0xFC, 0xFC, 0xFC, 0x18, 0x63, 0x87, 0x81, 0x83,
  0xFF, 0xF8, 0x0C, 0x38, 0x71, 0xE6, 0xC9, 0xBF, 0xFF, 0x0C, 0x18, 0xFB,
  0xEC, 0x30, 0xFA, 0x70, 0xC3, 0xFB, 0xE0, 0x1C, 0xF9, 0x82, 0x47, 0xDC,
  0xD1, 0xB3, 0x7E, 0x78, 0xFF, 0xFC, 0x18, 0x60, 0xC3, 0x06, 0x1C, 0x30,
  0xE0, 0x3C, 0xDD, 0x9B, 0x63, 0x8F, 0x99, 0xE3, 0x6E, 0xF8, 0x38, 0xFB,
  0x1E, 0x36, 0x6F, 0xCD, 0x82, 0x7C, 0xF0, 0xF8, 0x0F, 0x6D, 0x00, 0x1B,
  0x58, 0x02, 0x0C, 0x73, 0x8F, 0x03, 0x81, 0x81, 0xFC, 0x00, 0x3F, 0x83,
  0x07, 0x07, 0x1F, 0xCC, 0x20, 0xFB, 0xF0, 0xC3, 0x38, 0xC2, 0x00, 0x31,
  0xC0, 0x1F, 0x18, 0x6C, 0x0F, 0x7B, 0xB2, 0x6C, 0x9B, 0x2E, 0x7E, 0xC0,
  0x18, 0x43, 0xF0, 0x1C, 0x0E, 0x0D, 0x06, 0xC3, 0x63, 0x31, 0xFC, 0xFE,
  0xE3, 0x61, 0xC0, 0xFD, 0xFF, 0x1E, 0x7F, 0xDF, 0xB1, 0xE3, 0xFF, 0xF8,
  0x3E, 0xFB, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x7C, 0x78, 0xF8, 0xFE, 0xC6,
  0xC7, 0xC3, 0xC3, 0xC6, 0xC6, 0xFE, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF, 0x18,
  0xFF, 0xC0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC6, 0x00, 0x3E, 0xFF, 0x86,
  0x0C, 0xF9, 0xF1, 0xE3, 0x7E, 0x7C, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFB, 0x8C, 0x63, 0x18, 0xC6, 0x77, 0xC0, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC7, 0xCC, 0xCC, 0xD8, 0xF0, 0xF8,
  0xDC, 0xCC, 0xCE, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0,
  0xE1, 0xF8, 0x7F, 0x1F, 0xCF, 0xD3, 0xF6, 0xBD, 0xEF, 0x7B, 0xCC, 0xF3,
  0x30, 0xE3, 0xE3, 0xF3, 0xFB, 0xDB, 0xDF, 0xCF, 0xCF, 0xC7, 0xC3, 0x3C,
  0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xF9, 0xFB, 0x36,
  0x7C, 0xDF, 0xB0, 0x60, 0xC1, 0x80, 0x3E, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x7E, 0x3C, 0x0E, 0x07, 0xF9, 0xFB, 0x3E, 0x7D, 0xDF, 0x36,
  0x66, 0xCF, 0x8C, 0x7F, 0xEC, 0x30, 0xF0, 0xE1, 0x83, 0xFB, 0xC0, 0xFF,
  0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC6, 0x7E, 0x7C, 0xC3, 0xC3, 0x63, 0x66, 0x66, 0x36,
  0x34, 0x3C, 0x1C, 0x18, 0xC6, 0x3C, 0x63, 0x47, 0x36, 0xF3, 0x6D, 0x66,
  0xD6, 0x69, 0xE2, 0x9E, 0x39, 0xC3, 0x8C, 0xE3, 0x66, 0x36, 0x3C, 0x1C,
  0x1C, 0x3C, 0x76, 0x66, 0xE3, 0xC3, 0x66, 0x66, 0x3C, 0x3C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0xE1, 0x86, 0x0C, 0x30, 0xFF, 0xFC,
  0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC1, 0x06, 0x18, 0x30, 0xC1, 0x06, 0x18,
  0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x18, 0x30, 0xF1, 0x66, 0x78,
  0xC0, 0xFC, 0xCC, 0x80, 0x3C, 0xFC, 0x19, 0xF7, 0x7C, 0xDB, 0xBB, 0xC1,
  0x83, 0x06, 0xCF, 0xD9, 0xB3, 0xE3, 0xCD, 0xFB, 0xF0, 0x3F, 0xF1, 0x8C,
  0x63, 0xEF, 0x0C, 0x30, 0xDB, 0xFF, 0x3C, 0xF3, 0xCF, 0xF7, 0xC0, 0x73,
  0xFC, 0xFF, 0xFF, 0x0E, 0xDF, 0x3D, 0xE6, 0x1E, 0xF9, 0x86, 0x18, 0x61,
  0x86, 0x00, 0x67, 0xFC, 0xF3, 0xCF, 0x3F, 0xDF, 0x0E, 0x3F, 0x80, 0xC3,
  0x0C, 0x36, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0xF3, 0xFF, 0xFC, 0x33,
  0x03, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xC1, 0x83, 0x06, 0x3C, 0xDB, 0x3C,
  0x7C, 0xD9, 0x9B, 0x38, 0xFF, 0xFF, 0xFC, 0xD9, 0x9F, 0xFB, 0x3B, 0xE6,
  0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xDB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3,
  0x3B, 0xFC, 0xF3, 0xCF, 0x3F, 0xDE, 0xD9, 0xFB, 0x36, 0x7C, 0x79, 0xBF,
  0x7E, 0xC1, 0x83, 0x00, 0x67, 0xFC, 0xF3, 0xCF, 0x3F, 0xDF, 0x0C, 0x30,
  0xC0, 0xDF, 0xB9, 0x8C, 0x63, 0x18, 0x77, 0xF1, 0xC7, 0x8E, 0xFE, 0x23,
  0xFE, 0xC6, 0x31, 0x8F, 0x38, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xDD, 0xC7,
  0x8D, 0x9B, 0x66, 0xC7, 0x8E, 0x1C, 0xCE, 0x79, 0xCD, 0xAB, 0x35, 0x66,
  0xBC, 0xF7, 0x8E, 0xE1, 0x8C, 0xC6, 0xD9, 0xF1, 0xC3, 0x87, 0x9B, 0x73,
  0xC7, 0x8D, 0x9B, 0x62, 0xC7, 0x8E, 0x0C, 0x18, 0x63, 0xC0, 0x7D, 0xF1,
  0x8E, 0x31, 0x87, 0xFF, 0x39, 0xCC, 0x63, 0x73, 0x86, 0x31, 0x8C, 0x70,
  0xFF, 0xFC, 0xCC, 0x44, 0x47, 0x76, 0x44, 0xCC, 0x73, 0xBC,
};

const GFXglyph NotoSans_SemiCondensed_Bold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 6, 12, 7, 1, -11 },
  { 26, 12, 10, 12, 0, -10 },
  { 41, 10, 10, 10, 0, -10 },
  { 54, 2, 4, 4, 1, -10 },
  { 55, 3, 12, 5, 1, -10 },
  { 60, 4, 12, 5, 0, -10 },
  { 66, 7, 7, 7, 0, -11 },
  { 73, 6, 6, 7, 1, -8 },
  { 78, 3, 4, 4, 0, -2 },
  { 80, 4, 2, 4, 0, -5 },
  { 81, 2, 2, 4, 1, -2 },
  { 82, 6, 10, 6, 0, -10 },
  { 90, 7, 10, 7, 0, -10 },
  { 99, 4, 10, 7, 1, -10 },
  { 104, 7, 10, 7, 0, -10 },
  { 113, 7, 10, 7, 0, -10 },
  { 122, 7, 10, 7, 0, -10 },
  { 131, 6, 10, 7, 1, -10 },
  { 139, 7, 10, 7, 0, -10 },
  { 148, 7, 10, 7, 0, -10 },
  { 157, 7, 10, 7, 0, -10 },
  { 166, 7, 10, 7, 0, -10 },
  { 175, 2, 8, 4, 1, -8 },
  { 177, 3, 10, 4, 0, -8 },
  { 181, 7, 8, 7, 0, -9 },
  { 188, 6, 4, 7, 1, -7 },
  { 191, 6, 8, 7, 1, -9 },
  { 197, 6, 10, 6, 0, -10 },
  { 205, 10, 11, 12, 1, -10 },
  { 219, 9, 10, 9, 0, -10 },
  { 231, 7, 10, 9, 1, -10 },
  { 240, 7, 10, 8, 1, -10 },
  { 249, 8, 10, 9, 1, -10 },
  { 259, 5, 10, 7, 1, -10 },
  { 266, 5, 10, 7, 1, -10 },
  { 273, 7, 10, 9, 1, -10 },
  { 282, 8, 10, 10, 1, -10 },
  { 292, 5, 10, 5, 0, -10 },
  { 299, 4, 13, 4, -1, -10 },
  { 306, 8, 10, 9, 1, -10 },
  { 316, 6, 10, 7, 1, -10 },
  { 324, 10, 10, 12, 1, -10 },
  { 337, 8, 10, 10, 1, -10 },
  { 347, 8, 10, 10, 1, -10 },
  { 357, 7, 10, 8, 1, -10 },
  { 366, 8, 12, 10, 1, -10 },
  { 378, 7, 10, 8, 1, -10 },
  { 387, 6, 10, 7, 1, -10 },
  { 395, 7, 10, 7, 0, -10 },
  { 404, 8, 10, 10, 1, -10 },
  { 414, 8, 10, 8, 0, -10 },
  { 424, 12, 10, 12, 0, -10 },
  { 439, 8, 10, 8, 0, -10 },
  { 449, 8, 10, 8, 0, -10 },
  { 459, 7, 10, 7, 0, -10 },
  { 468, 3, 12, 5, 1, -10 },
  { 473, 6, 10, 6, 0, -10 },
  { 481, 4, 12, 5, 0, -10 },
  { 487, 7, 6, 8, 0, -10 },
  { 493, 6, 1, 6, 0, 1 },
  { 494, 3, 3, 5, 1, -11 },
  { 496, 7, 8, 8, 0, -8 },
  { 503, 7, 11, 8, 1, -11 },
  { 513, 5, 8, 7, 1, -8 },
  { 518, 6, 11, 8, 1, -11 },
  { 527, 6, 8, 8, 1, -8 },
  { 533, 6, 11, 5, 0, -11 },
  { 542, 6, 11, 8, 1, -8 },
  { 551, 6, 11, 8, 1, -11 },
  { 560, 2, 11, 4, 1, -11 },
  { 563, 4, 14, 4, -1, -11 },
  { 570, 7, 11, 8, 1, -11 },
  { 580, 2, 11, 4, 1, -11 },
  { 583, 11, 8, 12, 1, -8 },
  { 594, 6, 8, 8, 1, -8 },
  { 600, 6, 8, 8, 1, -8 },
  { 606, 7, 11, 8, 1, -8 },
  { 616, 6, 11, 8, 1, -8 },
  { 625, 5, 8, 6, 1, -8 },
  { 630, 5, 8, 6, 1, -8 },
  { 635, 5, 9, 6, 0, -9 },
  { 641, 6, 8, 8, 1, -8 },
  { 647, 7, 8, 7, 0, -8 },
  { 654, 11, 8, 11, 0, -8 },
  { 665, 7, 8, 7, 0, -8 },
  { 672, 7, 11, 7, 0, -8 },
  { 682, 6, 8, 6, 0, -8 },
  { 688, 5, 12, 5, 0, -10 },
  { 696, 1, 14, 7, 3, -11 },
  { 698, 4, 12, 5, 1, -10 },
  { 704, 7, 2, 7, 0, -6 },
};

const GFXfont NotoSans_SemiCondensed_Bold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD14PT7B_H_
